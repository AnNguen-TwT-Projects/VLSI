    I_MXI1658_MN4 (VSS fa205_1 XI1658_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1658_MN27 (fa297_1 XI1658_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1658_MN10 (XI1658_n4 fa245_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1658_MN11 (XI1658_n5 fa205_1 XI1658_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1658_MN11_1 (XI1658_n4 fa205_1 XI1658_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1658_MN10_1 (VSS fa245_1 XI1658_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1658_MN6 (XI1658_n3 fa245_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1658_MN7 (VSS fa205_1 XI1658_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1658_MN8 (XI1658_n3 fa206_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1658_MN9 (XI1658_sn XI1658_con XI1658_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1658_MN12_1 (XI1658_n5 fa206_0 XI1658_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1496_MN12 (XI1496_sn pp15_29 XI1496_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1496_MN25 (fa135_0 XI1496_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1496_MN5 (XI1496_con pp15_29 XI1496_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1496_MN2 (XI1496_n1 pp14_31 XI1496_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1496_MN1 (VSS sn13 XI1496_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1496_MN3 (XI1496_n2 sn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1496_MN4 (VSS pp14_31 XI1496_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1496_MN27 (fa135_1 XI1496_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1496_MN10 (XI1496_n4 sn13 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1496_MN11 (XI1496_n5 pp14_31 XI1496_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1496_MN11_1 (XI1496_n4 pp14_31 XI1496_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1496_MN10_1 (VSS sn13 XI1496_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1496_MN6 (XI1496_n3 sn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1496_MN7 (VSS pp14_31 XI1496_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1496_MN8 (XI1496_n3 pp15_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1496_MN9 (XI1496_sn XI1496_con XI1496_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1496_MN12_1 (XI1496_n5 pp15_29 XI1496_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1659_MN12 (XI1659_sn cm134_0 XI1659_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1659_MN25 (fa298_0 XI1659_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1659_MN5 (XI1659_con cm134_0 XI1659_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1659_MN2 (XI1659_n1 cm133_1 XI1659_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1659_MN1 (VSS fa246_1 XI1659_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1659_MN3 (XI1659_n2 fa246_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1659_MN4 (VSS cm133_1 XI1659_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1659_MN27 (fa298_1 XI1659_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1659_MN10 (XI1659_n4 fa246_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1659_MN11 (XI1659_n5 cm133_1 XI1659_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1659_MN11_1 (XI1659_n4 cm133_1 XI1659_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1659_MN10_1 (VSS fa246_1 XI1659_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1659_MN6 (XI1659_n3 fa246_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1659_MN7 (VSS cm133_1 XI1659_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1659_MN8 (XI1659_n3 cm134_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1659_MN9 (XI1659_sn XI1659_con XI1659_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1659_MN12_1 (XI1659_n5 cm134_0 XI1659_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1497_MN12 (XI1497_sn pp15_30 XI1497_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1497_MN25 (fa136_0 XI1497_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1497_MN5 (XI1497_con pp15_30 XI1497_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1497_MN2 (XI1497_n1 pp14_32 XI1497_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1497_MN1 (VSS VDD XI1497_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1497_MN3 (XI1497_n2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1497_MN4 (VSS pp14_32 XI1497_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1497_MN27 (fa136_1 XI1497_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1497_MN10 (XI1497_n4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1497_MN11 (XI1497_n5 pp14_32 XI1497_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1497_MN11_1 (XI1497_n4 pp14_32 XI1497_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1497_MN10_1 (VSS VDD XI1497_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1497_MN6 (XI1497_n3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1497_MN7 (VSS pp14_32 XI1497_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1497_MN8 (XI1497_n3 pp15_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1497_MN9 (XI1497_sn XI1497_con XI1497_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1497_MN12_1 (XI1497_n5 pp15_30 XI1497_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1568_MN12 (XI1568_sn cm134_2 XI1568_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1568_MN25 (fa207_0 XI1568_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1568_MN5 (XI1568_con cm134_2 XI1568_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1568_MN2 (XI1568_n1 fa135_0 XI1568_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1568_MN1 (VSS cm134_1 XI1568_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1568_MN3 (XI1568_n2 cm134_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1568_MN4 (VSS fa135_0 XI1568_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1568_MN27 (fa207_1 XI1568_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1568_MN10 (XI1568_n4 cm134_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1568_MN11 (XI1568_n5 fa135_0 XI1568_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1568_MN11_1 (XI1568_n4 fa135_0 XI1568_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1568_MN10_1 (VSS cm134_1 XI1568_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1568_MN6 (XI1568_n3 cm134_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1568_MN7 (VSS fa135_0 XI1568_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1568_MN8 (XI1568_n3 cm134_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1568_MN9 (XI1568_sn XI1568_con XI1568_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1568_MN12_1 (XI1568_n5 cm134_2 XI1568_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1569_MN12 (XI1569_sn pp15_31 XI1569_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1569_MN25 (fa208_0 XI1569_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1569_MN5 (XI1569_con pp15_31 XI1569_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1569_MN2 (XI1569_n1 sn14 XI1569_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1569_MN1 (VSS fa136_1 XI1569_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1569_MN3 (XI1569_n2 fa136_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1569_MN4 (VSS sn14 XI1569_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1569_MN27 (fa208_1 XI1569_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1569_MN10 (XI1569_n4 fa136_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1569_MN11 (XI1569_n5 sn14 XI1569_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1569_MN11_1 (XI1569_n4 sn14 XI1569_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1569_MN10_1 (VSS fa136_1 XI1569_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1569_MN6 (XI1569_n3 fa136_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1569_MN7 (VSS sn14 XI1569_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1569_MN8 (XI1569_n3 pp15_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1569_MN9 (XI1569_sn XI1569_con XI1569_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1569_MN12_1 (XI1569_n5 pp15_31 XI1569_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1608_MN12 (XI1608_sn fa136_0 XI1608_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1608_MN25 (fa247_0 XI1608_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1608_MN5 (XI1608_con fa136_0 XI1608_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1608_MN2 (XI1608_n1 fa135_1 XI1608_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1608_MN1 (VSS fa207_1 XI1608_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1608_MN3 (XI1608_n2 fa207_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1608_MN4 (VSS fa135_1 XI1608_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1608_MN27 (fa247_1 XI1608_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1608_MN10 (XI1608_n4 fa207_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1608_MN11 (XI1608_n5 fa135_1 XI1608_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1608_MN11_1 (XI1608_n4 fa135_1 XI1608_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1608_MN10_1 (VSS fa207_1 XI1608_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1608_MN6 (XI1608_n3 fa207_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1608_MN7 (VSS fa135_1 XI1608_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1608_MN8 (XI1608_n3 fa136_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1608_MN9 (XI1608_sn XI1608_con XI1608_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1608_MN12_1 (XI1608_n5 fa136_0 XI1608_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1421_MN12 (XI1421_sn pp14_1 XI1421_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1421_MN25 (fa60_0 XI1421_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1421_MN5 (XI1421_con pp14_1 XI1421_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1421_MN2 (XI1421_n1 pp13_3 XI1421_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1421_MN1 (VSS pp12_5 XI1421_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1421_MN3 (XI1421_n2 pp12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1421_MN4 (VSS pp13_3 XI1421_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1421_MN27 (fa60_1 XI1421_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1421_MN10 (XI1421_n4 pp12_5 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1421_MN11 (XI1421_n5 pp13_3 XI1421_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1421_MN11_1 (XI1421_n4 pp13_3 XI1421_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1421_MN10_1 (VSS pp12_5 XI1421_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1421_MN6 (XI1421_n3 pp12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1421_MN7 (VSS pp13_3 XI1421_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1421_MN8 (XI1421_n3 pp14_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1421_MN9 (XI1421_sn XI1421_con XI1421_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1421_MN12_1 (XI1421_n5 pp14_1 XI1421_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1417_MN12 (XI1417_sn pp14_0 XI1417_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1417_MN25 (fa56_0 XI1417_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1417_MN5 (XI1417_con pp14_0 XI1417_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1417_MN2 (XI1417_n1 pp13_2 XI1417_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1417_MN1 (VSS pp12_4 XI1417_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1417_MN3 (XI1417_n2 pp12_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1417_MN4 (VSS pp13_2 XI1417_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1417_MN27 (fa56_1 XI1417_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1417_MN10 (XI1417_n4 pp12_4 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1417_MN11 (XI1417_n5 pp13_2 XI1417_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1417_MN11_1 (XI1417_n4 pp13_2 XI1417_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1417_MN10_1 (VSS pp12_4 XI1417_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1417_MN6 (XI1417_n3 pp12_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1417_MN7 (VSS pp13_2 XI1417_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1417_MN8 (XI1417_n3 pp14_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1417_MN9 (XI1417_sn XI1417_con XI1417_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1417_MN12_1 (XI1417_n5 pp14_0 XI1417_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1609_MN12 (XI1609_sn pp15_32 XI1609_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1609_MN25 (fa248_0 XI1609_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1609_MN5 (XI1609_con pp15_32 XI1609_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1609_MN2 (XI1609_n1 VDD XI1609_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1609_MN1 (VSS fa208_1 XI1609_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1609_MN3 (XI1609_n2 fa208_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1609_MN4 (VSS VDD XI1609_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1609_MN27 (fa248_1 XI1609_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1609_MN10 (XI1609_n4 fa208_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1609_MN11 (XI1609_n5 VDD XI1609_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1609_MN11_1 (XI1609_n4 VDD XI1609_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1609_MN10_1 (VSS fa208_1 XI1609_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1609_MN6 (XI1609_n3 fa208_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1609_MN7 (VSS VDD XI1609_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1609_MN8 (XI1609_n3 pp15_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1609_MN9 (XI1609_sn XI1609_con XI1609_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1609_MN12_1 (XI1609_n5 pp15_32 XI1609_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1521_MN12 (XI1521_sn fa49_0 XI1521_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1521_MN25 (fa160_0 XI1521_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1521_MN5 (XI1521_con fa49_0 XI1521_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1521_MN2 (XI1521_n1 cm48_0 XI1521_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1521_MN1 (VSS cm47_0 XI1521_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1521_MN3 (XI1521_n2 cm47_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1521_MN4 (VSS cm48_0 XI1521_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1521_MN27 (fa160_1 XI1521_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1521_MN10 (XI1521_n4 cm47_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1521_MN11 (XI1521_n5 cm48_0 XI1521_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1521_MN11_1 (XI1521_n4 cm48_0 XI1521_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1521_MN10_1 (VSS cm47_0 XI1521_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1521_MN6 (XI1521_n3 cm47_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1521_MN7 (VSS cm48_0 XI1521_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1521_MN8 (XI1521_n3 fa49_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1521_MN9 (XI1521_sn XI1521_con XI1521_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1521_MN12_1 (XI1521_n5 fa49_0 XI1521_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1410_MN12 (XI1410_sn B_27_b3_5 XI1410_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1410_MN25 (fa49_0 XI1410_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1410_MN5 (XI1410_con B_27_b3_5 XI1410_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1410_MN2 (XI1410_n1 pp13_0 XI1410_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1410_MN1 (VSS pp12_2 XI1410_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1410_MN3 (XI1410_n2 pp12_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1410_MN4 (VSS pp13_0 XI1410_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1410_MN27 (fa49_1 XI1410_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1410_MN10 (XI1410_n4 pp12_2 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1410_MN11 (XI1410_n5 pp13_0 XI1410_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1410_MN11_1 (XI1410_n4 pp13_0 XI1410_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1410_MN10_1 (VSS pp12_2 XI1410_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1410_MN6 (XI1410_n3 pp12_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1410_MN7 (VSS pp13_0 XI1410_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1410_MN8 (XI1410_n3 B_27_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1410_MN9 (XI1410_sn XI1410_con XI1410_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1410_MN12_1 (XI1410_n5 B_27_b3_5 XI1410_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1519_MN12 (XI1519_sn pp12_1 XI1519_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1519_MN25 (fa158_0 XI1519_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1519_MN5 (XI1519_con pp12_1 XI1519_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1519_MN2 (XI1519_n1 cm45_0 XI1519_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1519_MN1 (VSS cm44_0 XI1519_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1519_MN3 (XI1519_n2 cm44_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1519_MN4 (VSS cm45_0 XI1519_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1519_MN27 (fa158_1 XI1519_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1519_MN10 (XI1519_n4 cm44_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1519_MN11 (XI1519_n5 cm45_0 XI1519_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1519_MN11_1 (XI1519_n4 cm45_0 XI1519_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1519_MN10_1 (VSS cm44_0 XI1519_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1519_MN6 (XI1519_n3 cm44_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1519_MN7 (VSS cm45_0 XI1519_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1519_MN8 (XI1519_n3 pp12_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1519_MN9 (XI1519_sn XI1519_con XI1519_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1519_MN12_1 (XI1519_n5 pp12_1 XI1519_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1517_MN12 (XI1517_sn pp12_0 XI1517_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1517_MN25 (fa156_0 XI1517_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1517_MN5 (XI1517_con pp12_0 XI1517_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1517_MN2 (XI1517_n1 cm42_0 XI1517_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1517_MN1 (VSS cm41_0 XI1517_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1517_MN3 (XI1517_n2 cm41_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1517_MN4 (VSS cm42_0 XI1517_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1517_MN27 (fa156_1 XI1517_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1517_MN10 (XI1517_n4 cm41_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1517_MN11 (XI1517_n5 cm42_0 XI1517_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1517_MN11_1 (XI1517_n4 cm42_0 XI1517_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1517_MN10_1 (VSS cm41_0 XI1517_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1517_MN6 (XI1517_n3 cm41_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1517_MN7 (VSS cm42_0 XI1517_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1517_MN8 (XI1517_n3 pp12_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1517_MN9 (XI1517_sn XI1517_con XI1517_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1517_MN12_1 (XI1517_n5 pp12_0 XI1517_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1394_MN12 (XI1394_sn pp10_1 XI1394_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1394_MN25 (fa33_0 XI1394_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1394_MN5 (XI1394_con pp10_1 XI1394_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1394_MN2 (XI1394_n1 pp9_3 XI1394_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1394_MN1 (VSS pp8_5 XI1394_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1394_MN3 (XI1394_n2 pp8_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1394_MN4 (VSS pp9_3 XI1394_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1394_MN27 (fa33_1 XI1394_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1394_MN10 (XI1394_n4 pp8_5 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1394_MN11 (XI1394_n5 pp9_3 XI1394_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1394_MN11_1 (XI1394_n4 pp9_3 XI1394_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1394_MN10_1 (VSS pp8_5 XI1394_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1394_MN6 (XI1394_n3 pp8_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1394_MN7 (VSS pp9_3 XI1394_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1394_MN8 (XI1394_n3 pp10_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1394_MN9 (XI1394_sn XI1394_con XI1394_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1394_MN12_1 (XI1394_n5 pp10_1 XI1394_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1391_MN12 (XI1391_sn pp10_0 XI1391_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1391_MN25 (fa30_0 XI1391_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1391_MN5 (XI1391_con pp10_0 XI1391_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1391_MN2 (XI1391_n1 pp9_2 XI1391_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1391_MN1 (VSS pp8_4 XI1391_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1391_MN3 (XI1391_n2 pp8_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1391_MN4 (VSS pp9_2 XI1391_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1391_MN27 (fa30_1 XI1391_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1391_MN10 (XI1391_n4 pp8_4 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1391_MN11 (XI1391_n5 pp9_2 XI1391_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1391_MN11_1 (XI1391_n4 pp9_2 XI1391_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1391_MN10_1 (VSS pp8_4 XI1391_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1391_MN6 (XI1391_n3 pp8_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1391_MN7 (VSS pp9_2 XI1391_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1391_MN8 (XI1391_n3 pp10_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1391_MN9 (XI1391_sn XI1391_con XI1391_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1391_MN12_1 (XI1391_n5 pp10_0 XI1391_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1511_MN12 (XI1511_sn pp9_1 XI1511_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1511_MN25 (fa150_0 XI1511_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1511_MN5 (XI1511_con pp9_1 XI1511_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1511_MN2 (XI1511_n1 pp8_3 XI1511_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1511_MN1 (VSS cm27_0 XI1511_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1511_MN3 (XI1511_n2 cm27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1511_MN4 (VSS pp8_3 XI1511_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1511_MN27 (fa150_1 XI1511_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1511_MN10 (XI1511_n4 cm27_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1511_MN11 (XI1511_n5 pp8_3 XI1511_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1511_MN11_1 (XI1511_n4 pp8_3 XI1511_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1511_MN10_1 (VSS cm27_0 XI1511_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1511_MN6 (XI1511_n3 cm27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1511_MN7 (VSS pp8_3 XI1511_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1511_MN8 (XI1511_n3 pp9_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1511_MN9 (XI1511_sn XI1511_con XI1511_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1511_MN12_1 (XI1511_n5 pp9_1 XI1511_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1386_MN12 (XI1386_sn B_19_b3_5 XI1386_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1386_MN25 (fa25_0 XI1386_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1386_MN5 (XI1386_con B_19_b3_5 XI1386_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1386_MN2 (XI1386_n1 pp9_0 XI1386_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1386_MN1 (VSS pp8_2 XI1386_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1386_MN3 (XI1386_n2 pp8_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1386_MN4 (VSS pp9_0 XI1386_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1386_MN27 (fa25_1 XI1386_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1386_MN10 (XI1386_n4 pp8_2 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1386_MN11 (XI1386_n5 pp9_0 XI1386_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1386_MN11_1 (XI1386_n4 pp9_0 XI1386_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1386_MN10_1 (VSS pp8_2 XI1386_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1386_MN6 (XI1386_n3 pp8_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1386_MN7 (VSS pp9_0 XI1386_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1386_MN8 (XI1386_n3 B_19_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1386_MN9 (XI1386_sn XI1386_con XI1386_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1386_MN12_1 (XI1386_n5 B_19_b3_5 XI1386_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1574_MN12 (XI1574_sn fa150_0 XI1574_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1574_MN25 (fa213_0 XI1574_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1574_MN5 (XI1574_con fa150_0 XI1574_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1574_MN2 (XI1574_n1 cm149_0 XI1574_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1574_MN1 (VSS cm148_1 XI1574_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1574_MN3 (XI1574_n2 cm148_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1574_MN4 (VSS cm149_0 XI1574_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1574_MN27 (fa213_1 XI1574_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1574_MN10 (XI1574_n4 cm148_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1574_MN11 (XI1574_n5 cm149_0 XI1574_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1574_MN11_1 (XI1574_n4 cm149_0 XI1574_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1574_MN10_1 (VSS cm148_1 XI1574_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1574_MN6 (XI1574_n3 cm148_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1574_MN7 (VSS cm149_0 XI1574_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1574_MN8 (XI1574_n3 fa150_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1574_MN9 (XI1574_sn XI1574_con XI1574_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1574_MN12_1 (XI1574_n5 fa150_0 XI1574_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1573_MN12 (XI1573_sn fa25_0 XI1573_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1573_MN25 (fa212_0 XI1573_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1573_MN5 (XI1573_con fa25_0 XI1573_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1573_MN2 (XI1573_n1 cm148_0 XI1573_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1573_MN1 (VSS cm147_1 XI1573_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1573_MN3 (XI1573_n2 cm147_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1573_MN4 (VSS cm148_0 XI1573_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1573_MN27 (fa212_1 XI1573_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1573_MN10 (XI1573_n4 cm147_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1573_MN11 (XI1573_n5 cm148_0 XI1573_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1573_MN11_1 (XI1573_n4 cm148_0 XI1573_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1573_MN10_1 (VSS cm147_1 XI1573_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1573_MN6 (XI1573_n3 cm147_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1573_MN7 (VSS cm148_0 XI1573_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1573_MN8 (XI1573_n3 fa25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1573_MN9 (XI1573_sn XI1573_con XI1573_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1573_MN12_1 (XI1573_n5 fa25_0 XI1573_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1571_MN12 (XI1571_sn pp8_0 XI1571_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1571_MN25 (fa210_0 XI1571_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1571_MN5 (XI1571_con pp8_0 XI1571_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1571_MN2 (XI1571_n1 cm146_0 XI1571_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1571_MN1 (VSS cm145_1 XI1571_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1571_MN3 (XI1571_n2 cm145_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1571_MN4 (VSS cm146_0 XI1571_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1571_MN27 (fa210_1 XI1571_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1571_MN10 (XI1571_n4 cm145_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1571_MN11 (XI1571_n5 cm146_0 XI1571_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1571_MN11_1 (XI1571_n4 cm146_0 XI1571_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1571_MN10_1 (VSS cm145_1 XI1571_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1571_MN6 (XI1571_n3 cm145_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1571_MN7 (VSS cm146_0 XI1571_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1571_MN8 (XI1571_n3 pp8_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1571_MN9 (XI1571_sn XI1571_con XI1571_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1571_MN12_1 (XI1571_n5 pp8_0 XI1571_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1572_MN12 (XI1572_sn pp8_1 XI1572_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1572_MN25 (fa211_0 XI1572_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1572_MN5 (XI1572_con pp8_1 XI1572_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1572_MN2 (XI1572_n1 cm147_0 XI1572_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1572_MN1 (VSS cm146_1 XI1572_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1572_MN3 (XI1572_n2 cm146_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1572_MN4 (VSS cm147_0 XI1572_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1572_MN27 (fa211_1 XI1572_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1572_MN10 (XI1572_n4 cm146_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1572_MN11 (XI1572_n5 cm147_0 XI1572_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1572_MN11_1 (XI1572_n4 cm147_0 XI1572_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1572_MN10_1 (VSS cm146_1 XI1572_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1572_MN6 (XI1572_n3 cm146_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1572_MN7 (VSS cm147_0 XI1572_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1572_MN8 (XI1572_n3 pp8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1572_MN9 (XI1572_sn XI1572_con XI1572_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1572_MN12_1 (XI1572_n5 pp8_1 XI1572_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1362_MN12 (XI1362_sn B_3_b3_5 XI1362_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1362_MN25 (fa1_0 XI1362_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1362_MN5 (XI1362_con B_3_b3_5 XI1362_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1362_MN2 (XI1362_n1 pp1_0 XI1362_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1362_MN1 (VSS pp0_2 XI1362_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1362_MN3 (XI1362_n2 pp0_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1362_MN4 (VSS pp1_0 XI1362_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1362_MN27 (fa1_1 XI1362_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1362_MN10 (XI1362_n4 pp0_2 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1362_MN11 (XI1362_n5 pp1_0 XI1362_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1362_MN11_1 (XI1362_n4 pp1_0 XI1362_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1362_MN10_1 (VSS pp0_2 XI1362_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1362_MN6 (XI1362_n3 pp0_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1362_MN7 (VSS pp1_0 XI1362_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1362_MN8 (XI1362_n3 B_3_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1362_MN9 (XI1362_sn XI1362_con XI1362_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1362_MN12_1 (XI1362_n5 B_3_b3_5 XI1362_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1498_MN12 (XI1498_sn pp1_1 XI1498_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1498_MN25 (fa137_0 XI1498_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1498_MN5 (XI1498_con pp1_1 XI1498_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1498_MN2 (XI1498_n1 pp0_3 XI1498_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1498_MN1 (VSS fa1_1 XI1498_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1498_MN3 (XI1498_n2 fa1_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1498_MN4 (VSS pp0_3 XI1498_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1498_MN27 (fa137_1 XI1498_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1498_MN10 (XI1498_n4 fa1_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1498_MN11 (XI1498_n5 pp0_3 XI1498_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1498_MN11_1 (XI1498_n4 pp0_3 XI1498_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1498_MN10_1 (VSS fa1_1 XI1498_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1498_MN6 (XI1498_n3 fa1_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1498_MN7 (VSS pp0_3 XI1498_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1498_MN8 (XI1498_n3 pp1_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1498_MN9 (XI1498_sn XI1498_con XI1498_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1498_MN12_1 (XI1498_n5 pp1_1 XI1498_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1570_MN12 (XI1570_sn B_5_b3_5 XI1570_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1570_MN25 (fa209_0 XI1570_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1570_MN5 (XI1570_con B_5_b3_5 XI1570_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1570_MN2 (XI1570_n1 fa2_0 XI1570_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1570_MN1 (VSS fa137_1 XI1570_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1570_MN3 (XI1570_n2 fa137_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1570_MN4 (VSS fa2_0 XI1570_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1570_MN27 (fa209_1 XI1570_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1570_MN10 (XI1570_n4 fa137_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1570_MN11 (XI1570_n5 fa2_0 XI1570_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1570_MN11_1 (XI1570_n4 fa2_0 XI1570_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1570_MN10_1 (VSS fa137_1 XI1570_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1570_MN6 (XI1570_n3 fa137_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1570_MN7 (VSS fa2_0 XI1570_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1570_MN8 (XI1570_n3 B_5_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1570_MN9 (XI1570_sn XI1570_con XI1570_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1570_MN12_1 (XI1570_n5 B_5_b3_5 XI1570_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1375_MN12 (XI1375_sn pp6_1 XI1375_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1375_MN25 (fa14_0 XI1375_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1375_MN5 (XI1375_con pp6_1 XI1375_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1375_MN2 (XI1375_n1 pp5_3 XI1375_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1375_MN1 (VSS pp4_5 XI1375_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1375_MN3 (XI1375_n2 pp4_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1375_MN4 (VSS pp5_3 XI1375_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1375_MN27 (fa14_1 XI1375_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1375_MN10 (XI1375_n4 pp4_5 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1375_MN11 (XI1375_n5 pp5_3 XI1375_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1375_MN11_1 (XI1375_n4 pp5_3 XI1375_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1375_MN10_1 (VSS pp4_5 XI1375_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1375_MN6 (XI1375_n3 pp4_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1375_MN7 (VSS pp5_3 XI1375_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1375_MN8 (XI1375_n3 pp6_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1375_MN9 (XI1375_sn XI1375_con XI1375_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1375_MN12_1 (XI1375_n5 pp6_1 XI1375_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1363_MN12 (XI1363_sn pp2_0 XI1363_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1363_MN25 (fa2_0 XI1363_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1363_MN5 (XI1363_con pp2_0 XI1363_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1363_MN2 (XI1363_n1 pp1_2 XI1363_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1363_MN1 (VSS pp0_4 XI1363_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1363_MN3 (XI1363_n2 pp0_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1363_MN4 (VSS pp1_2 XI1363_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1363_MN27 (fa2_1 XI1363_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1363_MN10 (XI1363_n4 pp0_4 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1363_MN11 (XI1363_n5 pp1_2 XI1363_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1363_MN11_1 (XI1363_n4 pp1_2 XI1363_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1363_MN10_1 (VSS pp0_4 XI1363_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1363_MN6 (XI1363_n3 pp0_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1363_MN7 (VSS pp1_2 XI1363_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1363_MN8 (XI1363_n3 pp2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1363_MN9 (XI1363_sn XI1363_con XI1363_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1363_MN12_1 (XI1363_n5 pp2_0 XI1363_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1610_MN12 (XI1610_sn fa3_0 XI1610_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1610_MN25 (fa249_0 XI1610_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1610_MN5 (XI1610_con fa3_0 XI1610_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1610_MN2 (XI1610_n1 fa2_1 XI1610_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1610_MN1 (VSS fa209_1 XI1610_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1610_MN3 (XI1610_n2 fa209_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1610_MN4 (VSS fa2_1 XI1610_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1610_MN27 (fa249_1 XI1610_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1610_MN10 (XI1610_n4 fa209_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1610_MN11 (XI1610_n5 fa2_1 XI1610_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1610_MN11_1 (XI1610_n4 fa2_1 XI1610_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1610_MN10_1 (VSS fa209_1 XI1610_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1610_MN6 (XI1610_n3 fa209_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1610_MN7 (VSS fa2_1 XI1610_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1610_MN8 (XI1610_n3 fa3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1610_MN9 (XI1610_sn XI1610_con XI1610_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1610_MN12_1 (XI1610_n5 fa3_0 XI1610_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1373_MN12 (XI1373_sn pp6_0 XI1373_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1373_MN25 (fa12_0 XI1373_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1373_MN5 (XI1373_con pp6_0 XI1373_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1373_MN2 (XI1373_n1 pp5_2 XI1373_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1373_MN1 (VSS pp4_4 XI1373_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1373_MN3 (XI1373_n2 pp4_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1373_MN4 (VSS pp5_2 XI1373_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1373_MN27 (fa12_1 XI1373_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1373_MN10 (XI1373_n4 pp4_4 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1373_MN11 (XI1373_n5 pp5_2 XI1373_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1373_MN11_1 (XI1373_n4 pp5_2 XI1373_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1373_MN10_1 (VSS pp4_4 XI1373_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1373_MN6 (XI1373_n3 pp4_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1373_MN7 (VSS pp5_2 XI1373_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1373_MN8 (XI1373_n3 pp6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1373_MN9 (XI1373_sn XI1373_con XI1373_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1373_MN12_1 (XI1373_n5 pp6_0 XI1373_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1364_MN12 (XI1364_sn pp2_1 XI1364_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1364_MN25 (fa3_0 XI1364_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1364_MN5 (XI1364_con pp2_1 XI1364_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1364_MN2 (XI1364_n1 pp1_3 XI1364_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1364_MN1 (VSS pp0_5 XI1364_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1364_MN3 (XI1364_n2 pp0_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1364_MN4 (VSS pp1_3 XI1364_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1364_MN27 (fa3_1 XI1364_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1364_MN10 (XI1364_n4 pp0_5 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1364_MN11 (XI1364_n5 pp1_3 XI1364_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1364_MN11_1 (XI1364_n4 pp1_3 XI1364_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1364_MN10_1 (VSS pp0_5 XI1364_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1364_MN6 (XI1364_n3 pp0_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1364_MN7 (VSS pp1_3 XI1364_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1364_MN8 (XI1364_n3 pp2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1364_MN9 (XI1364_sn XI1364_con XI1364_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1364_MN12_1 (XI1364_n5 pp2_1 XI1364_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1370_MN12 (XI1370_sn B_11_b3_5 XI1370_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1370_MN25 (fa9_0 XI1370_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1370_MN5 (XI1370_con B_11_b3_5 XI1370_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1370_MN2 (XI1370_n1 pp5_0 XI1370_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1370_MN1 (VSS pp4_2 XI1370_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1370_MN3 (XI1370_n2 pp4_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1370_MN4 (VSS pp5_0 XI1370_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1370_MN27 (fa9_1 XI1370_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1370_MN10 (XI1370_n4 pp4_2 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1370_MN11 (XI1370_n5 pp5_0 XI1370_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1370_MN11_1 (XI1370_n4 pp5_0 XI1370_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1370_MN10_1 (VSS pp4_2 XI1370_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1370_MN6 (XI1370_n3 pp4_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1370_MN7 (VSS pp5_0 XI1370_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1370_MN8 (XI1370_n3 B_11_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1370_MN9 (XI1370_sn XI1370_con XI1370_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1370_MN12_1 (XI1370_n5 B_11_b3_5 XI1370_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1501_MN12 (XI1501_sn fa9_0 XI1501_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1501_MN25 (fa140_0 XI1501_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1501_MN5 (XI1501_con fa9_0 XI1501_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1501_MN2 (XI1501_n1 cm8_0 XI1501_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1501_MN1 (VSS cm7_1 XI1501_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1501_MN3 (XI1501_n2 cm7_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1501_MN4 (VSS cm8_0 XI1501_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1501_MN27 (fa140_1 XI1501_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1501_MN10 (XI1501_n4 cm7_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1501_MN11 (XI1501_n5 cm8_0 XI1501_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1501_MN11_1 (XI1501_n4 cm8_0 XI1501_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1501_MN10_1 (VSS cm7_1 XI1501_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1501_MN6 (XI1501_n3 cm7_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1501_MN7 (VSS cm8_0 XI1501_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1501_MN8 (XI1501_n3 fa9_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1501_MN9 (XI1501_sn XI1501_con XI1501_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1501_MN12_1 (XI1501_n5 fa9_0 XI1501_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1500_MN12 (XI1500_sn pp4_1 XI1500_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1500_MN25 (fa139_0 XI1500_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1500_MN5 (XI1500_con pp4_1 XI1500_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1500_MN2 (XI1500_n1 cm7_0 XI1500_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1500_MN1 (VSS cm6_1 XI1500_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1500_MN3 (XI1500_n2 cm6_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1500_MN4 (VSS cm7_0 XI1500_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1500_MN27 (fa139_1 XI1500_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1500_MN10 (XI1500_n4 cm6_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1500_MN11 (XI1500_n5 cm7_0 XI1500_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1500_MN11_1 (XI1500_n4 cm7_0 XI1500_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1500_MN10_1 (VSS cm6_1 XI1500_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1500_MN6 (XI1500_n3 cm6_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1500_MN7 (VSS cm7_0 XI1500_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1500_MN8 (XI1500_n3 pp4_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1500_MN9 (XI1500_sn XI1500_con XI1500_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1500_MN12_1 (XI1500_n5 pp4_1 XI1500_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1499_MN12 (XI1499_sn pp4_0 XI1499_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1499_MN25 (fa138_0 XI1499_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1499_MN5 (XI1499_con pp4_0 XI1499_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1499_MN2 (XI1499_n1 cm6_0 XI1499_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1499_MN1 (VSS cm5_1 XI1499_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1499_MN3 (XI1499_n2 cm5_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1499_MN4 (VSS cm6_0 XI1499_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1499_MN27 (fa138_1 XI1499_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1499_MN10 (XI1499_n4 cm5_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.67999u ps=1.15999u
    I_MXI1499_MN11 (XI1499_n5 cm6_0 XI1499_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1499_MN11_1 (XI1499_n4 cm6_0 XI1499_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1499_MN10_1 (VSS cm5_1 XI1499_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1499_MN6 (XI1499_n3 cm5_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1499_MN7 (VSS cm6_0 XI1499_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.21999u ps=0.67999u
    I_MXI1499_MN8 (XI1499_n3 pp4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.67999u ps=1.21999u
    I_MXI1499_MN9 (XI1499_sn XI1499_con XI1499_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1499_MN12_1 (XI1499_n5 pp4_0 XI1499_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1660_I170_XG_MN2 (XI1660_I170_XG_n1 I1660_gn40 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I170_XG_MN0 (I1660_G40_39 I1660_pn40 XI1660_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I170_XG_MN1 (XI1660_I170_XG_n1 I1660_gn39 I1660_G40_39 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I171_XG_MN2 (XI1660_I171_XG_n1 I1660_gn41 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I171_XG_MN0 (I1660_G41_40 I1660_pn41 XI1660_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I171_XG_MN1 (XI1660_I171_XG_n1 I1660_gn40 I1660_G41_40 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I172_XG_MN2 (XI1660_I172_XG_n1 I1660_gn42 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I172_XG_MN0 (I1660_G42_41 I1660_pn42 XI1660_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I172_XG_MN1 (XI1660_I172_XG_n1 I1660_gn41 I1660_G42_41 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I173_XG_MN2 (XI1660_I173_XG_n1 I1660_gn43 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I173_XG_MN0 (I1660_G43_42 I1660_pn43 XI1660_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I173_XG_MN1 (XI1660_I173_XG_n1 I1660_gn42 I1660_G43_42 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I174_XG_MN2 (XI1660_I174_XG_n1 I1660_gn44 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I174_XG_MN0 (I1660_G44_43 I1660_pn44 XI1660_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I174_XG_MN1 (XI1660_I174_XG_n1 I1660_gn43 I1660_G44_43 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I175_XG_MN2 (XI1660_I175_XG_n1 I1660_gn45 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I175_XG_MN0 (I1660_G45_44 I1660_pn45 XI1660_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I175_XG_MN1 (XI1660_I175_XG_n1 I1660_gn44 I1660_G45_44 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I176_XG_MN2 (XI1660_I176_XG_n1 I1660_gn46 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I176_XG_MN0 (I1660_G46_45 I1660_pn46 XI1660_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I176_XG_MN1 (XI1660_I176_XG_n1 I1660_gn45 I1660_G46_45 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I168_XG_MN2 (XI1660_I168_XG_n1 I1660_gn38 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I168_XG_MN0 (I1660_G38_37 I1660_pn38 XI1660_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I168_XG_MN1 (XI1660_I168_XG_n1 I1660_gn37 I1660_G38_37 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I169_XG_MN2 (XI1660_I169_XG_n1 I1660_gn39 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I169_XG_MN0 (I1660_G39_38 I1660_pn39 XI1660_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I169_XG_MN1 (XI1660_I169_XG_n1 I1660_gn38 I1660_G39_38 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I177_XG_MN2 (XI1660_I177_XG_n1 I1660_gn47 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I177_XG_MN0 (I1660_G47_46 I1660_pn47 XI1660_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I177_XG_MN1 (XI1660_I177_XG_n1 I1660_gn46 I1660_G47_46 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I178_XG_MN2 (XI1660_I178_XG_n1 I1660_gn48 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I178_XG_MN0 (I1660_G48_47 I1660_pn48 XI1660_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I178_XG_MN1 (XI1660_I178_XG_n1 I1660_gn47 I1660_G48_47 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I179_XG_MN2 (XI1660_I179_XG_n1 I1660_gn49 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I179_XG_MN0 (I1660_G49_48 I1660_pn49 XI1660_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I179_XG_MN1 (XI1660_I179_XG_n1 I1660_gn48 I1660_G49_48 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I180_XG_MN2 (XI1660_I180_XG_n1 I1660_gn50 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I180_XG_MN0 (I1660_G50_49 I1660_pn50 XI1660_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I180_XG_MN1 (XI1660_I180_XG_n1 I1660_gn49 I1660_G50_49 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I182_XG_MN2 (XI1660_I182_XG_n1 I1660_gn52 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I182_XG_MN0 (I1660_G52_51 I1660_pn52 XI1660_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I182_XG_MN1 (XI1660_I182_XG_n1 I1660_gn51 I1660_G52_51 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I183_XG_MN2 (XI1660_I183_XG_n1 I1660_gn53 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I183_XG_MN0 (I1660_G53_52 I1660_pn53 XI1660_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I183_XG_MN1 (XI1660_I183_XG_n1 I1660_gn52 I1660_G53_52 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I184_XG_MN2 (XI1660_I184_XG_n1 I1660_gn54 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I184_XG_MN0 (I1660_G54_53 I1660_pn54 XI1660_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I184_XG_MN1 (XI1660_I184_XG_n1 I1660_gn53 I1660_G54_53 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I185_XG_MN2 (XI1660_I185_XG_n1 I1660_gn55 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I185_XG_MN0 (I1660_G55_54 I1660_pn55 XI1660_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I185_XG_MN1 (XI1660_I185_XG_n1 I1660_gn54 I1660_G55_54 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I166_XG_MN2 (XI1660_I166_XG_n1 I1660_gn36 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I166_XG_MN0 (I1660_G36_35 I1660_pn36 XI1660_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I166_XG_MN1 (XI1660_I166_XG_n1 I1660_gn35 I1660_G36_35 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I167_XG_MN2 (XI1660_I167_XG_n1 I1660_gn37 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I167_XG_MN0 (I1660_G37_36 I1660_pn37 XI1660_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I167_XG_MN1 (XI1660_I167_XG_n1 I1660_gn36 I1660_G37_36 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I297_XG_MN2 (XI1660_I297_XG_n1 I1660_G44_41n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I297_XG_MN0 (I1660_G44_37 I1660_P44_41n XI1660_I297_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I297_XG_MN1 (XI1660_I297_XG_n1 I1660_G40_37n I1660_G44_37 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I301_XG_MN2 (XI1660_I301_XG_n1 I1660_G48_45n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I301_XG_MN0 (I1660_G48_41 I1660_P48_45n XI1660_I301_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I301_XG_MN1 (XI1660_I301_XG_n1 I1660_G44_41n I1660_G48_41 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I181_XG_MN2 (XI1660_I181_XG_n1 I1660_gn51 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I181_XG_MN0 (I1660_G51_50 I1660_pn51 XI1660_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I181_XG_MN1 (XI1660_I181_XG_n1 I1660_gn50 I1660_G51_50 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I188_XG_MN2 (XI1660_I188_XG_n1 I1660_gn58 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I188_XG_MN0 (I1660_G58_57 I1660_pn58 XI1660_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I188_XG_MN1 (XI1660_I188_XG_n1 I1660_gn57 I1660_G58_57 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I187_XG_MN2 (XI1660_I187_XG_n1 I1660_gn57 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I187_XG_MN0 (I1660_G57_56 I1660_pn57 XI1660_I187_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I187_XG_MN1 (XI1660_I187_XG_n1 I1660_gn56 I1660_G57_56 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I186_XG_MN2 (XI1660_I186_XG_n1 I1660_gn56 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I186_XG_MN0 (I1660_G56_55 I1660_pn56 XI1660_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I186_XG_MN1 (XI1660_I186_XG_n1 I1660_gn55 I1660_G56_55 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I165_XG_MN2 (XI1660_I165_XG_n1 I1660_gn35 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I165_XG_MN0 (I1660_G35_34 I1660_pn35 XI1660_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I165_XG_MN1 (XI1660_I165_XG_n1 I1660_gn34 I1660_G35_34 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I305_XG_MN2 (XI1660_I305_XG_n1 I1660_G52_49n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I305_XG_MN0 (I1660_G52_45 I1660_P52_49n XI1660_I305_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I305_XG_MN1 (XI1660_I305_XG_n1 I1660_G48_45n I1660_G52_45 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I309_XG_MN2 (XI1660_I309_XG_n1 I1660_G56_53n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I309_XG_MN0 (I1660_G56_49 I1660_P56_53n XI1660_I309_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I309_XG_MN1 (XI1660_I309_XG_n1 I1660_G52_49n I1660_G56_49 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I307_XG_MN2 (XI1660_I307_XG_n1 I1660_G54_51n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I307_XG_MN0 (I1660_G54_47 I1660_P54_51n XI1660_I307_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I307_XG_MN1 (XI1660_I307_XG_n1 I1660_G50_47n I1660_G54_47 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I313_XG_MN2 (XI1660_I313_XG_n1 I1660_G60_57n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I313_XG_MN0 (I1660_G60_53 I1660_P60_57n XI1660_I313_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I313_XG_MN1 (XI1660_I313_XG_n1 I1660_G56_53n I1660_G60_53 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I190_XG_MN2 (XI1660_I190_XG_n1 I1660_gn60 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I190_XG_MN0 (I1660_G60_59 I1660_pn60 XI1660_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I190_XG_MN1 (XI1660_I190_XG_n1 I1660_gn59 I1660_G60_59 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I189_XG_MN2 (XI1660_I189_XG_n1 I1660_gn59 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I189_XG_MN0 (I1660_G59_58 I1660_pn59 XI1660_I189_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I189_XG_MN1 (XI1660_I189_XG_n1 I1660_gn58 I1660_G59_58 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I164_XG_MN2 (XI1660_I164_XG_n1 I1660_gn34 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I164_XG_MN0 (I1660_G34_33 I1660_pn34 XI1660_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I164_XG_MN1 (XI1660_I164_XG_n1 I1660_gn33 I1660_G34_33 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I293_XG_MN2 (XI1660_I293_XG_n1 I1660_G40_37n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I293_XG_MN0 (I1660_G40_33 I1660_P40_37n XI1660_I293_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I293_XG_MN1 (XI1660_I293_XG_n1 I1660_G36_33n I1660_G40_33 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I291_XG_MN2 (XI1660_I291_XG_n1 I1660_G38_35n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I291_XG_MN0 (I1660_G38_31 I1660_P38_35n XI1660_I291_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I291_XG_MN1 (XI1660_I291_XG_n1 I1660_G34_31n I1660_G38_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I295_XG_MN2 (XI1660_I295_XG_n1 I1660_G42_39n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I295_XG_MN0 (I1660_G42_35 I1660_P42_39n XI1660_I295_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I295_XG_MN1 (XI1660_I295_XG_n1 I1660_G38_35n I1660_G42_35 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I299_XG_MN2 (XI1660_I299_XG_n1 I1660_G46_43n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I299_XG_MN0 (I1660_G46_39 I1660_P46_43n XI1660_I299_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I299_XG_MN1 (XI1660_I299_XG_n1 I1660_G42_39n I1660_G46_39 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I303_XG_MN2 (XI1660_I303_XG_n1 I1660_G50_47n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I303_XG_MN0 (I1660_G50_43 I1660_P50_47n XI1660_I303_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I303_XG_MN1 (XI1660_I303_XG_n1 I1660_G46_43n I1660_G50_43 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I311_XG_MN2 (XI1660_I311_XG_n1 I1660_G58_55n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I311_XG_MN0 (I1660_G58_51 I1660_P58_55n XI1660_I311_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I311_XG_MN1 (XI1660_I311_XG_n1 I1660_G54_51n I1660_G58_51 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I191_XG_MN2 (XI1660_I191_XG_n1 I1660_gn61 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I191_XG_MN0 (I1660_G61_60 I1660_pn61 XI1660_I191_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I191_XG_MN1 (XI1660_I191_XG_n1 I1660_gn60 I1660_G61_60 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I192_XG_MN2 (XI1660_I192_XG_n1 I1660_gn62 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I192_XG_MN0 (I1660_G62_61 I1660_pn62 XI1660_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I192_XG_MN1 (XI1660_I192_XG_n1 I1660_gn61 I1660_G62_61 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I162_XG_MN2 (XI1660_I162_XG_n1 I1660_gn32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I162_XG_MN0 (I1660_G32_31 I1660_pn32 XI1660_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I162_XG_MN1 (XI1660_I162_XG_n1 I1660_gn31 I1660_G32_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I163_XG_MN2 (XI1660_I163_XG_n1 I1660_gn33 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I163_XG_MN0 (I1660_G33_32 I1660_pn33 XI1660_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I163_XG_MN1 (XI1660_I163_XG_n1 I1660_gn32 I1660_G33_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I407_XG_MN2 (XI1660_I407_XG_n1 I1660_G44_29n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I407_XG_MN0 (I1660_G44_13 I1660_P44_29n XI1660_I407_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I407_XG_MN1 (XI1660_I407_XG_n1 I1660_G28_13n I1660_G44_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I423_XG_MN2 (XI1660_I423_XG_n1 I1660_G60_45n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I423_XG_MN0 (I1660_G60_29 I1660_P60_45n XI1660_I423_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I423_XG_MN1 (XI1660_I423_XG_n1 I1660_G44_29n I1660_G60_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I425_XG_MN2 (XI1660_I425_XG_n1 I1660_G62_47n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I425_XG_MN0 (I1660_G62_31 I1660_P62_47n XI1660_I425_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I425_XG_MN1 (XI1660_I425_XG_n1 I1660_G46_31n I1660_G62_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I315_XG_MN2 (XI1660_I315_XG_n1 I1660_G62_59n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I315_XG_MN0 (I1660_G62_55 I1660_P62_59n XI1660_I315_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I315_XG_MN1 (XI1660_I315_XG_n1 I1660_G58_55n I1660_G62_55 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I193_XG_MN2 (XI1660_I193_XG_n1 I1660_gn63 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I193_XG_MN0 (I1660_G63_62 I1660_pn63 XI1660_I193_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I193_XG_MN1 (XI1660_I193_XG_n1 I1660_gn62 I1660_G63_62 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I161_XG_MN2 (XI1660_I161_XG_n1 I1660_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I161_XG_MN0 (I1660_G31_30 I1660_pn31 XI1660_I161_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I161_XG_MN1 (XI1660_I161_XG_n1 I1660_gn30 I1660_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I289_XG_MN2 (XI1660_I289_XG_n1 I1660_G36_33n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I289_XG_MN0 (I1660_G36_29 I1660_P36_33n XI1660_I289_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I289_XG_MN1 (XI1660_I289_XG_n1 I1660_G32_29n I1660_G36_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I419_XG_MN2 (XI1660_I419_XG_n1 I1660_G56_41n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I419_XG_MN0 (I1660_G56_25 I1660_P56_41n XI1660_I419_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I419_XG_MN1 (XI1660_I419_XG_n1 I1660_G40_25n I1660_G56_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I409_XG_MN2 (XI1660_I409_XG_n1 I1660_G46_31n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I409_XG_MN0 (I1660_G46_15 I1660_P46_31n XI1660_I409_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I409_XG_MN1 (XI1660_I409_XG_n1 I1660_G30_15n I1660_G46_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I160_XG_MN2 (XI1660_I160_XG_n1 I1660_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I160_XG_MN0 (I1660_G30_29 I1660_pn30 XI1660_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I160_XG_MN1 (XI1660_I160_XG_n1 I1660_gn29 I1660_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I391_XG_MN2 (XI1660_I391_XG_n1 I1660_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I391_XG_MN0 (I1660_G28_0 I1660_P28_13n XI1660_I391_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I391_XG_MN1 (XI1660_I391_XG_n1 I1660_G12_0n I1660_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I287_XG_MN2 (XI1660_I287_XG_n1 I1660_G34_31n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I287_XG_MN0 (I1660_G34_27 I1660_P34_31n XI1660_I287_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I287_XG_MN1 (XI1660_I287_XG_n1 I1660_G30_27n I1660_G34_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I417_XG_MN2 (XI1660_I417_XG_n1 I1660_G54_39n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I417_XG_MN0 (I1660_G54_23 I1660_P54_39n XI1660_I417_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I417_XG_MN1 (XI1660_I417_XG_n1 I1660_G38_23n I1660_G54_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I421_XG_MN2 (XI1660_I421_XG_n1 I1660_G58_43n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I421_XG_MN0 (I1660_G58_27 I1660_P58_43n XI1660_I421_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I421_XG_MN1 (XI1660_I421_XG_n1 I1660_G42_27n I1660_G58_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I158_XG_MN2 (XI1660_I158_XG_n1 I1660_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I158_XG_MN0 (I1660_G28_27 I1660_pn28 XI1660_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I158_XG_MN1 (XI1660_I158_XG_n1 I1660_gn27 I1660_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I159_XG_MN2 (XI1660_I159_XG_n1 I1660_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I159_XG_MN0 (I1660_G29_28 I1660_pn29 XI1660_I159_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I159_XG_MN1 (XI1660_I159_XG_n1 I1660_gn28 I1660_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I285_XG_MN2 (XI1660_I285_XG_n1 I1660_G32_29n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I285_XG_MN0 (I1660_G32_25 I1660_P32_29n XI1660_I285_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I285_XG_MN1 (XI1660_I285_XG_n1 I1660_G28_25n I1660_G32_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I283_XG_MN2 (XI1660_I283_XG_n1 I1660_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I283_XG_MN0 (I1660_G30_23 I1660_P30_27n XI1660_I283_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I283_XG_MN1 (XI1660_I283_XG_n1 I1660_G26_23n I1660_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I415_XG_MN2 (XI1660_I415_XG_n1 I1660_G52_37n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I415_XG_MN0 (I1660_G52_21 I1660_P52_37n XI1660_I415_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I415_XG_MN1 (XI1660_I415_XG_n1 I1660_G36_21n I1660_G52_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I393_XG_MN2 (XI1660_I393_XG_n1 I1660_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I393_XG_MN0 (I1660_G30_0 I1660_P30_15n XI1660_I393_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I393_XG_MN1 (XI1660_I393_XG_n1 I1660_G14_0n I1660_G30_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I302_XG_MN2 (XI1660_I302_XG_n1 I1660_G49_46n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I302_XG_MN0 (I1660_G49_42 I1660_P49_46n XI1660_I302_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I302_XG_MN1 (XI1660_I302_XG_n1 I1660_G45_42n I1660_G49_42 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I306_XG_MN2 (XI1660_I306_XG_n1 I1660_G53_50n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I306_XG_MN0 (I1660_G53_46 I1660_P53_50n XI1660_I306_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I306_XG_MN1 (XI1660_I306_XG_n1 I1660_G49_46n I1660_G53_46 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I310_XG_MN2 (XI1660_I310_XG_n1 I1660_G57_54n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I310_XG_MN0 (I1660_G57_50 I1660_P57_54n XI1660_I310_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I310_XG_MN1 (XI1660_I310_XG_n1 I1660_G53_50n I1660_G57_50 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I314_XG_MN2 (XI1660_I314_XG_n1 I1660_G61_58n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I314_XG_MN0 (I1660_G61_54 I1660_P61_58n XI1660_I314_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I314_XG_MN1 (XI1660_I314_XG_n1 I1660_G57_54n I1660_G61_54 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I312_XG_MN2 (XI1660_I312_XG_n1 I1660_G59_56n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I312_XG_MN0 (I1660_G59_52 I1660_P59_56n XI1660_I312_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I312_XG_MN1 (XI1660_I312_XG_n1 I1660_G55_52n I1660_G59_52 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I316_XG_MN2 (XI1660_I316_XG_n1 I1660_G63_60n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I316_XG_MN0 (I1660_G63_56 I1660_P63_60n XI1660_I316_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I316_XG_MN1 (XI1660_I316_XG_n1 I1660_G59_56n I1660_G63_56 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I281_XG_MN2 (XI1660_I281_XG_n1 I1660_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I281_XG_MN0 (I1660_G28_21 I1660_P28_25n XI1660_I281_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I281_XG_MN1 (XI1660_I281_XG_n1 I1660_G24_21n I1660_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I413_XG_MN2 (XI1660_I413_XG_n1 I1660_G50_35n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I413_XG_MN0 (I1660_G50_19 I1660_P50_35n XI1660_I413_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I413_XG_MN1 (XI1660_I413_XG_n1 I1660_G34_19n I1660_G50_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I405_XG_MN2 (XI1660_I405_XG_n1 I1660_G42_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I405_XG_MN0 (I1660_G42_11 I1660_P42_27n XI1660_I405_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I405_XG_MN1 (XI1660_I405_XG_n1 I1660_G26_11n I1660_G42_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I298_XG_MN2 (XI1660_I298_XG_n1 I1660_G45_42n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I298_XG_MN0 (I1660_G45_38 I1660_P45_42n XI1660_I298_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I298_XG_MN1 (XI1660_I298_XG_n1 I1660_G41_38n I1660_G45_38 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I304_XG_MN2 (XI1660_I304_XG_n1 I1660_G51_48n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I304_XG_MN0 (I1660_G51_44 I1660_P51_48n XI1660_I304_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I304_XG_MN1 (XI1660_I304_XG_n1 I1660_G47_44n I1660_G51_44 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I308_XG_MN2 (XI1660_I308_XG_n1 I1660_G55_52n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I308_XG_MN0 (I1660_G55_48 I1660_P55_52n XI1660_I308_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I308_XG_MN1 (XI1660_I308_XG_n1 I1660_G51_48n I1660_G55_48 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I157_XG_MN2 (XI1660_I157_XG_n1 I1660_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I157_XG_MN0 (I1660_G27_26 I1660_pn27 XI1660_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I157_XG_MN1 (XI1660_I157_XG_n1 I1660_gn26 I1660_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I156_XG_MN2 (XI1660_I156_XG_n1 I1660_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I156_XG_MN0 (I1660_G26_25 I1660_pn26 XI1660_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I156_XG_MN1 (XI1660_I156_XG_n1 I1660_gn25 I1660_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I403_XG_MN2 (XI1660_I403_XG_n1 I1660_G40_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I403_XG_MN0 (I1660_G40_9 I1660_P40_25n XI1660_I403_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I403_XG_MN1 (XI1660_I403_XG_n1 I1660_G24_9n I1660_G40_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I279_XG_MN2 (XI1660_I279_XG_n1 I1660_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I279_XG_MN0 (I1660_G26_19 I1660_P26_23n XI1660_I279_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I279_XG_MN1 (XI1660_I279_XG_n1 I1660_G22_19n I1660_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I389_XG_MN2 (XI1660_I389_XG_n1 I1660_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I389_XG_MN0 (I1660_G26_0 I1660_P26_11n XI1660_I389_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I389_XG_MN1 (XI1660_I389_XG_n1 I1660_G10_0n I1660_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I424_XG_MN2 (XI1660_I424_XG_n1 I1660_G61_46n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I424_XG_MN0 (I1660_G61_30 I1660_P61_46n XI1660_I424_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I424_XG_MN1 (XI1660_I424_XG_n1 I1660_G45_30n I1660_G61_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I300_XG_MN2 (XI1660_I300_XG_n1 I1660_G47_44n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I300_XG_MN0 (I1660_G47_40 I1660_P47_44n XI1660_I300_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I300_XG_MN1 (XI1660_I300_XG_n1 I1660_G43_40n I1660_G47_40 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I155_XG_MN2 (XI1660_I155_XG_n1 I1660_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I155_XG_MN0 (I1660_G25_24 I1660_pn25 XI1660_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I155_XG_MN1 (XI1660_I155_XG_n1 I1660_gn24 I1660_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I277_XG_MN2 (XI1660_I277_XG_n1 I1660_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I277_XG_MN0 (I1660_G24_17 I1660_P24_21n XI1660_I277_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I277_XG_MN1 (XI1660_I277_XG_n1 I1660_G20_17n I1660_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I411_XG_MN2 (XI1660_I411_XG_n1 I1660_G48_33n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I411_XG_MN0 (I1660_G48_17 I1660_P48_33n XI1660_I411_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I411_XG_MN1 (XI1660_I411_XG_n1 I1660_G32_17n I1660_G48_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I401_XG_MN2 (XI1660_I401_XG_n1 I1660_G38_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I401_XG_MN0 (I1660_G38_7 I1660_P38_23n XI1660_I401_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I401_XG_MN1 (XI1660_I401_XG_n1 I1660_G22_7n I1660_G38_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I294_XG_MN2 (XI1660_I294_XG_n1 I1660_G41_38n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I294_XG_MN0 (I1660_G41_34 I1660_P41_38n XI1660_I294_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I294_XG_MN1 (XI1660_I294_XG_n1 I1660_G37_34n I1660_G41_34 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I408_XG_MN2 (XI1660_I408_XG_n1 I1660_G45_30n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I408_XG_MN0 (I1660_G45_14 I1660_P45_30n XI1660_I408_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I408_XG_MN1 (XI1660_I408_XG_n1 I1660_G29_14n I1660_G45_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I296_XG_MN2 (XI1660_I296_XG_n1 I1660_G43_40n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I296_XG_MN0 (I1660_G43_36 I1660_P43_40n XI1660_I296_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I296_XG_MN1 (XI1660_I296_XG_n1 I1660_G39_36n I1660_G43_36 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I422_XG_MN2 (XI1660_I422_XG_n1 I1660_G59_44n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I422_XG_MN0 (I1660_G59_28 I1660_P59_44n XI1660_I422_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I422_XG_MN1 (XI1660_I422_XG_n1 I1660_G43_28n I1660_G59_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I153_XG_MN2 (XI1660_I153_XG_n1 I1660_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I153_XG_MN0 (I1660_G23_22 I1660_pn23 XI1660_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I153_XG_MN1 (XI1660_I153_XG_n1 I1660_gn22 I1660_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I154_XG_MN2 (XI1660_I154_XG_n1 I1660_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I154_XG_MN0 (I1660_G24_23 I1660_pn24 XI1660_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I154_XG_MN1 (XI1660_I154_XG_n1 I1660_gn23 I1660_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I387_XG_MN2 (XI1660_I387_XG_n1 I1660_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I387_XG_MN0 (I1660_G24_0 I1660_P24_9n XI1660_I387_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I387_XG_MN1 (XI1660_I387_XG_n1 I1660_G8_0n I1660_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I275_XG_MN2 (XI1660_I275_XG_n1 I1660_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I275_XG_MN0 (I1660_G22_15 I1660_P22_19n XI1660_I275_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I275_XG_MN1 (XI1660_I275_XG_n1 I1660_G18_15n I1660_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I384_XG_MN2 (XI1660_I384_XG_n1 I1660_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I384_XG_MN0 (I1660_G22_0 I1660_P22_7n XI1660_I384_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I384_XG_MN1 (XI1660_I384_XG_n1 I1660_G6_0n I1660_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I290_XG_MN2 (XI1660_I290_XG_n1 I1660_G37_34n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I290_XG_MN0 (I1660_G37_30 I1660_P37_34n XI1660_I290_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I290_XG_MN1 (XI1660_I290_XG_n1 I1660_G33_30n I1660_G37_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I420_XG_MN2 (XI1660_I420_XG_n1 I1660_G57_42n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I420_XG_MN0 (I1660_G57_26 I1660_P57_42n XI1660_I420_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I420_XG_MN1 (XI1660_I420_XG_n1 I1660_G41_26n I1660_G57_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I292_XG_MN2 (XI1660_I292_XG_n1 I1660_G39_36n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I292_XG_MN0 (I1660_G39_32 I1660_P39_36n XI1660_I292_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I292_XG_MN1 (XI1660_I292_XG_n1 I1660_G35_32n I1660_G39_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I152_XG_MN2 (XI1660_I152_XG_n1 I1660_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I152_XG_MN0 (I1660_G22_21 I1660_pn22 XI1660_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I152_XG_MN1 (XI1660_I152_XG_n1 I1660_gn21 I1660_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I399_XG_MN2 (XI1660_I399_XG_n1 I1660_G36_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I399_XG_MN0 (I1660_G36_5 I1660_P36_21n XI1660_I399_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I399_XG_MN1 (XI1660_I399_XG_n1 I1660_G20_5n I1660_G36_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I286_XG_MN2 (XI1660_I286_XG_n1 I1660_G33_30n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I286_XG_MN0 (I1660_G33_26 I1660_P33_30n XI1660_I286_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I286_XG_MN1 (XI1660_I286_XG_n1 I1660_G29_26n I1660_G33_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I392_XG_MN2 (XI1660_I392_XG_n1 I1660_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I392_XG_MN0 (I1660_G29_0 I1660_P29_14n XI1660_I392_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I392_XG_MN1 (XI1660_I392_XG_n1 I1660_G13_0n I1660_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I288_XG_MN2 (XI1660_I288_XG_n1 I1660_G35_32n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I288_XG_MN0 (I1660_G35_28 I1660_P35_32n XI1660_I288_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I288_XG_MN1 (XI1660_I288_XG_n1 I1660_G31_28n I1660_G35_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I426_XG_MN2 (XI1660_I426_XG_n1 I1660_G63_48n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I426_XG_MN0 (I1660_G63_32 I1660_P63_48n XI1660_I426_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I426_XG_MN1 (XI1660_I426_XG_n1 I1660_G47_32n I1660_G63_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I151_XG_MN2 (XI1660_I151_XG_n1 I1660_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I151_XG_MN0 (I1660_G21_20 I1660_pn21 XI1660_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I151_XG_MN1 (XI1660_I151_XG_n1 I1660_gn20 I1660_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I150_XG_MN2 (XI1660_I150_XG_n1 I1660_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I150_XG_MN0 (I1660_G20_19 I1660_pn20 XI1660_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I150_XG_MN1 (XI1660_I150_XG_n1 I1660_gn19 I1660_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I273_XG_MN2 (XI1660_I273_XG_n1 I1660_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I273_XG_MN0 (I1660_G20_13 I1660_P20_17n XI1660_I273_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I273_XG_MN1 (XI1660_I273_XG_n1 I1660_G16_13n I1660_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I380_XG_MN2 (XI1660_I380_XG_n1 I1660_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I380_XG_MN0 (I1660_G20_0 I1660_P20_5n XI1660_I380_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I380_XG_MN1 (XI1660_I380_XG_n1 I1660_G4_0n I1660_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I397_XG_MN2 (XI1660_I397_XG_n1 I1660_G34_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I397_XG_MN0 (I1660_G34_3 I1660_P34_19n XI1660_I397_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I397_XG_MN1 (XI1660_I397_XG_n1 I1660_G18_3n I1660_G34_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I282_XG_MN2 (XI1660_I282_XG_n1 I1660_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I282_XG_MN0 (I1660_G29_22 I1660_P29_26n XI1660_I282_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I282_XG_MN1 (XI1660_I282_XG_n1 I1660_G25_22n I1660_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I416_XG_MN2 (XI1660_I416_XG_n1 I1660_G53_38n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I416_XG_MN0 (I1660_G53_22 I1660_P53_38n XI1660_I416_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I416_XG_MN1 (XI1660_I416_XG_n1 I1660_G37_22n I1660_G53_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I404_XG_MN2 (XI1660_I404_XG_n1 I1660_G41_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I404_XG_MN0 (I1660_G41_10 I1660_P41_26n XI1660_I404_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I404_XG_MN1 (XI1660_I404_XG_n1 I1660_G25_10n I1660_G41_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I284_XG_MN2 (XI1660_I284_XG_n1 I1660_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I284_XG_MN0 (I1660_G31_24 I1660_P31_28n XI1660_I284_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I284_XG_MN1 (XI1660_I284_XG_n1 I1660_G27_24n I1660_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I418_XG_MN2 (XI1660_I418_XG_n1 I1660_G55_40n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I418_XG_MN0 (I1660_G55_24 I1660_P55_40n XI1660_I418_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I418_XG_MN1 (XI1660_I418_XG_n1 I1660_G39_24n I1660_G55_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I410_XG_MN2 (XI1660_I410_XG_n1 I1660_G47_32n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I410_XG_MN0 (I1660_G47_16 I1660_P47_32n XI1660_I410_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I410_XG_MN1 (XI1660_I410_XG_n1 I1660_G31_16n I1660_G47_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I149_XG_MN2 (XI1660_I149_XG_n1 I1660_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I149_XG_MN0 (I1660_G19_18 I1660_pn19 XI1660_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I149_XG_MN1 (XI1660_I149_XG_n1 I1660_gn18 I1660_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I395_XG_MN2 (XI1660_I395_XG_n1 I1660_G32_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I395_XG_MN0 (I1660_G32_1 I1660_P32_17n XI1660_I395_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I395_XG_MN1 (XI1660_I395_XG_n1 I1660_G16_1n I1660_G32_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I271_XG_MN2 (XI1660_I271_XG_n1 I1660_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I271_XG_MN0 (I1660_G18_11 I1660_P18_15n XI1660_I271_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I271_XG_MN1 (XI1660_I271_XG_n1 I1660_G14_11n I1660_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I377_XG_MN2 (XI1660_I377_XG_n1 I1660_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I377_XG_MN0 (I1660_G18_0 I1660_P18_3n XI1660_I377_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I377_XG_MN1 (XI1660_I377_XG_n1 I1660_G2_0n I1660_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I278_XG_MN2 (XI1660_I278_XG_n1 I1660_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I278_XG_MN0 (I1660_G25_18 I1660_P25_22n XI1660_I278_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I278_XG_MN1 (XI1660_I278_XG_n1 I1660_G21_18n I1660_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I388_XG_MN2 (XI1660_I388_XG_n1 I1660_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I388_XG_MN0 (I1660_G25_0 I1660_P25_10n XI1660_I388_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I388_XG_MN1 (XI1660_I388_XG_n1 I1660_G9_0n I1660_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I394_XG_MN2 (XI1660_I394_XG_n1 I1660_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I394_XG_MN0 (I1660_G31_0 I1660_P31_16n XI1660_I394_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I394_XG_MN1 (XI1660_I394_XG_n1 I1660_G15_0n I1660_G31_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I129_XG_MN2 (XI1660_I129_XG_n1 I1660_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I129_XG_MN0 (I1660_G0_0 I1660_pn0 XI1660_I129_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I129_XG_MN1 (XI1660_I129_XG_n1 I1660_cinn I1660_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I148_XG_MN2 (XI1660_I148_XG_n1 I1660_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I148_XG_MN0 (I1660_G18_17 I1660_pn18 XI1660_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I148_XG_MN1 (XI1660_I148_XG_n1 I1660_gn17 I1660_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I269_XG_MN2 (XI1660_I269_XG_n1 I1660_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I269_XG_MN0 (I1660_G16_9 I1660_P16_13n XI1660_I269_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I269_XG_MN1 (XI1660_I269_XG_n1 I1660_G12_9n I1660_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I375_XG_MN2 (XI1660_I375_XG_n1 I1660_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I375_XG_MN0 (I1660_G16_0 I1660_P16_1n XI1660_I375_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I375_XG_MN1 (XI1660_I375_XG_n1 I1660_G0_0n I1660_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I267_XG_MN2 (XI1660_I267_XG_n1 I1660_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I267_XG_MN0 (I1660_G14_7 I1660_P14_11n XI1660_I267_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I267_XG_MN1 (XI1660_I267_XG_n1 I1660_G10_7n I1660_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I274_XG_MN2 (XI1660_I274_XG_n1 I1660_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I274_XG_MN0 (I1660_G21_14 I1660_P21_18n XI1660_I274_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I274_XG_MN1 (XI1660_I274_XG_n1 I1660_G17_14n I1660_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I400_XG_MN2 (XI1660_I400_XG_n1 I1660_G37_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I400_XG_MN0 (I1660_G37_6 I1660_P37_22n XI1660_I400_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I400_XG_MN1 (XI1660_I400_XG_n1 I1660_G21_6n I1660_G37_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I412_XG_MN2 (XI1660_I412_XG_n1 I1660_G49_34n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I412_XG_MN0 (I1660_G49_18 I1660_P49_34n XI1660_I412_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I412_XG_MN1 (XI1660_I412_XG_n1 I1660_G33_18n I1660_G49_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I280_XG_MN2 (XI1660_I280_XG_n1 I1660_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I280_XG_MN0 (I1660_G27_20 I1660_P27_24n XI1660_I280_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I280_XG_MN1 (XI1660_I280_XG_n1 I1660_G23_20n I1660_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I414_XG_MN2 (XI1660_I414_XG_n1 I1660_G51_36n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I414_XG_MN0 (I1660_G51_20 I1660_P51_36n XI1660_I414_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I414_XG_MN1 (XI1660_I414_XG_n1 I1660_G35_20n I1660_G51_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I406_XG_MN2 (XI1660_I406_XG_n1 I1660_G43_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I406_XG_MN0 (I1660_G43_12 I1660_P43_28n XI1660_I406_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I406_XG_MN1 (XI1660_I406_XG_n1 I1660_G27_12n I1660_G43_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I146_XG_MN2 (XI1660_I146_XG_n1 I1660_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I146_XG_MN0 (I1660_G16_15 I1660_pn16 XI1660_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I146_XG_MN1 (XI1660_I146_XG_n1 I1660_gn15 I1660_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I147_XG_MN2 (XI1660_I147_XG_n1 I1660_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I147_XG_MN0 (I1660_G17_16 I1660_pn17 XI1660_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I147_XG_MN1 (XI1660_I147_XG_n1 I1660_gn16 I1660_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I382_XG_MN2 (XI1660_I382_XG_n1 I1660_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I382_XG_MN0 (I1660_G21_0 I1660_P21_6n XI1660_I382_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I382_XG_MN1 (XI1660_I382_XG_n1 I1660_G5_0n I1660_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I276_XG_MN2 (XI1660_I276_XG_n1 I1660_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I276_XG_MN0 (I1660_G23_16 I1660_P23_20n XI1660_I276_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I276_XG_MN1 (XI1660_I276_XG_n1 I1660_G19_16n I1660_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I390_XG_MN2 (XI1660_I390_XG_n1 I1660_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I390_XG_MN0 (I1660_G27_0 I1660_P27_12n XI1660_I390_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I390_XG_MN1 (XI1660_I390_XG_n1 I1660_G11_0n I1660_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I145_XG_MN2 (XI1660_I145_XG_n1 I1660_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I145_XG_MN0 (I1660_G15_14 I1660_pn15 XI1660_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I145_XG_MN1 (XI1660_I145_XG_n1 I1660_gn14 I1660_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I144_XG_MN2 (XI1660_I144_XG_n1 I1660_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I144_XG_MN0 (I1660_G14_13 I1660_pn14 XI1660_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I144_XG_MN1 (XI1660_I144_XG_n1 I1660_gn13 I1660_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I265_XG_MN2 (XI1660_I265_XG_n1 I1660_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I265_XG_MN0 (I1660_G12_5 I1660_P12_9n XI1660_I265_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I265_XG_MN1 (XI1660_I265_XG_n1 I1660_G8_5n I1660_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I261_XG_MN2 (XI1660_I261_XG_n1 I1660_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I261_XG_MN0 (I1660_G8_1 I1660_P8_5n XI1660_I261_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I261_XG_MN1 (XI1660_I261_XG_n1 I1660_G4_1n I1660_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I256_XG_MN2 (XI1660_I256_XG_n1 I1660_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I256_XG_MN0 (I1660_G4_0 I1660_P4_1n XI1660_I256_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I256_XG_MN1 (XI1660_I256_XG_n1 I1660_G0_0n I1660_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I263_XG_MN2 (XI1660_I263_XG_n1 I1660_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I263_XG_MN0 (I1660_G10_3 I1660_P10_7n XI1660_I263_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I263_XG_MN1 (XI1660_I263_XG_n1 I1660_G6_3n I1660_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I259_XG_MN2 (XI1660_I259_XG_n1 I1660_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I259_XG_MN0 (I1660_G6_0 I1660_P6_3n XI1660_I259_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I259_XG_MN1 (XI1660_I259_XG_n1 I1660_G2_0n I1660_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I270_XG_MN2 (XI1660_I270_XG_n1 I1660_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I270_XG_MN0 (I1660_G17_10 I1660_P17_14n XI1660_I270_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I270_XG_MN1 (XI1660_I270_XG_n1 I1660_G13_10n I1660_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I396_XG_MN2 (XI1660_I396_XG_n1 I1660_G33_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I396_XG_MN0 (I1660_G33_2 I1660_P33_18n XI1660_I396_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I396_XG_MN1 (XI1660_I396_XG_n1 I1660_G17_2n I1660_G33_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I272_XG_MN2 (XI1660_I272_XG_n1 I1660_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I272_XG_MN0 (I1660_G19_12 I1660_P19_16n XI1660_I272_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I272_XG_MN1 (XI1660_I272_XG_n1 I1660_G15_12n I1660_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I386_XG_MN2 (XI1660_I386_XG_n1 I1660_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I386_XG_MN0 (I1660_G23_0 I1660_P23_8n XI1660_I386_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I386_XG_MN1 (XI1660_I386_XG_n1 I1660_G7_0n I1660_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I402_XG_MN2 (XI1660_I402_XG_n1 I1660_G39_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I402_XG_MN0 (I1660_G39_8 I1660_P39_24n XI1660_I402_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I402_XG_MN1 (XI1660_I402_XG_n1 I1660_G23_8n I1660_G39_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I132_XG_MN2 (XI1660_I132_XG_n1 I1660_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I132_XG_MN0 (I1660_G2_1 I1660_pn2 XI1660_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I132_XG_MN1 (XI1660_I132_XG_n1 I1660_gn1 I1660_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I266_XG_MN2 (XI1660_I266_XG_n1 I1660_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I266_XG_MN0 (I1660_G13_6 I1660_P13_10n XI1660_I266_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I266_XG_MN1 (XI1660_I266_XG_n1 I1660_G9_6n I1660_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I376_XG_MN2 (XI1660_I376_XG_n1 I1660_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I376_XG_MN0 (I1660_G17_0 I1660_P17_2n XI1660_I376_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I376_XG_MN1 (XI1660_I376_XG_n1 I1660_G1_0n I1660_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I268_XG_MN2 (XI1660_I268_XG_n1 I1660_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I268_XG_MN0 (I1660_G15_8 I1660_P15_12n XI1660_I268_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I268_XG_MN1 (XI1660_I268_XG_n1 I1660_G11_8n I1660_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I398_XG_MN2 (XI1660_I398_XG_n1 I1660_G35_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I398_XG_MN0 (I1660_G35_4 I1660_P35_20n XI1660_I398_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I398_XG_MN1 (XI1660_I398_XG_n1 I1660_G19_4n I1660_G35_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I143_XG_MN2 (XI1660_I143_XG_n1 I1660_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I143_XG_MN0 (I1660_G13_12 I1660_pn13 XI1660_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I143_XG_MN1 (XI1660_I143_XG_n1 I1660_gn12 I1660_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I142_XG_MN2 (XI1660_I142_XG_n1 I1660_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I142_XG_MN0 (I1660_G12_11 I1660_pn12 XI1660_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I142_XG_MN1 (XI1660_I142_XG_n1 I1660_gn11 I1660_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I131_XG_MN2 (XI1660_I131_XG_n1 I1660_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I131_XG_MN0 (I1660_G1_0 I1660_pn1 XI1660_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I131_XG_MN1 (XI1660_I131_XG_n1 I1660_G0_0n I1660_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I262_XG_MN2 (XI1660_I262_XG_n1 I1660_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I262_XG_MN0 (I1660_G9_2 I1660_P9_6n XI1660_I262_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I262_XG_MN1 (XI1660_I262_XG_n1 I1660_G5_2n I1660_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I264_XG_MN2 (XI1660_I264_XG_n1 I1660_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I264_XG_MN0 (I1660_G11_4 I1660_P11_8n XI1660_I264_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I264_XG_MN1 (XI1660_I264_XG_n1 I1660_G7_4n I1660_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I378_XG_MN2 (XI1660_I378_XG_n1 I1660_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I378_XG_MN0 (I1660_G19_0 I1660_P19_4n XI1660_I378_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I378_XG_MN1 (XI1660_I378_XG_n1 I1660_G3_0n I1660_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I140_XG_MN2 (XI1660_I140_XG_n1 I1660_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I140_XG_MN0 (I1660_G10_9 I1660_pn10 XI1660_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I140_XG_MN1 (XI1660_I140_XG_n1 I1660_gn9 I1660_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I141_XG_MN2 (XI1660_I141_XG_n1 I1660_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I141_XG_MN0 (I1660_G11_10 I1660_pn11 XI1660_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I141_XG_MN1 (XI1660_I141_XG_n1 I1660_gn10 I1660_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I137_XG_MN2 (XI1660_I137_XG_n1 I1660_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I137_XG_MN0 (I1660_G7_6 I1660_pn7 XI1660_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I137_XG_MN1 (XI1660_I137_XG_n1 I1660_gn6 I1660_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I136_XG_MN2 (XI1660_I136_XG_n1 I1660_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I136_XG_MN0 (I1660_G6_5 I1660_pn6 XI1660_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I136_XG_MN1 (XI1660_I136_XG_n1 I1660_gn5 I1660_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I135_XG_MN2 (XI1660_I135_XG_n1 I1660_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I135_XG_MN0 (I1660_G5_4 I1660_pn5 XI1660_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I135_XG_MN1 (XI1660_I135_XG_n1 I1660_gn4 I1660_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I134_XG_MN2 (XI1660_I134_XG_n1 I1660_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I134_XG_MN0 (I1660_G4_3 I1660_pn4 XI1660_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I134_XG_MN1 (XI1660_I134_XG_n1 I1660_gn3 I1660_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I133_XG_MN2 (XI1660_I133_XG_n1 I1660_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I133_XG_MN0 (I1660_G3_2 I1660_pn3 XI1660_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I133_XG_MN1 (XI1660_I133_XG_n1 I1660_gn2 I1660_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I258_XG_MN2 (XI1660_I258_XG_n1 I1660_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I258_XG_MN0 (I1660_G5_0 I1660_P5_2n XI1660_I258_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I258_XG_MN1 (XI1660_I258_XG_n1 I1660_G1_0n I1660_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I139_XG_MN2 (XI1660_I139_XG_n1 I1660_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I139_XG_MN0 (I1660_G9_8 I1660_pn9 XI1660_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I139_XG_MN1 (XI1660_I139_XG_n1 I1660_gn8 I1660_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I138_XG_MN2 (XI1660_I138_XG_n1 I1660_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I138_XG_MN0 (I1660_G8_7 I1660_pn8 XI1660_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I138_XG_MN1 (XI1660_I138_XG_n1 I1660_gn7 I1660_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I260_XG_MN2 (XI1660_I260_XG_n1 I1660_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I260_XG_MN0 (I1660_G7_0 I1660_P7_4n XI1660_I260_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1660_I260_XG_MN1 (XI1660_I260_XG_n1 I1660_G3_0n I1660_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI917_MN11 (VSS B_15_b3_5 XI917_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI917_MN14 (VSS XI917_xbn XI917_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI917_MN16 (XI917_xn2 B_15_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI917_MN15 (pp7_29 XI917_xan XI917_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI917_MN13 (XI917_xn1 XI917_xn pp7_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI917_MN2 (VSS A_29_b3_2 XI917_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI917_MN4 (XI917_n2 A_28_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI917_MN3 (XI917_xn two7_b3_5 XI917_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI917_MN1 (XI917_n1 one7_b3_5 XI917_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI917_MN9 (VSS XI917_xn XI917_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI970_MN11 (VSS B_17_b3_4 XI970_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI970_MN14 (VSS XI970_xbn XI970_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI970_MN16 (XI970_xn2 B_17_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI970_MN15 (pp8_27 XI970_xan XI970_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI970_MN13 (XI970_xn1 XI970_xn pp8_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI970_MN2 (VSS A_27_b3_3 XI970_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI970_MN4 (XI970_n2 A_26_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI970_MN3 (XI970_xn two8_b3_4 XI970_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI970_MN1 (XI970_n1 one8_b3_4 XI970_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI970_MN9 (VSS XI970_xn XI970_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI973_MN11 (VSS B_17_b3_5 XI973_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI973_MN14 (VSS XI973_xbn XI973_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI973_MN16 (XI973_xn2 B_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI973_MN15 (pp8_30 XI973_xan XI973_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI973_MN13 (XI973_xn1 XI973_xn pp8_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI973_MN2 (VSS A_30_b3_3 XI973_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI973_MN4 (XI973_n2 A_29_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI973_MN3 (XI973_xn two8_b3_5 XI973_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI973_MN1 (XI973_n1 one8_b3_5 XI973_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI973_MN9 (VSS XI973_xn XI973_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI975_MN11 (VSS B_17_b3_5 XI975_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI975_MN14 (VSS XI975_xbn XI975_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI975_MN16 (XI975_xn2 B_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI975_MN15 (pp8_32 XI975_xan XI975_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI975_MN13 (XI975_xn1 XI975_xn pp8_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI975_MN2 (VSS A_31_b3_4 XI975_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI975_MN4 (XI975_n2 A_31_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI975_MN3 (XI975_xn two8_b3_5 XI975_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI975_MN1 (XI975_n1 one8_b3_5 XI975_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI975_MN9 (VSS XI975_xn XI975_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1028_MN11 (VSS B_19_b3_5 XI1028_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1028_MN14 (VSS XI1028_xbn XI1028_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1028_MN16 (XI1028_xn2 B_19_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1028_MN15 (pp9_30 XI1028_xan XI1028_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1028_MN13 (XI1028_xn1 XI1028_xn pp9_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1028_MN2 (VSS A_30_b3_3 XI1028_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1028_MN4 (XI1028_n2 A_29_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1028_MN3 (XI1028_xn two9_b3_5 XI1028_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1028_MN1 (XI1028_n1 one9_b3_5 XI1028_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1028_MN9 (VSS XI1028_xn XI1028_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1029_MN11 (VSS B_19_b3_5 XI1029_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1029_MN14 (VSS XI1029_xbn XI1029_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1029_MN16 (XI1029_xn2 B_19_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1029_MN15 (pp9_31 XI1029_xan XI1029_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1029_MN13 (XI1029_xn1 XI1029_xn pp9_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1029_MN2 (VSS A_31_b3_4 XI1029_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1029_MN4 (XI1029_n2 A_30_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1029_MN3 (XI1029_xn two9_b3_5 XI1029_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1029_MN1 (XI1029_n1 one9_b3_5 XI1029_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1029_MN9 (VSS XI1029_xn XI1029_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI916_MN11 (VSS B_15_b3_4 XI916_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI916_MN14 (VSS XI916_xbn XI916_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI916_MN16 (XI916_xn2 B_15_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI916_MN15 (pp7_28 XI916_xan XI916_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI916_MN13 (XI916_xn1 XI916_xn pp7_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI916_MN2 (VSS A_28_b3_2 XI916_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI916_MN4 (XI916_n2 A_27_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI916_MN3 (XI916_xn two7_b3_5 XI916_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI916_MN1 (XI916_n1 one7_b3_5 XI916_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI916_MN9 (VSS XI916_xn XI916_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI915_MN11 (VSS B_15_b3_4 XI915_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI915_MN14 (VSS XI915_xbn XI915_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI915_MN16 (XI915_xn2 B_15_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI915_MN15 (pp7_27 XI915_xan XI915_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI915_MN13 (XI915_xn1 XI915_xn pp7_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI915_MN2 (VSS A_27_b3_2 XI915_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI915_MN4 (XI915_n2 A_26_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI915_MN3 (XI915_xn two7_b3_4 XI915_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI915_MN1 (XI915_n1 one7_b3_4 XI915_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI915_MN9 (VSS XI915_xn XI915_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI862_MN11 (VSS B_13_b3_5 XI862_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI862_MN14 (VSS XI862_xbn XI862_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI862_MN16 (XI862_xn2 B_13_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI862_MN15 (pp6_29 XI862_xan XI862_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI862_MN13 (XI862_xn1 XI862_xn pp6_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI862_MN2 (VSS A_29_b3_2 XI862_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI862_MN4 (XI862_n2 A_28_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI862_MN3 (XI862_xn two6_b3_5 XI862_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI862_MN1 (XI862_n1 one6_b3_5 XI862_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI862_MN9 (VSS XI862_xn XI862_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI918_MN11 (VSS B_15_b3_5 XI918_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI918_MN14 (VSS XI918_xbn XI918_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI918_MN16 (XI918_xn2 B_15_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI918_MN15 (pp7_30 XI918_xan XI918_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI918_MN13 (XI918_xn1 XI918_xn pp7_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI918_MN2 (VSS A_30_b3_2 XI918_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI918_MN4 (XI918_n2 A_29_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI918_MN3 (XI918_xn two7_b3_5 XI918_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI918_MN1 (XI918_n1 one7_b3_5 XI918_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI918_MN9 (VSS XI918_xn XI918_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI865_MN11 (VSS B_13_b3_5 XI865_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI865_MN14 (VSS XI865_xbn XI865_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI865_MN16 (XI865_xn2 B_13_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI865_MN15 (pp6_32 XI865_xan XI865_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI865_MN13 (XI865_xn1 XI865_xn pp6_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI865_MN2 (VSS A_31_b3_3 XI865_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI865_MN4 (XI865_n2 A_31_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI865_MN3 (XI865_xn two6_b3_5 XI865_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI865_MN1 (XI865_n1 one6_b3_5 XI865_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI865_MN9 (VSS XI865_xn XI865_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI864_MN11 (VSS B_13_b3_5 XI864_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI864_MN14 (VSS XI864_xbn XI864_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI864_MN16 (XI864_xn2 B_13_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI864_MN15 (pp6_31 XI864_xan XI864_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI864_MN13 (XI864_xn1 XI864_xn pp6_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI864_MN2 (VSS A_31_b3_3 XI864_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI864_MN4 (XI864_n2 A_30_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI864_MN3 (XI864_xn two6_b3_5 XI864_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI864_MN1 (XI864_n1 one6_b3_5 XI864_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI864_MN9 (VSS XI864_xn XI864_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI919_MN11 (VSS B_15_b3_5 XI919_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI919_MN14 (VSS XI919_xbn XI919_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI919_MN16 (XI919_xn2 B_15_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI919_MN15 (pp7_31 XI919_xan XI919_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI919_MN13 (XI919_xn1 XI919_xn pp7_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI919_MN2 (VSS A_31_b3_3 XI919_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI919_MN4 (XI919_n2 A_30_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI919_MN3 (XI919_xn two7_b3_5 XI919_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI919_MN1 (XI919_n1 one7_b3_5 XI919_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI919_MN9 (VSS XI919_xn XI919_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI920_MN11 (VSS B_15_b3_5 XI920_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI920_MN14 (VSS XI920_xbn XI920_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI920_MN16 (XI920_xn2 B_15_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI920_MN15 (pp7_32 XI920_xan XI920_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI920_MN13 (XI920_xn1 XI920_xn pp7_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI920_MN2 (VSS A_31_b3_3 XI920_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI920_MN4 (XI920_n2 A_31_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI920_MN3 (XI920_xn two7_b3_5 XI920_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI920_MN1 (XI920_n1 one7_b3_5 XI920_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI920_MN9 (VSS XI920_xn XI920_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1017_MN11 (VSS B_19_b3_3 XI1017_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1017_MN14 (VSS XI1017_xbn XI1017_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1017_MN16 (XI1017_xn2 B_19_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1017_MN15 (pp9_19 XI1017_xan XI1017_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1017_MN13 (XI1017_xn1 XI1017_xn pp9_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1017_MN2 (VSS A_19_b3_3 XI1017_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1017_MN4 (XI1017_n2 A_18_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1017_MN3 (XI1017_xn two9_b3_3 XI1017_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1017_MN1 (XI1017_n1 one9_b3_3 XI1017_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1017_MN9 (VSS XI1017_xn XI1017_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1018_MN11 (VSS B_19_b3_3 XI1018_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1018_MN14 (VSS XI1018_xbn XI1018_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1018_MN16 (XI1018_xn2 B_19_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1018_MN15 (pp9_20 XI1018_xan XI1018_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1018_MN13 (XI1018_xn1 XI1018_xn pp9_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1018_MN2 (VSS A_20_b3_3 XI1018_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1018_MN4 (XI1018_n2 A_19_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1018_MN3 (XI1018_xn two9_b3_3 XI1018_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1018_MN1 (XI1018_n1 one9_b3_3 XI1018_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1018_MN9 (VSS XI1018_xn XI1018_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1016_MN11 (VSS B_19_b3_3 XI1016_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1016_MN14 (VSS XI1016_xbn XI1016_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1016_MN16 (XI1016_xn2 B_19_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1016_MN15 (pp9_18 XI1016_xan XI1016_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1016_MN13 (XI1016_xn1 XI1016_xn pp9_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1016_MN2 (VSS A_18_b3_3 XI1016_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1016_MN4 (XI1016_n2 A_17_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1016_MN3 (XI1016_xn two9_b3_3 XI1016_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1016_MN1 (XI1016_n1 one9_b3_3 XI1016_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1016_MN9 (VSS XI1016_xn XI1016_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI966_MN11 (VSS B_17_b3_4 XI966_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI966_MN14 (VSS XI966_xbn XI966_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI966_MN16 (XI966_xn2 B_17_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI966_MN15 (pp8_23 XI966_xan XI966_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI966_MN13 (XI966_xn1 XI966_xn pp8_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI966_MN2 (VSS A_23_b3_3 XI966_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI966_MN4 (XI966_n2 A_22_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI966_MN3 (XI966_xn two8_b3_4 XI966_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI966_MN1 (XI966_n1 one8_b3_4 XI966_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI966_MN9 (VSS XI966_xn XI966_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1021_MN11 (VSS B_19_b3_4 XI1021_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1021_MN14 (VSS XI1021_xbn XI1021_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1021_MN16 (XI1021_xn2 B_19_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1021_MN15 (pp9_23 XI1021_xan XI1021_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1021_MN13 (XI1021_xn1 XI1021_xn pp9_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1021_MN2 (VSS A_23_b3_3 XI1021_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1021_MN4 (XI1021_n2 A_22_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1021_MN3 (XI1021_xn two9_b3_4 XI1021_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1021_MN1 (XI1021_n1 one9_b3_4 XI1021_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1021_MN9 (VSS XI1021_xn XI1021_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1022_MN11 (VSS B_19_b3_4 XI1022_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1022_MN14 (VSS XI1022_xbn XI1022_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1022_MN16 (XI1022_xn2 B_19_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1022_MN15 (pp9_24 XI1022_xan XI1022_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1022_MN13 (XI1022_xn1 XI1022_xn pp9_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1022_MN2 (VSS A_24_b3_3 XI1022_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1022_MN4 (XI1022_n2 A_23_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1022_MN3 (XI1022_xn two9_b3_4 XI1022_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1022_MN1 (XI1022_n1 one9_b3_4 XI1022_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1022_MN9 (VSS XI1022_xn XI1022_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI969_MN11 (VSS B_17_b3_4 XI969_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI969_MN14 (VSS XI969_xbn XI969_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI969_MN16 (XI969_xn2 B_17_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI969_MN15 (pp8_26 XI969_xan XI969_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI969_MN13 (XI969_xn1 XI969_xn pp8_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI969_MN2 (VSS A_26_b3_3 XI969_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI969_MN4 (XI969_n2 A_25_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI969_MN3 (XI969_xn two8_b3_4 XI969_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI969_MN1 (XI969_n1 one8_b3_4 XI969_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI969_MN9 (VSS XI969_xn XI969_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1023_MN11 (VSS B_19_b3_4 XI1023_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1023_MN14 (VSS XI1023_xbn XI1023_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1023_MN16 (XI1023_xn2 B_19_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1023_MN15 (pp9_25 XI1023_xan XI1023_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1023_MN13 (XI1023_xn1 XI1023_xn pp9_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1023_MN2 (VSS A_25_b3_3 XI1023_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1023_MN4 (XI1023_n2 A_24_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1023_MN3 (XI1023_xn two9_b3_4 XI1023_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1023_MN1 (XI1023_n1 one9_b3_4 XI1023_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1023_MN9 (VSS XI1023_xn XI1023_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1025_MN11 (VSS B_19_b3_4 XI1025_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1025_MN14 (VSS XI1025_xbn XI1025_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1025_MN16 (XI1025_xn2 B_19_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1025_MN15 (pp9_27 XI1025_xan XI1025_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1025_MN13 (XI1025_xn1 XI1025_xn pp9_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1025_MN2 (VSS A_27_b3_3 XI1025_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1025_MN4 (XI1025_n2 A_26_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1025_MN3 (XI1025_xn two9_b3_4 XI1025_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1025_MN1 (XI1025_n1 one9_b3_4 XI1025_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1025_MN9 (VSS XI1025_xn XI1025_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI971_MN11 (VSS B_17_b3_4 XI971_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI971_MN14 (VSS XI971_xbn XI971_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI971_MN16 (XI971_xn2 B_17_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI971_MN15 (pp8_28 XI971_xan XI971_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI971_MN13 (XI971_xn1 XI971_xn pp8_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI971_MN2 (VSS A_28_b3_3 XI971_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI971_MN4 (XI971_n2 A_27_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI971_MN3 (XI971_xn two8_b3_5 XI971_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI971_MN1 (XI971_n1 one8_b3_5 XI971_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI971_MN9 (VSS XI971_xn XI971_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1026_MN11 (VSS B_19_b3_4 XI1026_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1026_MN14 (VSS XI1026_xbn XI1026_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1026_MN16 (XI1026_xn2 B_19_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1026_MN15 (pp9_28 XI1026_xan XI1026_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1026_MN13 (XI1026_xn1 XI1026_xn pp9_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1026_MN2 (VSS A_28_b3_3 XI1026_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1026_MN4 (XI1026_n2 A_27_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1026_MN3 (XI1026_xn two9_b3_5 XI1026_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1026_MN1 (XI1026_n1 one9_b3_5 XI1026_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1026_MN9 (VSS XI1026_xn XI1026_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI972_MN11 (VSS B_17_b3_5 XI972_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI972_MN14 (VSS XI972_xbn XI972_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI972_MN16 (XI972_xn2 B_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI972_MN15 (pp8_29 XI972_xan XI972_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI972_MN13 (XI972_xn1 XI972_xn pp8_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI972_MN2 (VSS A_29_b3_3 XI972_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI972_MN4 (XI972_n2 A_28_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI972_MN3 (XI972_xn two8_b3_5 XI972_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI972_MN1 (XI972_n1 one8_b3_5 XI972_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI972_MN9 (VSS XI972_xn XI972_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI974_MN11 (VSS B_17_b3_5 XI974_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI974_MN14 (VSS XI974_xbn XI974_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI974_MN16 (XI974_xn2 B_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI974_MN15 (pp8_31 XI974_xan XI974_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI974_MN13 (XI974_xn1 XI974_xn pp8_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI974_MN2 (VSS A_31_b3_4 XI974_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI974_MN4 (XI974_n2 A_30_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI974_MN3 (XI974_xn two8_b3_5 XI974_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI974_MN1 (XI974_n1 one8_b3_5 XI974_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI974_MN9 (VSS XI974_xn XI974_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1027_MN11 (VSS B_19_b3_5 XI1027_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1027_MN14 (VSS XI1027_xbn XI1027_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1027_MN16 (XI1027_xn2 B_19_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1027_MN15 (pp9_29 XI1027_xan XI1027_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1027_MN13 (XI1027_xn1 XI1027_xn pp9_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1027_MN2 (VSS A_29_b3_3 XI1027_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1027_MN4 (XI1027_n2 A_28_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1027_MN3 (XI1027_xn two9_b3_5 XI1027_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1027_MN1 (XI1027_n1 one9_b3_5 XI1027_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1027_MN9 (VSS XI1027_xn XI1027_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1030_MN11 (VSS B_19_b3_5 XI1030_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1030_MN14 (VSS XI1030_xbn XI1030_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1030_MN16 (XI1030_xn2 B_19_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1030_MN15 (pp9_32 XI1030_xan XI1030_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1030_MN13 (XI1030_xn1 XI1030_xn pp9_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1030_MN2 (VSS A_31_b3_4 XI1030_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1030_MN4 (XI1030_n2 A_31_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1030_MN3 (XI1030_xn two9_b3_5 XI1030_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1030_MN1 (XI1030_n1 one9_b3_5 XI1030_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1030_MN9 (VSS XI1030_xn XI1030_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI914_MN11 (VSS B_15_b3_4 XI914_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI914_MN14 (VSS XI914_xbn XI914_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI914_MN16 (XI914_xn2 B_15_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI914_MN15 (pp7_26 XI914_xan XI914_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI914_MN13 (XI914_xn1 XI914_xn pp7_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI914_MN2 (VSS A_26_b3_2 XI914_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI914_MN4 (XI914_n2 A_25_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI914_MN3 (XI914_xn two7_b3_4 XI914_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI914_MN1 (XI914_n1 one7_b3_4 XI914_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI914_MN9 (VSS XI914_xn XI914_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI913_MN11 (VSS B_15_b3_4 XI913_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI913_MN14 (VSS XI913_xbn XI913_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI913_MN16 (XI913_xn2 B_15_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI913_MN15 (pp7_25 XI913_xan XI913_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI913_MN13 (XI913_xn1 XI913_xn pp7_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI913_MN2 (VSS A_25_b3_2 XI913_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI913_MN4 (XI913_n2 A_24_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI913_MN3 (XI913_xn two7_b3_4 XI913_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI913_MN1 (XI913_n1 one7_b3_4 XI913_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI913_MN9 (VSS XI913_xn XI913_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI809_MN11 (VSS B_11_b3_5 XI809_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI809_MN14 (VSS XI809_xbn XI809_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI809_MN16 (XI809_xn2 B_11_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI809_MN15 (pp5_31 XI809_xan XI809_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI809_MN13 (XI809_xn1 XI809_xn pp5_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI809_MN2 (VSS A_31_b3_2 XI809_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI809_MN4 (XI809_n2 A_30_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI809_MN3 (XI809_xn two5_b3_5 XI809_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI809_MN1 (XI809_n1 one5_b3_5 XI809_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI809_MN9 (VSS XI809_xn XI809_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI863_MN11 (VSS B_13_b3_5 XI863_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI863_MN14 (VSS XI863_xbn XI863_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI863_MN16 (XI863_xn2 B_13_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI863_MN15 (pp6_30 XI863_xan XI863_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI863_MN13 (XI863_xn1 XI863_xn pp6_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI863_MN2 (VSS A_30_b3_2 XI863_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI863_MN4 (XI863_n2 A_29_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI863_MN3 (XI863_xn two6_b3_5 XI863_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI863_MN1 (XI863_n1 one6_b3_5 XI863_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI863_MN9 (VSS XI863_xn XI863_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1019_MN11 (VSS B_19_b3_3 XI1019_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1019_MN14 (VSS XI1019_xbn XI1019_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1019_MN16 (XI1019_xn2 B_19_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1019_MN15 (pp9_21 XI1019_xan XI1019_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1019_MN13 (XI1019_xn1 XI1019_xn pp9_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1019_MN2 (VSS A_21_b3_3 XI1019_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1019_MN4 (XI1019_n2 A_20_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1019_MN3 (XI1019_xn two9_b3_3 XI1019_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1019_MN1 (XI1019_n1 one9_b3_3 XI1019_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1019_MN9 (VSS XI1019_xn XI1019_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1015_MN11 (VSS B_19_b3_3 XI1015_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1015_MN14 (VSS XI1015_xbn XI1015_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1015_MN16 (XI1015_xn2 B_19_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1015_MN15 (pp9_17 XI1015_xan XI1015_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1015_MN13 (XI1015_xn1 XI1015_xn pp9_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1015_MN2 (VSS A_17_b3_3 XI1015_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1015_MN4 (XI1015_n2 A_16_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1015_MN3 (XI1015_xn two9_b3_3 XI1015_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1015_MN1 (XI1015_n1 one9_b3_3 XI1015_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1015_MN9 (VSS XI1015_xn XI1015_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI965_MN11 (VSS B_17_b3_3 XI965_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI965_MN14 (VSS XI965_xbn XI965_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI965_MN16 (XI965_xn2 B_17_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI965_MN15 (pp8_22 XI965_xan XI965_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI965_MN13 (XI965_xn1 XI965_xn pp8_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI965_MN2 (VSS A_22_b3_3 XI965_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI965_MN4 (XI965_n2 A_21_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI965_MN3 (XI965_xn two8_b3_4 XI965_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI965_MN1 (XI965_n1 one8_b3_4 XI965_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI965_MN9 (VSS XI965_xn XI965_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1020_MN11 (VSS B_19_b3_3 XI1020_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1020_MN14 (VSS XI1020_xbn XI1020_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1020_MN16 (XI1020_xn2 B_19_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1020_MN15 (pp9_22 XI1020_xan XI1020_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1020_MN13 (XI1020_xn1 XI1020_xn pp9_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1020_MN2 (VSS A_22_b3_3 XI1020_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1020_MN4 (XI1020_n2 A_21_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1020_MN3 (XI1020_xn two9_b3_4 XI1020_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1020_MN1 (XI1020_n1 one9_b3_4 XI1020_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1020_MN9 (VSS XI1020_xn XI1020_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI967_MN11 (VSS B_17_b3_4 XI967_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI967_MN14 (VSS XI967_xbn XI967_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI967_MN16 (XI967_xn2 B_17_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI967_MN15 (pp8_24 XI967_xan XI967_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI967_MN13 (XI967_xn1 XI967_xn pp8_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI967_MN2 (VSS A_24_b3_3 XI967_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI967_MN4 (XI967_n2 A_23_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI967_MN3 (XI967_xn two8_b3_4 XI967_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI967_MN1 (XI967_n1 one8_b3_4 XI967_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI967_MN9 (VSS XI967_xn XI967_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1076_MN11 (VSS B_21_b3_4 XI1076_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1076_MN14 (VSS XI1076_xbn XI1076_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1076_MN16 (XI1076_xn2 B_21_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1076_MN15 (pp10_23 XI1076_xan XI1076_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1076_MN13 (XI1076_xn1 XI1076_xn pp10_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1076_MN2 (VSS A_23_b3_3 XI1076_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1076_MN4 (XI1076_n2 A_22_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1076_MN3 (XI1076_xn two10_b3_4 XI1076_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1076_MN1 (XI1076_n1 one10_b3_4 XI1076_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1076_MN9 (VSS XI1076_xn XI1076_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI968_MN11 (VSS B_17_b3_4 XI968_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI968_MN14 (VSS XI968_xbn XI968_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI968_MN16 (XI968_xn2 B_17_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI968_MN15 (pp8_25 XI968_xan XI968_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI968_MN13 (XI968_xn1 XI968_xn pp8_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI968_MN2 (VSS A_25_b3_3 XI968_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI968_MN4 (XI968_n2 A_24_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI968_MN3 (XI968_xn two8_b3_4 XI968_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI968_MN1 (XI968_n1 one8_b3_4 XI968_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI968_MN9 (VSS XI968_xn XI968_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1024_MN11 (VSS B_19_b3_4 XI1024_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1024_MN14 (VSS XI1024_xbn XI1024_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1024_MN16 (XI1024_xn2 B_19_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1024_MN15 (pp9_26 XI1024_xan XI1024_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1024_MN13 (XI1024_xn1 XI1024_xn pp9_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1024_MN2 (VSS A_26_b3_3 XI1024_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1024_MN4 (XI1024_n2 A_25_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1024_MN3 (XI1024_xn two9_b3_4 XI1024_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1024_MN1 (XI1024_n1 one9_b3_4 XI1024_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1024_MN9 (VSS XI1024_xn XI1024_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1080_MN11 (VSS B_21_b3_4 XI1080_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1080_MN14 (VSS XI1080_xbn XI1080_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1080_MN16 (XI1080_xn2 B_21_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1080_MN15 (pp10_27 XI1080_xan XI1080_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1080_MN13 (XI1080_xn1 XI1080_xn pp10_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1080_MN2 (VSS A_27_b3_3 XI1080_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1080_MN4 (XI1080_n2 A_26_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1080_MN3 (XI1080_xn two10_b3_4 XI1080_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1080_MN1 (XI1080_n1 one10_b3_4 XI1080_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1080_MN9 (VSS XI1080_xn XI1080_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1081_MN11 (VSS B_21_b3_4 XI1081_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1081_MN14 (VSS XI1081_xbn XI1081_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1081_MN16 (XI1081_xn2 B_21_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1081_MN15 (pp10_28 XI1081_xan XI1081_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1081_MN13 (XI1081_xn1 XI1081_xn pp10_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1081_MN2 (VSS A_28_b3_3 XI1081_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1081_MN4 (XI1081_n2 A_27_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1081_MN3 (XI1081_xn two10_b3_5 XI1081_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1081_MN1 (XI1081_n1 one10_b3_5 XI1081_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1081_MN9 (VSS XI1081_xn XI1081_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1083_MN11 (VSS B_21_b3_5 XI1083_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1083_MN14 (VSS XI1083_xbn XI1083_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1083_MN16 (XI1083_xn2 B_21_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1083_MN15 (pp10_30 XI1083_xan XI1083_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1083_MN13 (XI1083_xn1 XI1083_xn pp10_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1083_MN2 (VSS A_30_b3_3 XI1083_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1083_MN4 (XI1083_n2 A_29_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1083_MN3 (XI1083_xn two10_b3_5 XI1083_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1083_MN1 (XI1083_n1 one10_b3_5 XI1083_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1083_MN9 (VSS XI1083_xn XI1083_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI912_MN11 (VSS B_15_b3_4 XI912_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI912_MN14 (VSS XI912_xbn XI912_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI912_MN16 (XI912_xn2 B_15_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI912_MN15 (pp7_24 XI912_xan XI912_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI912_MN13 (XI912_xn1 XI912_xn pp7_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI912_MN2 (VSS A_24_b3_2 XI912_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI912_MN4 (XI912_n2 A_23_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI912_MN3 (XI912_xn two7_b3_4 XI912_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI912_MN1 (XI912_n1 one7_b3_4 XI912_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI912_MN9 (VSS XI912_xn XI912_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI911_MN11 (VSS B_15_b3_4 XI911_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI911_MN14 (VSS XI911_xbn XI911_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI911_MN16 (XI911_xn2 B_15_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI911_MN15 (pp7_23 XI911_xan XI911_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI911_MN13 (XI911_xn1 XI911_xn pp7_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI911_MN2 (VSS A_23_b3_2 XI911_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI911_MN4 (XI911_n2 A_22_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI911_MN3 (XI911_xn two7_b3_4 XI911_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI911_MN1 (XI911_n1 one7_b3_4 XI911_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI911_MN9 (VSS XI911_xn XI911_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI861_MN11 (VSS B_13_b3_4 XI861_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI861_MN14 (VSS XI861_xbn XI861_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI861_MN16 (XI861_xn2 B_13_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI861_MN15 (pp6_28 XI861_xan XI861_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI861_MN13 (XI861_xn1 XI861_xn pp6_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI861_MN2 (VSS A_28_b3_2 XI861_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI861_MN4 (XI861_n2 A_27_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI861_MN3 (XI861_xn two6_b3_5 XI861_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI861_MN1 (XI861_n1 one6_b3_5 XI861_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI861_MN9 (VSS XI861_xn XI861_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI810_MN11 (VSS B_11_b3_5 XI810_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI810_MN14 (VSS XI810_xbn XI810_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI810_MN16 (XI810_xn2 B_11_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI810_MN15 (pp5_32 XI810_xan XI810_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI810_MN13 (XI810_xn1 XI810_xn pp5_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI810_MN2 (VSS A_31_b3_2 XI810_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI810_MN4 (XI810_n2 A_31_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI810_MN3 (XI810_xn two5_b3_5 XI810_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI810_MN1 (XI810_n1 one5_b3_5 XI810_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI810_MN9 (VSS XI810_xn XI810_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1070_MN11 (VSS B_21_b3_3 XI1070_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1070_MN14 (VSS XI1070_xbn XI1070_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1070_MN16 (XI1070_xn2 B_21_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1070_MN15 (pp10_17 XI1070_xan XI1070_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1070_MN13 (XI1070_xn1 XI1070_xn pp10_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1070_MN2 (VSS A_17_b3_3 XI1070_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1070_MN4 (XI1070_n2 A_16_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1070_MN3 (XI1070_xn two10_b3_3 XI1070_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1070_MN1 (XI1070_n1 one10_b3_3 XI1070_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1070_MN9 (VSS XI1070_xn XI1070_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1072_MN11 (VSS B_21_b3_3 XI1072_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1072_MN14 (VSS XI1072_xbn XI1072_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1072_MN16 (XI1072_xn2 B_21_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1072_MN15 (pp10_19 XI1072_xan XI1072_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1072_MN13 (XI1072_xn1 XI1072_xn pp10_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1072_MN2 (VSS A_19_b3_3 XI1072_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1072_MN4 (XI1072_n2 A_18_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1072_MN3 (XI1072_xn two10_b3_3 XI1072_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1072_MN1 (XI1072_n1 one10_b3_3 XI1072_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1072_MN9 (VSS XI1072_xn XI1072_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1074_MN11 (VSS B_21_b3_3 XI1074_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1074_MN14 (VSS XI1074_xbn XI1074_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1074_MN16 (XI1074_xn2 B_21_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1074_MN15 (pp10_21 XI1074_xan XI1074_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1074_MN13 (XI1074_xn1 XI1074_xn pp10_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1074_MN2 (VSS A_21_b3_3 XI1074_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1074_MN4 (XI1074_n2 A_20_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1074_MN3 (XI1074_xn two10_b3_3 XI1074_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1074_MN1 (XI1074_n1 one10_b3_3 XI1074_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1074_MN9 (VSS XI1074_xn XI1074_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1073_MN11 (VSS B_21_b3_3 XI1073_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1073_MN14 (VSS XI1073_xbn XI1073_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1073_MN16 (XI1073_xn2 B_21_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1073_MN15 (pp10_20 XI1073_xan XI1073_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1073_MN13 (XI1073_xn1 XI1073_xn pp10_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1073_MN2 (VSS A_20_b3_3 XI1073_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1073_MN4 (XI1073_n2 A_19_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1073_MN3 (XI1073_xn two10_b3_3 XI1073_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1073_MN1 (XI1073_n1 one10_b3_3 XI1073_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1073_MN9 (VSS XI1073_xn XI1073_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1075_MN11 (VSS B_21_b3_3 XI1075_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1075_MN14 (VSS XI1075_xbn XI1075_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1075_MN16 (XI1075_xn2 B_21_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1075_MN15 (pp10_22 XI1075_xan XI1075_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1075_MN13 (XI1075_xn1 XI1075_xn pp10_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1075_MN2 (VSS A_22_b3_3 XI1075_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1075_MN4 (XI1075_n2 A_21_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1075_MN3 (XI1075_xn two10_b3_4 XI1075_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1075_MN1 (XI1075_n1 one10_b3_4 XI1075_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1075_MN9 (VSS XI1075_xn XI1075_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1077_MN11 (VSS B_21_b3_4 XI1077_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1077_MN14 (VSS XI1077_xbn XI1077_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1077_MN16 (XI1077_xn2 B_21_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1077_MN15 (pp10_24 XI1077_xan XI1077_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1077_MN13 (XI1077_xn1 XI1077_xn pp10_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1077_MN2 (VSS A_24_b3_3 XI1077_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1077_MN4 (XI1077_n2 A_23_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1077_MN3 (XI1077_xn two10_b3_4 XI1077_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1077_MN1 (XI1077_n1 one10_b3_4 XI1077_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1077_MN9 (VSS XI1077_xn XI1077_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1078_MN11 (VSS B_21_b3_4 XI1078_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1078_MN14 (VSS XI1078_xbn XI1078_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1078_MN16 (XI1078_xn2 B_21_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1078_MN15 (pp10_25 XI1078_xan XI1078_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1078_MN13 (XI1078_xn1 XI1078_xn pp10_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1078_MN2 (VSS A_25_b3_3 XI1078_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1078_MN4 (XI1078_n2 A_24_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1078_MN3 (XI1078_xn two10_b3_4 XI1078_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1078_MN1 (XI1078_n1 one10_b3_4 XI1078_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1078_MN9 (VSS XI1078_xn XI1078_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1079_MN11 (VSS B_21_b3_4 XI1079_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1079_MN14 (VSS XI1079_xbn XI1079_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1079_MN16 (XI1079_xn2 B_21_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1079_MN15 (pp10_26 XI1079_xan XI1079_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1079_MN13 (XI1079_xn1 XI1079_xn pp10_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1079_MN2 (VSS A_26_b3_3 XI1079_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1079_MN4 (XI1079_n2 A_25_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1079_MN3 (XI1079_xn two10_b3_4 XI1079_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1079_MN1 (XI1079_n1 one10_b3_4 XI1079_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1079_MN9 (VSS XI1079_xn XI1079_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1082_MN11 (VSS B_21_b3_5 XI1082_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1082_MN14 (VSS XI1082_xbn XI1082_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1082_MN16 (XI1082_xn2 B_21_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1082_MN15 (pp10_29 XI1082_xan XI1082_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1082_MN13 (XI1082_xn1 XI1082_xn pp10_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1082_MN2 (VSS A_29_b3_3 XI1082_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1082_MN4 (XI1082_n2 A_28_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1082_MN3 (XI1082_xn two10_b3_5 XI1082_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1082_MN1 (XI1082_n1 one10_b3_5 XI1082_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1082_MN9 (VSS XI1082_xn XI1082_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI910_MN11 (VSS B_15_b3_3 XI910_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI910_MN14 (VSS XI910_xbn XI910_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI910_MN16 (XI910_xn2 B_15_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI910_MN15 (pp7_22 XI910_xan XI910_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI910_MN13 (XI910_xn1 XI910_xn pp7_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI910_MN2 (VSS A_22_b3_2 XI910_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI910_MN4 (XI910_n2 A_21_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI910_MN3 (XI910_xn two7_b3_4 XI910_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI910_MN1 (XI910_n1 one7_b3_4 XI910_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI910_MN9 (VSS XI910_xn XI910_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI859_MN11 (VSS B_13_b3_4 XI859_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI859_MN14 (VSS XI859_xbn XI859_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI859_MN16 (XI859_xn2 B_13_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI859_MN15 (pp6_26 XI859_xan XI859_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI859_MN13 (XI859_xn1 XI859_xn pp6_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI859_MN2 (VSS A_26_b3_2 XI859_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI859_MN4 (XI859_n2 A_25_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI859_MN3 (XI859_xn two6_b3_4 XI859_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI859_MN1 (XI859_n1 one6_b3_4 XI859_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI859_MN9 (VSS XI859_xn XI859_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI754_MN11 (VSS B_9_b3_5 XI754_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI754_MN14 (VSS XI754_xbn XI754_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI754_MN16 (XI754_xn2 B_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI754_MN15 (pp4_31 XI754_xan XI754_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI754_MN13 (XI754_xn1 XI754_xn pp4_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI754_MN2 (VSS A_31_b3_2 XI754_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI754_MN4 (XI754_n2 A_30_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI754_MN3 (XI754_xn two4_b3_5 XI754_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI754_MN1 (XI754_n1 one4_b3_5 XI754_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI754_MN9 (VSS XI754_xn XI754_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI858_MN11 (VSS B_13_b3_4 XI858_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI858_MN14 (VSS XI858_xbn XI858_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI858_MN16 (XI858_xn2 B_13_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI858_MN15 (pp6_25 XI858_xan XI858_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI858_MN13 (XI858_xn1 XI858_xn pp6_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI858_MN2 (VSS A_25_b3_2 XI858_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI858_MN4 (XI858_n2 A_24_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI858_MN3 (XI858_xn two6_b3_4 XI858_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI858_MN1 (XI858_n1 one6_b3_4 XI858_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI858_MN9 (VSS XI858_xn XI858_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI808_MN11 (VSS B_11_b3_5 XI808_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI808_MN14 (VSS XI808_xbn XI808_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI808_MN16 (XI808_xn2 B_11_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI808_MN15 (pp5_30 XI808_xan XI808_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI808_MN13 (XI808_xn1 XI808_xn pp5_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI808_MN2 (VSS A_30_b3_1 XI808_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI808_MN4 (XI808_n2 A_29_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI808_MN3 (XI808_xn two5_b3_5 XI808_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI808_MN1 (XI808_n1 one5_b3_5 XI808_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI808_MN9 (VSS XI808_xn XI808_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI755_MN11 (VSS B_9_b3_5 XI755_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI755_MN14 (VSS XI755_xbn XI755_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI755_MN16 (XI755_xn2 B_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI755_MN15 (pp4_32 XI755_xan XI755_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI755_MN13 (XI755_xn1 XI755_xn pp4_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI755_MN2 (VSS A_31_b3_2 XI755_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI755_MN4 (XI755_n2 A_31_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI755_MN3 (XI755_xn two4_b3_5 XI755_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI755_MN1 (XI755_n1 one4_b3_5 XI755_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI755_MN9 (VSS XI755_xn XI755_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI963_MN11 (VSS B_17_b3_3 XI963_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI963_MN14 (VSS XI963_xbn XI963_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI963_MN16 (XI963_xn2 B_17_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI963_MN15 (pp8_20 XI963_xan XI963_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI963_MN13 (XI963_xn1 XI963_xn pp8_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI963_MN2 (VSS A_20_b3_3 XI963_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI963_MN4 (XI963_n2 A_19_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI963_MN3 (XI963_xn two8_b3_3 XI963_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI963_MN1 (XI963_n1 one8_b3_3 XI963_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI963_MN9 (VSS XI963_xn XI963_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI964_MN11 (VSS B_17_b3_3 XI964_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI964_MN14 (VSS XI964_xbn XI964_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI964_MN16 (XI964_xn2 B_17_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI964_MN15 (pp8_21 XI964_xan XI964_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI964_MN13 (XI964_xn1 XI964_xn pp8_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI964_MN2 (VSS A_21_b3_3 XI964_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI964_MN4 (XI964_n2 A_20_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI964_MN3 (XI964_xn two8_b3_3 XI964_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI964_MN1 (XI964_n1 one8_b3_3 XI964_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI964_MN9 (VSS XI964_xn XI964_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI960_MN11 (VSS B_17_b3_3 XI960_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI960_MN14 (VSS XI960_xbn XI960_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI960_MN16 (XI960_xn2 B_17_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI960_MN15 (pp8_17 XI960_xan XI960_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI960_MN13 (XI960_xn1 XI960_xn pp8_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI960_MN2 (VSS A_17_b3_3 XI960_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI960_MN4 (XI960_n2 A_16_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI960_MN3 (XI960_xn two8_b3_3 XI960_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI960_MN1 (XI960_n1 one8_b3_3 XI960_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI960_MN9 (VSS XI960_xn XI960_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1071_MN11 (VSS B_21_b3_3 XI1071_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1071_MN14 (VSS XI1071_xbn XI1071_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1071_MN16 (XI1071_xn2 B_21_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1071_MN15 (pp10_18 XI1071_xan XI1071_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1071_MN13 (XI1071_xn1 XI1071_xn pp10_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1071_MN2 (VSS A_18_b3_3 XI1071_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1071_MN4 (XI1071_n2 A_17_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1071_MN3 (XI1071_xn two10_b3_3 XI1071_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1071_MN1 (XI1071_n1 one10_b3_3 XI1071_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1071_MN9 (VSS XI1071_xn XI1071_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1131_MN11 (VSS B_23_b3_4 XI1131_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1131_MN14 (VSS XI1131_xbn XI1131_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1131_MN16 (XI1131_xn2 B_23_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1131_MN15 (pp11_23 XI1131_xan XI1131_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1131_MN13 (XI1131_xn1 XI1131_xn pp11_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1131_MN2 (VSS A_23_b3_4 XI1131_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1131_MN4 (XI1131_n2 A_22_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1131_MN3 (XI1131_xn two11_b3_4 XI1131_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1131_MN1 (XI1131_n1 one11_b3_4 XI1131_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1131_MN9 (VSS XI1131_xn XI1131_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1085_MN11 (VSS B_21_b3_5 XI1085_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1085_MN14 (VSS XI1085_xbn XI1085_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1085_MN16 (XI1085_xn2 B_21_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1085_MN15 (pp10_32 XI1085_xan XI1085_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1085_MN13 (XI1085_xn1 XI1085_xn pp10_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1085_MN2 (VSS A_31_b3_5 XI1085_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1085_MN4 (XI1085_n2 A_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1085_MN3 (XI1085_xn two10_b3_5 XI1085_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1085_MN1 (XI1085_n1 one10_b3_5 XI1085_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1085_MN9 (VSS XI1085_xn XI1085_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1084_MN11 (VSS B_21_b3_5 XI1084_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1084_MN14 (VSS XI1084_xbn XI1084_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1084_MN16 (XI1084_xn2 B_21_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1084_MN15 (pp10_31 XI1084_xan XI1084_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1084_MN13 (XI1084_xn1 XI1084_xn pp10_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1084_MN2 (VSS A_31_b3_5 XI1084_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1084_MN4 (XI1084_n2 A_30_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1084_MN3 (XI1084_xn two10_b3_5 XI1084_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1084_MN1 (XI1084_n1 one10_b3_5 XI1084_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1084_MN9 (VSS XI1084_xn XI1084_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1135_MN11 (VSS B_23_b3_4 XI1135_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1135_MN14 (VSS XI1135_xbn XI1135_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1135_MN16 (XI1135_xn2 B_23_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1135_MN15 (pp11_27 XI1135_xan XI1135_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1135_MN13 (XI1135_xn1 XI1135_xn pp11_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1135_MN2 (VSS A_27_b3_4 XI1135_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1135_MN4 (XI1135_n2 A_26_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1135_MN3 (XI1135_xn two11_b3_4 XI1135_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1135_MN1 (XI1135_n1 one11_b3_4 XI1135_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1135_MN9 (VSS XI1135_xn XI1135_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1134_MN11 (VSS B_23_b3_4 XI1134_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1134_MN14 (VSS XI1134_xbn XI1134_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1134_MN16 (XI1134_xn2 B_23_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1134_MN15 (pp11_26 XI1134_xan XI1134_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1134_MN13 (XI1134_xn1 XI1134_xn pp11_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1134_MN2 (VSS A_26_b3_4 XI1134_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1134_MN4 (XI1134_n2 A_25_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1134_MN3 (XI1134_xn two11_b3_4 XI1134_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1134_MN1 (XI1134_n1 one11_b3_4 XI1134_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1134_MN9 (VSS XI1134_xn XI1134_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1190_MN11 (VSS B_25_b3_4 XI1190_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1190_MN14 (VSS XI1190_xbn XI1190_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1190_MN16 (XI1190_xn2 B_25_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1190_MN15 (pp12_27 XI1190_xan XI1190_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1190_MN13 (XI1190_xn1 XI1190_xn pp12_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1190_MN2 (VSS A_27_b3_4 XI1190_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1190_MN4 (XI1190_n2 A_26_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1190_MN3 (XI1190_xn two12_b3_4 XI1190_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1190_MN1 (XI1190_n1 one12_b3_4 XI1190_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1190_MN9 (VSS XI1190_xn XI1190_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI856_MN11 (VSS B_13_b3_4 XI856_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI856_MN14 (VSS XI856_xbn XI856_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI856_MN16 (XI856_xn2 B_13_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI856_MN15 (pp6_23 XI856_xan XI856_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI856_MN13 (XI856_xn1 XI856_xn pp6_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI856_MN2 (VSS A_23_b3_2 XI856_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI856_MN4 (XI856_n2 A_22_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI856_MN3 (XI856_xn two6_b3_4 XI856_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI856_MN1 (XI856_n1 one6_b3_4 XI856_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI856_MN9 (VSS XI856_xn XI856_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI857_MN11 (VSS B_13_b3_4 XI857_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI857_MN14 (VSS XI857_xbn XI857_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI857_MN16 (XI857_xn2 B_13_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI857_MN15 (pp6_24 XI857_xan XI857_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI857_MN13 (XI857_xn1 XI857_xn pp6_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI857_MN2 (VSS A_24_b3_2 XI857_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI857_MN4 (XI857_n2 A_23_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI857_MN3 (XI857_xn two6_b3_4 XI857_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI857_MN1 (XI857_n1 one6_b3_4 XI857_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI857_MN9 (VSS XI857_xn XI857_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI860_MN11 (VSS B_13_b3_4 XI860_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI860_MN14 (VSS XI860_xbn XI860_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI860_MN16 (XI860_xn2 B_13_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI860_MN15 (pp6_27 XI860_xan XI860_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI860_MN13 (XI860_xn1 XI860_xn pp6_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI860_MN2 (VSS A_27_b3_2 XI860_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI860_MN4 (XI860_n2 A_26_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI860_MN3 (XI860_xn two6_b3_4 XI860_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI860_MN1 (XI860_n1 one6_b3_4 XI860_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI860_MN9 (VSS XI860_xn XI860_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI807_MN11 (VSS B_11_b3_5 XI807_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI807_MN14 (VSS XI807_xbn XI807_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI807_MN16 (XI807_xn2 B_11_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI807_MN15 (pp5_29 XI807_xan XI807_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI807_MN13 (XI807_xn1 XI807_xn pp5_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI807_MN2 (VSS A_29_b3_1 XI807_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI807_MN4 (XI807_n2 A_28_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI807_MN3 (XI807_xn two5_b3_5 XI807_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI807_MN1 (XI807_n1 one5_b3_5 XI807_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI807_MN9 (VSS XI807_xn XI807_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI962_MN11 (VSS B_17_b3_3 XI962_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI962_MN14 (VSS XI962_xbn XI962_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI962_MN16 (XI962_xn2 B_17_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI962_MN15 (pp8_19 XI962_xan XI962_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI962_MN13 (XI962_xn1 XI962_xn pp8_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI962_MN2 (VSS A_19_b3_3 XI962_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI962_MN4 (XI962_n2 A_18_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI962_MN3 (XI962_xn two8_b3_3 XI962_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI962_MN1 (XI962_n1 one8_b3_3 XI962_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI962_MN9 (VSS XI962_xn XI962_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI961_MN11 (VSS B_17_b3_3 XI961_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI961_MN14 (VSS XI961_xbn XI961_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI961_MN16 (XI961_xn2 B_17_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI961_MN15 (pp8_18 XI961_xan XI961_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI961_MN13 (XI961_xn1 XI961_xn pp8_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI961_MN2 (VSS A_18_b3_3 XI961_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI961_MN4 (XI961_n2 A_17_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI961_MN3 (XI961_xn two8_b3_3 XI961_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI961_MN1 (XI961_n1 one8_b3_3 XI961_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI961_MN9 (VSS XI961_xn XI961_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1183_MN11 (VSS B_25_b3_3 XI1183_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1183_MN14 (VSS XI1183_xbn XI1183_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1183_MN16 (XI1183_xn2 B_25_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1183_MN15 (pp12_20 XI1183_xan XI1183_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1183_MN13 (XI1183_xn1 XI1183_xn pp12_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1183_MN2 (VSS A_20_b3_4 XI1183_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1183_MN4 (XI1183_n2 A_19_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1183_MN3 (XI1183_xn two12_b3_3 XI1183_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1183_MN1 (XI1183_n1 one12_b3_3 XI1183_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1183_MN9 (VSS XI1183_xn XI1183_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1184_MN11 (VSS B_25_b3_3 XI1184_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1184_MN14 (VSS XI1184_xbn XI1184_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1184_MN16 (XI1184_xn2 B_25_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1184_MN15 (pp12_21 XI1184_xan XI1184_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1184_MN13 (XI1184_xn1 XI1184_xn pp12_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1184_MN2 (VSS A_21_b3_4 XI1184_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1184_MN4 (XI1184_n2 A_20_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1184_MN3 (XI1184_xn two12_b3_3 XI1184_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1184_MN1 (XI1184_n1 one12_b3_3 XI1184_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1184_MN9 (VSS XI1184_xn XI1184_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1185_MN11 (VSS B_25_b3_3 XI1185_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1185_MN14 (VSS XI1185_xbn XI1185_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1185_MN16 (XI1185_xn2 B_25_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1185_MN15 (pp12_22 XI1185_xan XI1185_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1185_MN13 (XI1185_xn1 XI1185_xn pp12_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1185_MN2 (VSS A_22_b3_4 XI1185_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1185_MN4 (XI1185_n2 A_21_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1185_MN3 (XI1185_xn two12_b3_4 XI1185_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1185_MN1 (XI1185_n1 one12_b3_4 XI1185_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1185_MN9 (VSS XI1185_xn XI1185_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1130_MN11 (VSS B_23_b3_3 XI1130_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1130_MN14 (VSS XI1130_xbn XI1130_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1130_MN16 (XI1130_xn2 B_23_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1130_MN15 (pp11_22 XI1130_xan XI1130_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1130_MN13 (XI1130_xn1 XI1130_xn pp11_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1130_MN2 (VSS A_22_b3_4 XI1130_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1130_MN4 (XI1130_n2 A_21_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1130_MN3 (XI1130_xn two11_b3_4 XI1130_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1130_MN1 (XI1130_n1 one11_b3_4 XI1130_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1130_MN9 (VSS XI1130_xn XI1130_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1132_MN11 (VSS B_23_b3_4 XI1132_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1132_MN14 (VSS XI1132_xbn XI1132_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1132_MN16 (XI1132_xn2 B_23_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1132_MN15 (pp11_24 XI1132_xan XI1132_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1132_MN13 (XI1132_xn1 XI1132_xn pp11_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1132_MN2 (VSS A_24_b3_4 XI1132_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1132_MN4 (XI1132_n2 A_23_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1132_MN3 (XI1132_xn two11_b3_4 XI1132_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1132_MN1 (XI1132_n1 one11_b3_4 XI1132_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1132_MN9 (VSS XI1132_xn XI1132_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1133_MN11 (VSS B_23_b3_4 XI1133_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1133_MN14 (VSS XI1133_xbn XI1133_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1133_MN16 (XI1133_xn2 B_23_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1133_MN15 (pp11_25 XI1133_xan XI1133_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1133_MN13 (XI1133_xn1 XI1133_xn pp11_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1133_MN2 (VSS A_25_b3_4 XI1133_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1133_MN4 (XI1133_n2 A_24_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1133_MN3 (XI1133_xn two11_b3_4 XI1133_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1133_MN1 (XI1133_n1 one11_b3_4 XI1133_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1133_MN9 (VSS XI1133_xn XI1133_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1186_MN11 (VSS B_25_b3_4 XI1186_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1186_MN14 (VSS XI1186_xbn XI1186_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1186_MN16 (XI1186_xn2 B_25_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1186_MN15 (pp12_23 XI1186_xan XI1186_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1186_MN13 (XI1186_xn1 XI1186_xn pp12_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1186_MN2 (VSS A_23_b3_4 XI1186_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1186_MN4 (XI1186_n2 A_22_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1186_MN3 (XI1186_xn two12_b3_4 XI1186_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1186_MN1 (XI1186_n1 one12_b3_4 XI1186_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1186_MN9 (VSS XI1186_xn XI1186_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1189_MN11 (VSS B_25_b3_4 XI1189_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1189_MN14 (VSS XI1189_xbn XI1189_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1189_MN16 (XI1189_xn2 B_25_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1189_MN15 (pp12_26 XI1189_xan XI1189_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1189_MN13 (XI1189_xn1 XI1189_xn pp12_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1189_MN2 (VSS A_26_b3_4 XI1189_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1189_MN4 (XI1189_n2 A_25_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1189_MN3 (XI1189_xn two12_b3_4 XI1189_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1189_MN1 (XI1189_n1 one12_b3_4 XI1189_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1189_MN9 (VSS XI1189_xn XI1189_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1187_MN11 (VSS B_25_b3_4 XI1187_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1187_MN14 (VSS XI1187_xbn XI1187_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1187_MN16 (XI1187_xn2 B_25_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1187_MN15 (pp12_24 XI1187_xan XI1187_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1187_MN13 (XI1187_xn1 XI1187_xn pp12_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1187_MN2 (VSS A_24_b3_4 XI1187_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1187_MN4 (XI1187_n2 A_23_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1187_MN3 (XI1187_xn two12_b3_4 XI1187_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1187_MN1 (XI1187_n1 one12_b3_4 XI1187_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1187_MN9 (VSS XI1187_xn XI1187_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1188_MN11 (VSS B_25_b3_4 XI1188_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1188_MN14 (VSS XI1188_xbn XI1188_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1188_MN16 (XI1188_xn2 B_25_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1188_MN15 (pp12_25 XI1188_xan XI1188_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1188_MN13 (XI1188_xn1 XI1188_xn pp12_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1188_MN2 (VSS A_25_b3_4 XI1188_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1188_MN4 (XI1188_n2 A_24_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1188_MN3 (XI1188_xn two12_b3_4 XI1188_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1188_MN1 (XI1188_n1 one12_b3_4 XI1188_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1188_MN9 (VSS XI1188_xn XI1188_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI855_MN11 (VSS B_13_b3_3 XI855_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI855_MN14 (VSS XI855_xbn XI855_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI855_MN16 (XI855_xn2 B_13_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI855_MN15 (pp6_22 XI855_xan XI855_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI855_MN13 (XI855_xn1 XI855_xn pp6_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI855_MN2 (VSS A_22_b3_2 XI855_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI855_MN4 (XI855_n2 A_21_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI855_MN3 (XI855_xn two6_b3_4 XI855_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI855_MN1 (XI855_n1 one6_b3_4 XI855_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI855_MN9 (VSS XI855_xn XI855_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI806_MN11 (VSS B_11_b3_4 XI806_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI806_MN14 (VSS XI806_xbn XI806_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI806_MN16 (XI806_xn2 B_11_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI806_MN15 (pp5_28 XI806_xan XI806_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI806_MN13 (XI806_xn1 XI806_xn pp5_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI806_MN2 (VSS A_28_b3_1 XI806_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI806_MN4 (XI806_n2 A_27_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI806_MN3 (XI806_xn two5_b3_5 XI806_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI806_MN1 (XI806_n1 one5_b3_5 XI806_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI806_MN9 (VSS XI806_xn XI806_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI753_MN11 (VSS B_9_b3_5 XI753_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI753_MN14 (VSS XI753_xbn XI753_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI753_MN16 (XI753_xn2 B_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI753_MN15 (pp4_30 XI753_xan XI753_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI753_MN13 (XI753_xn1 XI753_xn pp4_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI753_MN2 (VSS A_30_b3_1 XI753_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI753_MN4 (XI753_n2 A_29_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI753_MN3 (XI753_xn two4_b3_5 XI753_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI753_MN1 (XI753_n1 one4_b3_5 XI753_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI753_MN9 (VSS XI753_xn XI753_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1129_MN11 (VSS B_23_b3_3 XI1129_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1129_MN14 (VSS XI1129_xbn XI1129_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1129_MN16 (XI1129_xn2 B_23_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1129_MN15 (pp11_21 XI1129_xan XI1129_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1129_MN13 (XI1129_xn1 XI1129_xn pp11_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1129_MN2 (VSS A_21_b3_4 XI1129_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1129_MN4 (XI1129_n2 A_20_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1129_MN3 (XI1129_xn two11_b3_3 XI1129_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1129_MN1 (XI1129_n1 one11_b3_3 XI1129_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1129_MN9 (VSS XI1129_xn XI1129_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1128_MN11 (VSS B_23_b3_3 XI1128_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1128_MN14 (VSS XI1128_xbn XI1128_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1128_MN16 (XI1128_xn2 B_23_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1128_MN15 (pp11_20 XI1128_xan XI1128_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1128_MN13 (XI1128_xn1 XI1128_xn pp11_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1128_MN2 (VSS A_20_b3_4 XI1128_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1128_MN4 (XI1128_n2 A_19_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1128_MN3 (XI1128_xn two11_b3_3 XI1128_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1128_MN1 (XI1128_n1 one11_b3_3 XI1128_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1128_MN9 (VSS XI1128_xn XI1128_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1182_MN11 (VSS B_25_b3_3 XI1182_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1182_MN14 (VSS XI1182_xbn XI1182_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1182_MN16 (XI1182_xn2 B_25_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1182_MN15 (pp12_19 XI1182_xan XI1182_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1182_MN13 (XI1182_xn1 XI1182_xn pp12_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1182_MN2 (VSS A_19_b3_4 XI1182_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1182_MN4 (XI1182_n2 A_18_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1182_MN3 (XI1182_xn two12_b3_3 XI1182_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1182_MN1 (XI1182_n1 one12_b3_3 XI1182_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1182_MN9 (VSS XI1182_xn XI1182_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1238_MN11 (VSS B_27_b3_3 XI1238_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1238_MN14 (VSS XI1238_xbn XI1238_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1238_MN16 (XI1238_xn2 B_27_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1238_MN15 (pp13_20 XI1238_xan XI1238_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1238_MN13 (XI1238_xn1 XI1238_xn pp13_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1238_MN2 (VSS A_20_b3_4 XI1238_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1238_MN4 (XI1238_n2 A_19_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1238_MN3 (XI1238_xn two13_b3_3 XI1238_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1238_MN1 (XI1238_n1 one13_b3_3 XI1238_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1238_MN9 (VSS XI1238_xn XI1238_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1239_MN11 (VSS B_27_b3_3 XI1239_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1239_MN14 (VSS XI1239_xbn XI1239_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1239_MN16 (XI1239_xn2 B_27_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1239_MN15 (pp13_21 XI1239_xan XI1239_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1239_MN13 (XI1239_xn1 XI1239_xn pp13_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1239_MN2 (VSS A_21_b3_4 XI1239_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1239_MN4 (XI1239_n2 A_20_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1239_MN3 (XI1239_xn two13_b3_3 XI1239_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1239_MN1 (XI1239_n1 one13_b3_3 XI1239_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1239_MN9 (VSS XI1239_xn XI1239_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1294_MN11 (VSS B_29_b3_3 XI1294_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1294_MN14 (VSS XI1294_xbn XI1294_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1294_MN16 (XI1294_xn2 B_29_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1294_MN15 (pp14_21 XI1294_xan XI1294_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1294_MN13 (XI1294_xn1 XI1294_xn pp14_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1294_MN2 (VSS A_21_b3_5 XI1294_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1294_MN4 (XI1294_n2 A_20_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1294_MN3 (XI1294_xn two14_b3_3 XI1294_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1294_MN1 (XI1294_n1 one14_b3_3 XI1294_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1294_MN9 (VSS XI1294_xn XI1294_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1240_MN11 (VSS B_27_b3_3 XI1240_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1240_MN14 (VSS XI1240_xbn XI1240_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1240_MN16 (XI1240_xn2 B_27_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1240_MN15 (pp13_22 XI1240_xan XI1240_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1240_MN13 (XI1240_xn1 XI1240_xn pp13_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1240_MN2 (VSS A_22_b3_4 XI1240_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1240_MN4 (XI1240_n2 A_21_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1240_MN3 (XI1240_xn two13_b3_4 XI1240_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1240_MN1 (XI1240_n1 one13_b3_4 XI1240_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1240_MN9 (VSS XI1240_xn XI1240_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1348_MN11 (VSS B_31_b3_3 XI1348_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1348_MN14 (VSS XI1348_xbn XI1348_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1348_MN16 (XI1348_xn2 B_31_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1348_MN15 (pp15_20 XI1348_xan XI1348_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1348_MN13 (XI1348_xn1 XI1348_xn pp15_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1348_MN2 (VSS A_20_b3_5 XI1348_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1348_MN4 (XI1348_n2 A_19_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1348_MN3 (XI1348_xn two15_b3_3 XI1348_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1348_MN1 (XI1348_n1 one15_b3_3 XI1348_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1348_MN9 (VSS XI1348_xn XI1348_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1241_MN11 (VSS B_27_b3_4 XI1241_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1241_MN14 (VSS XI1241_xbn XI1241_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1241_MN16 (XI1241_xn2 B_27_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1241_MN15 (pp13_23 XI1241_xan XI1241_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1241_MN13 (XI1241_xn1 XI1241_xn pp13_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1241_MN2 (VSS A_23_b3_4 XI1241_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1241_MN4 (XI1241_n2 A_22_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1241_MN3 (XI1241_xn two13_b3_4 XI1241_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1241_MN1 (XI1241_n1 one13_b3_4 XI1241_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1241_MN9 (VSS XI1241_xn XI1241_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1243_MN11 (VSS B_27_b3_4 XI1243_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1243_MN14 (VSS XI1243_xbn XI1243_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1243_MN16 (XI1243_xn2 B_27_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1243_MN15 (pp13_25 XI1243_xan XI1243_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1243_MN13 (XI1243_xn1 XI1243_xn pp13_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1243_MN2 (VSS A_25_b3_4 XI1243_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1243_MN4 (XI1243_n2 A_24_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1243_MN3 (XI1243_xn two13_b3_4 XI1243_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1243_MN1 (XI1243_n1 one13_b3_4 XI1243_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1243_MN9 (VSS XI1243_xn XI1243_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1242_MN11 (VSS B_27_b3_4 XI1242_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1242_MN14 (VSS XI1242_xbn XI1242_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1242_MN16 (XI1242_xn2 B_27_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1242_MN15 (pp13_24 XI1242_xan XI1242_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1242_MN13 (XI1242_xn1 XI1242_xn pp13_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1242_MN2 (VSS A_24_b3_4 XI1242_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1242_MN4 (XI1242_n2 A_23_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1242_MN3 (XI1242_xn two13_b3_4 XI1242_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1242_MN1 (XI1242_n1 one13_b3_4 XI1242_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1242_MN9 (VSS XI1242_xn XI1242_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI804_MN11 (VSS B_11_b3_4 XI804_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI804_MN14 (VSS XI804_xbn XI804_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI804_MN16 (XI804_xn2 B_11_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI804_MN15 (pp5_26 XI804_xan XI804_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI804_MN13 (XI804_xn1 XI804_xn pp5_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI804_MN2 (VSS A_26_b3_1 XI804_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI804_MN4 (XI804_n2 A_25_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI804_MN3 (XI804_xn two5_b3_4 XI804_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI804_MN1 (XI804_n1 one5_b3_4 XI804_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI804_MN9 (VSS XI804_xn XI804_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI805_MN11 (VSS B_11_b3_4 XI805_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI805_MN14 (VSS XI805_xbn XI805_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI805_MN16 (XI805_xn2 B_11_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI805_MN15 (pp5_27 XI805_xan XI805_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI805_MN13 (XI805_xn1 XI805_xn pp5_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI805_MN2 (VSS A_27_b3_1 XI805_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI805_MN4 (XI805_n2 A_26_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI805_MN3 (XI805_xn two5_b3_4 XI805_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI805_MN1 (XI805_n1 one5_b3_4 XI805_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI805_MN9 (VSS XI805_xn XI805_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI752_MN11 (VSS B_9_b3_5 XI752_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI752_MN14 (VSS XI752_xbn XI752_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI752_MN16 (XI752_xn2 B_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI752_MN15 (pp4_29 XI752_xan XI752_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI752_MN13 (XI752_xn1 XI752_xn pp4_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI752_MN2 (VSS A_29_b3_1 XI752_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI752_MN4 (XI752_n2 A_28_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI752_MN3 (XI752_xn two4_b3_5 XI752_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI752_MN1 (XI752_n1 one4_b3_5 XI752_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI752_MN9 (VSS XI752_xn XI752_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1177_MN11 (VSS B_25_b3_2 XI1177_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1177_MN14 (VSS XI1177_xbn XI1177_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1177_MN16 (XI1177_xn2 B_25_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1177_MN15 (pp12_14 XI1177_xan XI1177_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1177_MN13 (XI1177_xn1 XI1177_xn pp12_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1177_MN2 (VSS A_14_b3_4 XI1177_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1177_MN4 (XI1177_n2 A_13_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1177_MN3 (XI1177_xn two12_b3_2 XI1177_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1177_MN1 (XI1177_n1 one12_b3_2 XI1177_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1177_MN9 (VSS XI1177_xn XI1177_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1126_MN11 (VSS B_23_b3_3 XI1126_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1126_MN14 (VSS XI1126_xbn XI1126_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1126_MN16 (XI1126_xn2 B_23_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1126_MN15 (pp11_18 XI1126_xan XI1126_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1126_MN13 (XI1126_xn1 XI1126_xn pp11_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1126_MN2 (VSS A_18_b3_4 XI1126_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1126_MN4 (XI1126_n2 A_17_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1126_MN3 (XI1126_xn two11_b3_3 XI1126_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1126_MN1 (XI1126_n1 one11_b3_3 XI1126_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1126_MN9 (VSS XI1126_xn XI1126_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1127_MN11 (VSS B_23_b3_3 XI1127_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1127_MN14 (VSS XI1127_xbn XI1127_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1127_MN16 (XI1127_xn2 B_23_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1127_MN15 (pp11_19 XI1127_xan XI1127_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1127_MN13 (XI1127_xn1 XI1127_xn pp11_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1127_MN2 (VSS A_19_b3_4 XI1127_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1127_MN4 (XI1127_n2 A_18_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1127_MN3 (XI1127_xn two11_b3_3 XI1127_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1127_MN1 (XI1127_n1 one11_b3_3 XI1127_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1127_MN9 (VSS XI1127_xn XI1127_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1180_MN11 (VSS B_25_b3_3 XI1180_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1180_MN14 (VSS XI1180_xbn XI1180_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1180_MN16 (XI1180_xn2 B_25_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1180_MN15 (pp12_17 XI1180_xan XI1180_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1180_MN13 (XI1180_xn1 XI1180_xn pp12_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1180_MN2 (VSS A_17_b3_4 XI1180_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1180_MN4 (XI1180_n2 A_16_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1180_MN3 (XI1180_xn two12_b3_3 XI1180_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1180_MN1 (XI1180_n1 one12_b3_3 XI1180_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1180_MN9 (VSS XI1180_xn XI1180_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1237_MN11 (VSS B_27_b3_3 XI1237_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1237_MN14 (VSS XI1237_xbn XI1237_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1237_MN16 (XI1237_xn2 B_27_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1237_MN15 (pp13_19 XI1237_xan XI1237_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1237_MN13 (XI1237_xn1 XI1237_xn pp13_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1237_MN2 (VSS A_19_b3_4 XI1237_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1237_MN4 (XI1237_n2 A_18_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1237_MN3 (XI1237_xn two13_b3_3 XI1237_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1237_MN1 (XI1237_n1 one13_b3_3 XI1237_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1237_MN9 (VSS XI1237_xn XI1237_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1293_MN11 (VSS B_29_b3_3 XI1293_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1293_MN14 (VSS XI1293_xbn XI1293_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1293_MN16 (XI1293_xn2 B_29_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1293_MN15 (pp14_20 XI1293_xan XI1293_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1293_MN13 (XI1293_xn1 XI1293_xn pp14_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1293_MN2 (VSS A_20_b3_5 XI1293_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1293_MN4 (XI1293_n2 A_19_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1293_MN3 (XI1293_xn two14_b3_3 XI1293_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1293_MN1 (XI1293_n1 one14_b3_3 XI1293_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1293_MN9 (VSS XI1293_xn XI1293_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1347_MN11 (VSS B_31_b3_3 XI1347_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1347_MN14 (VSS XI1347_xbn XI1347_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1347_MN16 (XI1347_xn2 B_31_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1347_MN15 (pp15_19 XI1347_xan XI1347_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1347_MN13 (XI1347_xn1 XI1347_xn pp15_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1347_MN2 (VSS A_19_b3_5 XI1347_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1347_MN4 (XI1347_n2 A_18_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1347_MN3 (XI1347_xn two15_b3_3 XI1347_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1347_MN1 (XI1347_n1 one15_b3_3 XI1347_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1347_MN9 (VSS XI1347_xn XI1347_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1295_MN11 (VSS B_29_b3_3 XI1295_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1295_MN14 (VSS XI1295_xbn XI1295_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1295_MN16 (XI1295_xn2 B_29_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1295_MN15 (pp14_22 XI1295_xan XI1295_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1295_MN13 (XI1295_xn1 XI1295_xn pp14_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1295_MN2 (VSS A_22_b3_5 XI1295_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1295_MN4 (XI1295_n2 A_21_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1295_MN3 (XI1295_xn two14_b3_4 XI1295_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1295_MN1 (XI1295_n1 one14_b3_4 XI1295_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1295_MN9 (VSS XI1295_xn XI1295_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1349_MN11 (VSS B_31_b3_3 XI1349_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1349_MN14 (VSS XI1349_xbn XI1349_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1349_MN16 (XI1349_xn2 B_31_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1349_MN15 (pp15_21 XI1349_xan XI1349_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1349_MN13 (XI1349_xn1 XI1349_xn pp15_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1349_MN2 (VSS A_21_b3_5 XI1349_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1349_MN4 (XI1349_n2 A_20_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1349_MN3 (XI1349_xn two15_b3_3 XI1349_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1349_MN1 (XI1349_n1 one15_b3_3 XI1349_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1349_MN9 (VSS XI1349_xn XI1349_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1244_MN11 (VSS B_27_b3_4 XI1244_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1244_MN14 (VSS XI1244_xbn XI1244_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1244_MN16 (XI1244_xn2 B_27_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1244_MN15 (pp13_26 XI1244_xan XI1244_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1244_MN13 (XI1244_xn1 XI1244_xn pp13_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1244_MN2 (VSS A_26_b3_4 XI1244_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1244_MN4 (XI1244_n2 A_25_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1244_MN3 (XI1244_xn two13_b3_4 XI1244_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1244_MN1 (XI1244_n1 one13_b3_4 XI1244_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1244_MN9 (VSS XI1244_xn XI1244_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1297_MN11 (VSS B_29_b3_4 XI1297_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1297_MN14 (VSS XI1297_xbn XI1297_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1297_MN16 (XI1297_xn2 B_29_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1297_MN15 (pp14_24 XI1297_xan XI1297_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1297_MN13 (XI1297_xn1 XI1297_xn pp14_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1297_MN2 (VSS A_24_b3_5 XI1297_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1297_MN4 (XI1297_n2 A_23_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1297_MN3 (XI1297_xn two14_b3_4 XI1297_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1297_MN1 (XI1297_n1 one14_b3_4 XI1297_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1297_MN9 (VSS XI1297_xn XI1297_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1296_MN11 (VSS B_29_b3_4 XI1296_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1296_MN14 (VSS XI1296_xbn XI1296_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1296_MN16 (XI1296_xn2 B_29_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1296_MN15 (pp14_23 XI1296_xan XI1296_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1296_MN13 (XI1296_xn1 XI1296_xn pp14_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1296_MN2 (VSS A_23_b3_5 XI1296_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1296_MN4 (XI1296_n2 A_22_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1296_MN3 (XI1296_xn two14_b3_4 XI1296_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1296_MN1 (XI1296_n1 one14_b3_4 XI1296_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1296_MN9 (VSS XI1296_xn XI1296_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI801_MN11 (VSS B_11_b3_4 XI801_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI801_MN14 (VSS XI801_xbn XI801_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI801_MN16 (XI801_xn2 B_11_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI801_MN15 (pp5_23 XI801_xan XI801_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI801_MN13 (XI801_xn1 XI801_xn pp5_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI801_MN2 (VSS A_23_b3_1 XI801_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI801_MN4 (XI801_n2 A_22_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI801_MN3 (XI801_xn two5_b3_4 XI801_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI801_MN1 (XI801_n1 one5_b3_4 XI801_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI801_MN9 (VSS XI801_xn XI801_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI802_MN11 (VSS B_11_b3_4 XI802_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI802_MN14 (VSS XI802_xbn XI802_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI802_MN16 (XI802_xn2 B_11_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI802_MN15 (pp5_24 XI802_xan XI802_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI802_MN13 (XI802_xn1 XI802_xn pp5_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI802_MN2 (VSS A_24_b3_1 XI802_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI802_MN4 (XI802_n2 A_23_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI802_MN3 (XI802_xn two5_b3_4 XI802_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI802_MN1 (XI802_n1 one5_b3_4 XI802_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI802_MN9 (VSS XI802_xn XI802_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI698_MN11 (VSS B_7_b3_5 XI698_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI698_MN14 (VSS XI698_xbn XI698_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI698_MN16 (XI698_xn2 B_7_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI698_MN15 (pp3_30 XI698_xan XI698_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI698_MN13 (XI698_xn1 XI698_xn pp3_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI698_MN2 (VSS A_30_b3_1 XI698_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI698_MN4 (XI698_n2 A_29_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI698_MN3 (XI698_xn two3_b3_5 XI698_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI698_MN1 (XI698_n1 one3_b3_5 XI698_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI698_MN9 (VSS XI698_xn XI698_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1124_MN11 (VSS B_23_b3_2 XI1124_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1124_MN14 (VSS XI1124_xbn XI1124_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1124_MN16 (XI1124_xn2 B_23_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1124_MN15 (pp11_16 XI1124_xan XI1124_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1124_MN13 (XI1124_xn1 XI1124_xn pp11_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1124_MN2 (VSS A_16_b3_4 XI1124_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1124_MN4 (XI1124_n2 A_15_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1124_MN3 (XI1124_xn two11_b3_2 XI1124_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1124_MN1 (XI1124_n1 one11_b3_2 XI1124_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1124_MN9 (VSS XI1124_xn XI1124_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1123_MN11 (VSS B_23_b3_2 XI1123_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1123_MN14 (VSS XI1123_xbn XI1123_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1123_MN16 (XI1123_xn2 B_23_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1123_MN15 (pp11_15 XI1123_xan XI1123_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1123_MN13 (XI1123_xn1 XI1123_xn pp11_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1123_MN2 (VSS A_15_b3_4 XI1123_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1123_MN4 (XI1123_n2 A_14_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1123_MN3 (XI1123_xn two11_b3_2 XI1123_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1123_MN1 (XI1123_n1 one11_b3_2 XI1123_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1123_MN9 (VSS XI1123_xn XI1123_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1176_MN11 (VSS B_25_b3_2 XI1176_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1176_MN14 (VSS XI1176_xbn XI1176_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1176_MN16 (XI1176_xn2 B_25_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1176_MN15 (pp12_13 XI1176_xan XI1176_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1176_MN13 (XI1176_xn1 XI1176_xn pp12_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1176_MN2 (VSS A_13_b3_4 XI1176_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1176_MN4 (XI1176_n2 A_12_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1176_MN3 (XI1176_xn two12_b3_2 XI1176_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1176_MN1 (XI1176_n1 one12_b3_2 XI1176_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1176_MN9 (VSS XI1176_xn XI1176_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1178_MN11 (VSS B_25_b3_2 XI1178_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1178_MN14 (VSS XI1178_xbn XI1178_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1178_MN16 (XI1178_xn2 B_25_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1178_MN15 (pp12_15 XI1178_xan XI1178_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1178_MN13 (XI1178_xn1 XI1178_xn pp12_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1178_MN2 (VSS A_15_b3_4 XI1178_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1178_MN4 (XI1178_n2 A_14_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1178_MN3 (XI1178_xn two12_b3_2 XI1178_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1178_MN1 (XI1178_n1 one12_b3_2 XI1178_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1178_MN9 (VSS XI1178_xn XI1178_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1179_MN11 (VSS B_25_b3_2 XI1179_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1179_MN14 (VSS XI1179_xbn XI1179_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1179_MN16 (XI1179_xn2 B_25_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1179_MN15 (pp12_16 XI1179_xan XI1179_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1179_MN13 (XI1179_xn1 XI1179_xn pp12_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1179_MN2 (VSS A_16_b3_4 XI1179_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1179_MN4 (XI1179_n2 A_15_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1179_MN3 (XI1179_xn two12_b3_2 XI1179_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1179_MN1 (XI1179_n1 one12_b3_2 XI1179_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1179_MN9 (VSS XI1179_xn XI1179_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1234_MN11 (VSS B_27_b3_2 XI1234_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1234_MN14 (VSS XI1234_xbn XI1234_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1234_MN16 (XI1234_xn2 B_27_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1234_MN15 (pp13_16 XI1234_xan XI1234_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1234_MN13 (XI1234_xn1 XI1234_xn pp13_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1234_MN2 (VSS A_16_b3_4 XI1234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1234_MN4 (XI1234_n2 A_15_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1234_MN3 (XI1234_xn two13_b3_2 XI1234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1234_MN1 (XI1234_n1 one13_b3_2 XI1234_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1234_MN9 (VSS XI1234_xn XI1234_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1125_MN11 (VSS B_23_b3_3 XI1125_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1125_MN14 (VSS XI1125_xbn XI1125_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1125_MN16 (XI1125_xn2 B_23_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1125_MN15 (pp11_17 XI1125_xan XI1125_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1125_MN13 (XI1125_xn1 XI1125_xn pp11_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1125_MN2 (VSS A_17_b3_4 XI1125_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1125_MN4 (XI1125_n2 A_16_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1125_MN3 (XI1125_xn two11_b3_3 XI1125_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1125_MN1 (XI1125_n1 one11_b3_3 XI1125_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1125_MN9 (VSS XI1125_xn XI1125_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1181_MN11 (VSS B_25_b3_3 XI1181_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1181_MN14 (VSS XI1181_xbn XI1181_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1181_MN16 (XI1181_xn2 B_25_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1181_MN15 (pp12_18 XI1181_xan XI1181_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1181_MN13 (XI1181_xn1 XI1181_xn pp12_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1181_MN2 (VSS A_18_b3_4 XI1181_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1181_MN4 (XI1181_n2 A_17_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1181_MN3 (XI1181_xn two12_b3_3 XI1181_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1181_MN1 (XI1181_n1 one12_b3_3 XI1181_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1181_MN9 (VSS XI1181_xn XI1181_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1235_MN11 (VSS B_27_b3_3 XI1235_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1235_MN14 (VSS XI1235_xbn XI1235_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1235_MN16 (XI1235_xn2 B_27_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1235_MN15 (pp13_17 XI1235_xan XI1235_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1235_MN13 (XI1235_xn1 XI1235_xn pp13_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1235_MN2 (VSS A_17_b3_4 XI1235_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1235_MN4 (XI1235_n2 A_16_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1235_MN3 (XI1235_xn two13_b3_3 XI1235_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1235_MN1 (XI1235_n1 one13_b3_3 XI1235_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1235_MN9 (VSS XI1235_xn XI1235_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1292_MN11 (VSS B_29_b3_3 XI1292_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1292_MN14 (VSS XI1292_xbn XI1292_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1292_MN16 (XI1292_xn2 B_29_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1292_MN15 (pp14_19 XI1292_xan XI1292_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1292_MN13 (XI1292_xn1 XI1292_xn pp14_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1292_MN2 (VSS A_19_b3_5 XI1292_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1292_MN4 (XI1292_n2 A_18_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1292_MN3 (XI1292_xn two14_b3_3 XI1292_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1292_MN1 (XI1292_n1 one14_b3_3 XI1292_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1292_MN9 (VSS XI1292_xn XI1292_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1346_MN11 (VSS B_31_b3_3 XI1346_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1346_MN14 (VSS XI1346_xbn XI1346_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1346_MN16 (XI1346_xn2 B_31_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1346_MN15 (pp15_18 XI1346_xan XI1346_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1346_MN13 (XI1346_xn1 XI1346_xn pp15_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1346_MN2 (VSS A_18_b3_5 XI1346_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1346_MN4 (XI1346_n2 A_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1346_MN3 (XI1346_xn two15_b3_3 XI1346_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1346_MN1 (XI1346_n1 one15_b3_3 XI1346_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1346_MN9 (VSS XI1346_xn XI1346_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1136_MN11 (VSS B_23_b3_4 XI1136_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1136_MN14 (VSS XI1136_xbn XI1136_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1136_MN16 (XI1136_xn2 B_23_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1136_MN15 (pp11_28 XI1136_xan XI1136_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1136_MN13 (XI1136_xn1 XI1136_xn pp11_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1136_MN2 (VSS A_28_b3_4 XI1136_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1136_MN4 (XI1136_n2 A_27_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1136_MN3 (XI1136_xn two11_b3_5 XI1136_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1136_MN1 (XI1136_n1 one11_b3_5 XI1136_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1136_MN9 (VSS XI1136_xn XI1136_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1245_MN11 (VSS B_27_b3_4 XI1245_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1245_MN14 (VSS XI1245_xbn XI1245_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1245_MN16 (XI1245_xn2 B_27_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1245_MN15 (pp13_27 XI1245_xan XI1245_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1245_MN13 (XI1245_xn1 XI1245_xn pp13_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1245_MN2 (VSS A_27_b3_4 XI1245_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1245_MN4 (XI1245_n2 A_26_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1245_MN3 (XI1245_xn two13_b3_4 XI1245_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1245_MN1 (XI1245_n1 one13_b3_4 XI1245_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1245_MN9 (VSS XI1245_xn XI1245_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1298_MN11 (VSS B_29_b3_4 XI1298_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1298_MN14 (VSS XI1298_xbn XI1298_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1298_MN16 (XI1298_xn2 B_29_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1298_MN15 (pp14_25 XI1298_xan XI1298_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1298_MN13 (XI1298_xn1 XI1298_xn pp14_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1298_MN2 (VSS A_25_b3_5 XI1298_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1298_MN4 (XI1298_n2 A_24_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1298_MN3 (XI1298_xn two14_b3_4 XI1298_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1298_MN1 (XI1298_n1 one14_b3_4 XI1298_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1298_MN9 (VSS XI1298_xn XI1298_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI803_MN11 (VSS B_11_b3_4 XI803_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI803_MN14 (VSS XI803_xbn XI803_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI803_MN16 (XI803_xn2 B_11_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI803_MN15 (pp5_25 XI803_xan XI803_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI803_MN13 (XI803_xn1 XI803_xn pp5_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI803_MN2 (VSS A_25_b3_1 XI803_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI803_MN4 (XI803_n2 A_24_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI803_MN3 (XI803_xn two5_b3_4 XI803_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI803_MN1 (XI803_n1 one5_b3_4 XI803_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI803_MN9 (VSS XI803_xn XI803_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI699_MN11 (VSS B_7_b3_5 XI699_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI699_MN14 (VSS XI699_xbn XI699_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI699_MN16 (XI699_xn2 B_7_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI699_MN15 (pp3_31 XI699_xan XI699_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI699_MN13 (XI699_xn1 XI699_xn pp3_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI699_MN2 (VSS A_31_b3_1 XI699_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI699_MN4 (XI699_n2 A_30_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI699_MN3 (XI699_xn two3_b3_5 XI699_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI699_MN1 (XI699_n1 one3_b3_5 XI699_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI699_MN9 (VSS XI699_xn XI699_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1231_MN11 (VSS B_27_b3_2 XI1231_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1231_MN14 (VSS XI1231_xbn XI1231_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1231_MN16 (XI1231_xn2 B_27_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1231_MN15 (pp13_13 XI1231_xan XI1231_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1231_MN13 (XI1231_xn1 XI1231_xn pp13_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1231_MN2 (VSS A_13_b3_4 XI1231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1231_MN4 (XI1231_n2 A_12_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1231_MN3 (XI1231_xn two13_b3_2 XI1231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1231_MN1 (XI1231_n1 one13_b3_2 XI1231_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1231_MN9 (VSS XI1231_xn XI1231_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1175_MN11 (VSS B_25_b3_2 XI1175_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1175_MN14 (VSS XI1175_xbn XI1175_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1175_MN16 (XI1175_xn2 B_25_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1175_MN15 (pp12_12 XI1175_xan XI1175_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1175_MN13 (XI1175_xn1 XI1175_xn pp12_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1175_MN2 (VSS A_12_b3_4 XI1175_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1175_MN4 (XI1175_n2 A_11_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1175_MN3 (XI1175_xn two12_b3_2 XI1175_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1175_MN1 (XI1175_n1 one12_b3_2 XI1175_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1175_MN9 (VSS XI1175_xn XI1175_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1232_MN11 (VSS B_27_b3_2 XI1232_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1232_MN14 (VSS XI1232_xbn XI1232_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1232_MN16 (XI1232_xn2 B_27_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1232_MN15 (pp13_14 XI1232_xan XI1232_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1232_MN13 (XI1232_xn1 XI1232_xn pp13_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1232_MN2 (VSS A_14_b3_4 XI1232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1232_MN4 (XI1232_n2 A_13_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1232_MN3 (XI1232_xn two13_b3_2 XI1232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1232_MN1 (XI1232_n1 one13_b3_2 XI1232_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1232_MN9 (VSS XI1232_xn XI1232_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1233_MN11 (VSS B_27_b3_2 XI1233_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1233_MN14 (VSS XI1233_xbn XI1233_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1233_MN16 (XI1233_xn2 B_27_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1233_MN15 (pp13_15 XI1233_xan XI1233_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1233_MN13 (XI1233_xn1 XI1233_xn pp13_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1233_MN2 (VSS A_15_b3_4 XI1233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1233_MN4 (XI1233_n2 A_14_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1233_MN3 (XI1233_xn two13_b3_2 XI1233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1233_MN1 (XI1233_n1 one13_b3_2 XI1233_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1233_MN9 (VSS XI1233_xn XI1233_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1286_MN11 (VSS B_29_b3_2 XI1286_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1286_MN14 (VSS XI1286_xbn XI1286_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1286_MN16 (XI1286_xn2 B_29_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1286_MN15 (pp14_13 XI1286_xan XI1286_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1286_MN13 (XI1286_xn1 XI1286_xn pp14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1286_MN2 (VSS A_13_b3_5 XI1286_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1286_MN4 (XI1286_n2 A_12_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1286_MN3 (XI1286_xn two14_b3_2 XI1286_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1286_MN1 (XI1286_n1 one14_b3_2 XI1286_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1286_MN9 (VSS XI1286_xn XI1286_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1288_MN11 (VSS B_29_b3_2 XI1288_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1288_MN14 (VSS XI1288_xbn XI1288_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1288_MN16 (XI1288_xn2 B_29_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1288_MN15 (pp14_15 XI1288_xan XI1288_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1288_MN13 (XI1288_xn1 XI1288_xn pp14_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1288_MN2 (VSS A_15_b3_5 XI1288_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1288_MN4 (XI1288_n2 A_14_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1288_MN3 (XI1288_xn two14_b3_2 XI1288_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1288_MN1 (XI1288_n1 one14_b3_2 XI1288_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1288_MN9 (VSS XI1288_xn XI1288_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1289_MN11 (VSS B_29_b3_2 XI1289_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1289_MN14 (VSS XI1289_xbn XI1289_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1289_MN16 (XI1289_xn2 B_29_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1289_MN15 (pp14_16 XI1289_xan XI1289_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1289_MN13 (XI1289_xn1 XI1289_xn pp14_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1289_MN2 (VSS A_16_b3_5 XI1289_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1289_MN4 (XI1289_n2 A_15_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1289_MN3 (XI1289_xn two14_b3_2 XI1289_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1289_MN1 (XI1289_n1 one14_b3_2 XI1289_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1289_MN9 (VSS XI1289_xn XI1289_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1287_MN11 (VSS B_29_b3_2 XI1287_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1287_MN14 (VSS XI1287_xbn XI1287_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1287_MN16 (XI1287_xn2 B_29_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1287_MN15 (pp14_14 XI1287_xan XI1287_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1287_MN13 (XI1287_xn1 XI1287_xn pp14_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1287_MN2 (VSS A_14_b3_5 XI1287_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1287_MN4 (XI1287_n2 A_13_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1287_MN3 (XI1287_xn two14_b3_2 XI1287_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1287_MN1 (XI1287_n1 one14_b3_2 XI1287_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1287_MN9 (VSS XI1287_xn XI1287_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1236_MN11 (VSS B_27_b3_3 XI1236_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1236_MN14 (VSS XI1236_xbn XI1236_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1236_MN16 (XI1236_xn2 B_27_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1236_MN15 (pp13_18 XI1236_xan XI1236_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1236_MN13 (XI1236_xn1 XI1236_xn pp13_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1236_MN2 (VSS A_18_b3_4 XI1236_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1236_MN4 (XI1236_n2 A_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1236_MN3 (XI1236_xn two13_b3_3 XI1236_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1236_MN1 (XI1236_n1 one13_b3_3 XI1236_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1236_MN9 (VSS XI1236_xn XI1236_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1291_MN11 (VSS B_29_b3_3 XI1291_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1291_MN14 (VSS XI1291_xbn XI1291_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1291_MN16 (XI1291_xn2 B_29_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1291_MN15 (pp14_18 XI1291_xan XI1291_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1291_MN13 (XI1291_xn1 XI1291_xn pp14_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1291_MN2 (VSS A_18_b3_5 XI1291_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1291_MN4 (XI1291_n2 A_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1291_MN3 (XI1291_xn two14_b3_3 XI1291_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1291_MN1 (XI1291_n1 one14_b3_3 XI1291_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1291_MN9 (VSS XI1291_xn XI1291_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1350_MN11 (VSS B_31_b3_3 XI1350_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1350_MN14 (VSS XI1350_xbn XI1350_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1350_MN16 (XI1350_xn2 B_31_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1350_MN15 (pp15_22 XI1350_xan XI1350_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1350_MN13 (XI1350_xn1 XI1350_xn pp15_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1350_MN2 (VSS A_22_b3_5 XI1350_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1350_MN4 (XI1350_n2 A_21_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1350_MN3 (XI1350_xn two15_b3_4 XI1350_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1350_MN1 (XI1350_n1 one15_b3_4 XI1350_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1350_MN9 (VSS XI1350_xn XI1350_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1139_MN11 (VSS B_23_b3_5 XI1139_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1139_MN14 (VSS XI1139_xbn XI1139_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1139_MN16 (XI1139_xn2 B_23_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1139_MN15 (pp11_31 XI1139_xan XI1139_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1139_MN13 (XI1139_xn1 XI1139_xn pp11_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1139_MN2 (VSS A_31_b3_5 XI1139_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1139_MN4 (XI1139_n2 A_30_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1139_MN3 (XI1139_xn two11_b3_5 XI1139_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1139_MN1 (XI1139_n1 one11_b3_5 XI1139_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1139_MN9 (VSS XI1139_xn XI1139_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1138_MN11 (VSS B_23_b3_5 XI1138_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1138_MN14 (VSS XI1138_xbn XI1138_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1138_MN16 (XI1138_xn2 B_23_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1138_MN15 (pp11_30 XI1138_xan XI1138_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1138_MN13 (XI1138_xn1 XI1138_xn pp11_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1138_MN2 (VSS A_30_b3_4 XI1138_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1138_MN4 (XI1138_n2 A_29_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1138_MN3 (XI1138_xn two11_b3_5 XI1138_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1138_MN1 (XI1138_n1 one11_b3_5 XI1138_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1138_MN9 (VSS XI1138_xn XI1138_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1191_MN11 (VSS B_25_b3_4 XI1191_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1191_MN14 (VSS XI1191_xbn XI1191_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1191_MN16 (XI1191_xn2 B_25_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1191_MN15 (pp12_28 XI1191_xan XI1191_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1191_MN13 (XI1191_xn1 XI1191_xn pp12_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1191_MN2 (VSS A_28_b3_4 XI1191_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1191_MN4 (XI1191_n2 A_27_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1191_MN3 (XI1191_xn two12_b3_5 XI1191_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1191_MN1 (XI1191_n1 one12_b3_5 XI1191_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1191_MN9 (VSS XI1191_xn XI1191_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1351_MN11 (VSS B_31_b3_4 XI1351_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1351_MN14 (VSS XI1351_xbn XI1351_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1351_MN16 (XI1351_xn2 B_31_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1351_MN15 (pp15_23 XI1351_xan XI1351_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1351_MN13 (XI1351_xn1 XI1351_xn pp15_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1351_MN2 (VSS A_23_b3_5 XI1351_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1351_MN4 (XI1351_n2 A_22_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1351_MN3 (XI1351_xn two15_b3_4 XI1351_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1351_MN1 (XI1351_n1 one15_b3_4 XI1351_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1351_MN9 (VSS XI1351_xn XI1351_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI909_MN11 (VSS B_15_b3_3 XI909_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI909_MN14 (VSS XI909_xbn XI909_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI909_MN16 (XI909_xn2 B_15_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI909_MN15 (pp7_21 XI909_xan XI909_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI909_MN13 (XI909_xn1 XI909_xn pp7_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI909_MN2 (VSS A_21_b3_2 XI909_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI909_MN4 (XI909_n2 A_20_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI909_MN3 (XI909_xn two7_b3_3 XI909_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI909_MN1 (XI909_n1 one7_b3_3 XI909_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI909_MN9 (VSS XI909_xn XI909_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI749_MN11 (VSS B_9_b3_4 XI749_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI749_MN14 (VSS XI749_xbn XI749_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI749_MN16 (XI749_xn2 B_9_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI749_MN15 (pp4_26 XI749_xan XI749_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI749_MN13 (XI749_xn1 XI749_xn pp4_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI749_MN2 (VSS A_26_b3_1 XI749_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI749_MN4 (XI749_n2 A_25_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI749_MN3 (XI749_xn two4_b3_4 XI749_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI749_MN1 (XI749_n1 one4_b3_4 XI749_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI749_MN9 (VSS XI749_xn XI749_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI751_MN11 (VSS B_9_b3_4 XI751_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI751_MN14 (VSS XI751_xbn XI751_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI751_MN16 (XI751_xn2 B_9_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI751_MN15 (pp4_28 XI751_xan XI751_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI751_MN13 (XI751_xn1 XI751_xn pp4_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI751_MN2 (VSS A_28_b3_1 XI751_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI751_MN4 (XI751_n2 A_27_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI751_MN3 (XI751_xn two4_b3_5 XI751_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI751_MN1 (XI751_n1 one4_b3_5 XI751_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI751_MN9 (VSS XI751_xn XI751_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI700_MN11 (VSS B_7_b3_5 XI700_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI700_MN14 (VSS XI700_xbn XI700_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI700_MN16 (XI700_xn2 B_7_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI700_MN15 (pp3_32 XI700_xan XI700_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI700_MN13 (XI700_xn1 XI700_xn pp3_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI700_MN2 (VSS A_31_b3_1 XI700_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI700_MN4 (XI700_n2 A_31_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI700_MN3 (XI700_xn two3_b3_5 XI700_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI700_MN1 (XI700_n1 one3_b3_5 XI700_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI700_MN9 (VSS XI700_xn XI700_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI697_MN11 (VSS B_7_b3_5 XI697_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI697_MN14 (VSS XI697_xbn XI697_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI697_MN16 (XI697_xn2 B_7_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI697_MN15 (pp3_29 XI697_xan XI697_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI697_MN13 (XI697_xn1 XI697_xn pp3_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI697_MN2 (VSS A_29_b3_1 XI697_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI697_MN4 (XI697_n2 A_28_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI697_MN3 (XI697_xn two3_b3_5 XI697_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI697_MN1 (XI697_n1 one3_b3_5 XI697_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI697_MN9 (VSS XI697_xn XI697_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI644_MN11 (VSS B_5_b3_5 XI644_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI644_MN14 (VSS XI644_xbn XI644_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI644_MN16 (XI644_xn2 B_5_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI644_MN15 (pp2_31 XI644_xan XI644_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI644_MN13 (XI644_xn1 XI644_xn pp2_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI644_MN2 (VSS A_31_b3_1 XI644_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI644_MN4 (XI644_n2 A_30_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI644_MN3 (XI644_xn two2_b3_5 XI644_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI644_MN1 (XI644_n1 one2_b3_5 XI644_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI644_MN9 (VSS XI644_xn XI644_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1121_MN11 (VSS B_23_b3_2 XI1121_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1121_MN14 (VSS XI1121_xbn XI1121_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1121_MN16 (XI1121_xn2 B_23_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1121_MN15 (pp11_13 XI1121_xan XI1121_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1121_MN13 (XI1121_xn1 XI1121_xn pp11_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1121_MN2 (VSS A_13_b3_4 XI1121_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1121_MN4 (XI1121_n2 A_12_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1121_MN3 (XI1121_xn two11_b3_2 XI1121_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1121_MN1 (XI1121_n1 one11_b3_2 XI1121_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1121_MN9 (VSS XI1121_xn XI1121_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1069_MN11 (VSS B_21_b3_2 XI1069_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1069_MN14 (VSS XI1069_xbn XI1069_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1069_MN16 (XI1069_xn2 B_21_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1069_MN15 (pp10_16 XI1069_xan XI1069_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1069_MN13 (XI1069_xn1 XI1069_xn pp10_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1069_MN2 (VSS A_16_b3_3 XI1069_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1069_MN4 (XI1069_n2 A_15_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1069_MN3 (XI1069_xn two10_b3_2 XI1069_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1069_MN1 (XI1069_n1 one10_b3_2 XI1069_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1069_MN9 (VSS XI1069_xn XI1069_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1229_MN11 (VSS B_27_b3_2 XI1229_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1229_MN14 (VSS XI1229_xbn XI1229_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1229_MN16 (XI1229_xn2 B_27_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1229_MN15 (pp13_11 XI1229_xan XI1229_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1229_MN13 (XI1229_xn1 XI1229_xn pp13_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1229_MN2 (VSS A_11_b3_4 XI1229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1229_MN4 (XI1229_n2 A_10_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1229_MN3 (XI1229_xn two13_b3_2 XI1229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1229_MN1 (XI1229_n1 one13_b3_2 XI1229_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1229_MN9 (VSS XI1229_xn XI1229_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1122_MN11 (VSS B_23_b3_2 XI1122_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1122_MN14 (VSS XI1122_xbn XI1122_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1122_MN16 (XI1122_xn2 B_23_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1122_MN15 (pp11_14 XI1122_xan XI1122_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1122_MN13 (XI1122_xn1 XI1122_xn pp11_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1122_MN2 (VSS A_14_b3_4 XI1122_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1122_MN4 (XI1122_n2 A_13_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1122_MN3 (XI1122_xn two11_b3_2 XI1122_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1122_MN1 (XI1122_n1 one11_b3_2 XI1122_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1122_MN9 (VSS XI1122_xn XI1122_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1230_MN11 (VSS B_27_b3_2 XI1230_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1230_MN14 (VSS XI1230_xbn XI1230_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1230_MN16 (XI1230_xn2 B_27_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1230_MN15 (pp13_12 XI1230_xan XI1230_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1230_MN13 (XI1230_xn1 XI1230_xn pp13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1230_MN2 (VSS A_12_b3_4 XI1230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1230_MN4 (XI1230_n2 A_11_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1230_MN3 (XI1230_xn two13_b3_2 XI1230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1230_MN1 (XI1230_n1 one13_b3_2 XI1230_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1230_MN9 (VSS XI1230_xn XI1230_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1337_MN11 (VSS B_31_b3_1 XI1337_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1337_MN14 (VSS XI1337_xbn XI1337_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1337_MN16 (XI1337_xn2 B_31_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1337_MN15 (pp15_9 XI1337_xan XI1337_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1337_MN13 (XI1337_xn1 XI1337_xn pp15_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1337_MN2 (VSS A_9_b3_5 XI1337_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1337_MN4 (XI1337_n2 A_8_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1337_MN3 (XI1337_xn two15_b3_1 XI1337_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1337_MN1 (XI1337_n1 one15_b3_1 XI1337_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1337_MN9 (VSS XI1337_xn XI1337_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1338_MN11 (VSS B_31_b3_1 XI1338_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1338_MN14 (VSS XI1338_xbn XI1338_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1338_MN16 (XI1338_xn2 B_31_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1338_MN15 (pp15_10 XI1338_xan XI1338_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1338_MN13 (XI1338_xn1 XI1338_xn pp15_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1338_MN2 (VSS A_10_b3_5 XI1338_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1338_MN4 (XI1338_n2 A_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1338_MN3 (XI1338_xn two15_b3_1 XI1338_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1338_MN1 (XI1338_n1 one15_b3_1 XI1338_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1338_MN9 (VSS XI1338_xn XI1338_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1285_MN11 (VSS B_29_b3_2 XI1285_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1285_MN14 (VSS XI1285_xbn XI1285_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1285_MN16 (XI1285_xn2 B_29_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1285_MN15 (pp14_12 XI1285_xan XI1285_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1285_MN13 (XI1285_xn1 XI1285_xn pp14_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1285_MN2 (VSS A_12_b3_5 XI1285_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1285_MN4 (XI1285_n2 A_11_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1285_MN3 (XI1285_xn two14_b3_2 XI1285_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1285_MN1 (XI1285_n1 one14_b3_2 XI1285_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1285_MN9 (VSS XI1285_xn XI1285_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1284_MN11 (VSS B_29_b3_2 XI1284_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1284_MN14 (VSS XI1284_xbn XI1284_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1284_MN16 (XI1284_xn2 B_29_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1284_MN15 (pp14_11 XI1284_xan XI1284_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1284_MN13 (XI1284_xn1 XI1284_xn pp14_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1284_MN2 (VSS A_11_b3_5 XI1284_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1284_MN4 (XI1284_n2 A_10_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1284_MN3 (XI1284_xn two14_b3_2 XI1284_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1284_MN1 (XI1284_n1 one14_b3_2 XI1284_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1284_MN9 (VSS XI1284_xn XI1284_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1340_MN11 (VSS B_31_b3_2 XI1340_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1340_MN14 (VSS XI1340_xbn XI1340_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1340_MN16 (XI1340_xn2 B_31_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1340_MN15 (pp15_12 XI1340_xan XI1340_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1340_MN13 (XI1340_xn1 XI1340_xn pp15_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1340_MN2 (VSS A_12_b3_5 XI1340_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1340_MN4 (XI1340_n2 A_11_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1340_MN3 (XI1340_xn two15_b3_2 XI1340_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1340_MN1 (XI1340_n1 one15_b3_2 XI1340_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1340_MN9 (VSS XI1340_xn XI1340_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1341_MN11 (VSS B_31_b3_2 XI1341_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1341_MN14 (VSS XI1341_xbn XI1341_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1341_MN16 (XI1341_xn2 B_31_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1341_MN15 (pp15_13 XI1341_xan XI1341_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1341_MN13 (XI1341_xn1 XI1341_xn pp15_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1341_MN2 (VSS A_13_b3_5 XI1341_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1341_MN4 (XI1341_n2 A_12_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1341_MN3 (XI1341_xn two15_b3_2 XI1341_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1341_MN1 (XI1341_n1 one15_b3_2 XI1341_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1341_MN9 (VSS XI1341_xn XI1341_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1343_MN11 (VSS B_31_b3_2 XI1343_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1343_MN14 (VSS XI1343_xbn XI1343_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1343_MN16 (XI1343_xn2 B_31_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1343_MN15 (pp15_15 XI1343_xan XI1343_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1343_MN13 (XI1343_xn1 XI1343_xn pp15_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1343_MN2 (VSS A_15_b3_5 XI1343_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1343_MN4 (XI1343_n2 A_14_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1343_MN3 (XI1343_xn two15_b3_2 XI1343_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1343_MN1 (XI1343_n1 one15_b3_2 XI1343_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1343_MN9 (VSS XI1343_xn XI1343_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1342_MN11 (VSS B_31_b3_2 XI1342_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1342_MN14 (VSS XI1342_xbn XI1342_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1342_MN16 (XI1342_xn2 B_31_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1342_MN15 (pp15_14 XI1342_xan XI1342_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1342_MN13 (XI1342_xn1 XI1342_xn pp15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1342_MN2 (VSS A_14_b3_5 XI1342_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1342_MN4 (XI1342_n2 A_13_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1342_MN3 (XI1342_xn two15_b3_2 XI1342_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1342_MN1 (XI1342_n1 one15_b3_2 XI1342_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1342_MN9 (VSS XI1342_xn XI1342_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1290_MN11 (VSS B_29_b3_3 XI1290_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1290_MN14 (VSS XI1290_xbn XI1290_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1290_MN16 (XI1290_xn2 B_29_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1290_MN15 (pp14_17 XI1290_xan XI1290_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1290_MN13 (XI1290_xn1 XI1290_xn pp14_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1290_MN2 (VSS A_17_b3_5 XI1290_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1290_MN4 (XI1290_n2 A_16_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1290_MN3 (XI1290_xn two14_b3_3 XI1290_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1290_MN1 (XI1290_n1 one14_b3_3 XI1290_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1290_MN9 (VSS XI1290_xn XI1290_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1345_MN11 (VSS B_31_b3_3 XI1345_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1345_MN14 (VSS XI1345_xbn XI1345_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1345_MN16 (XI1345_xn2 B_31_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1345_MN15 (pp15_17 XI1345_xan XI1345_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1345_MN13 (XI1345_xn1 XI1345_xn pp15_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1345_MN2 (VSS A_17_b3_5 XI1345_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1345_MN4 (XI1345_n2 A_16_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1345_MN3 (XI1345_xn two15_b3_3 XI1345_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1345_MN1 (XI1345_n1 one15_b3_3 XI1345_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1345_MN9 (VSS XI1345_xn XI1345_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1140_MN11 (VSS B_23_b3_5 XI1140_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1140_MN14 (VSS XI1140_xbn XI1140_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1140_MN16 (XI1140_xn2 B_23_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1140_MN15 (pp11_32 XI1140_xan XI1140_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1140_MN13 (XI1140_xn1 XI1140_xn pp11_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1140_MN2 (VSS A_31_b3_5 XI1140_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1140_MN4 (XI1140_n2 A_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1140_MN3 (XI1140_xn two11_b3_5 XI1140_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1140_MN1 (XI1140_n1 one11_b3_5 XI1140_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1140_MN9 (VSS XI1140_xn XI1140_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1137_MN11 (VSS B_23_b3_5 XI1137_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1137_MN14 (VSS XI1137_xbn XI1137_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1137_MN16 (XI1137_xn2 B_23_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1137_MN15 (pp11_29 XI1137_xan XI1137_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1137_MN13 (XI1137_xn1 XI1137_xn pp11_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1137_MN2 (VSS A_29_b3_4 XI1137_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1137_MN4 (XI1137_n2 A_28_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1137_MN3 (XI1137_xn two11_b3_5 XI1137_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1137_MN1 (XI1137_n1 one11_b3_5 XI1137_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1137_MN9 (VSS XI1137_xn XI1137_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1299_MN11 (VSS B_29_b3_4 XI1299_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1299_MN14 (VSS XI1299_xbn XI1299_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1299_MN16 (XI1299_xn2 B_29_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1299_MN15 (pp14_26 XI1299_xan XI1299_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1299_MN13 (XI1299_xn1 XI1299_xn pp14_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1299_MN2 (VSS A_26_b3_5 XI1299_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1299_MN4 (XI1299_n2 A_25_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1299_MN3 (XI1299_xn two14_b3_4 XI1299_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1299_MN1 (XI1299_n1 one14_b3_4 XI1299_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1299_MN9 (VSS XI1299_xn XI1299_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1352_MN11 (VSS B_31_b3_4 XI1352_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1352_MN14 (VSS XI1352_xbn XI1352_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1352_MN16 (XI1352_xn2 B_31_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1352_MN15 (pp15_24 XI1352_xan XI1352_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1352_MN13 (XI1352_xn1 XI1352_xn pp15_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1352_MN2 (VSS A_24_b3_5 XI1352_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1352_MN4 (XI1352_n2 A_23_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1352_MN3 (XI1352_xn two15_b3_4 XI1352_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1352_MN1 (XI1352_n1 one15_b3_4 XI1352_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1352_MN9 (VSS XI1352_xn XI1352_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI908_MN11 (VSS B_15_b3_3 XI908_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI908_MN14 (VSS XI908_xbn XI908_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI908_MN16 (XI908_xn2 B_15_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI908_MN15 (pp7_20 XI908_xan XI908_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI908_MN13 (XI908_xn1 XI908_xn pp7_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI908_MN2 (VSS A_20_b3_2 XI908_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI908_MN4 (XI908_n2 A_19_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI908_MN3 (XI908_xn two7_b3_3 XI908_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI908_MN1 (XI908_n1 one7_b3_3 XI908_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI908_MN9 (VSS XI908_xn XI908_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI748_MN11 (VSS B_9_b3_4 XI748_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI748_MN14 (VSS XI748_xbn XI748_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI748_MN16 (XI748_xn2 B_9_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI748_MN15 (pp4_25 XI748_xan XI748_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI748_MN13 (XI748_xn1 XI748_xn pp4_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI748_MN2 (VSS A_25_b3_1 XI748_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI748_MN4 (XI748_n2 A_24_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI748_MN3 (XI748_xn two4_b3_4 XI748_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI748_MN1 (XI748_n1 one4_b3_4 XI748_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI748_MN9 (VSS XI748_xn XI748_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI750_MN11 (VSS B_9_b3_4 XI750_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI750_MN14 (VSS XI750_xbn XI750_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI750_MN16 (XI750_xn2 B_9_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI750_MN15 (pp4_27 XI750_xan XI750_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI750_MN13 (XI750_xn1 XI750_xn pp4_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI750_MN2 (VSS A_27_b3_1 XI750_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI750_MN4 (XI750_n2 A_26_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI750_MN3 (XI750_xn two4_b3_4 XI750_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI750_MN1 (XI750_n1 one4_b3_4 XI750_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI750_MN9 (VSS XI750_xn XI750_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI696_MN11 (VSS B_7_b3_4 XI696_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI696_MN14 (VSS XI696_xbn XI696_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI696_MN16 (XI696_xn2 B_7_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI696_MN15 (pp3_28 XI696_xan XI696_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI696_MN13 (XI696_xn1 XI696_xn pp3_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI696_MN2 (VSS A_28_b3_1 XI696_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI696_MN4 (XI696_n2 A_27_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI696_MN3 (XI696_xn two3_b3_5 XI696_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI696_MN1 (XI696_n1 one3_b3_5 XI696_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI696_MN9 (VSS XI696_xn XI696_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI645_MN11 (VSS B_5_b3_5 XI645_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI645_MN14 (VSS XI645_xbn XI645_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI645_MN16 (XI645_xn2 B_5_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI645_MN15 (pp2_32 XI645_xan XI645_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI645_MN13 (XI645_xn1 XI645_xn pp2_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI645_MN2 (VSS A_31_b3_1 XI645_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI645_MN4 (XI645_n2 A_31_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI645_MN3 (XI645_xn two2_b3_5 XI645_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI645_MN1 (XI645_n1 one2_b3_5 XI645_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI645_MN9 (VSS XI645_xn XI645_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1120_MN11 (VSS B_23_b3_2 XI1120_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1120_MN14 (VSS XI1120_xbn XI1120_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1120_MN16 (XI1120_xn2 B_23_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1120_MN15 (pp11_12 XI1120_xan XI1120_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1120_MN13 (XI1120_xn1 XI1120_xn pp11_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1120_MN2 (VSS A_12_b3_4 XI1120_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1120_MN4 (XI1120_n2 A_11_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1120_MN3 (XI1120_xn two11_b3_2 XI1120_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1120_MN1 (XI1120_n1 one11_b3_2 XI1120_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1120_MN9 (VSS XI1120_xn XI1120_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1068_MN11 (VSS B_21_b3_2 XI1068_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1068_MN14 (VSS XI1068_xbn XI1068_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1068_MN16 (XI1068_xn2 B_21_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1068_MN15 (pp10_15 XI1068_xan XI1068_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1068_MN13 (XI1068_xn1 XI1068_xn pp10_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1068_MN2 (VSS A_15_b3_3 XI1068_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1068_MN4 (XI1068_n2 A_14_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1068_MN3 (XI1068_xn two10_b3_2 XI1068_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1068_MN1 (XI1068_n1 one10_b3_2 XI1068_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1068_MN9 (VSS XI1068_xn XI1068_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1283_MN11 (VSS B_29_b3_1 XI1283_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1283_MN14 (VSS XI1283_xbn XI1283_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1283_MN16 (XI1283_xn2 B_29_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1283_MN15 (pp14_10 XI1283_xan XI1283_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1283_MN13 (XI1283_xn1 XI1283_xn pp14_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1283_MN2 (VSS A_10_b3_5 XI1283_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1283_MN4 (XI1283_n2 A_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1283_MN3 (XI1283_xn two14_b3_1 XI1283_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1283_MN1 (XI1283_n1 one14_b3_1 XI1283_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1283_MN9 (VSS XI1283_xn XI1283_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1281_MN11 (VSS B_29_b3_1 XI1281_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1281_MN14 (VSS XI1281_xbn XI1281_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1281_MN16 (XI1281_xn2 B_29_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1281_MN15 (pp14_8 XI1281_xan XI1281_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1281_MN13 (XI1281_xn1 XI1281_xn pp14_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1281_MN2 (VSS A_8_b3_5 XI1281_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1281_MN4 (XI1281_n2 A_7_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1281_MN3 (XI1281_xn two14_b3_1 XI1281_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1281_MN1 (XI1281_n1 one14_b3_1 XI1281_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1281_MN9 (VSS XI1281_xn XI1281_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1336_MN11 (VSS B_31_b3_1 XI1336_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1336_MN14 (VSS XI1336_xbn XI1336_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1336_MN16 (XI1336_xn2 B_31_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1336_MN15 (pp15_8 XI1336_xan XI1336_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1336_MN13 (XI1336_xn1 XI1336_xn pp15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1336_MN2 (VSS A_8_b3_5 XI1336_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1336_MN4 (XI1336_n2 A_7_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1336_MN3 (XI1336_xn two15_b3_1 XI1336_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1336_MN1 (XI1336_n1 one15_b3_1 XI1336_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1336_MN9 (VSS XI1336_xn XI1336_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1334_MN11 (VSS B_31_b3_1 XI1334_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1334_MN14 (VSS XI1334_xbn XI1334_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1334_MN16 (XI1334_xn2 B_31_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1334_MN15 (pp15_6 XI1334_xan XI1334_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1334_MN13 (XI1334_xn1 XI1334_xn pp15_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1334_MN2 (VSS A_6_b3_5 XI1334_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1334_MN4 (XI1334_n2 A_5_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1334_MN3 (XI1334_xn two15_b3_1 XI1334_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1334_MN1 (XI1334_n1 one15_b3_1 XI1334_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1334_MN9 (VSS XI1334_xn XI1334_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1335_MN11 (VSS B_31_b3_1 XI1335_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1335_MN14 (VSS XI1335_xbn XI1335_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1335_MN16 (XI1335_xn2 B_31_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1335_MN15 (pp15_7 XI1335_xan XI1335_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1335_MN13 (XI1335_xn1 XI1335_xn pp15_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1335_MN2 (VSS A_7_b3_5 XI1335_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1335_MN4 (XI1335_n2 A_6_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1335_MN3 (XI1335_xn two15_b3_1 XI1335_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1335_MN1 (XI1335_n1 one15_b3_1 XI1335_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1335_MN9 (VSS XI1335_xn XI1335_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1339_MN11 (VSS B_31_b3_2 XI1339_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1339_MN14 (VSS XI1339_xbn XI1339_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1339_MN16 (XI1339_xn2 B_31_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1339_MN15 (pp15_11 XI1339_xan XI1339_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1339_MN13 (XI1339_xn1 XI1339_xn pp15_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1339_MN2 (VSS A_11_b3_5 XI1339_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1339_MN4 (XI1339_n2 A_10_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1339_MN3 (XI1339_xn two15_b3_2 XI1339_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1339_MN1 (XI1339_n1 one15_b3_2 XI1339_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1339_MN9 (VSS XI1339_xn XI1339_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1344_MN11 (VSS B_31_b3_2 XI1344_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1344_MN14 (VSS XI1344_xbn XI1344_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1344_MN16 (XI1344_xn2 B_31_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1344_MN15 (pp15_16 XI1344_xan XI1344_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1344_MN13 (XI1344_xn1 XI1344_xn pp15_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1344_MN2 (VSS A_16_b3_5 XI1344_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1344_MN4 (XI1344_n2 A_15_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1344_MN3 (XI1344_xn two15_b3_2 XI1344_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1344_MN1 (XI1344_n1 one15_b3_2 XI1344_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1344_MN9 (VSS XI1344_xn XI1344_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1193_MN11 (VSS B_25_b3_5 XI1193_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1193_MN14 (VSS XI1193_xbn XI1193_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1193_MN16 (XI1193_xn2 B_25_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1193_MN15 (pp12_30 XI1193_xan XI1193_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1193_MN13 (XI1193_xn1 XI1193_xn pp12_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1193_MN2 (VSS A_30_b3_4 XI1193_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1193_MN4 (XI1193_n2 A_29_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1193_MN3 (XI1193_xn two12_b3_5 XI1193_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1193_MN1 (XI1193_n1 one12_b3_5 XI1193_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1193_MN9 (VSS XI1193_xn XI1193_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1192_MN11 (VSS B_25_b3_5 XI1192_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1192_MN14 (VSS XI1192_xbn XI1192_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1192_MN16 (XI1192_xn2 B_25_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1192_MN15 (pp12_29 XI1192_xan XI1192_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1192_MN13 (XI1192_xn1 XI1192_xn pp12_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1192_MN2 (VSS A_29_b3_4 XI1192_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1192_MN4 (XI1192_n2 A_28_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1192_MN3 (XI1192_xn two12_b3_5 XI1192_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1192_MN1 (XI1192_n1 one12_b3_5 XI1192_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1192_MN9 (VSS XI1192_xn XI1192_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1300_MN11 (VSS B_29_b3_4 XI1300_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1300_MN14 (VSS XI1300_xbn XI1300_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1300_MN16 (XI1300_xn2 B_29_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1300_MN15 (pp14_27 XI1300_xan XI1300_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1300_MN13 (XI1300_xn1 XI1300_xn pp14_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1300_MN2 (VSS A_27_b3_5 XI1300_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1300_MN4 (XI1300_n2 A_26_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1300_MN3 (XI1300_xn two14_b3_4 XI1300_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1300_MN1 (XI1300_n1 one14_b3_4 XI1300_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1300_MN9 (VSS XI1300_xn XI1300_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI907_MN11 (VSS B_15_b3_3 XI907_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI907_MN14 (VSS XI907_xbn XI907_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI907_MN16 (XI907_xn2 B_15_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI907_MN15 (pp7_19 XI907_xan XI907_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI907_MN13 (XI907_xn1 XI907_xn pp7_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI907_MN2 (VSS A_19_b3_2 XI907_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI907_MN4 (XI907_n2 A_18_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI907_MN3 (XI907_xn two7_b3_3 XI907_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI907_MN1 (XI907_n1 one7_b3_3 XI907_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI907_MN9 (VSS XI907_xn XI907_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI854_MN11 (VSS B_13_b3_3 XI854_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI854_MN14 (VSS XI854_xbn XI854_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI854_MN16 (XI854_xn2 B_13_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI854_MN15 (pp6_21 XI854_xan XI854_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI854_MN13 (XI854_xn1 XI854_xn pp6_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI854_MN2 (VSS A_21_b3_2 XI854_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI854_MN4 (XI854_n2 A_20_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI854_MN3 (XI854_xn two6_b3_3 XI854_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI854_MN1 (XI854_n1 one6_b3_3 XI854_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI854_MN9 (VSS XI854_xn XI854_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI800_MN11 (VSS B_11_b3_3 XI800_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI800_MN14 (VSS XI800_xbn XI800_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI800_MN16 (XI800_xn2 B_11_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI800_MN15 (pp5_22 XI800_xan XI800_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI800_MN13 (XI800_xn1 XI800_xn pp5_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI800_MN2 (VSS A_22_b3_1 XI800_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI800_MN4 (XI800_n2 A_21_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI800_MN3 (XI800_xn two5_b3_4 XI800_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI800_MN1 (XI800_n1 one5_b3_4 XI800_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI800_MN9 (VSS XI800_xn XI800_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI694_MN11 (VSS B_7_b3_4 XI694_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI694_MN14 (VSS XI694_xbn XI694_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI694_MN16 (XI694_xn2 B_7_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI694_MN15 (pp3_26 XI694_xan XI694_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI694_MN13 (XI694_xn1 XI694_xn pp3_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI694_MN2 (VSS A_26_b3_1 XI694_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI694_MN4 (XI694_n2 A_25_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI694_MN3 (XI694_xn two3_b3_4 XI694_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI694_MN1 (XI694_n1 one3_b3_4 XI694_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI694_MN9 (VSS XI694_xn XI694_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI695_MN11 (VSS B_7_b3_4 XI695_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI695_MN14 (VSS XI695_xbn XI695_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI695_MN16 (XI695_xn2 B_7_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI695_MN15 (pp3_27 XI695_xan XI695_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI695_MN13 (XI695_xn1 XI695_xn pp3_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI695_MN2 (VSS A_27_b3_1 XI695_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI695_MN4 (XI695_n2 A_26_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI695_MN3 (XI695_xn two3_b3_4 XI695_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI695_MN1 (XI695_n1 one3_b3_4 XI695_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI695_MN9 (VSS XI695_xn XI695_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI643_MN11 (VSS B_5_b3_5 XI643_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI643_MN14 (VSS XI643_xbn XI643_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI643_MN16 (XI643_xn2 B_5_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI643_MN15 (pp2_30 XI643_xan XI643_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI643_MN13 (XI643_xn1 XI643_xn pp2_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI643_MN2 (VSS A_30_b3_0 XI643_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI643_MN4 (XI643_n2 A_29_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI643_MN3 (XI643_xn two2_b3_5 XI643_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI643_MN1 (XI643_n1 one2_b3_5 XI643_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI643_MN9 (VSS XI643_xn XI643_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1119_MN11 (VSS B_23_b3_2 XI1119_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1119_MN14 (VSS XI1119_xbn XI1119_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1119_MN16 (XI1119_xn2 B_23_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1119_MN15 (pp11_11 XI1119_xan XI1119_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1119_MN13 (XI1119_xn1 XI1119_xn pp11_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
