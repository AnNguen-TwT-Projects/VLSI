    I_MXI162_MP2_1 (VDD A_15_b1_0 A_15_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI611_MP2 (two2_b3_4 two2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI611_MP2_1 (VDD two2_b2_1 two2_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI601_MP2 (one2_b3_4 one2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI601_MP2_1 (VDD one2_b2_1 one2_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI980_MP2 (one9_b2_0 one9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI980_MP2_1 (VDD one9_b1_0 one9_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI78_MP2 (A_6_b3_4 A_6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI78_MP2_1 (VDD A_6_b2_1 A_6_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1092_MP2 (one11_b3_0 one11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1092_MP2_1 (VDD one11_b2_0 one11_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1102_MP2 (two11_b3_0 two11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1102_MP2_1 (VDD two11_b2_0 two11_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1147_MP2 (one12_b3_0 one12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1147_MP2_1 (VDD one12_b2_0 one12_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1157_MP2 (two12_b3_0 two12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1157_MP2_1 (VDD two12_b2_0 two12_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI59_MP2 (A_4_b3_5 A_4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI59_MP2_1 (VDD A_4_b2_1 A_4_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI771_MP2 (two5_b2_1 two5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI771_MP2_1 (VDD two5_b1_0 two5_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI655_MP2 (one3_b3_3 one3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI655_MP2_1 (VDD one3_b2_1 one3_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI194_MP2 (A_18_b3_0 A_18_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI194_MP2_1 (VDD A_18_b2_0 A_18_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI121_MP2 (A_11_b1_0 A_11_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI121_MP2_1 (VDD A_11_b0 A_11_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI547_MP2 (one1_b3_5 one1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI547_MP2_1 (VDD one1_b2_1 one1_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI924_MP2 (one8_b1_0 one8_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI924_MP2_1 (VDD one8_b0 one8_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI925_MP2 (one8_b2_0 one8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI925_MP2_1 (VDD one8_b1_0 one8_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI934_MP2 (two8_b1_0 two8_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI934_MP2_1 (VDD two8_b0 two8_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI929_MP2 (one8_b3_2 one8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI929_MP2_1 (VDD one8_b2_0 one8_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI935_MP2 (two8_b2_0 two8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI935_MP2_1 (VDD two8_b1_0 two8_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI939_MP2 (two8_b3_2 two8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI939_MP2_1 (VDD two8_b2_0 two8_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI107_MP2 (A_9_b3_3 A_9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI107_MP2_1 (VDD A_9_b2_1 A_9_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI427_MP2 (B_21_b3_1 B_21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI427_MP2_1 (VDD B_21_b2_0 B_21_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI426_MP2 (B_21_b3_0 B_21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI426_MP2_1 (VDD B_21_b2_0 B_21_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1038_MP2 (one10_b3_1 one10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1038_MP2_1 (VDD one10_b2_0 one10_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1048_MP2 (two10_b3_1 two10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1048_MP2_1 (VDD two10_b2_0 two10_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI68_MP2 (A_5_b3_4 A_5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI68_MP2_1 (VDD A_5_b2_1 A_5_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI979_MP2 (one9_b1_0 one9_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI979_MP2_1 (VDD one9_b0 one9_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI990_MP2 (two9_b2_0 two9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI990_MP2_1 (VDD two9_b1_0 two9_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI989_MP2 (two9_b1_0 two9_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI989_MP2_1 (VDD two9_b0 two9_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI870_MP2 (one7_b2_0 one7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI870_MP2_1 (VDD one7_b1_0 one7_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI880_MP2 (two7_b2_0 two7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI880_MP2_1 (VDD two7_b1_0 two7_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI396_MP2 (B_15_b3_0 B_15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI396_MP2_1 (VDD B_15_b2_0 B_15_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI364_MP2 (B_9_b2_0 B_9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI364_MP2_1 (VDD B_9_b1_0 B_9_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI720_MP2 (two4_b3_3 two4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI720_MP2_1 (VDD two4_b2_1 two4_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI492_MP2 (one0_b3_5 one0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI492_MP2_1 (VDD one0_b2_1 one0_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI350_MP2 (B_5_b3_4 B_5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI350_MP2_1 (VDD B_5_b2_1 B_5_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1037_MP2 (one10_b3_0 one10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1037_MP2_1 (VDD one10_b2_0 one10_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1047_MP2 (two10_b3_0 two10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1047_MP2_1 (VDD two10_b2_0 two10_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI87_MP2 (A_7_b3_3 A_7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI87_MP2_1 (VDD A_7_b2_1 A_7_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI58_MP2 (A_4_b3_4 A_4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI58_MP2_1 (VDD A_4_b2_1 A_4_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI49_MP2 (A_3_b3_5 A_3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI49_MP2_1 (VDD A_3_b2_1 A_3_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_MP2 (two7_b3_2 two7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_MP2_1 (VDD two7_b2_0 two7_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI398_MP2 (B_15_b3_2 B_15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI398_MP2_1 (VDD B_15_b2_0 B_15_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI406_MP2 (B_17_b3_0 B_17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI406_MP2_1 (VDD B_17_b2_0 B_17_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI117_MP2 (A_10_b3_3 A_10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI117_MP2_1 (VDD A_10_b2_1 A_10_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI77_MP2 (A_6_b3_3 A_6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI77_MP2_1 (VDD A_6_b2_1 A_6_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI416_MP2 (B_19_b3_0 B_19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI416_MP2_1 (VDD B_19_b2_0 B_19_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI48_MP2 (A_3_b3_4 A_3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI48_MP2_1 (VDD A_3_b2_1 A_3_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI397_MP2 (B_15_b3_1 B_15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI397_MP2_1 (VDD B_15_b2_0 B_15_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI706_MP2 (one4_b2_1 one4_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI706_MP2_1 (VDD one4_b1_0 one4_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI353_MP2 (B_7_b1_0 B_7_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI353_MP2_1 (VDD B_7_b0 B_7_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI156_MP2 (A_14_b3_2 A_14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI156_MP2_1 (VDD A_14_b2_0 A_14_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI716_MP2 (two4_b2_1 two4_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI716_MP2_1 (VDD two4_b1_0 two4_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI166_MP2 (A_15_b3_2 A_15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI166_MP2_1 (VDD A_15_b2_0 A_15_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI175_MP2 (A_16_b3_1 A_16_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI175_MP2_1 (VDD A_16_b2_0 A_16_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI184_MP2 (A_17_b3_0 A_17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI184_MP2_1 (VDD A_17_b2_0 A_17_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI502_MP2 (two0_b3_5 two0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI502_MP2_1 (VDD two0_b2_1 two0_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI546_MP2 (one1_b3_4 one1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI546_MP2_1 (VDD one1_b2_1 one1_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI557_MP2 (two1_b3_5 two1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI557_MP2_1 (VDD two1_b2_1 two1_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI349_MP2 (B_5_b3_3 B_5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI349_MP2_1 (VDD B_5_b2_1 B_5_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI993_MP2 (two9_b3_1 two9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI993_MP2_1 (VDD two9_b2_0 two9_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI983_MP2 (one9_b3_1 one9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI983_MP2_1 (VDD one9_b2_0 one9_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI982_MP2 (one9_b3_0 one9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI982_MP2_1 (VDD one9_b2_0 one9_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI417_MP2 (B_19_b3_1 B_19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI417_MP2_1 (VDD B_19_b2_0 B_19_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI815_MP2 (one6_b2_0 one6_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI815_MP2_1 (VDD one6_b1_0 one6_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI874_MP2 (one7_b3_2 one7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI874_MP2_1 (VDD one7_b2_0 one7_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI388_MP2 (B_13_b3_2 B_13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI388_MP2_1 (VDD B_13_b2_0 B_13_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI174_MP2 (A_16_b3_0 A_16_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI174_MP2_1 (VDD A_16_b2_0 A_16_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI491_MP2 (one0_b3_4 one0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI491_MP2_1 (VDD one0_b2_1 one0_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI556_MP2 (two1_b3_4 two1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI556_MP2_1 (VDD two1_b2_1 two1_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI340_MP2 (B_3_b3_4 B_3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI340_MP2_1 (VDD B_3_b2_1 B_3_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI407_MP2 (B_17_b3_1 B_17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI407_MP2_1 (VDD B_17_b2_0 B_17_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI992_MP2 (two9_b3_0 two9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI992_MP2_1 (VDD two9_b2_0 two9_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI38_MP2 (A_2_b3_4 A_2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI38_MP2_1 (VDD A_2_b2_1 A_2_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI39_MP2 (A_2_b3_5 A_2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI39_MP2_1 (VDD A_2_b2_1 A_2_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI814_MP2 (one6_b1_0 one6_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI814_MP2_1 (VDD one6_b0 one6_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI824_MP2 (two6_b1_0 two6_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI824_MP2_1 (VDD two6_b0 two6_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI825_MP2 (two6_b2_0 two6_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI825_MP2_1 (VDD two6_b1_0 two6_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI819_MP2 (one6_b3_2 one6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI819_MP2_1 (VDD one6_b2_0 one6_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI829_MP2 (two6_b3_2 two6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI829_MP2_1 (VDD two6_b2_0 two6_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI146_MP2 (A_13_b3_2 A_13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI146_MP2_1 (VDD A_13_b2_0 A_13_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI661_MP2 (two3_b2_1 two3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI661_MP2_1 (VDD two3_b1_0 two3_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI142_MP2 (A_13_b2_0 A_13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI142_MP2_1 (VDD A_13_b1_0 A_13_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI651_MP2 (one3_b2_1 one3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI651_MP2_1 (VDD one3_b1_0 one3_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI501_MP2 (two0_b3_4 two0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI501_MP2_1 (VDD two0_b2_1 two0_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI339_MP2 (B_3_b3_3 B_3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI339_MP2_1 (VDD B_3_b2_1 B_3_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI341_MP2 (B_3_b3_5 B_3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI341_MP2_1 (VDD B_3_b2_1 B_3_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI97_MP2 (A_8_b3_3 A_8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI97_MP2_1 (VDD A_8_b2_1 A_8_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI67_MP2 (A_5_b3_3 A_5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI67_MP2_1 (VDD A_5_b2_1 A_5_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI18_MP2 (A_0_b3_4 A_0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI18_MP2_1 (VDD A_0_b2_1 A_0_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI28_MP2 (A_1_b3_4 A_1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI28_MP2_1 (VDD A_1_b2_1 A_1_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI29_MP2 (A_1_b3_5 A_1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI29_MP2_1 (VDD A_1_b2_1 A_1_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI19_MP2 (A_0_b3_5 A_0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI19_MP2_1 (VDD A_0_b2_1 A_0_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI769_MP2 (two5_b1_0 two5_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI769_MP2_1 (VDD two5_b0 two5_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI386_MP2 (B_13_b3_0 B_13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI386_MP2_1 (VDD B_13_b2_0 B_13_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI387_MP2 (B_13_b3_1 B_13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI387_MP2_1 (VDD B_13_b2_0 B_13_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI136_MP2 (A_12_b3_2 A_12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI136_MP2_1 (VDD A_12_b2_0 A_12_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI354_MP2 (B_7_b2_0 B_7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI354_MP2_1 (VDD B_7_b1_0 B_7_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI164_MP2 (A_15_b3_0 A_15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI164_MP2_1 (VDD A_15_b2_0 A_15_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI132_MP2 (A_12_b2_0 A_12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI132_MP2_1 (VDD A_12_b1_0 A_12_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI928_MP2 (one8_b3_1 one8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI928_MP2_1 (VDD one8_b2_0 one8_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI938_MP2 (two8_b3_1 two8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI938_MP2_1 (VDD two8_b2_0 two8_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI759_MP2 (one5_b1_0 one5_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI759_MP2_1 (VDD one5_b0 one5_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI770_MP2 (two5_b2_0 two5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI770_MP2_1 (VDD two5_b1_0 two5_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI774_MP2 (two5_b3_2 two5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI774_MP2_1 (VDD two5_b2_0 two5_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI378_MP2 (B_11_b3_2 B_11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI378_MP2_1 (VDD B_11_b2_0 B_11_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI145_MP2 (A_13_b3_1 A_13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI145_MP2_1 (VDD A_13_b2_0 A_13_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI165_MP2 (A_15_b3_1 A_15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI165_MP2_1 (VDD A_15_b2_0 A_15_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI144_MP2 (A_13_b3_0 A_13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI144_MP2_1 (VDD A_13_b2_0 A_13_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI155_MP2 (A_14_b3_1 A_14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI155_MP2_1 (VDD A_14_b2_0 A_14_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI358_MP2 (B_7_b3_2 B_7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI358_MP2_1 (VDD B_7_b2_0 B_7_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI610_MP2 (two2_b3_3 two2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI610_MP2_1 (VDD two2_b2_1 two2_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI600_MP2 (one2_b3_3 one2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI600_MP2_1 (VDD one2_b2_1 one2_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI122_MP2 (A_11_b2_0 A_11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI122_MP2_1 (VDD A_11_b1_0 A_11_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI7_MP2 (B_1_b3_3 B_1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI7_MP2_1 (VDD B_1_b2_1 B_1_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI8_MP2 (B_1_b3_4 B_1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI8_MP2_1 (VDD B_1_b2_1 B_1_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI545_MP2 (one1_b3_3 one1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI545_MP2_1 (VDD one1_b2_1 one1_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI555_MP2 (two1_b3_3 two1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI555_MP2_1 (VDD two1_b2_1 two1_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI9_MP2 (B_1_b3_5 B_1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI9_MP2_1 (VDD B_1_b2_1 B_1_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI351_MP2 (B_5_b3_5 B_5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI351_MP2_1 (VDD B_5_b2_1 B_5_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI606_MP2 (two2_b2_1 two2_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI606_MP2_1 (VDD two2_b1_0 two2_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI335_MP2 (B_3_b2_1 B_3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI335_MP2_1 (VDD B_3_b1_0 B_3_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI551_MP2 (two1_b2_1 two1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI551_MP2_1 (VDD two1_b1_0 two1_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI937_MP2 (two8_b3_0 two8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI937_MP2_1 (VDD two8_b2_0 two8_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI760_MP2 (one5_b2_0 one5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI760_MP2_1 (VDD one5_b1_0 one5_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI764_MP2 (one5_b3_2 one5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI764_MP2_1 (VDD one5_b2_0 one5_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI376_MP2 (B_11_b3_0 B_11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI376_MP2_1 (VDD B_11_b2_0 B_11_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI126_MP2 (A_11_b3_2 A_11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI126_MP2_1 (VDD A_11_b2_0 A_11_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI135_MP2 (A_12_b3_1 A_12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI135_MP2_1 (VDD A_12_b2_0 A_12_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI500_MP2 (two0_b3_3 two0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI500_MP2_1 (VDD two0_b2_1 two0_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI927_MP2 (one8_b3_0 one8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI927_MP2_1 (VDD one8_b2_0 one8_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI57_MP2 (A_4_b3_3 A_4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI57_MP2_1 (VDD A_4_b2_1 A_4_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI873_MP2 (one7_b3_1 one7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI873_MP2_1 (VDD one7_b2_0 one7_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI125_MP2 (A_11_b3_1 A_11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI125_MP2_1 (VDD A_11_b2_0 A_11_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI134_MP2 (A_12_b3_0 A_12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI134_MP2_1 (VDD A_12_b2_0 A_12_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI490_MP2 (one0_b3_3 one0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI490_MP2_1 (VDD one0_b2_1 one0_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI883_MP2 (two7_b3_1 two7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI883_MP2_1 (VDD two7_b2_0 two7_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI116_MP2 (A_10_b3_2 A_10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI116_MP2_1 (VDD A_10_b2_0 A_10_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI377_MP2 (B_11_b3_1 B_11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI377_MP2_1 (VDD B_11_b2_0 B_11_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI115_MP2 (A_10_b3_1 A_10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI115_MP2_1 (VDD A_10_b2_0 A_10_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI124_MP2 (A_11_b3_0 A_11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI124_MP2_1 (VDD A_11_b2_0 A_11_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI3_MP2 (B_1_b2_1 B_1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI3_MP2_1 (VDD B_1_b1_0 B_1_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI345_MP2 (B_5_b2_1 B_5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI345_MP2_1 (VDD B_5_b1_0 B_5_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI541_MP2 (one1_b2_1 one1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI541_MP2_1 (VDD one1_b1_0 one1_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI103_MP2 (A_9_b2_1 A_9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI103_MP2_1 (VDD A_9_b1_0 A_9_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI47_MP2 (A_3_b3_3 A_3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI47_MP2_1 (VDD A_3_b2_1 A_3_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI882_MP2 (two7_b3_0 two7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI882_MP2_1 (VDD two7_b2_0 two7_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI818_MP2 (one6_b3_1 one6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI818_MP2_1 (VDD one6_b2_0 one6_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI828_MP2 (two6_b3_1 two6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI828_MP2_1 (VDD two6_b2_0 two6_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI368_MP2 (B_9_b3_2 B_9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI368_MP2_1 (VDD B_9_b2_0 B_9_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI719_MP2 (two4_b3_2 two4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI719_MP2_1 (VDD two4_b2_0 two4_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI715_MP2 (two4_b2_0 two4_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI715_MP2_1 (VDD two4_b1_0 two4_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI660_MP2 (two3_b2_0 two3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI660_MP2_1 (VDD two3_b1_0 two3_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI664_MP2 (two3_b3_2 two3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI664_MP2_1 (VDD two3_b2_0 two3_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_MP2 (one3_b3_2 one3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_MP2_1 (VDD one3_b2_0 one3_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI650_MP2 (one3_b2_0 one3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI650_MP2_1 (VDD one3_b1_0 one3_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI154_MP2 (A_14_b3_0 A_14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI154_MP2_1 (VDD A_14_b2_0 A_14_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI596_MP2 (one2_b2_1 one2_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI596_MP2_1 (VDD one2_b1_0 one2_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI872_MP2 (one7_b3_0 one7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI872_MP2_1 (VDD one7_b2_0 one7_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI705_MP2 (one4_b2_0 one4_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI705_MP2_1 (VDD one4_b1_0 one4_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI709_MP2 (one4_b3_2 one4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI709_MP2_1 (VDD one4_b2_0 one4_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI714_MP2 (two4_b1_0 two4_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI714_MP2_1 (VDD two4_b0 two4_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI106_MP2 (A_9_b3_2 A_9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI106_MP2_1 (VDD A_9_b2_0 A_9_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI659_MP2 (two3_b1_0 two3_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI659_MP2_1 (VDD two3_b0 two3_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI649_MP2 (one3_b1_0 one3_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI649_MP2_1 (VDD one3_b0 one3_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI486_MP2 (one0_b2_1 one0_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI486_MP2_1 (VDD one0_b1_0 one0_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI111_MP2 (A_10_b1_0 A_10_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI111_MP2_1 (VDD A_10_b0 A_10_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI102_MP2 (A_9_b2_0 A_9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI102_MP2_1 (VDD A_9_b1_0 A_9_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI113_MP2 (A_10_b2_1 A_10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI113_MP2_1 (VDD A_10_b1_0 A_10_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI93_MP2 (A_8_b2_1 A_8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI93_MP2_1 (VDD A_8_b1_0 A_8_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI83_MP2 (A_7_b2_1 A_7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI83_MP2_1 (VDD A_7_b1_0 A_7_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI37_MP2 (A_2_b3_3 A_2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI37_MP2_1 (VDD A_2_b2_1 A_2_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI27_MP2 (A_1_b3_3 A_1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI27_MP2_1 (VDD A_1_b2_1 A_1_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI53_MP2 (A_4_b2_1 A_4_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI53_MP2_1 (VDD A_4_b1_0 A_4_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI817_MP2 (one6_b3_0 one6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI817_MP2_1 (VDD one6_b2_0 one6_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI96_MP2 (A_8_b3_2 A_8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI96_MP2_1 (VDD A_8_b2_0 A_8_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI827_MP2 (two6_b3_0 two6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI827_MP2_1 (VDD two6_b2_0 two6_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI763_MP2 (one5_b3_1 one5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI763_MP2_1 (VDD one5_b2_0 one5_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI704_MP2 (one4_b1_0 one4_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI704_MP2_1 (VDD one4_b0 one4_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI356_MP2 (B_7_b3_0 B_7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI356_MP2_1 (VDD B_7_b2_0 B_7_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI599_MP2 (one2_b3_2 one2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI599_MP2_1 (VDD one2_b2_0 one2_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI348_MP2 (B_5_b3_2 B_5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI348_MP2_1 (VDD B_5_b2_0 B_5_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI609_MP2 (two2_b3_2 two2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI609_MP2_1 (VDD two2_b2_0 two2_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI344_MP2 (B_5_b2_0 B_5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI344_MP2_1 (VDD B_5_b1_0 B_5_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI605_MP2 (two2_b2_0 two2_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI605_MP2_1 (VDD two2_b1_0 two2_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI595_MP2 (one2_b2_0 one2_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI595_MP2_1 (VDD one2_b1_0 one2_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI604_MP2 (two2_b1_0 two2_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI604_MP2_1 (VDD two2_b0 two2_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI101_MP2 (A_9_b1_0 A_9_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI101_MP2_1 (VDD A_9_b0 A_9_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI92_MP2 (A_8_b2_0 A_8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI92_MP2_1 (VDD A_8_b1_0 A_8_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI91_MP2 (A_8_b1_0 A_8_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI91_MP2_1 (VDD A_8_b0 A_8_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI82_MP2 (A_7_b2_0 A_7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI82_MP2_1 (VDD A_7_b1_0 A_7_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI81_MP2 (A_7_b1_0 A_7_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI81_MP2_1 (VDD A_7_b0 A_7_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI63_MP2 (A_5_b2_1 A_5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI63_MP2_1 (VDD A_5_b1_0 A_5_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI73_MP2 (A_6_b2_1 A_6_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI73_MP2_1 (VDD A_6_b1_0 A_6_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI33_MP2 (A_2_b2_1 A_2_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI33_MP2_1 (VDD A_2_b1_0 A_2_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI17_MP2 (A_0_b3_3 A_0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI17_MP2_1 (VDD A_0_b2_1 A_0_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI367_MP2 (B_9_b3_1 B_9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI367_MP2_1 (VDD B_9_b2_0 B_9_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI366_MP2 (B_9_b3_0 B_9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI366_MP2_1 (VDD B_9_b2_0 B_9_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI86_MP2 (A_7_b3_2 A_7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI86_MP2_1 (VDD A_7_b2_0 A_7_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI105_MP2 (A_9_b3_1 A_9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI105_MP2_1 (VDD A_9_b2_0 A_9_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI544_MP2 (one1_b3_2 one1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI544_MP2_1 (VDD one1_b2_0 one1_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI554_MP2 (two1_b3_2 two1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI554_MP2_1 (VDD two1_b2_0 two1_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI343_MP2 (B_5_b1_0 B_5_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI343_MP2_1 (VDD B_5_b0 B_5_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI540_MP2 (one1_b2_0 one1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI540_MP2_1 (VDD one1_b1_0 one1_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI346_MP2 (B_5_b3_0 B_5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI346_MP2_1 (VDD B_5_b2_0 B_5_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI594_MP2 (one2_b1_0 one2_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI594_MP2_1 (VDD one2_b0 one2_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI496_MP2 (two0_b2_1 two0_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI496_MP2_1 (VDD two0_b1_0 two0_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI550_MP2 (two1_b2_0 two1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI550_MP2_1 (VDD two1_b1_0 two1_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI549_MP2 (two1_b1_0 two1_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI549_MP2_1 (VDD two1_b0 two1_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI539_MP2 (one1_b1_0 one1_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI539_MP2_1 (VDD one1_b0 one1_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI72_MP2 (A_6_b2_0 A_6_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI72_MP2_1 (VDD A_6_b1_0 A_6_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI71_MP2 (A_6_b1_0 A_6_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI71_MP2_1 (VDD A_6_b0 A_6_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI43_MP2 (A_3_b2_1 A_3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI43_MP2_1 (VDD A_3_b1_0 A_3_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI13_MP2 (A_0_b2_1 A_0_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI13_MP2_1 (VDD A_0_b1_0 A_0_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI23_MP2 (A_1_b2_1 A_1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI23_MP2_1 (VDD A_1_b1_0 A_1_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI773_MP2 (two5_b3_1 two5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI773_MP2_1 (VDD two5_b2_0 two5_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI762_MP2 (one5_b3_0 one5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI762_MP2_1 (VDD one5_b2_0 one5_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI708_MP2 (one4_b3_1 one4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI708_MP2_1 (VDD one4_b2_0 one4_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI66_MP2 (A_5_b3_2 A_5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI66_MP2_1 (VDD A_5_b2_0 A_5_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI76_MP2 (A_6_b3_2 A_6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI76_MP2_1 (VDD A_6_b2_0 A_6_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI95_MP2 (A_8_b3_1 A_8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI95_MP2_1 (VDD A_8_b2_0 A_8_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI357_MP2 (B_7_b3_1 B_7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI357_MP2_1 (VDD B_7_b2_0 B_7_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI338_MP2 (B_3_b3_2 B_3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI338_MP2_1 (VDD B_3_b2_0 B_3_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI104_MP2 (A_9_b3_0 A_9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI104_MP2_1 (VDD A_9_b2_0 A_9_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI334_MP2 (B_3_b2_0 B_3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI334_MP2_1 (VDD B_3_b1_0 B_3_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI333_MP2 (B_3_b1_0 B_3_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI333_MP2_1 (VDD B_3_b0 B_3_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI499_MP2 (two0_b3_2 two0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI499_MP2_1 (VDD two0_b2_0 two0_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI94_MP2 (A_8_b3_0 A_8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI94_MP2_1 (VDD A_8_b2_0 A_8_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI495_MP2 (two0_b2_0 two0_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI495_MP2_1 (VDD two0_b1_0 two0_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI494_MP2 (two0_b1_0 two0_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI494_MP2_1 (VDD two0_b0 two0_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI336_MP2 (B_3_b3_0 B_3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI336_MP2_1 (VDD B_3_b2_0 B_3_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI62_MP2 (A_5_b2_0 A_5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI62_MP2_1 (VDD A_5_b1_0 A_5_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI61_MP2 (A_5_b1_0 A_5_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI61_MP2_1 (VDD A_5_b0 A_5_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI42_MP2 (A_3_b2_0 A_3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI42_MP2_1 (VDD A_3_b1_0 A_3_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI32_MP2 (A_2_b2_0 A_2_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI32_MP2_1 (VDD A_2_b1_0 A_2_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI41_MP2 (A_3_b1_0 A_3_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI41_MP2_1 (VDD A_3_b0 A_3_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI31_MP2 (A_2_b1_0 A_2_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI31_MP2_1 (VDD A_2_b0 A_2_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI11_MP2 (A_0_b1_0 A_0_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI11_MP2_1 (VDD A_0_b0 A_0_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI12_MP2 (A_0_b2_0 A_0_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI12_MP2_1 (VDD A_0_b1_0 A_0_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI772_MP2 (two5_b3_0 two5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI772_MP2_1 (VDD two5_b2_0 two5_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI718_MP2 (two4_b3_1 two4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI718_MP2_1 (VDD two4_b2_0 two4_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI85_MP2 (A_7_b3_1 A_7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI85_MP2_1 (VDD A_7_b2_0 A_7_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI75_MP2 (A_6_b3_1 A_6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI75_MP2_1 (VDD A_6_b2_0 A_6_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI6_MP2 (B_1_b3_2 B_1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI6_MP2_1 (VDD B_1_b2_0 B_1_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_MP2 (B_1_b2_0 B_1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_MP2_1 (VDD B_1_b1_0 B_1_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_MP2 (B_1_b1_0 B_1_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_MP2_1 (VDD B_1_b0 B_1_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI489_MP2 (one0_b3_2 one0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI489_MP2_1 (VDD one0_b2_0 one0_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI485_MP2 (one0_b2_0 one0_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI485_MP2_1 (VDD one0_b1_0 one0_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI487_MP2 (one0_b3_0 one0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI487_MP2_1 (VDD one0_b2_0 one0_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI484_MP2 (one0_b1_0 one0_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI484_MP2_1 (VDD one0_b0 one0_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI22_MP2 (A_1_b2_0 A_1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI22_MP2_1 (VDD A_1_b1_0 A_1_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI51_MP2 (A_4_b1_0 A_4_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI51_MP2_1 (VDD A_4_b0 A_4_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI14_MP2 (A_0_b3_0 A_0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI14_MP2_1 (VDD A_0_b2_0 A_0_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI21_MP2 (A_1_b1_0 A_1_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI21_MP2_1 (VDD A_1_b0 A_1_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI56_MP2 (A_4_b3_2 A_4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI56_MP2_1 (VDD A_4_b2_0 A_4_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI663_MP2 (two3_b3_1 two3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI663_MP2_1 (VDD two3_b2_0 two3_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI653_MP2 (one3_b3_1 one3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI653_MP2_1 (VDD one3_b2_0 one3_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI598_MP2 (one2_b3_1 one2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI598_MP2_1 (VDD one2_b2_0 one2_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_MP2 (two2_b3_1 two2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_MP2_1 (VDD two2_b2_0 two2_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI553_MP2 (two1_b3_1 two1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI553_MP2_1 (VDD two1_b2_0 two1_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI543_MP2 (one1_b3_1 one1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI543_MP2_1 (VDD one1_b2_0 one1_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI337_MP2 (B_3_b3_1 B_3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI337_MP2_1 (VDD B_3_b2_0 B_3_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI488_MP2 (one0_b3_1 one0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI488_MP2_1 (VDD one0_b2_0 one0_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI498_MP2 (two0_b3_1 two0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI498_MP2_1 (VDD two0_b2_0 two0_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI542_MP2 (one1_b3_0 one1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI542_MP2_1 (VDD one1_b2_0 one1_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI607_MP2 (two2_b3_0 two2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI607_MP2_1 (VDD two2_b2_0 two2_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI552_MP2 (two1_b3_0 two1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI552_MP2_1 (VDD two1_b2_0 two1_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI497_MP2 (two0_b3_0 two0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI497_MP2_1 (VDD two0_b2_0 two0_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI5_MP2 (B_1_b3_1 B_1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI5_MP2_1 (VDD B_1_b2_0 B_1_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI4_MP2 (B_1_b3_0 B_1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI4_MP2_1 (VDD B_1_b2_0 B_1_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI44_MP2 (A_3_b3_0 A_3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI44_MP2_1 (VDD A_3_b2_0 A_3_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI52_MP2 (A_4_b2_0 A_4_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI52_MP2_1 (VDD A_4_b1_0 A_4_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI24_MP2 (A_1_b3_0 A_1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI24_MP2_1 (VDD A_1_b2_0 A_1_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI34_MP2 (A_2_b3_0 A_2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI34_MP2_1 (VDD A_2_b2_0 A_2_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI46_MP2 (A_3_b3_2 A_3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI46_MP2_1 (VDD A_3_b2_0 A_3_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI36_MP2 (A_2_b3_2 A_2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI36_MP2_1 (VDD A_2_b2_0 A_2_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI707_MP2 (one4_b3_0 one4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI707_MP2_1 (VDD one4_b2_0 one4_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI717_MP2 (two4_b3_0 two4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI717_MP2_1 (VDD two4_b2_0 two4_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI65_MP2 (A_5_b3_1 A_5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI65_MP2_1 (VDD A_5_b2_0 A_5_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI55_MP2 (A_4_b3_1 A_4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI55_MP2_1 (VDD A_4_b2_0 A_4_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI662_MP2 (two3_b3_0 two3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI662_MP2_1 (VDD two3_b2_0 two3_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI652_MP2 (one3_b3_0 one3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI652_MP2_1 (VDD one3_b2_0 one3_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI597_MP2 (one2_b3_0 one2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI597_MP2_1 (VDD one2_b2_0 one2_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI64_MP2 (A_5_b3_0 A_5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI64_MP2_1 (VDD A_5_b2_0 A_5_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI54_MP2 (A_4_b3_0 A_4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI54_MP2_1 (VDD A_4_b2_0 A_4_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI35_MP2 (A_2_b3_1 A_2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI35_MP2_1 (VDD A_2_b2_0 A_2_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI45_MP2 (A_3_b3_1 A_3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI45_MP2_1 (VDD A_3_b2_0 A_3_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI16_MP2 (A_0_b3_2 A_0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI16_MP2_1 (VDD A_0_b2_0 A_0_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI15_MP2 (A_0_b3_1 A_0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI15_MP2_1 (VDD A_0_b2_0 A_0_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI26_MP2 (A_1_b3_2 A_1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI26_MP2_1 (VDD A_1_b2_0 A_1_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI25_MP2 (A_1_b3_1 A_1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI25_MP2_1 (VDD A_1_b2_0 A_1_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1640_MP9 (XI1640_xp1 cm228_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1640_MP11 (ha279_0 XI1640_xan XI1640_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1640_MP12 (XI1640_xp1 XI1640_xbn ha279_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1640_MP10 (VDD cm229_0 XI1640_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1640_MP2 (VDD cm228_1 XI1640_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1640_MP16 (XI1640_con cm229_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1640_MP15 (VDD cm228_1 XI1640_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1640_MP18 (VDD XI1640_con ha279_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1640_MP4 (XI1640_xbn cm229_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1643_MP9 (XI1643_xp1 cm231_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1643_MP11 (ha282_0 XI1643_xan XI1643_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1643_MP12 (XI1643_xp1 XI1643_xbn ha282_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1643_MP10 (VDD cm232_0 XI1643_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1643_MP2 (VDD cm231_1 XI1643_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1643_MP16 (XI1643_con cm232_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1643_MP15 (VDD cm231_1 XI1643_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1643_MP18 (VDD XI1643_con ha282_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1643_MP4 (XI1643_xbn cm232_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1645_MP9 (XI1645_xp1 cm233_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1645_MP11 (ha284_0 XI1645_xan XI1645_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1645_MP12 (XI1645_xp1 XI1645_xbn ha284_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1645_MP10 (VDD cm234_0 XI1645_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1645_MP2 (VDD cm233_1 XI1645_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1645_MP16 (XI1645_con cm234_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1645_MP15 (VDD cm233_1 XI1645_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1645_MP18 (VDD XI1645_con ha284_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1645_MP4 (XI1645_xbn cm234_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1647_MP9 (XI1647_xp1 cm235_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1647_MP11 (ha286_0 XI1647_xan XI1647_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1647_MP12 (XI1647_xp1 XI1647_xbn ha286_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1647_MP10 (VDD cm236_0 XI1647_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1647_MP2 (VDD cm235_1 XI1647_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1647_MP16 (XI1647_con cm236_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1647_MP15 (VDD cm235_1 XI1647_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1647_MP18 (VDD XI1647_con ha286_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1647_MP4 (XI1647_xbn cm236_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1649_MP9 (XI1649_xp1 fa237_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1649_MP11 (ha288_0 XI1649_xan XI1649_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1649_MP12 (XI1649_xp1 XI1649_xbn ha288_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1649_MP10 (VDD cm238_0 XI1649_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1649_MP2 (VDD fa237_1 XI1649_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1649_MP16 (XI1649_con cm238_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1649_MP15 (VDD fa237_1 XI1649_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1649_MP18 (VDD XI1649_con ha288_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1649_MP4 (XI1649_xbn cm238_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1651_MP9 (XI1651_xp1 fa239_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1651_MP11 (ha290_0 XI1651_xan XI1651_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1651_MP12 (XI1651_xp1 XI1651_xbn ha290_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1651_MP10 (VDD cm240_0 XI1651_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1651_MP2 (VDD fa239_1 XI1651_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1651_MP16 (XI1651_con cm240_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1651_MP15 (VDD fa239_1 XI1651_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1651_MP18 (VDD XI1651_con ha290_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1651_MP4 (XI1651_xbn cm240_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1653_MP9 (XI1653_xp1 fa241_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1653_MP11 (ha292_0 XI1653_xan XI1653_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1653_MP12 (XI1653_xp1 XI1653_xbn ha292_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1653_MP10 (VDD fa242_0 XI1653_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1653_MP2 (VDD fa241_1 XI1653_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1653_MP16 (XI1653_con fa242_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1653_MP15 (VDD fa241_1 XI1653_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1653_MP18 (VDD XI1653_con ha292_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1653_MP4 (XI1653_xbn fa242_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1655_MP9 (XI1655_xp1 cm199_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1655_MP11 (ha294_0 XI1655_xan XI1655_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1655_MP12 (XI1655_xp1 XI1655_xbn ha294_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1655_MP10 (VDD cm200_0 XI1655_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1655_MP2 (VDD cm199_1 XI1655_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1655_MP16 (XI1655_con cm200_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1655_MP15 (VDD cm199_1 XI1655_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1655_MP18 (VDD XI1655_con ha294_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1655_MP4 (XI1655_xbn cm200_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1639_MP9 (XI1639_xp1 cm227_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1639_MP11 (ha278_0 XI1639_xan XI1639_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1639_MP12 (XI1639_xp1 XI1639_xbn ha278_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1639_MP10 (VDD cm228_0 XI1639_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1639_MP2 (VDD cm227_1 XI1639_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1639_MP16 (XI1639_con cm228_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1639_MP15 (VDD cm227_1 XI1639_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1639_MP18 (VDD XI1639_con ha278_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1639_MP4 (XI1639_xbn cm228_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1636_MP9 (XI1636_xp1 cm224_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1636_MP11 (ha275_0 XI1636_xan XI1636_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1636_MP12 (XI1636_xp1 XI1636_xbn ha275_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1636_MP10 (VDD cm225_0 XI1636_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1636_MP2 (VDD cm224_1 XI1636_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1636_MP16 (XI1636_con cm225_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1636_MP15 (VDD cm224_1 XI1636_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1636_MP18 (VDD XI1636_con ha275_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1636_MP4 (XI1636_xbn cm225_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1638_MP9 (XI1638_xp1 cm226_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1638_MP11 (ha277_0 XI1638_xan XI1638_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1638_MP12 (XI1638_xp1 XI1638_xbn ha277_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1638_MP10 (VDD cm227_0 XI1638_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1638_MP2 (VDD cm226_1 XI1638_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1638_MP16 (XI1638_con cm227_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1638_MP15 (VDD cm226_1 XI1638_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1638_MP18 (VDD XI1638_con ha277_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1638_MP4 (XI1638_xbn cm227_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1635_MP9 (XI1635_xp1 cm223_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1635_MP11 (ha274_0 XI1635_xan XI1635_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1635_MP12 (XI1635_xp1 XI1635_xbn ha274_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1635_MP10 (VDD cm224_0 XI1635_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1635_MP2 (VDD cm223_1 XI1635_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1635_MP16 (XI1635_con cm224_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1635_MP15 (VDD cm223_1 XI1635_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1635_MP18 (VDD XI1635_con ha274_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1635_MP4 (XI1635_xbn cm224_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1637_MP9 (XI1637_xp1 cm225_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1637_MP11 (ha276_0 XI1637_xan XI1637_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1637_MP12 (XI1637_xp1 XI1637_xbn ha276_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1637_MP10 (VDD cm226_0 XI1637_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1637_MP2 (VDD cm225_1 XI1637_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1637_MP16 (XI1637_con cm226_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1637_MP15 (VDD cm225_1 XI1637_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1637_MP18 (VDD XI1637_con ha276_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1637_MP4 (XI1637_xbn cm226_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1634_MP9 (XI1634_xp1 cm222_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1634_MP11 (ha273_0 XI1634_xan XI1634_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1634_MP12 (XI1634_xp1 XI1634_xbn ha273_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1634_MP10 (VDD cm223_0 XI1634_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1634_MP2 (VDD cm222_1 XI1634_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1634_MP16 (XI1634_con cm223_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1634_MP15 (VDD cm222_1 XI1634_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1634_MP18 (VDD XI1634_con ha273_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1634_MP4 (XI1634_xbn cm223_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1632_MP9 (XI1632_xp1 cm220_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1632_MP11 (ha271_0 XI1632_xan XI1632_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1632_MP12 (XI1632_xp1 XI1632_xbn ha271_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1632_MP10 (VDD cm221_0 XI1632_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1632_MP2 (VDD cm220_1 XI1632_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1632_MP16 (XI1632_con cm221_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1632_MP15 (VDD cm220_1 XI1632_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1632_MP18 (VDD XI1632_con ha271_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1632_MP4 (XI1632_xbn cm221_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1633_MP9 (XI1633_xp1 cm221_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1633_MP11 (ha272_0 XI1633_xan XI1633_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1633_MP12 (XI1633_xp1 XI1633_xbn ha272_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1633_MP10 (VDD cm222_0 XI1633_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1633_MP2 (VDD cm221_1 XI1633_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1633_MP16 (XI1633_con cm222_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1633_MP15 (VDD cm221_1 XI1633_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1633_MP18 (VDD XI1633_con ha272_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1633_MP4 (XI1633_xbn cm222_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1630_MP9 (XI1630_xp1 cm218_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1630_MP11 (ha269_0 XI1630_xan XI1630_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1630_MP12 (XI1630_xp1 XI1630_xbn ha269_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1630_MP10 (VDD cm219_0 XI1630_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1630_MP2 (VDD cm218_1 XI1630_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1630_MP16 (XI1630_con cm219_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1630_MP15 (VDD cm218_1 XI1630_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1630_MP18 (VDD XI1630_con ha269_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1630_MP4 (XI1630_xbn cm219_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1631_MP9 (XI1631_xp1 cm219_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1631_MP11 (ha270_0 XI1631_xan XI1631_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1631_MP12 (XI1631_xp1 XI1631_xbn ha270_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1631_MP10 (VDD cm220_0 XI1631_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1631_MP2 (VDD cm219_1 XI1631_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1631_MP16 (XI1631_con cm220_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1631_MP15 (VDD cm219_1 XI1631_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1631_MP18 (VDD XI1631_con ha270_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1631_MP4 (XI1631_xbn cm220_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1628_MP9 (XI1628_xp1 cm216_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1628_MP11 (ha267_0 XI1628_xan XI1628_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1628_MP12 (XI1628_xp1 XI1628_xbn ha267_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1628_MP10 (VDD cm217_0 XI1628_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1628_MP2 (VDD cm216_1 XI1628_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1628_MP16 (XI1628_con cm217_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1628_MP15 (VDD cm216_1 XI1628_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1628_MP18 (VDD XI1628_con ha267_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1628_MP4 (XI1628_xbn cm217_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1629_MP9 (XI1629_xp1 cm217_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1629_MP11 (ha268_0 XI1629_xan XI1629_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1629_MP12 (XI1629_xp1 XI1629_xbn ha268_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1629_MP10 (VDD cm218_0 XI1629_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1629_MP2 (VDD cm217_1 XI1629_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1629_MP16 (XI1629_con cm218_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1629_MP15 (VDD cm217_1 XI1629_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1629_MP18 (VDD XI1629_con ha268_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1629_MP4 (XI1629_xbn cm218_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1626_MP9 (XI1626_xp1 cm214_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1626_MP11 (ha265_0 XI1626_xan XI1626_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1626_MP12 (XI1626_xp1 XI1626_xbn ha265_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1626_MP10 (VDD cm215_0 XI1626_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1626_MP2 (VDD cm214_1 XI1626_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1626_MP16 (XI1626_con cm215_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1626_MP15 (VDD cm214_1 XI1626_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1626_MP18 (VDD XI1626_con ha265_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1626_MP4 (XI1626_xbn cm215_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1627_MP9 (XI1627_xp1 cm215_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1627_MP11 (ha266_0 XI1627_xan XI1627_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1627_MP12 (XI1627_xp1 XI1627_xbn ha266_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1627_MP10 (VDD cm216_0 XI1627_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1627_MP2 (VDD cm215_1 XI1627_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1627_MP16 (XI1627_con cm216_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1627_MP15 (VDD cm215_1 XI1627_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1627_MP18 (VDD XI1627_con ha266_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1627_MP4 (XI1627_xbn cm216_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1625_MP9 (XI1625_xp1 fa213_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1625_MP11 (ha264_0 XI1625_xan XI1625_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1625_MP12 (XI1625_xp1 XI1625_xbn ha264_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1625_MP10 (VDD cm214_0 XI1625_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1625_MP2 (VDD fa213_1 XI1625_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1625_MP16 (XI1625_con cm214_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1625_MP15 (VDD fa213_1 XI1625_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1625_MP18 (VDD XI1625_con ha264_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1625_MP4 (XI1625_xbn cm214_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1624_MP9 (XI1624_xp1 fa212_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1624_MP11 (ha263_0 XI1624_xan XI1624_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1624_MP12 (XI1624_xp1 XI1624_xbn ha263_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1624_MP10 (VDD fa213_0 XI1624_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1624_MP2 (VDD fa212_1 XI1624_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1624_MP16 (XI1624_con fa213_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1624_MP15 (VDD fa212_1 XI1624_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1624_MP18 (VDD XI1624_con ha263_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1624_MP4 (XI1624_xbn fa213_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1622_MP9 (XI1622_xp1 fa210_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1622_MP11 (ha261_0 XI1622_xan XI1622_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1622_MP12 (XI1622_xp1 XI1622_xbn ha261_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1622_MP10 (VDD fa211_0 XI1622_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1622_MP2 (VDD fa210_1 XI1622_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1622_MP16 (XI1622_con fa211_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1622_MP15 (VDD fa210_1 XI1622_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1622_MP18 (VDD XI1622_con ha261_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1622_MP4 (XI1622_xbn fa211_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1623_MP9 (XI1623_xp1 fa211_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1623_MP11 (ha262_0 XI1623_xan XI1623_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1623_MP12 (XI1623_xp1 XI1623_xbn ha262_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1623_MP10 (VDD fa212_0 XI1623_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1623_MP2 (VDD fa211_1 XI1623_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1623_MP16 (XI1623_con fa212_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1623_MP15 (VDD fa211_1 XI1623_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1623_MP18 (VDD XI1623_con ha262_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1623_MP4 (XI1623_xbn fa212_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1621_MP9 (XI1621_xp1 fa210_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1621_MP11 (ha260_0 XI1621_xan XI1621_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1621_MP12 (XI1621_xp1 XI1621_xbn ha260_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1621_MP10 (VDD B_17_b3_5 XI1621_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1621_MP2 (VDD fa210_0 XI1621_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1621_MP16 (XI1621_con B_17_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1621_MP15 (VDD fa210_0 XI1621_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1621_MP18 (VDD XI1621_con ha260_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1621_MP4 (XI1621_xbn B_17_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1620_MP9 (XI1620_xp1 cm144_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1620_MP11 (ha259_0 XI1620_xan XI1620_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_MP12 (XI1620_xp1 XI1620_xbn ha259_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1620_MP10 (VDD cm145_0 XI1620_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1620_MP2 (VDD cm144_1 XI1620_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1620_MP16 (XI1620_con cm145_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1620_MP15 (VDD cm144_1 XI1620_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1620_MP18 (VDD XI1620_con ha259_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1620_MP4 (XI1620_xbn cm145_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1619_MP9 (XI1619_xp1 cm143_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1619_MP11 (ha258_0 XI1619_xan XI1619_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1619_MP12 (XI1619_xp1 XI1619_xbn ha258_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1619_MP10 (VDD cm144_0 XI1619_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1619_MP2 (VDD cm143_1 XI1619_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1619_MP16 (XI1619_con cm144_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1619_MP15 (VDD cm143_1 XI1619_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1619_MP18 (VDD XI1619_con ha258_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1619_MP4 (XI1619_xbn cm144_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1618_MP9 (XI1618_xp1 cm142_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1618_MP11 (ha257_0 XI1618_xan XI1618_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1618_MP12 (XI1618_xp1 XI1618_xbn ha257_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1618_MP10 (VDD cm143_0 XI1618_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1618_MP2 (VDD cm142_1 XI1618_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1618_MP16 (XI1618_con cm143_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1618_MP15 (VDD cm142_1 XI1618_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1618_MP18 (VDD XI1618_con ha257_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1618_MP4 (XI1618_xbn cm143_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1617_MP9 (XI1617_xp1 cm141_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1617_MP11 (ha256_0 XI1617_xan XI1617_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1617_MP12 (XI1617_xp1 XI1617_xbn ha256_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1617_MP10 (VDD cm142_0 XI1617_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1617_MP2 (VDD cm141_1 XI1617_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1617_MP16 (XI1617_con cm142_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1617_MP15 (VDD cm141_1 XI1617_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1617_MP18 (VDD XI1617_con ha256_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1617_MP4 (XI1617_xbn cm142_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1611_MP9 (XI1611_xp1 fa3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1611_MP11 (ha250_0 XI1611_xan XI1611_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1611_MP12 (XI1611_xp1 XI1611_xbn ha250_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1611_MP10 (VDD cm4_0 XI1611_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1611_MP2 (VDD fa3_1 XI1611_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1611_MP16 (XI1611_con cm4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1611_MP15 (VDD fa3_1 XI1611_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1611_MP18 (VDD XI1611_con ha250_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1611_MP4 (XI1611_xbn cm4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1616_MP9 (XI1616_xp1 fa140_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1616_MP11 (ha255_0 XI1616_xan XI1616_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1616_MP12 (XI1616_xp1 XI1616_xbn ha255_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1616_MP10 (VDD cm141_0 XI1616_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1616_MP2 (VDD fa140_1 XI1616_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1616_MP16 (XI1616_con cm141_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1616_MP15 (VDD fa140_1 XI1616_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1616_MP18 (VDD XI1616_con ha255_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1616_MP4 (XI1616_xbn cm141_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1615_MP9 (XI1615_xp1 fa139_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1615_MP11 (ha254_0 XI1615_xan XI1615_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1615_MP12 (XI1615_xp1 XI1615_xbn ha254_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1615_MP10 (VDD fa140_0 XI1615_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1615_MP2 (VDD fa139_1 XI1615_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1615_MP16 (XI1615_con fa140_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1615_MP15 (VDD fa139_1 XI1615_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1615_MP18 (VDD XI1615_con ha254_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1615_MP4 (XI1615_xbn fa140_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1613_MP9 (XI1613_xp1 fa138_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1613_MP11 (ha252_0 XI1613_xan XI1613_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1613_MP12 (XI1613_xp1 XI1613_xbn ha252_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1613_MP10 (VDD B_9_b3_5 XI1613_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1613_MP2 (VDD fa138_0 XI1613_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1613_MP16 (XI1613_con B_9_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1613_MP15 (VDD fa138_0 XI1613_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1613_MP18 (VDD XI1613_con ha252_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1613_MP4 (XI1613_xbn B_9_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1612_MP9 (XI1612_xp1 cm4_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1612_MP11 (ha251_0 XI1612_xan XI1612_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1612_MP12 (XI1612_xp1 XI1612_xbn ha251_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1612_MP10 (VDD cm5_0 XI1612_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1612_MP2 (VDD cm4_1 XI1612_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1612_MP16 (XI1612_con cm5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1612_MP15 (VDD cm4_1 XI1612_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1612_MP18 (VDD XI1612_con ha251_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1612_MP4 (XI1612_xbn cm5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1614_MP9 (XI1614_xp1 fa138_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1614_MP11 (ha253_0 XI1614_xan XI1614_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1614_MP12 (XI1614_xp1 XI1614_xbn ha253_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1614_MP10 (VDD fa139_0 XI1614_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1614_MP2 (VDD fa138_1 XI1614_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1614_MP16 (XI1614_con fa139_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1614_MP15 (VDD fa138_1 XI1614_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1614_MP18 (VDD XI1614_con ha253_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1614_MP4 (XI1614_xbn fa139_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I234_XG_MP2 (XI1660_I234_XG_p1 I1660_G42_41 I1660_G42_39n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I234_XG_MP0 (VDD I1660_P42_41 XI1660_I234_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I234_XG_MP1 (XI1660_I234_XG_p1 I1660_G40_39 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I236_XG_MP2 (XI1660_I236_XG_p1 I1660_G44_43 I1660_G44_41n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I236_XG_MP0 (VDD I1660_P44_43 XI1660_I236_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I236_XG_MP1 (XI1660_I236_XG_p1 I1660_G42_41 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I238_XG_MP2 (XI1660_I238_XG_p1 I1660_G46_45 I1660_G46_43n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I238_XG_MP0 (VDD I1660_P46_45 XI1660_I238_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I238_XG_MP1 (XI1660_I238_XG_p1 I1660_G44_43 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I232_XG_MP2 (XI1660_I232_XG_p1 I1660_G40_39 I1660_G40_37n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I232_XG_MP0 (VDD I1660_P40_39 XI1660_I232_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I232_XG_MP1 (XI1660_I232_XG_p1 I1660_G38_37 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I240_XG_MP2 (XI1660_I240_XG_p1 I1660_G48_47 I1660_G48_45n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I240_XG_MP0 (VDD I1660_P48_47 XI1660_I240_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I240_XG_MP1 (XI1660_I240_XG_p1 I1660_G46_45 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I242_XG_MP2 (XI1660_I242_XG_p1 I1660_G50_49 I1660_G50_47n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I242_XG_MP0 (VDD I1660_P50_49 XI1660_I242_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I242_XG_MP1 (XI1660_I242_XG_p1 I1660_G48_47 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I244_XG_MP2 (XI1660_I244_XG_p1 I1660_G52_51 I1660_G52_49n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I244_XG_MP0 (VDD I1660_P52_51 XI1660_I244_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I244_XG_MP1 (XI1660_I244_XG_p1 I1660_G50_49 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I246_XG_MP2 (XI1660_I246_XG_p1 I1660_G54_53 I1660_G54_51n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I246_XG_MP0 (VDD I1660_P54_53 XI1660_I246_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I246_XG_MP1 (XI1660_I246_XG_p1 I1660_G52_51 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I230_XG_MP2 (XI1660_I230_XG_p1 I1660_G38_37 I1660_G38_35n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I230_XG_MP0 (VDD I1660_P38_37 XI1660_I230_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I230_XG_MP1 (XI1660_I230_XG_p1 I1660_G36_35 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I363_XG_MP2 (XI1660_I363_XG_p1 I1660_G52_45 I1660_G52_37n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I363_XG_MP0 (VDD I1660_P52_45 XI1660_I363_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I363_XG_MP1 (XI1660_I363_XG_p1 I1660_G44_37 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I367_XG_MP2 (XI1660_I367_XG_p1 I1660_G56_49 I1660_G56_41n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I367_XG_MP0 (VDD I1660_P56_49 XI1660_I367_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I367_XG_MP1 (XI1660_I367_XG_p1 I1660_G48_41 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I371_XG_MP2 (XI1660_I371_XG_p1 I1660_G60_53 I1660_G60_45n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I371_XG_MP0 (VDD I1660_P60_53 XI1660_I371_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I371_XG_MP1 (XI1660_I371_XG_p1 I1660_G52_45 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I248_XG_MP2 (XI1660_I248_XG_p1 I1660_G56_55 I1660_G56_53n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I248_XG_MP0 (VDD I1660_P56_55 XI1660_I248_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I248_XG_MP1 (XI1660_I248_XG_p1 I1660_G54_53 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I250_XG_MP2 (XI1660_I250_XG_p1 I1660_G58_57 I1660_G58_55n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I250_XG_MP0 (VDD I1660_P58_57 XI1660_I250_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I250_XG_MP1 (XI1660_I250_XG_p1 I1660_G56_55 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I228_XG_MP2 (XI1660_I228_XG_p1 I1660_G36_35 I1660_G36_33n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I228_XG_MP0 (VDD I1660_P36_35 XI1660_I228_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I228_XG_MP1 (XI1660_I228_XG_p1 I1660_G34_33 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I252_XG_MP2 (XI1660_I252_XG_p1 I1660_G60_59 I1660_G60_57n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I252_XG_MP0 (VDD I1660_P60_59 XI1660_I252_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I252_XG_MP1 (XI1660_I252_XG_p1 I1660_G58_57 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I226_XG_MP2 (XI1660_I226_XG_p1 I1660_G34_33 I1660_G34_31n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I226_XG_MP0 (VDD I1660_P34_33 XI1660_I226_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I226_XG_MP1 (XI1660_I226_XG_p1 I1660_G32_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I359_XG_MP2 (XI1660_I359_XG_p1 I1660_G48_41 I1660_G48_33n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I359_XG_MP0 (VDD I1660_P48_41 XI1660_I359_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I359_XG_MP1 (XI1660_I359_XG_p1 I1660_G40_33 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I355_XG_MP2 (XI1660_I355_XG_p1 I1660_G44_37 I1660_G44_29n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I355_XG_MP0 (VDD I1660_P44_37 XI1660_I355_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I355_XG_MP1 (XI1660_I355_XG_p1 I1660_G36_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I463_XG_MP2 (XI1660_I463_XG_p1 I1660_G60_29 I1660_G60_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I463_XG_MP0 (VDD I1660_P60_29 XI1660_I463_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I463_XG_MP1 (XI1660_I463_XG_p1 I1660_G28_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I365_XG_MP2 (XI1660_I365_XG_p1 I1660_G54_47 I1660_G54_39n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I365_XG_MP0 (VDD I1660_P54_47 XI1660_I365_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I365_XG_MP1 (XI1660_I365_XG_p1 I1660_G46_39 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I357_XG_MP2 (XI1660_I357_XG_p1 I1660_G46_39 I1660_G46_31n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I357_XG_MP0 (VDD I1660_P46_39 XI1660_I357_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I357_XG_MP1 (XI1660_I357_XG_p1 I1660_G38_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I369_XG_MP2 (XI1660_I369_XG_p1 I1660_G58_51 I1660_G58_43n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I369_XG_MP0 (VDD I1660_P58_51 XI1660_I369_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I369_XG_MP1 (XI1660_I369_XG_p1 I1660_G50_43 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I373_XG_MP2 (XI1660_I373_XG_p1 I1660_G62_55 I1660_G62_47n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I373_XG_MP0 (VDD I1660_P62_55 XI1660_I373_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I373_XG_MP1 (XI1660_I373_XG_p1 I1660_G54_47 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I254_XG_MP2 (XI1660_I254_XG_p1 I1660_G62_61 I1660_G62_59n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I254_XG_MP0 (VDD I1660_P62_61 XI1660_I254_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I254_XG_MP1 (XI1660_I254_XG_p1 I1660_G60_59 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I253_XG_MP2 (XI1660_I253_XG_p1 I1660_G61_60 I1660_G61_58n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I253_XG_MP0 (VDD I1660_P61_60 XI1660_I253_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I253_XG_MP1 (XI1660_I253_XG_p1 I1660_G59_58 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I255_XG_MP2 (XI1660_I255_XG_p1 I1660_G63_62 I1660_G63_60n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I255_XG_MP0 (VDD I1660_P63_62 XI1660_I255_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I255_XG_MP1 (XI1660_I255_XG_p1 I1660_G61_60 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I224_XG_MP2 (XI1660_I224_XG_p1 I1660_G32_31 I1660_G32_29n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I224_XG_MP0 (VDD I1660_P32_31 XI1660_I224_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I224_XG_MP1 (XI1660_I224_XG_p1 I1660_G30_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I444_XG_MP2 (XI1660_I444_XG_p1 I1660_G44_13 I1660_G44_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I444_XG_MP0 (VDD I1660_P44_13 XI1660_I444_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I444_XG_MP1 (XI1660_I444_XG_p1 I1660_G12_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I361_XG_MP2 (XI1660_I361_XG_p1 I1660_G50_43 I1660_G50_35n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I361_XG_MP0 (VDD I1660_P50_43 XI1660_I361_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I361_XG_MP1 (XI1660_I361_XG_p1 I1660_G42_35 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I448_XG_MP2 (XI1660_I448_XG_p1 I1660_G46_15 I1660_G46_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I448_XG_MP0 (VDD I1660_P46_15 XI1660_I448_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I448_XG_MP1 (XI1660_I448_XG_p1 I1660_G14_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I465_XG_MP2 (XI1660_I465_XG_p1 I1660_G62_31 I1660_G62_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I465_XG_MP0 (VDD I1660_P62_31 XI1660_I465_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I465_XG_MP1 (XI1660_I465_XG_p1 I1660_G30_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I241_XG_MP2 (XI1660_I241_XG_p1 I1660_G49_48 I1660_G49_46n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I241_XG_MP0 (VDD I1660_P49_48 XI1660_I241_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I241_XG_MP1 (XI1660_I241_XG_p1 I1660_G47_46 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I243_XG_MP2 (XI1660_I243_XG_p1 I1660_G51_50 I1660_G51_48n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I243_XG_MP0 (VDD I1660_P51_50 XI1660_I243_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I243_XG_MP1 (XI1660_I243_XG_p1 I1660_G49_48 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I245_XG_MP2 (XI1660_I245_XG_p1 I1660_G53_52 I1660_G53_50n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I245_XG_MP0 (VDD I1660_P53_52 XI1660_I245_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I245_XG_MP1 (XI1660_I245_XG_p1 I1660_G51_50 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I251_XG_MP2 (XI1660_I251_XG_p1 I1660_G59_58 I1660_G59_56n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I251_XG_MP0 (VDD I1660_P59_58 XI1660_I251_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I251_XG_MP1 (XI1660_I251_XG_p1 I1660_G57_56 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I249_XG_MP2 (XI1660_I249_XG_p1 I1660_G57_56 I1660_G57_54n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I249_XG_MP0 (VDD I1660_P57_56 XI1660_I249_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I249_XG_MP1 (XI1660_I249_XG_p1 I1660_G55_54 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I459_XG_MP2 (XI1660_I459_XG_p1 I1660_G56_25 I1660_G56_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I459_XG_MP0 (VDD I1660_P56_25 XI1660_I459_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I459_XG_MP1 (XI1660_I459_XG_p1 I1660_G24_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I349_XG_MP2 (XI1660_I349_XG_p1 I1660_G38_31 I1660_G38_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I349_XG_MP0 (VDD I1660_P38_31 XI1660_I349_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I349_XG_MP1 (XI1660_I349_XG_p1 I1660_G30_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I353_XG_MP2 (XI1660_I353_XG_p1 I1660_G42_35 I1660_G42_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I353_XG_MP0 (VDD I1660_P42_35 XI1660_I353_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I353_XG_MP1 (XI1660_I353_XG_p1 I1660_G34_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I461_XG_MP2 (XI1660_I461_XG_p1 I1660_G58_27 I1660_G58_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I461_XG_MP0 (VDD I1660_P58_27 XI1660_I461_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I461_XG_MP1 (XI1660_I461_XG_p1 I1660_G26_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I239_XG_MP2 (XI1660_I239_XG_p1 I1660_G47_46 I1660_G47_44n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I239_XG_MP0 (VDD I1660_P47_46 XI1660_I239_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I239_XG_MP1 (XI1660_I239_XG_p1 I1660_G45_44 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I247_XG_MP2 (XI1660_I247_XG_p1 I1660_G55_54 I1660_G55_52n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I247_XG_MP0 (VDD I1660_P55_54 XI1660_I247_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I247_XG_MP1 (XI1660_I247_XG_p1 I1660_G53_52 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I222_XG_MP2 (XI1660_I222_XG_p1 I1660_G30_29 I1660_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I222_XG_MP0 (VDD I1660_P30_29 XI1660_I222_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I222_XG_MP1 (XI1660_I222_XG_p1 I1660_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I351_XG_MP2 (XI1660_I351_XG_p1 I1660_G40_33 I1660_G40_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I351_XG_MP0 (VDD I1660_P40_33 XI1660_I351_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I351_XG_MP1 (XI1660_I351_XG_p1 I1660_G32_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I341_XG_MP2 (XI1660_I341_XG_p1 I1660_G30_23 I1660_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I341_XG_MP0 (VDD I1660_P30_23 XI1660_I341_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I341_XG_MP1 (XI1660_I341_XG_p1 I1660_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I457_XG_MP2 (XI1660_I457_XG_p1 I1660_G54_23 I1660_G54_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I457_XG_MP0 (VDD I1660_P54_23 XI1660_I457_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I457_XG_MP1 (XI1660_I457_XG_p1 I1660_G22_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I237_XG_MP2 (XI1660_I237_XG_p1 I1660_G45_44 I1660_G45_42n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I237_XG_MP0 (VDD I1660_P45_44 XI1660_I237_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I237_XG_MP1 (XI1660_I237_XG_p1 I1660_G43_42 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I220_XG_MP2 (XI1660_I220_XG_p1 I1660_G28_27 I1660_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I220_XG_MP0 (VDD I1660_P28_27 XI1660_I220_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I220_XG_MP1 (XI1660_I220_XG_p1 I1660_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I339_XG_MP2 (XI1660_I339_XG_p1 I1660_G28_21 I1660_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I339_XG_MP0 (VDD I1660_P28_21 XI1660_I339_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I339_XG_MP1 (XI1660_I339_XG_p1 I1660_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I347_XG_MP2 (XI1660_I347_XG_p1 I1660_G36_29 I1660_G36_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I347_XG_MP0 (VDD I1660_P36_29 XI1660_I347_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I347_XG_MP1 (XI1660_I347_XG_p1 I1660_G28_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I440_XG_MP2 (XI1660_I440_XG_p1 I1660_G42_11 I1660_G42_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I440_XG_MP0 (VDD I1660_P42_11 XI1660_I440_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I440_XG_MP1 (XI1660_I440_XG_p1 I1660_G10_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I233_XG_MP2 (XI1660_I233_XG_p1 I1660_G41_40 I1660_G41_38n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I233_XG_MP0 (VDD I1660_P41_40 XI1660_I233_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I233_XG_MP1 (XI1660_I233_XG_p1 I1660_G39_38 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I235_XG_MP2 (XI1660_I235_XG_p1 I1660_G43_42 I1660_G43_40n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I235_XG_MP0 (VDD I1660_P43_42 XI1660_I235_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I235_XG_MP1 (XI1660_I235_XG_p1 I1660_G41_40 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I364_XG_MP2 (XI1660_I364_XG_p1 I1660_G53_46 I1660_G53_38n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I364_XG_MP0 (VDD I1660_P53_46 XI1660_I364_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I364_XG_MP1 (XI1660_I364_XG_p1 I1660_G45_38 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I372_XG_MP2 (XI1660_I372_XG_p1 I1660_G61_54 I1660_G61_46n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I372_XG_MP0 (VDD I1660_P61_54 XI1660_I372_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I372_XG_MP1 (XI1660_I372_XG_p1 I1660_G53_46 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I374_XG_MP2 (XI1660_I374_XG_p1 I1660_G63_56 I1660_G63_48n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I374_XG_MP0 (VDD I1660_P63_56 XI1660_I374_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I374_XG_MP1 (XI1660_I374_XG_p1 I1660_G55_48 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I218_XG_MP2 (XI1660_I218_XG_p1 I1660_G26_25 I1660_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I218_XG_MP0 (VDD I1660_P26_25 XI1660_I218_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I218_XG_MP1 (XI1660_I218_XG_p1 I1660_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I436_XG_MP2 (XI1660_I436_XG_p1 I1660_G40_9 I1660_G40_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I436_XG_MP0 (VDD I1660_P40_9 XI1660_I436_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I436_XG_MP1 (XI1660_I436_XG_p1 I1660_G8_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I455_XG_MP2 (XI1660_I455_XG_p1 I1660_G52_21 I1660_G52_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I455_XG_MP0 (VDD I1660_P52_21 XI1660_I455_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I455_XG_MP1 (XI1660_I455_XG_p1 I1660_G20_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I345_XG_MP2 (XI1660_I345_XG_p1 I1660_G34_27 I1660_G34_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I345_XG_MP0 (VDD I1660_P34_27 XI1660_I345_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I345_XG_MP1 (XI1660_I345_XG_p1 I1660_G26_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I453_XG_MP2 (XI1660_I453_XG_p1 I1660_G50_19 I1660_G50_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I453_XG_MP0 (VDD I1660_P50_19 XI1660_I453_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I453_XG_MP1 (XI1660_I453_XG_p1 I1660_G18_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I356_XG_MP2 (XI1660_I356_XG_p1 I1660_G45_38 I1660_G45_30n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I356_XG_MP0 (VDD I1660_P45_38 XI1660_I356_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I356_XG_MP1 (XI1660_I356_XG_p1 I1660_G37_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I464_XG_MP2 (XI1660_I464_XG_p1 I1660_G61_30 I1660_G61_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I464_XG_MP0 (VDD I1660_P61_30 XI1660_I464_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I464_XG_MP1 (XI1660_I464_XG_p1 I1660_G29_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I370_XG_MP2 (XI1660_I370_XG_p1 I1660_G59_52 I1660_G59_44n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I370_XG_MP0 (VDD I1660_P59_52 XI1660_I370_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I370_XG_MP1 (XI1660_I370_XG_p1 I1660_G51_44 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I343_XG_MP2 (XI1660_I343_XG_p1 I1660_G32_25 I1660_G32_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I343_XG_MP0 (VDD I1660_P32_25 XI1660_I343_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I343_XG_MP1 (XI1660_I343_XG_p1 I1660_G24_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I337_XG_MP2 (XI1660_I337_XG_p1 I1660_G26_19 I1660_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I337_XG_MP0 (VDD I1660_P26_19 XI1660_I337_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I337_XG_MP1 (XI1660_I337_XG_p1 I1660_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I433_XG_MP2 (XI1660_I433_XG_p1 I1660_G38_7 I1660_G38_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I433_XG_MP0 (VDD I1660_P38_7 XI1660_I433_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I433_XG_MP1 (XI1660_I433_XG_p1 I1660_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I229_XG_MP2 (XI1660_I229_XG_p1 I1660_G37_36 I1660_G37_34n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I229_XG_MP0 (VDD I1660_P37_36 XI1660_I229_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I229_XG_MP1 (XI1660_I229_XG_p1 I1660_G35_34 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I231_XG_MP2 (XI1660_I231_XG_p1 I1660_G39_38 I1660_G39_36n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I231_XG_MP0 (VDD I1660_P39_38 XI1660_I231_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I231_XG_MP1 (XI1660_I231_XG_p1 I1660_G37_36 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I446_XG_MP2 (XI1660_I446_XG_p1 I1660_G45_14 I1660_G45_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I446_XG_MP0 (VDD I1660_P45_14 XI1660_I446_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I446_XG_MP1 (XI1660_I446_XG_p1 I1660_G13_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I368_XG_MP2 (XI1660_I368_XG_p1 I1660_G57_50 I1660_G57_42n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I368_XG_MP0 (VDD I1660_P57_50 XI1660_I368_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I368_XG_MP1 (XI1660_I368_XG_p1 I1660_G49_42 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I460_XG_MP2 (XI1660_I460_XG_p1 I1660_G57_26 I1660_G57_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I460_XG_MP0 (VDD I1660_P57_26 XI1660_I460_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I460_XG_MP1 (XI1660_I460_XG_p1 I1660_G25_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I362_XG_MP2 (XI1660_I362_XG_p1 I1660_G51_44 I1660_G51_36n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I362_XG_MP0 (VDD I1660_P51_44 XI1660_I362_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I362_XG_MP1 (XI1660_I362_XG_p1 I1660_G43_36 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I462_XG_MP2 (XI1660_I462_XG_p1 I1660_G59_28 I1660_G59_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I462_XG_MP0 (VDD I1660_P59_28 XI1660_I462_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I462_XG_MP1 (XI1660_I462_XG_p1 I1660_G27_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I216_XG_MP2 (XI1660_I216_XG_p1 I1660_G24_23 I1660_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I216_XG_MP0 (VDD I1660_P24_23 XI1660_I216_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I216_XG_MP1 (XI1660_I216_XG_p1 I1660_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I335_XG_MP2 (XI1660_I335_XG_p1 I1660_G24_17 I1660_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I335_XG_MP0 (VDD I1660_P24_17 XI1660_I335_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I335_XG_MP1 (XI1660_I335_XG_p1 I1660_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I451_XG_MP2 (XI1660_I451_XG_p1 I1660_G48_17 I1660_G48_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I451_XG_MP0 (VDD I1660_P48_17 XI1660_I451_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I451_XG_MP1 (XI1660_I451_XG_p1 I1660_G16_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I333_XG_MP2 (XI1660_I333_XG_p1 I1660_G22_15 I1660_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I333_XG_MP0 (VDD I1660_P22_15 XI1660_I333_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I333_XG_MP1 (XI1660_I333_XG_p1 I1660_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I225_XG_MP2 (XI1660_I225_XG_p1 I1660_G33_32 I1660_G33_30n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I225_XG_MP0 (VDD I1660_P33_32 XI1660_I225_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I225_XG_MP1 (XI1660_I225_XG_p1 I1660_G31_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I227_XG_MP2 (XI1660_I227_XG_p1 I1660_G35_34 I1660_G35_32n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I227_XG_MP0 (VDD I1660_P35_34 XI1660_I227_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I227_XG_MP1 (XI1660_I227_XG_p1 I1660_G33_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I360_XG_MP2 (XI1660_I360_XG_p1 I1660_G49_42 I1660_G49_34n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I360_XG_MP0 (VDD I1660_P49_42 XI1660_I360_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I360_XG_MP1 (XI1660_I360_XG_p1 I1660_G41_34 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I358_XG_MP2 (XI1660_I358_XG_p1 I1660_G47_40 I1660_G47_32n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I358_XG_MP0 (VDD I1660_P47_40 XI1660_I358_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I358_XG_MP1 (XI1660_I358_XG_p1 I1660_G39_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I354_XG_MP2 (XI1660_I354_XG_p1 I1660_G43_36 I1660_G43_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I354_XG_MP0 (VDD I1660_P43_36 XI1660_I354_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I354_XG_MP1 (XI1660_I354_XG_p1 I1660_G35_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I366_XG_MP2 (XI1660_I366_XG_p1 I1660_G55_48 I1660_G55_40n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I366_XG_MP0 (VDD I1660_P55_48 XI1660_I366_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I366_XG_MP1 (XI1660_I366_XG_p1 I1660_G47_40 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I214_XG_MP2 (XI1660_I214_XG_p1 I1660_G22_21 I1660_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I214_XG_MP0 (VDD I1660_P22_21 XI1660_I214_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I214_XG_MP1 (XI1660_I214_XG_p1 I1660_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I331_XG_MP2 (XI1660_I331_XG_p1 I1660_G20_13 I1660_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I331_XG_MP0 (VDD I1660_P20_13 XI1660_I331_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I331_XG_MP1 (XI1660_I331_XG_p1 I1660_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I325_XG_MP2 (XI1660_I325_XG_p1 I1660_G14_7 I1660_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I325_XG_MP0 (VDD I1660_P14_7 XI1660_I325_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I325_XG_MP1 (XI1660_I325_XG_p1 I1660_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I221_XG_MP2 (XI1660_I221_XG_p1 I1660_G29_28 I1660_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I221_XG_MP0 (VDD I1660_P29_28 XI1660_I221_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I221_XG_MP1 (XI1660_I221_XG_p1 I1660_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I223_XG_MP2 (XI1660_I223_XG_p1 I1660_G31_30 I1660_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I223_XG_MP0 (VDD I1660_P31_30 XI1660_I223_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I223_XG_MP1 (XI1660_I223_XG_p1 I1660_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I352_XG_MP2 (XI1660_I352_XG_p1 I1660_G41_34 I1660_G41_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I352_XG_MP0 (VDD I1660_P41_34 XI1660_I352_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I352_XG_MP1 (XI1660_I352_XG_p1 I1660_G33_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I466_XG_MP2 (XI1660_I466_XG_p1 I1660_G63_32 I1660_G63_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I466_XG_MP0 (VDD I1660_P63_32 XI1660_I466_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I466_XG_MP1 (XI1660_I466_XG_p1 I1660_G31_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I212_XG_MP2 (XI1660_I212_XG_p1 I1660_G20_19 I1660_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I212_XG_MP0 (VDD I1660_P20_19 XI1660_I212_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I212_XG_MP1 (XI1660_I212_XG_p1 I1660_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I323_XG_MP2 (XI1660_I323_XG_p1 I1660_G12_5 I1660_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I323_XG_MP0 (VDD I1660_P12_5 XI1660_I323_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I323_XG_MP1 (XI1660_I323_XG_p1 I1660_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I431_XG_MP2 (XI1660_I431_XG_p1 I1660_G36_5 I1660_G36_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I431_XG_MP0 (VDD I1660_P36_5 XI1660_I431_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I431_XG_MP1 (XI1660_I431_XG_p1 I1660_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I429_XG_MP2 (XI1660_I429_XG_p1 I1660_G34_3 I1660_G34_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I429_XG_MP0 (VDD I1660_P34_3 XI1660_I429_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I429_XG_MP1 (XI1660_I429_XG_p1 I1660_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I219_XG_MP2 (XI1660_I219_XG_p1 I1660_G27_26 I1660_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I219_XG_MP0 (VDD I1660_P27_26 XI1660_I219_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I219_XG_MP1 (XI1660_I219_XG_p1 I1660_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I348_XG_MP2 (XI1660_I348_XG_p1 I1660_G37_30 I1660_G37_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I348_XG_MP0 (VDD I1660_P37_30 XI1660_I348_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I348_XG_MP1 (XI1660_I348_XG_p1 I1660_G29_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I456_XG_MP2 (XI1660_I456_XG_p1 I1660_G53_22 I1660_G53_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I456_XG_MP0 (VDD I1660_P53_22 XI1660_I456_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I456_XG_MP1 (XI1660_I456_XG_p1 I1660_G21_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I350_XG_MP2 (XI1660_I350_XG_p1 I1660_G39_32 I1660_G39_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I350_XG_MP0 (VDD I1660_P39_32 XI1660_I350_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I350_XG_MP1 (XI1660_I350_XG_p1 I1660_G31_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I458_XG_MP2 (XI1660_I458_XG_p1 I1660_G55_24 I1660_G55_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I458_XG_MP0 (VDD I1660_P55_24 XI1660_I458_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I458_XG_MP1 (XI1660_I458_XG_p1 I1660_G23_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I450_XG_MP2 (XI1660_I450_XG_p1 I1660_G47_16 I1660_G47_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I450_XG_MP0 (VDD I1660_P47_16 XI1660_I450_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I450_XG_MP1 (XI1660_I450_XG_p1 I1660_G15_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I210_XG_MP2 (XI1660_I210_XG_p1 I1660_G18_17 I1660_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I210_XG_MP0 (VDD I1660_P18_17 XI1660_I210_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I210_XG_MP1 (XI1660_I210_XG_p1 I1660_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I427_XG_MP2 (XI1660_I427_XG_p1 I1660_G32_1 I1660_G32_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I427_XG_MP0 (VDD I1660_P32_1 XI1660_I427_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I427_XG_MP1 (XI1660_I427_XG_p1 I1660_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I329_XG_MP2 (XI1660_I329_XG_p1 I1660_G18_11 I1660_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I329_XG_MP0 (VDD I1660_P18_11 XI1660_I329_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I329_XG_MP1 (XI1660_I329_XG_p1 I1660_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I215_XG_MP2 (XI1660_I215_XG_p1 I1660_G23_22 I1660_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I215_XG_MP0 (VDD I1660_P23_22 XI1660_I215_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I215_XG_MP1 (XI1660_I215_XG_p1 I1660_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I217_XG_MP2 (XI1660_I217_XG_p1 I1660_G25_24 I1660_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I217_XG_MP0 (VDD I1660_P25_24 XI1660_I217_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I217_XG_MP1 (XI1660_I217_XG_p1 I1660_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I340_XG_MP2 (XI1660_I340_XG_p1 I1660_G29_22 I1660_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I340_XG_MP0 (VDD I1660_P29_22 XI1660_I340_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I340_XG_MP1 (XI1660_I340_XG_p1 I1660_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I344_XG_MP2 (XI1660_I344_XG_p1 I1660_G33_26 I1660_G33_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I344_XG_MP0 (VDD I1660_P33_26 XI1660_I344_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I344_XG_MP1 (XI1660_I344_XG_p1 I1660_G25_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I438_XG_MP2 (XI1660_I438_XG_p1 I1660_G41_10 I1660_G41_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I438_XG_MP0 (VDD I1660_P41_10 XI1660_I438_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I438_XG_MP1 (XI1660_I438_XG_p1 I1660_G9_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I342_XG_MP2 (XI1660_I342_XG_p1 I1660_G31_24 I1660_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I342_XG_MP0 (VDD I1660_P31_24 XI1660_I342_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I342_XG_MP1 (XI1660_I342_XG_p1 I1660_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I327_XG_MP2 (XI1660_I327_XG_p1 I1660_G16_9 I1660_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I327_XG_MP0 (VDD I1660_P16_9 XI1660_I327_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I327_XG_MP1 (XI1660_I327_XG_p1 I1660_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I213_XG_MP2 (XI1660_I213_XG_p1 I1660_G21_20 I1660_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I213_XG_MP0 (VDD I1660_P21_20 XI1660_I213_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I213_XG_MP1 (XI1660_I213_XG_p1 I1660_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I336_XG_MP2 (XI1660_I336_XG_p1 I1660_G25_18 I1660_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I336_XG_MP0 (VDD I1660_P25_18 XI1660_I336_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I336_XG_MP1 (XI1660_I336_XG_p1 I1660_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I452_XG_MP2 (XI1660_I452_XG_p1 I1660_G49_18 I1660_G49_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I452_XG_MP0 (VDD I1660_P49_18 XI1660_I452_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I452_XG_MP1 (XI1660_I452_XG_p1 I1660_G17_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I346_XG_MP2 (XI1660_I346_XG_p1 I1660_G35_28 I1660_G35_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I346_XG_MP0 (VDD I1660_P35_28 XI1660_I346_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I346_XG_MP1 (XI1660_I346_XG_p1 I1660_G27_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I454_XG_MP2 (XI1660_I454_XG_p1 I1660_G51_20 I1660_G51_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I454_XG_MP0 (VDD I1660_P51_20 XI1660_I454_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I454_XG_MP1 (XI1660_I454_XG_p1 I1660_G19_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I442_XG_MP2 (XI1660_I442_XG_p1 I1660_G43_12 I1660_G43_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I442_XG_MP0 (VDD I1660_P43_12 XI1660_I442_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I442_XG_MP1 (XI1660_I442_XG_p1 I1660_G11_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I208_XG_MP2 (XI1660_I208_XG_p1 I1660_G16_15 I1660_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I208_XG_MP0 (VDD I1660_P16_15 XI1660_I208_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I208_XG_MP1 (XI1660_I208_XG_p1 I1660_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I317_XG_MP2 (XI1660_I317_XG_p1 I1660_G8_1 I1660_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I317_XG_MP0 (VDD I1660_P8_1 XI1660_I317_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I317_XG_MP1 (XI1660_I317_XG_p1 I1660_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I320_XG_MP2 (XI1660_I320_XG_p1 I1660_G10_3 I1660_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I320_XG_MP0 (VDD I1660_P10_3 XI1660_I320_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I320_XG_MP1 (XI1660_I320_XG_p1 I1660_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I209_XG_MP2 (XI1660_I209_XG_p1 I1660_G17_16 I1660_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I209_XG_MP0 (VDD I1660_P17_16 XI1660_I209_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I209_XG_MP1 (XI1660_I209_XG_p1 I1660_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I211_XG_MP2 (XI1660_I211_XG_p1 I1660_G19_18 I1660_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I211_XG_MP0 (VDD I1660_P19_18 XI1660_I211_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I211_XG_MP1 (XI1660_I211_XG_p1 I1660_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I332_XG_MP2 (XI1660_I332_XG_p1 I1660_G21_14 I1660_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I332_XG_MP0 (VDD I1660_P21_14 XI1660_I332_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I332_XG_MP1 (XI1660_I332_XG_p1 I1660_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I338_XG_MP2 (XI1660_I338_XG_p1 I1660_G27_20 I1660_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I338_XG_MP0 (VDD I1660_P27_20 XI1660_I338_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I338_XG_MP1 (XI1660_I338_XG_p1 I1660_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I206_XG_MP2 (XI1660_I206_XG_p1 I1660_G14_13 I1660_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I206_XG_MP0 (VDD I1660_P14_13 XI1660_I206_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I206_XG_MP1 (XI1660_I206_XG_p1 I1660_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I432_XG_MP2 (XI1660_I432_XG_p1 I1660_G37_6 I1660_G37_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I432_XG_MP0 (VDD I1660_P37_6 XI1660_I432_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I432_XG_MP1 (XI1660_I432_XG_p1 I1660_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I328_XG_MP2 (XI1660_I328_XG_p1 I1660_G17_10 I1660_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I328_XG_MP0 (VDD I1660_P17_10 XI1660_I328_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I328_XG_MP1 (XI1660_I328_XG_p1 I1660_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I334_XG_MP2 (XI1660_I334_XG_p1 I1660_G23_16 I1660_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I334_XG_MP0 (VDD I1660_P23_16 XI1660_I334_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I334_XG_MP1 (XI1660_I334_XG_p1 I1660_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I204_XG_MP2 (XI1660_I204_XG_p1 I1660_G12_11 I1660_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I204_XG_MP0 (VDD I1660_P12_11 XI1660_I204_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I204_XG_MP1 (XI1660_I204_XG_p1 I1660_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I202_XG_MP2 (XI1660_I202_XG_p1 I1660_G10_9 I1660_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I202_XG_MP0 (VDD I1660_P10_9 XI1660_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I202_XG_MP1 (XI1660_I202_XG_p1 I1660_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I196_XG_MP2 (XI1660_I196_XG_p1 I1660_G4_3 I1660_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I196_XG_MP0 (VDD I1660_P4_3 XI1660_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I196_XG_MP1 (XI1660_I196_XG_p1 I1660_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I194_XG_MP2 (XI1660_I194_XG_p1 I1660_G2_1 I1660_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I194_XG_MP0 (VDD I1660_P2_1 XI1660_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I194_XG_MP1 (XI1660_I194_XG_p1 I1660_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I207_XG_MP2 (XI1660_I207_XG_p1 I1660_G15_14 I1660_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I207_XG_MP0 (VDD I1660_P15_14 XI1660_I207_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I207_XG_MP1 (XI1660_I207_XG_p1 I1660_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I205_XG_MP2 (XI1660_I205_XG_p1 I1660_G13_12 I1660_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I205_XG_MP0 (VDD I1660_P13_12 XI1660_I205_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I205_XG_MP1 (XI1660_I205_XG_p1 I1660_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I324_XG_MP2 (XI1660_I324_XG_p1 I1660_G13_6 I1660_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I324_XG_MP0 (VDD I1660_P13_6 XI1660_I324_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I324_XG_MP1 (XI1660_I324_XG_p1 I1660_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I326_XG_MP2 (XI1660_I326_XG_p1 I1660_G15_8 I1660_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I326_XG_MP0 (VDD I1660_P15_8 XI1660_I326_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I326_XG_MP1 (XI1660_I326_XG_p1 I1660_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I434_XG_MP2 (XI1660_I434_XG_p1 I1660_G39_8 I1660_G39_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I434_XG_MP0 (VDD I1660_P39_8 XI1660_I434_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I434_XG_MP1 (XI1660_I434_XG_p1 I1660_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I200_XG_MP2 (XI1660_I200_XG_p1 I1660_G8_7 I1660_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I200_XG_MP0 (VDD I1660_P8_7 XI1660_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I200_XG_MP1 (XI1660_I200_XG_p1 I1660_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I198_XG_MP2 (XI1660_I198_XG_p1 I1660_G6_5 I1660_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I198_XG_MP0 (VDD I1660_P6_5 XI1660_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I198_XG_MP1 (XI1660_I198_XG_p1 I1660_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I203_XG_MP2 (XI1660_I203_XG_p1 I1660_G11_10 I1660_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I203_XG_MP0 (VDD I1660_P11_10 XI1660_I203_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I203_XG_MP1 (XI1660_I203_XG_p1 I1660_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I428_XG_MP2 (XI1660_I428_XG_p1 I1660_G33_2 I1660_G33_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I428_XG_MP0 (VDD I1660_P33_2 XI1660_I428_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I428_XG_MP1 (XI1660_I428_XG_p1 I1660_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I318_XG_MP2 (XI1660_I318_XG_p1 I1660_G9_2 I1660_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I318_XG_MP0 (VDD I1660_P9_2 XI1660_I318_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I318_XG_MP1 (XI1660_I318_XG_p1 I1660_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I330_XG_MP2 (XI1660_I330_XG_p1 I1660_G19_12 I1660_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I330_XG_MP0 (VDD I1660_P19_12 XI1660_I330_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I330_XG_MP1 (XI1660_I330_XG_p1 I1660_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I430_XG_MP2 (XI1660_I430_XG_p1 I1660_G35_4 I1660_G35_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I430_XG_MP0 (VDD I1660_P35_4 XI1660_I430_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I430_XG_MP1 (XI1660_I430_XG_p1 I1660_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I201_XG_MP2 (XI1660_I201_XG_p1 I1660_G9_8 I1660_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I201_XG_MP0 (VDD I1660_P9_8 XI1660_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I201_XG_MP1 (XI1660_I201_XG_p1 I1660_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I199_XG_MP2 (XI1660_I199_XG_p1 I1660_G7_6 I1660_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I199_XG_MP0 (VDD I1660_P7_6 XI1660_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I199_XG_MP1 (XI1660_I199_XG_p1 I1660_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I197_XG_MP2 (XI1660_I197_XG_p1 I1660_G5_4 I1660_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I197_XG_MP0 (VDD I1660_P5_4 XI1660_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I197_XG_MP1 (XI1660_I197_XG_p1 I1660_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I322_XG_MP2 (XI1660_I322_XG_p1 I1660_G11_4 I1660_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I322_XG_MP0 (VDD I1660_P11_4 XI1660_I322_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I322_XG_MP1 (XI1660_I322_XG_p1 I1660_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I195_XG_MP2 (XI1660_I195_XG_p1 I1660_G3_2 I1660_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I195_XG_MP0 (VDD I1660_P3_2 XI1660_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I195_XG_MP1 (XI1660_I195_XG_p1 I1660_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1603_MP24 (XI1603_sn pp15_18 XI1603_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1603_MP26 (VDD XI1603_sn fa242_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1603_MP17 (XI1603_con pp15_18 XI1603_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1603_MP14 (XI1603_p1 cm198_0 XI1603_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1603_MP13 (VDD cm197_1 XI1603_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1603_MP15 (XI1603_p2 cm197_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1603_MP16 (VDD cm198_0 XI1603_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1603_MP28 (fa242_1 XI1603_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1603_MP22 (XI1603_p4 cm197_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1603_MP23 (XI1603_p5 cm198_0 XI1603_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1603_MP23_1 (XI1603_p4 cm198_0 XI1603_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1603_MP22_1 (VDD cm197_1 XI1603_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1603_MP19 (XI1603_p3 cm198_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1603_MP18 (VDD cm197_1 XI1603_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1603_MP20 (XI1603_p3 pp15_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1603_MP21 (XI1603_sn XI1603_con XI1603_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1603_MP24_1 (XI1603_p5 pp15_18 XI1603_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1654_MP24 (XI1654_sn cm199_0 XI1654_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1654_MP26 (VDD XI1654_sn fa293_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1654_MP17 (XI1654_con cm199_0 XI1654_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1654_MP14 (XI1654_p1 cm198_1 XI1654_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1654_MP13 (VDD fa242_1 XI1654_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1654_MP15 (XI1654_p2 fa242_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1654_MP16 (VDD cm198_1 XI1654_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1654_MP28 (fa293_1 XI1654_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1654_MP22 (XI1654_p4 fa242_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1654_MP23 (XI1654_p5 cm198_1 XI1654_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1654_MP23_1 (XI1654_p4 cm198_1 XI1654_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1654_MP22_1 (VDD fa242_1 XI1654_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1654_MP19 (XI1654_p3 cm198_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1654_MP18 (VDD fa242_1 XI1654_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1654_MP20 (XI1654_p3 cm199_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1654_MP21 (XI1654_sn XI1654_con XI1654_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1654_MP24_1 (XI1654_p5 cm199_0 XI1654_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1604_MP24 (XI1604_sn cm124_2 XI1604_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1604_MP26 (VDD XI1604_sn fa243_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1604_MP17 (XI1604_con cm124_2 XI1604_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1604_MP14 (XI1604_p1 cm201_0 XI1604_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1604_MP13 (VDD cm200_1 XI1604_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1604_MP15 (XI1604_p2 cm200_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1604_MP16 (VDD cm201_0 XI1604_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1604_MP28 (fa243_1 XI1604_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1604_MP22 (XI1604_p4 cm200_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1604_MP23 (XI1604_p5 cm201_0 XI1604_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1604_MP23_1 (XI1604_p4 cm201_0 XI1604_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1604_MP22_1 (VDD cm200_1 XI1604_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1604_MP19 (XI1604_p3 cm201_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1604_MP18 (VDD cm200_1 XI1604_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1604_MP20 (XI1604_p3 cm124_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1604_MP21 (XI1604_sn XI1604_con XI1604_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1604_MP24_1 (XI1604_p5 cm124_2 XI1604_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1547_MP24 (XI1547_sn pp15_9 XI1547_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1547_MP26 (VDD XI1547_sn fa186_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1547_MP17 (XI1547_con pp15_9 XI1547_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1547_MP14 (XI1547_p1 cm97_0 XI1547_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1547_MP13 (VDD cm96_0 XI1547_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1547_MP15 (XI1547_p2 cm96_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1547_MP16 (VDD cm97_0 XI1547_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1547_MP28 (fa186_1 XI1547_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1547_MP22 (XI1547_p4 cm96_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1547_MP23 (XI1547_p5 cm97_0 XI1547_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1547_MP23_1 (XI1547_p4 cm97_0 XI1547_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1547_MP22_1 (VDD cm96_0 XI1547_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1547_MP19 (XI1547_p3 cm97_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1547_MP18 (VDD cm96_0 XI1547_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1547_MP20 (XI1547_p3 pp15_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1547_MP21 (XI1547_sn XI1547_con XI1547_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1547_MP24_1 (XI1547_p5 pp15_9 XI1547_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1598_MP24 (XI1598_sn fa192_0 XI1598_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1598_MP26 (VDD XI1598_sn fa237_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1598_MP17 (XI1598_con fa192_0 XI1598_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1598_MP14 (XI1598_p1 cm191_0 XI1598_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1598_MP13 (VDD cm190_1 XI1598_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1598_MP15 (XI1598_p2 cm190_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1598_MP16 (VDD cm191_0 XI1598_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1598_MP28 (fa237_1 XI1598_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1598_MP22 (XI1598_p4 cm190_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1598_MP23 (XI1598_p5 cm191_0 XI1598_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1598_MP23_1 (XI1598_p4 cm191_0 XI1598_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1598_MP22_1 (VDD cm190_1 XI1598_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1598_MP19 (XI1598_p3 cm191_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1598_MP18 (VDD cm190_1 XI1598_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1598_MP20 (XI1598_p3 fa192_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1598_MP21 (XI1598_sn XI1598_con XI1598_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1598_MP24_1 (XI1598_p5 fa192_0 XI1598_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1648_MP24 (XI1648_sn cm236_2 XI1648_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1648_MP26 (VDD XI1648_sn fa287_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1648_MP17 (XI1648_con cm236_2 XI1648_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1648_MP14 (XI1648_p1 fa237_0 XI1648_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1648_MP13 (VDD cm236_1 XI1648_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1648_MP15 (XI1648_p2 cm236_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1648_MP16 (VDD fa237_0 XI1648_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1648_MP28 (fa287_1 XI1648_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1648_MP22 (XI1648_p4 cm236_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1648_MP23 (XI1648_p5 fa237_0 XI1648_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1648_MP23_1 (XI1648_p4 fa237_0 XI1648_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1648_MP22_1 (VDD cm236_1 XI1648_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1648_MP19 (XI1648_p3 fa237_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1648_MP18 (VDD cm236_1 XI1648_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1648_MP20 (XI1648_p3 cm236_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1648_MP21 (XI1648_sn XI1648_con XI1648_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1648_MP24_1 (XI1648_p5 cm236_2 XI1648_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1487_MP24 (XI1487_sn pp15_21 XI1487_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1487_MP26 (VDD XI1487_sn fa126_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1487_MP17 (XI1487_con pp15_21 XI1487_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1487_MP14 (XI1487_p1 pp14_23 XI1487_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1487_MP13 (VDD pp13_25 XI1487_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1487_MP15 (XI1487_p2 pp13_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1487_MP16 (VDD pp14_23 XI1487_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1487_MP28 (fa126_1 XI1487_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1487_MP22 (XI1487_p4 pp13_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1487_MP23 (XI1487_p5 pp14_23 XI1487_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1487_MP23_1 (XI1487_p4 pp14_23 XI1487_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1487_MP22_1 (VDD pp13_25 XI1487_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1487_MP19 (XI1487_p3 pp14_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1487_MP18 (VDD pp13_25 XI1487_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1487_MP20 (XI1487_p3 pp15_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1487_MP21 (XI1487_sn XI1487_con XI1487_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1487_MP24_1 (XI1487_p5 pp15_21 XI1487_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1549_MP24 (XI1549_sn pp15_10 XI1549_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1549_MP26 (VDD XI1549_sn fa188_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1549_MP17 (XI1549_con pp15_10 XI1549_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1549_MP14 (XI1549_p1 cm100_0 XI1549_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1549_MP13 (VDD cm99_0 XI1549_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1549_MP15 (XI1549_p2 cm99_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1549_MP16 (VDD cm100_0 XI1549_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1549_MP28 (fa188_1 XI1549_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1549_MP22 (XI1549_p4 cm99_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1549_MP23 (XI1549_p5 cm100_0 XI1549_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1549_MP23_1 (XI1549_p4 cm100_0 XI1549_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1549_MP22_1 (VDD cm99_0 XI1549_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1549_MP19 (XI1549_p3 cm100_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1549_MP18 (VDD cm99_0 XI1549_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1549_MP20 (XI1549_p3 pp15_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1549_MP21 (XI1549_sn XI1549_con XI1549_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1549_MP24_1 (XI1549_p5 pp15_10 XI1549_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1646_MP24 (XI1646_sn cm103_0 XI1646_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1646_MP26 (VDD XI1646_sn fa285_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1646_MP17 (XI1646_con cm103_0 XI1646_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1646_MP14 (XI1646_p1 cm235_0 XI1646_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1646_MP13 (VDD cm234_1 XI1646_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1646_MP15 (XI1646_p2 cm234_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1646_MP16 (VDD cm235_0 XI1646_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1646_MP28 (fa285_1 XI1646_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1646_MP22 (XI1646_p4 cm234_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1646_MP23 (XI1646_p5 cm235_0 XI1646_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1646_MP23_1 (XI1646_p4 cm235_0 XI1646_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1646_MP22_1 (VDD cm234_1 XI1646_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1646_MP19 (XI1646_p3 cm235_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1646_MP18 (VDD cm234_1 XI1646_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1646_MP20 (XI1646_p3 cm103_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1646_MP21 (XI1646_sn XI1646_con XI1646_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1646_MP24_1 (XI1646_p5 cm103_0 XI1646_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1553_MP24 (XI1553_sn cm106_2 XI1553_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1553_MP26 (VDD XI1553_sn fa192_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1553_MP17 (XI1553_con cm106_2 XI1553_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1553_MP14 (XI1553_p1 fa109_0 XI1553_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1553_MP13 (VDD cm108_0 XI1553_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1553_MP15 (XI1553_p2 cm108_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1553_MP16 (VDD fa109_0 XI1553_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1553_MP28 (fa192_1 XI1553_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1553_MP22 (XI1553_p4 cm108_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1553_MP23 (XI1553_p5 fa109_0 XI1553_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1553_MP23_1 (XI1553_p4 fa109_0 XI1553_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1553_MP22_1 (VDD cm108_0 XI1553_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1553_MP19 (XI1553_p3 fa109_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1553_MP18 (VDD cm108_0 XI1553_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1553_MP20 (XI1553_p3 cm106_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1553_MP21 (XI1553_sn XI1553_con XI1553_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1553_MP24_1 (XI1553_p5 cm106_2 XI1553_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1489_MP24 (XI1489_sn pp15_22 XI1489_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1489_MP26 (VDD XI1489_sn fa128_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1489_MP17 (XI1489_con pp15_22 XI1489_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1489_MP14 (XI1489_p1 pp14_24 XI1489_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1489_MP13 (VDD pp13_26 XI1489_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1489_MP15 (XI1489_p2 pp13_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1489_MP16 (VDD pp14_24 XI1489_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1489_MP28 (fa128_1 XI1489_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1489_MP22 (XI1489_p4 pp13_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1489_MP23 (XI1489_p5 pp14_24 XI1489_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1489_MP23_1 (XI1489_p4 pp14_24 XI1489_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1489_MP22_1 (VDD pp13_26 XI1489_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1489_MP19 (XI1489_p3 pp14_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1489_MP18 (VDD pp13_26 XI1489_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1489_MP20 (XI1489_p3 pp15_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1489_MP21 (XI1489_sn XI1489_con XI1489_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1489_MP24_1 (XI1489_p5 pp15_22 XI1489_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1656_MP24 (XI1656_sn cm202_0 XI1656_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1656_MP26 (VDD XI1656_sn fa295_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1656_MP17 (XI1656_con cm202_0 XI1656_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1656_MP14 (XI1656_p1 cm201_1 XI1656_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1656_MP13 (VDD fa243_1 XI1656_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1656_MP15 (XI1656_p2 fa243_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1656_MP16 (VDD cm201_1 XI1656_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1656_MP28 (fa295_1 XI1656_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1656_MP22 (XI1656_p4 fa243_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1656_MP23 (XI1656_p5 cm201_1 XI1656_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1656_MP23_1 (XI1656_p4 cm201_1 XI1656_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1656_MP22_1 (VDD fa243_1 XI1656_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1656_MP19 (XI1656_p3 cm201_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1656_MP18 (VDD fa243_1 XI1656_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1656_MP20 (XI1656_p3 cm202_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1656_MP21 (XI1656_sn XI1656_con XI1656_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1656_MP24_1 (XI1656_p5 cm202_0 XI1656_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1644_MP24 (XI1644_sn cm184_2 XI1644_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1644_MP26 (VDD XI1644_sn fa283_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1644_MP17 (XI1644_con cm184_2 XI1644_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1644_MP14 (XI1644_p1 cm233_0 XI1644_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1644_MP13 (VDD cm232_1 XI1644_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1644_MP15 (XI1644_p2 cm232_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1644_MP16 (VDD cm233_0 XI1644_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1644_MP28 (fa283_1 XI1644_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1644_MP22 (XI1644_p4 cm232_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1644_MP23 (XI1644_p5 cm233_0 XI1644_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1644_MP23_1 (XI1644_p4 cm233_0 XI1644_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1644_MP22_1 (VDD cm232_1 XI1644_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1644_MP19 (XI1644_p3 cm233_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1644_MP18 (VDD cm232_1 XI1644_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1644_MP20 (XI1644_p3 cm184_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1644_MP21 (XI1644_sn XI1644_con XI1644_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1644_MP24_1 (XI1644_p5 cm184_2 XI1644_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1470_MP24 (XI1470_sn pp15_13 XI1470_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1470_MP26 (VDD XI1470_sn fa109_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1470_MP17 (XI1470_con pp15_13 XI1470_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1470_MP14 (XI1470_p1 pp14_15 XI1470_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1470_MP13 (VDD pp13_17 XI1470_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1470_MP15 (XI1470_p2 pp13_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1470_MP16 (VDD pp14_15 XI1470_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1470_MP28 (fa109_1 XI1470_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1470_MP22 (XI1470_p4 pp13_17 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1470_MP23 (XI1470_p5 pp14_15 XI1470_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1470_MP23_1 (XI1470_p4 pp14_15 XI1470_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1470_MP22_1 (VDD pp13_17 XI1470_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1470_MP19 (XI1470_p3 pp14_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1470_MP18 (VDD pp13_17 XI1470_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1470_MP20 (XI1470_p3 pp15_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1470_MP21 (XI1470_sn XI1470_con XI1470_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1470_MP24_1 (XI1470_p5 pp15_13 XI1470_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1473_MP24 (XI1473_sn pp15_14 XI1473_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1473_MP26 (VDD XI1473_sn fa112_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1473_MP17 (XI1473_con pp15_14 XI1473_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1473_MP14 (XI1473_p1 pp14_16 XI1473_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1473_MP13 (VDD pp13_18 XI1473_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1473_MP15 (XI1473_p2 pp13_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1473_MP16 (VDD pp14_16 XI1473_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1473_MP28 (fa112_1 XI1473_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1473_MP22 (XI1473_p4 pp13_18 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1473_MP23 (XI1473_p5 pp14_16 XI1473_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1473_MP23_1 (XI1473_p4 pp14_16 XI1473_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1473_MP22_1 (VDD pp13_18 XI1473_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1473_MP19 (XI1473_p3 pp14_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1473_MP18 (VDD pp13_18 XI1473_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1473_MP20 (XI1473_p3 pp15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1473_MP21 (XI1473_sn XI1473_con XI1473_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1473_MP24_1 (XI1473_p5 pp15_14 XI1473_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1605_MP24 (XI1605_sn pp15_23 XI1605_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1605_MP26 (VDD XI1605_sn fa244_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1605_MP17 (XI1605_con pp15_23 XI1605_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1605_MP14 (XI1605_p1 cm203_0 XI1605_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1605_MP13 (VDD cm202_1 XI1605_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1605_MP15 (XI1605_p2 cm202_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1605_MP16 (VDD cm203_0 XI1605_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1605_MP28 (fa244_1 XI1605_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1605_MP22 (XI1605_p4 cm202_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1605_MP23 (XI1605_p5 cm203_0 XI1605_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1605_MP23_1 (XI1605_p4 cm203_0 XI1605_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1605_MP22_1 (VDD cm202_1 XI1605_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1605_MP19 (XI1605_p3 cm203_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1605_MP18 (VDD cm202_1 XI1605_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1605_MP20 (XI1605_p3 pp15_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1605_MP21 (XI1605_sn XI1605_con XI1605_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1605_MP24_1 (XI1605_p5 pp15_23 XI1605_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1449_MP24 (XI1449_sn pp15_6 XI1449_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1449_MP26 (VDD XI1449_sn fa88_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1449_MP17 (XI1449_con pp15_6 XI1449_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1449_MP14 (XI1449_p1 pp14_8 XI1449_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1449_MP13 (VDD pp13_10 XI1449_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1449_MP15 (XI1449_p2 pp13_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1449_MP16 (VDD pp14_8 XI1449_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1449_MP28 (fa88_1 XI1449_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1449_MP22 (XI1449_p4 pp13_10 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1449_MP23 (XI1449_p5 pp14_8 XI1449_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1449_MP23_1 (XI1449_p4 pp14_8 XI1449_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1449_MP22_1 (VDD pp13_10 XI1449_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1449_MP19 (XI1449_p3 pp14_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1449_MP18 (VDD pp13_10 XI1449_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1449_MP20 (XI1449_p3 pp15_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1449_MP21 (XI1449_sn XI1449_con XI1449_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1449_MP24_1 (XI1449_p5 pp15_6 XI1449_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1556_MP24 (XI1556_sn pp15_15 XI1556_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1556_MP26 (VDD XI1556_sn fa195_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1556_MP17 (XI1556_con pp15_15 XI1556_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1556_MP14 (XI1556_p1 pp14_17 XI1556_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1556_MP13 (VDD cm114_0 XI1556_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1556_MP15 (XI1556_p2 cm114_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1556_MP16 (VDD pp14_17 XI1556_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1556_MP28 (fa195_1 XI1556_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1556_MP22 (XI1556_p4 cm114_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1556_MP23 (XI1556_p5 pp14_17 XI1556_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1556_MP23_1 (XI1556_p4 pp14_17 XI1556_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1556_MP22_1 (VDD cm114_0 XI1556_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1556_MP19 (XI1556_p3 pp14_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1556_MP18 (VDD cm114_0 XI1556_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1556_MP20 (XI1556_p3 pp15_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1556_MP21 (XI1556_sn XI1556_con XI1556_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1556_MP24_1 (XI1556_p5 pp15_15 XI1556_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1657_MP24 (XI1657_sn cm204_0 XI1657_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1657_MP26 (VDD XI1657_sn fa296_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1657_MP17 (XI1657_con cm204_0 XI1657_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1657_MP14 (XI1657_p1 cm203_1 XI1657_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1657_MP13 (VDD fa244_1 XI1657_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1657_MP15 (XI1657_p2 fa244_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1657_MP16 (VDD cm203_1 XI1657_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1657_MP28 (fa296_1 XI1657_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1657_MP22 (XI1657_p4 fa244_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1657_MP23 (XI1657_p5 cm203_1 XI1657_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1657_MP23_1 (XI1657_p4 cm203_1 XI1657_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1657_MP22_1 (VDD fa244_1 XI1657_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1657_MP19 (XI1657_p3 cm203_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1657_MP18 (VDD fa244_1 XI1657_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1657_MP20 (XI1657_p3 cm204_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1657_MP21 (XI1657_sn XI1657_con XI1657_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1657_MP24_1 (XI1657_p5 cm204_0 XI1657_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1642_MP24 (XI1642_sn pp15_7 XI1642_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1642_MP26 (VDD XI1642_sn fa281_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1642_MP17 (XI1642_con pp15_7 XI1642_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1642_MP14 (XI1642_p1 cm231_0 XI1642_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1642_MP13 (VDD cm230_1 XI1642_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1642_MP15 (XI1642_p2 cm230_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1642_MP16 (VDD cm231_0 XI1642_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1642_MP28 (fa281_1 XI1642_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1642_MP22 (XI1642_p4 cm230_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1642_MP23 (XI1642_p5 cm231_0 XI1642_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1642_MP23_1 (XI1642_p4 cm231_0 XI1642_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1642_MP22_1 (VDD cm230_1 XI1642_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1642_MP19 (XI1642_p3 cm231_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1642_MP18 (VDD cm230_1 XI1642_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1642_MP20 (XI1642_p3 pp15_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1642_MP21 (XI1642_sn XI1642_con XI1642_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1642_MP24_1 (XI1642_p5 pp15_7 XI1642_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1600_MP24 (XI1600_sn fa195_0 XI1600_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1600_MP26 (VDD XI1600_sn fa239_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1600_MP17 (XI1600_con fa195_0 XI1600_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1600_MP14 (XI1600_p1 cm194_0 XI1600_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1600_MP13 (VDD cm193_1 XI1600_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1600_MP15 (XI1600_p2 cm193_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1600_MP16 (VDD cm194_0 XI1600_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1600_MP28 (fa239_1 XI1600_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1600_MP22 (XI1600_p4 cm193_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1600_MP23 (XI1600_p5 cm194_0 XI1600_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1600_MP23_1 (XI1600_p4 cm194_0 XI1600_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1600_MP22_1 (VDD cm193_1 XI1600_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1600_MP19 (XI1600_p3 cm194_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1600_MP18 (VDD cm193_1 XI1600_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1600_MP20 (XI1600_p3 fa195_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1600_MP21 (XI1600_sn XI1600_con XI1600_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1600_MP24_1 (XI1600_p5 fa195_0 XI1600_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1602_MP24 (XI1602_sn pp15_17 XI1602_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1602_MP26 (VDD XI1602_sn fa241_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1602_MP17 (XI1602_con pp15_17 XI1602_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1602_MP14 (XI1602_p1 cm197_0 XI1602_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1602_MP13 (VDD cm196_1 XI1602_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1602_MP15 (XI1602_p2 cm196_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1602_MP16 (VDD cm197_0 XI1602_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1602_MP28 (fa241_1 XI1602_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1602_MP22 (XI1602_p4 cm196_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1602_MP23 (XI1602_p5 cm197_0 XI1602_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1602_MP23_1 (XI1602_p4 cm197_0 XI1602_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1602_MP22_1 (VDD cm196_1 XI1602_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1602_MP19 (XI1602_p3 cm197_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1602_MP18 (VDD cm196_1 XI1602_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1602_MP20 (XI1602_p3 pp15_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1602_MP21 (XI1602_sn XI1602_con XI1602_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1602_MP24_1 (XI1602_p5 pp15_17 XI1602_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1650_MP24 (XI1650_sn cm238_2 XI1650_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1650_MP26 (VDD XI1650_sn fa289_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1650_MP17 (XI1650_con cm238_2 XI1650_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1650_MP14 (XI1650_p1 fa239_0 XI1650_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1650_MP13 (VDD cm238_1 XI1650_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1650_MP15 (XI1650_p2 cm238_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1650_MP16 (VDD fa239_0 XI1650_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1650_MP28 (fa289_1 XI1650_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1650_MP22 (XI1650_p4 cm238_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1650_MP23 (XI1650_p5 fa239_0 XI1650_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1650_MP23_1 (XI1650_p4 fa239_0 XI1650_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1650_MP22_1 (VDD cm238_1 XI1650_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1650_MP19 (XI1650_p3 fa239_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1650_MP18 (VDD cm238_1 XI1650_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1650_MP20 (XI1650_p3 cm238_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1650_MP21 (XI1650_sn XI1650_con XI1650_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1650_MP24_1 (XI1650_p5 cm238_2 XI1650_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1652_MP24 (XI1652_sn cm240_2 XI1652_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1652_MP26 (VDD XI1652_sn fa291_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1652_MP17 (XI1652_con cm240_2 XI1652_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1652_MP14 (XI1652_p1 fa241_0 XI1652_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1652_MP13 (VDD cm240_1 XI1652_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1652_MP15 (XI1652_p2 cm240_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1652_MP16 (VDD fa241_0 XI1652_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1652_MP28 (fa291_1 XI1652_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1652_MP22 (XI1652_p4 cm240_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1652_MP23 (XI1652_p5 fa241_0 XI1652_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1652_MP23_1 (XI1652_p4 fa241_0 XI1652_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1652_MP22_1 (VDD cm240_1 XI1652_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1652_MP19 (XI1652_p3 fa241_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1652_MP18 (VDD cm240_1 XI1652_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1652_MP20 (XI1652_p3 cm240_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1652_MP21 (XI1652_sn XI1652_con XI1652_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1652_MP24_1 (XI1652_p5 cm240_2 XI1652_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1566_MP24 (XI1566_sn pp15_25 XI1566_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1566_MP26 (VDD XI1566_sn fa205_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1566_MP17 (XI1566_con pp15_25 XI1566_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1566_MP14 (XI1566_p1 cm131_0 XI1566_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1566_MP13 (VDD cm130_1 XI1566_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1566_MP15 (XI1566_p2 cm130_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1566_MP16 (VDD cm131_0 XI1566_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1566_MP28 (fa205_1 XI1566_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1566_MP22 (XI1566_p4 cm130_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1566_MP23 (XI1566_p5 cm131_0 XI1566_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1566_MP23_1 (XI1566_p4 cm131_0 XI1566_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1566_MP22_1 (VDD cm130_1 XI1566_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1566_MP19 (XI1566_p3 cm131_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1566_MP18 (VDD cm130_1 XI1566_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1566_MP20 (XI1566_p3 pp15_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1566_MP21 (XI1566_sn XI1566_con XI1566_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1566_MP24_1 (XI1566_p5 pp15_25 XI1566_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1606_MP24 (XI1606_sn cm204_2 XI1606_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1606_MP26 (VDD XI1606_sn fa245_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1606_MP17 (XI1606_con cm204_2 XI1606_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1606_MP14 (XI1606_p1 fa205_0 XI1606_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1606_MP13 (VDD cm204_1 XI1606_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1606_MP15 (XI1606_p2 cm204_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1606_MP16 (VDD fa205_0 XI1606_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1606_MP28 (fa245_1 XI1606_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1606_MP22 (XI1606_p4 cm204_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1606_MP23 (XI1606_p5 fa205_0 XI1606_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1606_MP23_1 (XI1606_p4 fa205_0 XI1606_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1606_MP22_1 (VDD cm204_1 XI1606_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1606_MP19 (XI1606_p3 fa205_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1606_MP18 (VDD cm204_1 XI1606_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1606_MP20 (XI1606_p3 cm204_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1606_MP21 (XI1606_sn XI1606_con XI1606_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1606_MP24_1 (XI1606_p5 cm204_2 XI1606_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1641_MP24 (XI1641_sn cm84_2 XI1641_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1641_MP26 (VDD XI1641_sn fa280_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1641_MP17 (XI1641_con cm84_2 XI1641_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1641_MP14 (XI1641_p1 cm230_0 XI1641_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1641_MP13 (VDD cm229_1 XI1641_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1641_MP15 (XI1641_p2 cm229_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1641_MP16 (VDD cm230_0 XI1641_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1641_MP28 (fa280_1 XI1641_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1641_MP22 (XI1641_p4 cm229_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1641_MP23 (XI1641_p5 cm230_0 XI1641_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1641_MP23_1 (XI1641_p4 cm230_0 XI1641_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1641_MP22_1 (VDD cm229_1 XI1641_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1641_MP19 (XI1641_p3 cm230_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1641_MP18 (VDD cm229_1 XI1641_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1641_MP20 (XI1641_p3 cm84_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1641_MP21 (XI1641_sn XI1641_con XI1641_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1641_MP24_1 (XI1641_p5 cm84_2 XI1641_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1567_MP24 (XI1567_sn pp15_26 XI1567_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1567_MP26 (VDD XI1567_sn fa206_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1567_MP17 (XI1567_con pp15_26 XI1567_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1567_MP14 (XI1567_p1 cm132_0 XI1567_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1567_MP13 (VDD cm131_1 XI1567_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1567_MP15 (XI1567_p2 cm131_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1567_MP16 (VDD cm132_0 XI1567_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1567_MP28 (fa206_1 XI1567_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1567_MP22 (XI1567_p4 cm131_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1567_MP23 (XI1567_p5 cm132_0 XI1567_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1567_MP23_1 (XI1567_p4 cm132_0 XI1567_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1567_MP22_1 (VDD cm131_1 XI1567_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1567_MP19 (XI1567_p3 cm132_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1567_MP18 (VDD cm131_1 XI1567_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1567_MP20 (XI1567_p3 pp15_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1567_MP21 (XI1567_sn XI1567_con XI1567_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1567_MP24_1 (XI1567_p5 pp15_26 XI1567_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1607_MP24 (XI1607_sn cm133_0 XI1607_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1607_MP26 (VDD XI1607_sn fa246_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1607_MP17 (XI1607_con cm133_0 XI1607_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1607_MP14 (XI1607_p1 cm132_1 XI1607_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1607_MP13 (VDD fa206_1 XI1607_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1607_MP15 (XI1607_p2 fa206_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1607_MP16 (VDD cm132_1 XI1607_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1607_MP28 (fa246_1 XI1607_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1607_MP22 (XI1607_p4 fa206_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1607_MP23 (XI1607_p5 cm132_1 XI1607_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1607_MP23_1 (XI1607_p4 cm132_1 XI1607_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1607_MP22_1 (VDD fa206_1 XI1607_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1607_MP19 (XI1607_p3 cm132_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1607_MP18 (VDD fa206_1 XI1607_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1607_MP20 (XI1607_p3 cm133_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1607_MP21 (XI1607_sn XI1607_con XI1607_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1607_MP24_1 (XI1607_p5 cm133_0 XI1607_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1658_MP24 (XI1658_sn fa206_0 XI1658_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1658_MP26 (VDD XI1658_sn fa297_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1658_MP17 (XI1658_con fa206_0 XI1658_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1658_MP14 (XI1658_p1 fa205_1 XI1658_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1658_MP13 (VDD fa245_1 XI1658_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1658_MP15 (XI1658_p2 fa245_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1658_MP16 (VDD fa205_1 XI1658_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1658_MP28 (fa297_1 XI1658_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1658_MP22 (XI1658_p4 fa245_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1658_MP23 (XI1658_p5 fa205_1 XI1658_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1658_MP23_1 (XI1658_p4 fa205_1 XI1658_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1658_MP22_1 (VDD fa245_1 XI1658_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1658_MP19 (XI1658_p3 fa205_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1658_MP18 (VDD fa245_1 XI1658_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1658_MP20 (XI1658_p3 fa206_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1658_MP21 (XI1658_sn XI1658_con XI1658_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1658_MP24_1 (XI1658_p5 fa206_0 XI1658_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1496_MP24 (XI1496_sn pp15_29 XI1496_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1496_MP26 (VDD XI1496_sn fa135_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1496_MP17 (XI1496_con pp15_29 XI1496_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1496_MP14 (XI1496_p1 pp14_31 XI1496_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1496_MP13 (VDD sn13 XI1496_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1496_MP15 (XI1496_p2 sn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1496_MP16 (VDD pp14_31 XI1496_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1496_MP28 (fa135_1 XI1496_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1496_MP22 (XI1496_p4 sn13 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1496_MP23 (XI1496_p5 pp14_31 XI1496_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1496_MP23_1 (XI1496_p4 pp14_31 XI1496_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1496_MP22_1 (VDD sn13 XI1496_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1496_MP19 (XI1496_p3 pp14_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1496_MP18 (VDD sn13 XI1496_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1496_MP20 (XI1496_p3 pp15_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1496_MP21 (XI1496_sn XI1496_con XI1496_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1496_MP24_1 (XI1496_p5 pp15_29 XI1496_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1659_MP24 (XI1659_sn cm134_0 XI1659_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1659_MP26 (VDD XI1659_sn fa298_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1659_MP17 (XI1659_con cm134_0 XI1659_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1659_MP14 (XI1659_p1 cm133_1 XI1659_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1659_MP13 (VDD fa246_1 XI1659_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1659_MP15 (XI1659_p2 fa246_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1659_MP16 (VDD cm133_1 XI1659_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1659_MP28 (fa298_1 XI1659_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1659_MP22 (XI1659_p4 fa246_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1659_MP23 (XI1659_p5 cm133_1 XI1659_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1659_MP23_1 (XI1659_p4 cm133_1 XI1659_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1659_MP22_1 (VDD fa246_1 XI1659_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1659_MP19 (XI1659_p3 cm133_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1659_MP18 (VDD fa246_1 XI1659_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1659_MP20 (XI1659_p3 cm134_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1659_MP21 (XI1659_sn XI1659_con XI1659_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1659_MP24_1 (XI1659_p5 cm134_0 XI1659_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1497_MP24 (XI1497_sn pp15_30 XI1497_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1497_MP26 (VDD XI1497_sn fa136_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1497_MP17 (XI1497_con pp15_30 XI1497_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1497_MP14 (XI1497_p1 pp14_32 XI1497_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1497_MP13 (VDD VDD XI1497_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1497_MP15 (XI1497_p2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1497_MP16 (VDD pp14_32 XI1497_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1497_MP28 (fa136_1 XI1497_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1497_MP22 (XI1497_p4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1497_MP23 (XI1497_p5 pp14_32 XI1497_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1497_MP23_1 (XI1497_p4 pp14_32 XI1497_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1497_MP22_1 (VDD VDD XI1497_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1497_MP19 (XI1497_p3 pp14_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1497_MP18 (VDD VDD XI1497_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1497_MP20 (XI1497_p3 pp15_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1497_MP21 (XI1497_sn XI1497_con XI1497_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1497_MP24_1 (XI1497_p5 pp15_30 XI1497_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1568_MP24 (XI1568_sn cm134_2 XI1568_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1568_MP26 (VDD XI1568_sn fa207_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1568_MP17 (XI1568_con cm134_2 XI1568_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1568_MP14 (XI1568_p1 fa135_0 XI1568_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1568_MP13 (VDD cm134_1 XI1568_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1568_MP15 (XI1568_p2 cm134_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1568_MP16 (VDD fa135_0 XI1568_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1568_MP28 (fa207_1 XI1568_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1568_MP22 (XI1568_p4 cm134_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1568_MP23 (XI1568_p5 fa135_0 XI1568_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1568_MP23_1 (XI1568_p4 fa135_0 XI1568_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1568_MP22_1 (VDD cm134_1 XI1568_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1568_MP19 (XI1568_p3 fa135_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1568_MP18 (VDD cm134_1 XI1568_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1568_MP20 (XI1568_p3 cm134_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1568_MP21 (XI1568_sn XI1568_con XI1568_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1568_MP24_1 (XI1568_p5 cm134_2 XI1568_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1569_MP24 (XI1569_sn pp15_31 XI1569_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1569_MP26 (VDD XI1569_sn fa208_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1569_MP17 (XI1569_con pp15_31 XI1569_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1569_MP14 (XI1569_p1 sn14 XI1569_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1569_MP13 (VDD fa136_1 XI1569_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1569_MP15 (XI1569_p2 fa136_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1569_MP16 (VDD sn14 XI1569_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1569_MP28 (fa208_1 XI1569_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1569_MP22 (XI1569_p4 fa136_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1569_MP23 (XI1569_p5 sn14 XI1569_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1569_MP23_1 (XI1569_p4 sn14 XI1569_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1569_MP22_1 (VDD fa136_1 XI1569_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1569_MP19 (XI1569_p3 sn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1569_MP18 (VDD fa136_1 XI1569_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1569_MP20 (XI1569_p3 pp15_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1569_MP21 (XI1569_sn XI1569_con XI1569_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1569_MP24_1 (XI1569_p5 pp15_31 XI1569_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1608_MP24 (XI1608_sn fa136_0 XI1608_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1608_MP26 (VDD XI1608_sn fa247_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1608_MP17 (XI1608_con fa136_0 XI1608_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1608_MP14 (XI1608_p1 fa135_1 XI1608_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1608_MP13 (VDD fa207_1 XI1608_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1608_MP15 (XI1608_p2 fa207_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1608_MP16 (VDD fa135_1 XI1608_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1608_MP28 (fa247_1 XI1608_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1608_MP22 (XI1608_p4 fa207_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1608_MP23 (XI1608_p5 fa135_1 XI1608_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1608_MP23_1 (XI1608_p4 fa135_1 XI1608_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1608_MP22_1 (VDD fa207_1 XI1608_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1608_MP19 (XI1608_p3 fa135_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1608_MP18 (VDD fa207_1 XI1608_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1608_MP20 (XI1608_p3 fa136_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1608_MP21 (XI1608_sn XI1608_con XI1608_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1608_MP24_1 (XI1608_p5 fa136_0 XI1608_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1421_MP24 (XI1421_sn pp14_1 XI1421_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1421_MP26 (VDD XI1421_sn fa60_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1421_MP17 (XI1421_con pp14_1 XI1421_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1421_MP14 (XI1421_p1 pp13_3 XI1421_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1421_MP13 (VDD pp12_5 XI1421_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1421_MP15 (XI1421_p2 pp12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1421_MP16 (VDD pp13_3 XI1421_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1421_MP28 (fa60_1 XI1421_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1421_MP22 (XI1421_p4 pp12_5 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1421_MP23 (XI1421_p5 pp13_3 XI1421_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1421_MP23_1 (XI1421_p4 pp13_3 XI1421_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1421_MP22_1 (VDD pp12_5 XI1421_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1421_MP19 (XI1421_p3 pp13_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1421_MP18 (VDD pp12_5 XI1421_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1421_MP20 (XI1421_p3 pp14_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1421_MP21 (XI1421_sn XI1421_con XI1421_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1421_MP24_1 (XI1421_p5 pp14_1 XI1421_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1417_MP24 (XI1417_sn pp14_0 XI1417_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1417_MP26 (VDD XI1417_sn fa56_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1417_MP17 (XI1417_con pp14_0 XI1417_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1417_MP14 (XI1417_p1 pp13_2 XI1417_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1417_MP13 (VDD pp12_4 XI1417_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1417_MP15 (XI1417_p2 pp12_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1417_MP16 (VDD pp13_2 XI1417_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1417_MP28 (fa56_1 XI1417_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1417_MP22 (XI1417_p4 pp12_4 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1417_MP23 (XI1417_p5 pp13_2 XI1417_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1417_MP23_1 (XI1417_p4 pp13_2 XI1417_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1417_MP22_1 (VDD pp12_4 XI1417_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1417_MP19 (XI1417_p3 pp13_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1417_MP18 (VDD pp12_4 XI1417_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1417_MP20 (XI1417_p3 pp14_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1417_MP21 (XI1417_sn XI1417_con XI1417_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1417_MP24_1 (XI1417_p5 pp14_0 XI1417_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1609_MP24 (XI1609_sn pp15_32 XI1609_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1609_MP26 (VDD XI1609_sn fa248_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1609_MP17 (XI1609_con pp15_32 XI1609_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1609_MP14 (XI1609_p1 VDD XI1609_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1609_MP13 (VDD fa208_1 XI1609_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1609_MP15 (XI1609_p2 fa208_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1609_MP16 (VDD VDD XI1609_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1609_MP28 (fa248_1 XI1609_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1609_MP22 (XI1609_p4 fa208_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1609_MP23 (XI1609_p5 VDD XI1609_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1609_MP23_1 (XI1609_p4 VDD XI1609_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1609_MP22_1 (VDD fa208_1 XI1609_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1609_MP19 (XI1609_p3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1609_MP18 (VDD fa208_1 XI1609_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1609_MP20 (XI1609_p3 pp15_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1609_MP21 (XI1609_sn XI1609_con XI1609_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1609_MP24_1 (XI1609_p5 pp15_32 XI1609_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1521_MP24 (XI1521_sn fa49_0 XI1521_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1521_MP26 (VDD XI1521_sn fa160_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1521_MP17 (XI1521_con fa49_0 XI1521_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1521_MP14 (XI1521_p1 cm48_0 XI1521_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1521_MP13 (VDD cm47_0 XI1521_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1521_MP15 (XI1521_p2 cm47_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1521_MP16 (VDD cm48_0 XI1521_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1521_MP28 (fa160_1 XI1521_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1521_MP22 (XI1521_p4 cm47_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1521_MP23 (XI1521_p5 cm48_0 XI1521_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1521_MP23_1 (XI1521_p4 cm48_0 XI1521_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1521_MP22_1 (VDD cm47_0 XI1521_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1521_MP19 (XI1521_p3 cm48_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1521_MP18 (VDD cm47_0 XI1521_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1521_MP20 (XI1521_p3 fa49_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1521_MP21 (XI1521_sn XI1521_con XI1521_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1521_MP24_1 (XI1521_p5 fa49_0 XI1521_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1410_MP24 (XI1410_sn B_27_b3_5 XI1410_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1410_MP26 (VDD XI1410_sn fa49_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1410_MP17 (XI1410_con B_27_b3_5 XI1410_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1410_MP14 (XI1410_p1 pp13_0 XI1410_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1410_MP13 (VDD pp12_2 XI1410_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1410_MP15 (XI1410_p2 pp12_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1410_MP16 (VDD pp13_0 XI1410_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1410_MP28 (fa49_1 XI1410_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1410_MP22 (XI1410_p4 pp12_2 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1410_MP23 (XI1410_p5 pp13_0 XI1410_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1410_MP23_1 (XI1410_p4 pp13_0 XI1410_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1410_MP22_1 (VDD pp12_2 XI1410_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1410_MP19 (XI1410_p3 pp13_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1410_MP18 (VDD pp12_2 XI1410_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1410_MP20 (XI1410_p3 B_27_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1410_MP21 (XI1410_sn XI1410_con XI1410_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1410_MP24_1 (XI1410_p5 B_27_b3_5 XI1410_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1519_MP24 (XI1519_sn pp12_1 XI1519_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.4u ps=0.8u
    I_MXI1519_MP26 (VDD XI1519_sn fa158_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1519_MP17 (XI1519_con pp12_1 XI1519_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1519_MP14 (XI1519_p1 cm45_0 XI1519_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1519_MP13 (VDD cm44_0 XI1519_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1519_MP15 (XI1519_p2 cm44_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1519_MP16 (VDD cm45_0 XI1519_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1519_MP28 (fa158_1 XI1519_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.16u ps=0.92u
    I_MXI1519_MP22 (XI1519_p4 cm44_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.8u ps=1.4u
    I_MXI1519_MP23 (XI1519_p5 cm45_0 XI1519_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1519_MP23_1 (XI1519_p4 cm45_0 XI1519_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.8u ps=0.8u
    I_MXI1519_MP22_1 (VDD cm44_0 XI1519_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.46u ps=0.8u
    I_MXI1519_MP19 (XI1519_p3 cm45_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.92u ps=1.46u
    I_MXI1519_MP18 (VDD cm44_0 XI1519_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1519_MP20 (XI1519_p3 pp12_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1519_MP21 (XI1519_sn XI1519_con XI1519_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1519_MP24_1 (XI1519_p5 pp12_1 XI1519_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.8u ps=0.92u
    I_MXI1517_MP24 (XI1517_sn pp12_0 XI1517_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1517_MP26 (VDD XI1517_sn fa156_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1517_MP17 (XI1517_con pp12_0 XI1517_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1517_MP14 (XI1517_p1 cm42_0 XI1517_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1517_MP13 (VDD cm41_0 XI1517_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1517_MP15 (XI1517_p2 cm41_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1517_MP16 (VDD cm42_0 XI1517_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1517_MP28 (fa156_1 XI1517_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1517_MP22 (XI1517_p4 cm41_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1517_MP23 (XI1517_p5 cm42_0 XI1517_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1517_MP23_1 (XI1517_p4 cm42_0 XI1517_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1517_MP22_1 (VDD cm41_0 XI1517_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1517_MP19 (XI1517_p3 cm42_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1517_MP18 (VDD cm41_0 XI1517_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1517_MP20 (XI1517_p3 pp12_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1517_MP21 (XI1517_sn XI1517_con XI1517_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1517_MP24_1 (XI1517_p5 pp12_0 XI1517_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1394_MP24 (XI1394_sn pp10_1 XI1394_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1394_MP26 (VDD XI1394_sn fa33_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1394_MP17 (XI1394_con pp10_1 XI1394_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1394_MP14 (XI1394_p1 pp9_3 XI1394_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1394_MP13 (VDD pp8_5 XI1394_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1394_MP15 (XI1394_p2 pp8_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1394_MP16 (VDD pp9_3 XI1394_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1394_MP28 (fa33_1 XI1394_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1394_MP22 (XI1394_p4 pp8_5 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1394_MP23 (XI1394_p5 pp9_3 XI1394_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1394_MP23_1 (XI1394_p4 pp9_3 XI1394_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1394_MP22_1 (VDD pp8_5 XI1394_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1394_MP19 (XI1394_p3 pp9_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1394_MP18 (VDD pp8_5 XI1394_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1394_MP20 (XI1394_p3 pp10_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1394_MP21 (XI1394_sn XI1394_con XI1394_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1394_MP24_1 (XI1394_p5 pp10_1 XI1394_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1391_MP24 (XI1391_sn pp10_0 XI1391_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1391_MP26 (VDD XI1391_sn fa30_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1391_MP17 (XI1391_con pp10_0 XI1391_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1391_MP14 (XI1391_p1 pp9_2 XI1391_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1391_MP13 (VDD pp8_4 XI1391_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1391_MP15 (XI1391_p2 pp8_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1391_MP16 (VDD pp9_2 XI1391_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1391_MP28 (fa30_1 XI1391_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1391_MP22 (XI1391_p4 pp8_4 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1391_MP23 (XI1391_p5 pp9_2 XI1391_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1391_MP23_1 (XI1391_p4 pp9_2 XI1391_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1391_MP22_1 (VDD pp8_4 XI1391_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1391_MP19 (XI1391_p3 pp9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1391_MP18 (VDD pp8_4 XI1391_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1391_MP20 (XI1391_p3 pp10_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1391_MP21 (XI1391_sn XI1391_con XI1391_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1391_MP24_1 (XI1391_p5 pp10_0 XI1391_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1511_MP24 (XI1511_sn pp9_1 XI1511_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1511_MP26 (VDD XI1511_sn fa150_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1511_MP17 (XI1511_con pp9_1 XI1511_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1511_MP14 (XI1511_p1 pp8_3 XI1511_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1511_MP13 (VDD cm27_0 XI1511_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1511_MP15 (XI1511_p2 cm27_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1511_MP16 (VDD pp8_3 XI1511_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1511_MP28 (fa150_1 XI1511_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1511_MP22 (XI1511_p4 cm27_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1511_MP23 (XI1511_p5 pp8_3 XI1511_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1511_MP23_1 (XI1511_p4 pp8_3 XI1511_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1511_MP22_1 (VDD cm27_0 XI1511_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1511_MP19 (XI1511_p3 pp8_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1511_MP18 (VDD cm27_0 XI1511_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1511_MP20 (XI1511_p3 pp9_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1511_MP21 (XI1511_sn XI1511_con XI1511_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1511_MP24_1 (XI1511_p5 pp9_1 XI1511_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1386_MP24 (XI1386_sn B_19_b3_5 XI1386_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1386_MP26 (VDD XI1386_sn fa25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1386_MP17 (XI1386_con B_19_b3_5 XI1386_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1386_MP14 (XI1386_p1 pp9_0 XI1386_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1386_MP13 (VDD pp8_2 XI1386_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1386_MP15 (XI1386_p2 pp8_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1386_MP16 (VDD pp9_0 XI1386_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1386_MP28 (fa25_1 XI1386_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1386_MP22 (XI1386_p4 pp8_2 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1386_MP23 (XI1386_p5 pp9_0 XI1386_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1386_MP23_1 (XI1386_p4 pp9_0 XI1386_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1386_MP22_1 (VDD pp8_2 XI1386_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1386_MP19 (XI1386_p3 pp9_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1386_MP18 (VDD pp8_2 XI1386_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1386_MP20 (XI1386_p3 B_19_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1386_MP21 (XI1386_sn XI1386_con XI1386_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1386_MP24_1 (XI1386_p5 B_19_b3_5 XI1386_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1574_MP24 (XI1574_sn fa150_0 XI1574_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1574_MP26 (VDD XI1574_sn fa213_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1574_MP17 (XI1574_con fa150_0 XI1574_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1574_MP14 (XI1574_p1 cm149_0 XI1574_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1574_MP13 (VDD cm148_1 XI1574_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1574_MP15 (XI1574_p2 cm148_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1574_MP16 (VDD cm149_0 XI1574_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1574_MP28 (fa213_1 XI1574_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1574_MP22 (XI1574_p4 cm148_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1574_MP23 (XI1574_p5 cm149_0 XI1574_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1574_MP23_1 (XI1574_p4 cm149_0 XI1574_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1574_MP22_1 (VDD cm148_1 XI1574_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1574_MP19 (XI1574_p3 cm149_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1574_MP18 (VDD cm148_1 XI1574_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1574_MP20 (XI1574_p3 fa150_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1574_MP21 (XI1574_sn XI1574_con XI1574_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1574_MP24_1 (XI1574_p5 fa150_0 XI1574_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1573_MP24 (XI1573_sn fa25_0 XI1573_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1573_MP26 (VDD XI1573_sn fa212_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1573_MP17 (XI1573_con fa25_0 XI1573_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1573_MP14 (XI1573_p1 cm148_0 XI1573_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1573_MP13 (VDD cm147_1 XI1573_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1573_MP15 (XI1573_p2 cm147_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1573_MP16 (VDD cm148_0 XI1573_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1573_MP28 (fa212_1 XI1573_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1573_MP22 (XI1573_p4 cm147_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1573_MP23 (XI1573_p5 cm148_0 XI1573_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1573_MP23_1 (XI1573_p4 cm148_0 XI1573_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1573_MP22_1 (VDD cm147_1 XI1573_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1573_MP19 (XI1573_p3 cm148_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1573_MP18 (VDD cm147_1 XI1573_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1573_MP20 (XI1573_p3 fa25_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1573_MP21 (XI1573_sn XI1573_con XI1573_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1573_MP24_1 (XI1573_p5 fa25_0 XI1573_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1571_MP24 (XI1571_sn pp8_0 XI1571_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1571_MP26 (VDD XI1571_sn fa210_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1571_MP17 (XI1571_con pp8_0 XI1571_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1571_MP14 (XI1571_p1 cm146_0 XI1571_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1571_MP13 (VDD cm145_1 XI1571_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1571_MP15 (XI1571_p2 cm145_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1571_MP16 (VDD cm146_0 XI1571_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1571_MP28 (fa210_1 XI1571_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1571_MP22 (XI1571_p4 cm145_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1571_MP23 (XI1571_p5 cm146_0 XI1571_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1571_MP23_1 (XI1571_p4 cm146_0 XI1571_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1571_MP22_1 (VDD cm145_1 XI1571_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1571_MP19 (XI1571_p3 cm146_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1571_MP18 (VDD cm145_1 XI1571_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1571_MP20 (XI1571_p3 pp8_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1571_MP21 (XI1571_sn XI1571_con XI1571_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1571_MP24_1 (XI1571_p5 pp8_0 XI1571_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1572_MP24 (XI1572_sn pp8_1 XI1572_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1572_MP26 (VDD XI1572_sn fa211_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1572_MP17 (XI1572_con pp8_1 XI1572_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1572_MP14 (XI1572_p1 cm147_0 XI1572_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1572_MP13 (VDD cm146_1 XI1572_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1572_MP15 (XI1572_p2 cm146_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1572_MP16 (VDD cm147_0 XI1572_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1572_MP28 (fa211_1 XI1572_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1572_MP22 (XI1572_p4 cm146_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1572_MP23 (XI1572_p5 cm147_0 XI1572_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1572_MP23_1 (XI1572_p4 cm147_0 XI1572_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1572_MP22_1 (VDD cm146_1 XI1572_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1572_MP19 (XI1572_p3 cm147_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1572_MP18 (VDD cm146_1 XI1572_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1572_MP20 (XI1572_p3 pp8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1572_MP21 (XI1572_sn XI1572_con XI1572_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1572_MP24_1 (XI1572_p5 pp8_1 XI1572_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1362_MP24 (XI1362_sn B_3_b3_5 XI1362_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1362_MP26 (VDD XI1362_sn fa1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1362_MP17 (XI1362_con B_3_b3_5 XI1362_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1362_MP14 (XI1362_p1 pp1_0 XI1362_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1362_MP13 (VDD pp0_2 XI1362_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1362_MP15 (XI1362_p2 pp0_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1362_MP16 (VDD pp1_0 XI1362_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1362_MP28 (fa1_1 XI1362_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1362_MP22 (XI1362_p4 pp0_2 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1362_MP23 (XI1362_p5 pp1_0 XI1362_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1362_MP23_1 (XI1362_p4 pp1_0 XI1362_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1362_MP22_1 (VDD pp0_2 XI1362_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1362_MP19 (XI1362_p3 pp1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1362_MP18 (VDD pp0_2 XI1362_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1362_MP20 (XI1362_p3 B_3_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1362_MP21 (XI1362_sn XI1362_con XI1362_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1362_MP24_1 (XI1362_p5 B_3_b3_5 XI1362_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1498_MP24 (XI1498_sn pp1_1 XI1498_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1498_MP26 (VDD XI1498_sn fa137_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1498_MP17 (XI1498_con pp1_1 XI1498_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1498_MP14 (XI1498_p1 pp0_3 XI1498_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1498_MP13 (VDD fa1_1 XI1498_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1498_MP15 (XI1498_p2 fa1_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1498_MP16 (VDD pp0_3 XI1498_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1498_MP28 (fa137_1 XI1498_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1498_MP22 (XI1498_p4 fa1_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1498_MP23 (XI1498_p5 pp0_3 XI1498_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1498_MP23_1 (XI1498_p4 pp0_3 XI1498_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1498_MP22_1 (VDD fa1_1 XI1498_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1498_MP19 (XI1498_p3 pp0_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1498_MP18 (VDD fa1_1 XI1498_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1498_MP20 (XI1498_p3 pp1_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1498_MP21 (XI1498_sn XI1498_con XI1498_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1498_MP24_1 (XI1498_p5 pp1_1 XI1498_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1570_MP24 (XI1570_sn B_5_b3_5 XI1570_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1570_MP26 (VDD XI1570_sn fa209_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1570_MP17 (XI1570_con B_5_b3_5 XI1570_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1570_MP14 (XI1570_p1 fa2_0 XI1570_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1570_MP13 (VDD fa137_1 XI1570_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1570_MP15 (XI1570_p2 fa137_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1570_MP16 (VDD fa2_0 XI1570_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1570_MP28 (fa209_1 XI1570_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1570_MP22 (XI1570_p4 fa137_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1570_MP23 (XI1570_p5 fa2_0 XI1570_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1570_MP23_1 (XI1570_p4 fa2_0 XI1570_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1570_MP22_1 (VDD fa137_1 XI1570_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1570_MP19 (XI1570_p3 fa2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1570_MP18 (VDD fa137_1 XI1570_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1570_MP20 (XI1570_p3 B_5_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1570_MP21 (XI1570_sn XI1570_con XI1570_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1570_MP24_1 (XI1570_p5 B_5_b3_5 XI1570_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1375_MP24 (XI1375_sn pp6_1 XI1375_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1375_MP26 (VDD XI1375_sn fa14_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1375_MP17 (XI1375_con pp6_1 XI1375_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1375_MP14 (XI1375_p1 pp5_3 XI1375_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1375_MP13 (VDD pp4_5 XI1375_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1375_MP15 (XI1375_p2 pp4_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1375_MP16 (VDD pp5_3 XI1375_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1375_MP28 (fa14_1 XI1375_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1375_MP22 (XI1375_p4 pp4_5 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1375_MP23 (XI1375_p5 pp5_3 XI1375_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1375_MP23_1 (XI1375_p4 pp5_3 XI1375_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1375_MP22_1 (VDD pp4_5 XI1375_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1375_MP19 (XI1375_p3 pp5_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1375_MP18 (VDD pp4_5 XI1375_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1375_MP20 (XI1375_p3 pp6_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1375_MP21 (XI1375_sn XI1375_con XI1375_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1375_MP24_1 (XI1375_p5 pp6_1 XI1375_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1363_MP24 (XI1363_sn pp2_0 XI1363_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1363_MP26 (VDD XI1363_sn fa2_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1363_MP17 (XI1363_con pp2_0 XI1363_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1363_MP14 (XI1363_p1 pp1_2 XI1363_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1363_MP13 (VDD pp0_4 XI1363_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1363_MP15 (XI1363_p2 pp0_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1363_MP16 (VDD pp1_2 XI1363_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1363_MP28 (fa2_1 XI1363_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1363_MP22 (XI1363_p4 pp0_4 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1363_MP23 (XI1363_p5 pp1_2 XI1363_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1363_MP23_1 (XI1363_p4 pp1_2 XI1363_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1363_MP22_1 (VDD pp0_4 XI1363_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1363_MP19 (XI1363_p3 pp1_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1363_MP18 (VDD pp0_4 XI1363_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1363_MP20 (XI1363_p3 pp2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1363_MP21 (XI1363_sn XI1363_con XI1363_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1363_MP24_1 (XI1363_p5 pp2_0 XI1363_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1610_MP24 (XI1610_sn fa3_0 XI1610_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1610_MP26 (VDD XI1610_sn fa249_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1610_MP17 (XI1610_con fa3_0 XI1610_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1610_MP14 (XI1610_p1 fa2_1 XI1610_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1610_MP13 (VDD fa209_1 XI1610_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1610_MP15 (XI1610_p2 fa209_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1610_MP16 (VDD fa2_1 XI1610_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1610_MP28 (fa249_1 XI1610_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1610_MP22 (XI1610_p4 fa209_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1610_MP23 (XI1610_p5 fa2_1 XI1610_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1610_MP23_1 (XI1610_p4 fa2_1 XI1610_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1610_MP22_1 (VDD fa209_1 XI1610_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1610_MP19 (XI1610_p3 fa2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1610_MP18 (VDD fa209_1 XI1610_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1610_MP20 (XI1610_p3 fa3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1610_MP21 (XI1610_sn XI1610_con XI1610_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1610_MP24_1 (XI1610_p5 fa3_0 XI1610_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1373_MP24 (XI1373_sn pp6_0 XI1373_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1373_MP26 (VDD XI1373_sn fa12_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1373_MP17 (XI1373_con pp6_0 XI1373_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1373_MP14 (XI1373_p1 pp5_2 XI1373_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1373_MP13 (VDD pp4_4 XI1373_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1373_MP15 (XI1373_p2 pp4_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1373_MP16 (VDD pp5_2 XI1373_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1373_MP28 (fa12_1 XI1373_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1373_MP22 (XI1373_p4 pp4_4 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1373_MP23 (XI1373_p5 pp5_2 XI1373_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1373_MP23_1 (XI1373_p4 pp5_2 XI1373_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1373_MP22_1 (VDD pp4_4 XI1373_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1373_MP19 (XI1373_p3 pp5_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1373_MP18 (VDD pp4_4 XI1373_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1373_MP20 (XI1373_p3 pp6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1373_MP21 (XI1373_sn XI1373_con XI1373_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1373_MP24_1 (XI1373_p5 pp6_0 XI1373_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1364_MP24 (XI1364_sn pp2_1 XI1364_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1364_MP26 (VDD XI1364_sn fa3_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1364_MP17 (XI1364_con pp2_1 XI1364_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1364_MP14 (XI1364_p1 pp1_3 XI1364_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1364_MP13 (VDD pp0_5 XI1364_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1364_MP15 (XI1364_p2 pp0_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1364_MP16 (VDD pp1_3 XI1364_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1364_MP28 (fa3_1 XI1364_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1364_MP22 (XI1364_p4 pp0_5 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1364_MP23 (XI1364_p5 pp1_3 XI1364_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1364_MP23_1 (XI1364_p4 pp1_3 XI1364_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1364_MP22_1 (VDD pp0_5 XI1364_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1364_MP19 (XI1364_p3 pp1_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1364_MP18 (VDD pp0_5 XI1364_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1364_MP20 (XI1364_p3 pp2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1364_MP21 (XI1364_sn XI1364_con XI1364_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1364_MP24_1 (XI1364_p5 pp2_1 XI1364_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1370_MP24 (XI1370_sn B_11_b3_5 XI1370_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1370_MP26 (VDD XI1370_sn fa9_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1370_MP17 (XI1370_con B_11_b3_5 XI1370_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1370_MP14 (XI1370_p1 pp5_0 XI1370_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1370_MP13 (VDD pp4_2 XI1370_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1370_MP15 (XI1370_p2 pp4_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1370_MP16 (VDD pp5_0 XI1370_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1370_MP28 (fa9_1 XI1370_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1370_MP22 (XI1370_p4 pp4_2 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1370_MP23 (XI1370_p5 pp5_0 XI1370_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1370_MP23_1 (XI1370_p4 pp5_0 XI1370_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1370_MP22_1 (VDD pp4_2 XI1370_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1370_MP19 (XI1370_p3 pp5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1370_MP18 (VDD pp4_2 XI1370_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1370_MP20 (XI1370_p3 B_11_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1370_MP21 (XI1370_sn XI1370_con XI1370_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1370_MP24_1 (XI1370_p5 B_11_b3_5 XI1370_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1501_MP24 (XI1501_sn fa9_0 XI1501_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1501_MP26 (VDD XI1501_sn fa140_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1501_MP17 (XI1501_con fa9_0 XI1501_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1501_MP14 (XI1501_p1 cm8_0 XI1501_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1501_MP13 (VDD cm7_1 XI1501_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1501_MP15 (XI1501_p2 cm7_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1501_MP16 (VDD cm8_0 XI1501_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1501_MP28 (fa140_1 XI1501_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1501_MP22 (XI1501_p4 cm7_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1501_MP23 (XI1501_p5 cm8_0 XI1501_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1501_MP23_1 (XI1501_p4 cm8_0 XI1501_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1501_MP22_1 (VDD cm7_1 XI1501_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1501_MP19 (XI1501_p3 cm8_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1501_MP18 (VDD cm7_1 XI1501_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1501_MP20 (XI1501_p3 fa9_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1501_MP21 (XI1501_sn XI1501_con XI1501_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1501_MP24_1 (XI1501_p5 fa9_0 XI1501_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1500_MP24 (XI1500_sn pp4_1 XI1500_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1500_MP26 (VDD XI1500_sn fa139_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1500_MP17 (XI1500_con pp4_1 XI1500_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1500_MP14 (XI1500_p1 cm7_0 XI1500_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1500_MP13 (VDD cm6_1 XI1500_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1500_MP15 (XI1500_p2 cm6_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1500_MP16 (VDD cm7_0 XI1500_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1500_MP28 (fa139_1 XI1500_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1500_MP22 (XI1500_p4 cm6_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1500_MP23 (XI1500_p5 cm7_0 XI1500_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1500_MP23_1 (XI1500_p4 cm7_0 XI1500_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1500_MP22_1 (VDD cm6_1 XI1500_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1500_MP19 (XI1500_p3 cm7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1500_MP18 (VDD cm6_1 XI1500_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1500_MP20 (XI1500_p3 pp4_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1500_MP21 (XI1500_sn XI1500_con XI1500_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1500_MP24_1 (XI1500_p5 pp4_1 XI1500_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1499_MP24 (XI1499_sn pp4_0 XI1499_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1499_MP26 (VDD XI1499_sn fa138_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1499_MP17 (XI1499_con pp4_0 XI1499_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1499_MP14 (XI1499_p1 cm6_0 XI1499_con VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1499_MP13 (VDD cm5_1 XI1499_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1499_MP15 (XI1499_p2 cm5_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1499_MP16 (VDD cm6_0 XI1499_p2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1499_MP28 (fa138_1 XI1499_con VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1499_MP22 (XI1499_p4 cm5_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.1224p pd=0.79999u ps=1.39999u
    I_MXI1499_MP23 (XI1499_p5 cm6_0 XI1499_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1499_MP23_1 (XI1499_p4 cm6_0 XI1499_p5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1499_MP22_1 (VDD cm5_1 XI1499_p4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1968p as=0.0792p pd=1.45999u ps=0.79999u
    I_MXI1499_MP19 (XI1499_p3 cm6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1968p pd=0.91999u ps=1.45999u
    I_MXI1499_MP18 (VDD cm5_1 XI1499_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1499_MP20 (XI1499_p3 pp4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1499_MP21 (XI1499_sn XI1499_con XI1499_p3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1499_MP24_1 (XI1499_p5 pp4_0 XI1499_sn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1660_I170_XG_MP2 (VDD I1660_gn40 I1660_G40_39 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I170_XG_MP0 (XI1660_I170_XG_p1 I1660_pn40 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I170_XG_MP1 (I1660_G40_39 I1660_gn39 XI1660_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I171_XG_MP2 (VDD I1660_gn41 I1660_G41_40 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I171_XG_MP0 (XI1660_I171_XG_p1 I1660_pn41 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I171_XG_MP1 (I1660_G41_40 I1660_gn40 XI1660_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I172_XG_MP2 (VDD I1660_gn42 I1660_G42_41 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I172_XG_MP0 (XI1660_I172_XG_p1 I1660_pn42 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I172_XG_MP1 (I1660_G42_41 I1660_gn41 XI1660_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I173_XG_MP2 (VDD I1660_gn43 I1660_G43_42 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I173_XG_MP0 (XI1660_I173_XG_p1 I1660_pn43 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I173_XG_MP1 (I1660_G43_42 I1660_gn42 XI1660_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I174_XG_MP2 (VDD I1660_gn44 I1660_G44_43 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I174_XG_MP0 (XI1660_I174_XG_p1 I1660_pn44 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I174_XG_MP1 (I1660_G44_43 I1660_gn43 XI1660_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I175_XG_MP2 (VDD I1660_gn45 I1660_G45_44 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I175_XG_MP0 (XI1660_I175_XG_p1 I1660_pn45 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I175_XG_MP1 (I1660_G45_44 I1660_gn44 XI1660_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I176_XG_MP2 (VDD I1660_gn46 I1660_G46_45 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I176_XG_MP0 (XI1660_I176_XG_p1 I1660_pn46 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I176_XG_MP1 (I1660_G46_45 I1660_gn45 XI1660_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I168_XG_MP2 (VDD I1660_gn38 I1660_G38_37 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I168_XG_MP0 (XI1660_I168_XG_p1 I1660_pn38 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I168_XG_MP1 (I1660_G38_37 I1660_gn37 XI1660_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I169_XG_MP2 (VDD I1660_gn39 I1660_G39_38 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I169_XG_MP0 (XI1660_I169_XG_p1 I1660_pn39 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I169_XG_MP1 (I1660_G39_38 I1660_gn38 XI1660_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I177_XG_MP2 (VDD I1660_gn47 I1660_G47_46 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I177_XG_MP0 (XI1660_I177_XG_p1 I1660_pn47 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I177_XG_MP1 (I1660_G47_46 I1660_gn46 XI1660_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I178_XG_MP2 (VDD I1660_gn48 I1660_G48_47 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I178_XG_MP0 (XI1660_I178_XG_p1 I1660_pn48 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I178_XG_MP1 (I1660_G48_47 I1660_gn47 XI1660_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I179_XG_MP2 (VDD I1660_gn49 I1660_G49_48 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I179_XG_MP0 (XI1660_I179_XG_p1 I1660_pn49 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I179_XG_MP1 (I1660_G49_48 I1660_gn48 XI1660_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I180_XG_MP2 (VDD I1660_gn50 I1660_G50_49 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I180_XG_MP0 (XI1660_I180_XG_p1 I1660_pn50 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I180_XG_MP1 (I1660_G50_49 I1660_gn49 XI1660_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I182_XG_MP2 (VDD I1660_gn52 I1660_G52_51 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I182_XG_MP0 (XI1660_I182_XG_p1 I1660_pn52 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I182_XG_MP1 (I1660_G52_51 I1660_gn51 XI1660_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I183_XG_MP2 (VDD I1660_gn53 I1660_G53_52 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I183_XG_MP0 (XI1660_I183_XG_p1 I1660_pn53 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I183_XG_MP1 (I1660_G53_52 I1660_gn52 XI1660_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I184_XG_MP2 (VDD I1660_gn54 I1660_G54_53 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I184_XG_MP0 (XI1660_I184_XG_p1 I1660_pn54 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I184_XG_MP1 (I1660_G54_53 I1660_gn53 XI1660_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I185_XG_MP2 (VDD I1660_gn55 I1660_G55_54 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I185_XG_MP0 (XI1660_I185_XG_p1 I1660_pn55 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I185_XG_MP1 (I1660_G55_54 I1660_gn54 XI1660_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I166_XG_MP2 (VDD I1660_gn36 I1660_G36_35 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I166_XG_MP0 (XI1660_I166_XG_p1 I1660_pn36 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I166_XG_MP1 (I1660_G36_35 I1660_gn35 XI1660_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I167_XG_MP2 (VDD I1660_gn37 I1660_G37_36 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I167_XG_MP0 (XI1660_I167_XG_p1 I1660_pn37 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I167_XG_MP1 (I1660_G37_36 I1660_gn36 XI1660_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I297_XG_MP2 (VDD I1660_G44_41n I1660_G44_37 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I297_XG_MP0 (XI1660_I297_XG_p1 I1660_P44_41n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I297_XG_MP1 (I1660_G44_37 I1660_G40_37n XI1660_I297_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I301_XG_MP2 (VDD I1660_G48_45n I1660_G48_41 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I301_XG_MP0 (XI1660_I301_XG_p1 I1660_P48_45n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I301_XG_MP1 (I1660_G48_41 I1660_G44_41n XI1660_I301_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I181_XG_MP2 (VDD I1660_gn51 I1660_G51_50 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I181_XG_MP0 (XI1660_I181_XG_p1 I1660_pn51 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I181_XG_MP1 (I1660_G51_50 I1660_gn50 XI1660_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I188_XG_MP2 (VDD I1660_gn58 I1660_G58_57 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I188_XG_MP0 (XI1660_I188_XG_p1 I1660_pn58 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I188_XG_MP1 (I1660_G58_57 I1660_gn57 XI1660_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I187_XG_MP2 (VDD I1660_gn57 I1660_G57_56 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I187_XG_MP0 (XI1660_I187_XG_p1 I1660_pn57 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I187_XG_MP1 (I1660_G57_56 I1660_gn56 XI1660_I187_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I186_XG_MP2 (VDD I1660_gn56 I1660_G56_55 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I186_XG_MP0 (XI1660_I186_XG_p1 I1660_pn56 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I186_XG_MP1 (I1660_G56_55 I1660_gn55 XI1660_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I165_XG_MP2 (VDD I1660_gn35 I1660_G35_34 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I165_XG_MP0 (XI1660_I165_XG_p1 I1660_pn35 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I165_XG_MP1 (I1660_G35_34 I1660_gn34 XI1660_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I305_XG_MP2 (VDD I1660_G52_49n I1660_G52_45 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I305_XG_MP0 (XI1660_I305_XG_p1 I1660_P52_49n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I305_XG_MP1 (I1660_G52_45 I1660_G48_45n XI1660_I305_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I309_XG_MP2 (VDD I1660_G56_53n I1660_G56_49 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I309_XG_MP0 (XI1660_I309_XG_p1 I1660_P56_53n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I309_XG_MP1 (I1660_G56_49 I1660_G52_49n XI1660_I309_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I307_XG_MP2 (VDD I1660_G54_51n I1660_G54_47 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I307_XG_MP0 (XI1660_I307_XG_p1 I1660_P54_51n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I307_XG_MP1 (I1660_G54_47 I1660_G50_47n XI1660_I307_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I313_XG_MP2 (VDD I1660_G60_57n I1660_G60_53 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I313_XG_MP0 (XI1660_I313_XG_p1 I1660_P60_57n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I313_XG_MP1 (I1660_G60_53 I1660_G56_53n XI1660_I313_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I190_XG_MP2 (VDD I1660_gn60 I1660_G60_59 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I190_XG_MP0 (XI1660_I190_XG_p1 I1660_pn60 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I190_XG_MP1 (I1660_G60_59 I1660_gn59 XI1660_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I189_XG_MP2 (VDD I1660_gn59 I1660_G59_58 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I189_XG_MP0 (XI1660_I189_XG_p1 I1660_pn59 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I189_XG_MP1 (I1660_G59_58 I1660_gn58 XI1660_I189_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I164_XG_MP2 (VDD I1660_gn34 I1660_G34_33 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I164_XG_MP0 (XI1660_I164_XG_p1 I1660_pn34 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I164_XG_MP1 (I1660_G34_33 I1660_gn33 XI1660_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I293_XG_MP2 (VDD I1660_G40_37n I1660_G40_33 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I293_XG_MP0 (XI1660_I293_XG_p1 I1660_P40_37n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I293_XG_MP1 (I1660_G40_33 I1660_G36_33n XI1660_I293_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I291_XG_MP2 (VDD I1660_G38_35n I1660_G38_31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I291_XG_MP0 (XI1660_I291_XG_p1 I1660_P38_35n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I291_XG_MP1 (I1660_G38_31 I1660_G34_31n XI1660_I291_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I295_XG_MP2 (VDD I1660_G42_39n I1660_G42_35 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I295_XG_MP0 (XI1660_I295_XG_p1 I1660_P42_39n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I295_XG_MP1 (I1660_G42_35 I1660_G38_35n XI1660_I295_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I299_XG_MP2 (VDD I1660_G46_43n I1660_G46_39 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I299_XG_MP0 (XI1660_I299_XG_p1 I1660_P46_43n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I299_XG_MP1 (I1660_G46_39 I1660_G42_39n XI1660_I299_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I303_XG_MP2 (VDD I1660_G50_47n I1660_G50_43 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I303_XG_MP0 (XI1660_I303_XG_p1 I1660_P50_47n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I303_XG_MP1 (I1660_G50_43 I1660_G46_43n XI1660_I303_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I311_XG_MP2 (VDD I1660_G58_55n I1660_G58_51 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I311_XG_MP0 (XI1660_I311_XG_p1 I1660_P58_55n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I311_XG_MP1 (I1660_G58_51 I1660_G54_51n XI1660_I311_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I191_XG_MP2 (VDD I1660_gn61 I1660_G61_60 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I191_XG_MP0 (XI1660_I191_XG_p1 I1660_pn61 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I191_XG_MP1 (I1660_G61_60 I1660_gn60 XI1660_I191_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I192_XG_MP2 (VDD I1660_gn62 I1660_G62_61 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I192_XG_MP0 (XI1660_I192_XG_p1 I1660_pn62 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I192_XG_MP1 (I1660_G62_61 I1660_gn61 XI1660_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I162_XG_MP2 (VDD I1660_gn32 I1660_G32_31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I162_XG_MP0 (XI1660_I162_XG_p1 I1660_pn32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I162_XG_MP1 (I1660_G32_31 I1660_gn31 XI1660_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I163_XG_MP2 (VDD I1660_gn33 I1660_G33_32 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I163_XG_MP0 (XI1660_I163_XG_p1 I1660_pn33 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I163_XG_MP1 (I1660_G33_32 I1660_gn32 XI1660_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I407_XG_MP2 (VDD I1660_G44_29n I1660_G44_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I407_XG_MP0 (XI1660_I407_XG_p1 I1660_P44_29n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I407_XG_MP1 (I1660_G44_13 I1660_G28_13n XI1660_I407_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I423_XG_MP2 (VDD I1660_G60_45n I1660_G60_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I423_XG_MP0 (XI1660_I423_XG_p1 I1660_P60_45n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I423_XG_MP1 (I1660_G60_29 I1660_G44_29n XI1660_I423_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I425_XG_MP2 (VDD I1660_G62_47n I1660_G62_31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I425_XG_MP0 (XI1660_I425_XG_p1 I1660_P62_47n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I425_XG_MP1 (I1660_G62_31 I1660_G46_31n XI1660_I425_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I315_XG_MP2 (VDD I1660_G62_59n I1660_G62_55 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I315_XG_MP0 (XI1660_I315_XG_p1 I1660_P62_59n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I315_XG_MP1 (I1660_G62_55 I1660_G58_55n XI1660_I315_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I193_XG_MP2 (VDD I1660_gn63 I1660_G63_62 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I193_XG_MP0 (XI1660_I193_XG_p1 I1660_pn63 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I193_XG_MP1 (I1660_G63_62 I1660_gn62 XI1660_I193_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I161_XG_MP2 (VDD I1660_gn31 I1660_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I161_XG_MP0 (XI1660_I161_XG_p1 I1660_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I161_XG_MP1 (I1660_G31_30 I1660_gn30 XI1660_I161_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I289_XG_MP2 (VDD I1660_G36_33n I1660_G36_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I289_XG_MP0 (XI1660_I289_XG_p1 I1660_P36_33n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I289_XG_MP1 (I1660_G36_29 I1660_G32_29n XI1660_I289_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I419_XG_MP2 (VDD I1660_G56_41n I1660_G56_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I419_XG_MP0 (XI1660_I419_XG_p1 I1660_P56_41n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I419_XG_MP1 (I1660_G56_25 I1660_G40_25n XI1660_I419_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I409_XG_MP2 (VDD I1660_G46_31n I1660_G46_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I409_XG_MP0 (XI1660_I409_XG_p1 I1660_P46_31n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I409_XG_MP1 (I1660_G46_15 I1660_G30_15n XI1660_I409_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I160_XG_MP2 (VDD I1660_gn30 I1660_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I160_XG_MP0 (XI1660_I160_XG_p1 I1660_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I160_XG_MP1 (I1660_G30_29 I1660_gn29 XI1660_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I391_XG_MP2 (VDD I1660_G28_13n I1660_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I391_XG_MP0 (XI1660_I391_XG_p1 I1660_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I391_XG_MP1 (I1660_G28_0 I1660_G12_0n XI1660_I391_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I287_XG_MP2 (VDD I1660_G34_31n I1660_G34_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I287_XG_MP0 (XI1660_I287_XG_p1 I1660_P34_31n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I287_XG_MP1 (I1660_G34_27 I1660_G30_27n XI1660_I287_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I417_XG_MP2 (VDD I1660_G54_39n I1660_G54_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I417_XG_MP0 (XI1660_I417_XG_p1 I1660_P54_39n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I417_XG_MP1 (I1660_G54_23 I1660_G38_23n XI1660_I417_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I421_XG_MP2 (VDD I1660_G58_43n I1660_G58_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I421_XG_MP0 (XI1660_I421_XG_p1 I1660_P58_43n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I421_XG_MP1 (I1660_G58_27 I1660_G42_27n XI1660_I421_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I158_XG_MP2 (VDD I1660_gn28 I1660_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I158_XG_MP0 (XI1660_I158_XG_p1 I1660_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I158_XG_MP1 (I1660_G28_27 I1660_gn27 XI1660_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I159_XG_MP2 (VDD I1660_gn29 I1660_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I159_XG_MP0 (XI1660_I159_XG_p1 I1660_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I159_XG_MP1 (I1660_G29_28 I1660_gn28 XI1660_I159_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I285_XG_MP2 (VDD I1660_G32_29n I1660_G32_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I285_XG_MP0 (XI1660_I285_XG_p1 I1660_P32_29n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I285_XG_MP1 (I1660_G32_25 I1660_G28_25n XI1660_I285_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I283_XG_MP2 (VDD I1660_G30_27n I1660_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I283_XG_MP0 (XI1660_I283_XG_p1 I1660_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I283_XG_MP1 (I1660_G30_23 I1660_G26_23n XI1660_I283_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I415_XG_MP2 (VDD I1660_G52_37n I1660_G52_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I415_XG_MP0 (XI1660_I415_XG_p1 I1660_P52_37n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I415_XG_MP1 (I1660_G52_21 I1660_G36_21n XI1660_I415_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I393_XG_MP2 (VDD I1660_G30_15n I1660_G30_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I393_XG_MP0 (XI1660_I393_XG_p1 I1660_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I393_XG_MP1 (I1660_G30_0 I1660_G14_0n XI1660_I393_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I302_XG_MP2 (VDD I1660_G49_46n I1660_G49_42 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I302_XG_MP0 (XI1660_I302_XG_p1 I1660_P49_46n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I302_XG_MP1 (I1660_G49_42 I1660_G45_42n XI1660_I302_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I306_XG_MP2 (VDD I1660_G53_50n I1660_G53_46 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I306_XG_MP0 (XI1660_I306_XG_p1 I1660_P53_50n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I306_XG_MP1 (I1660_G53_46 I1660_G49_46n XI1660_I306_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I310_XG_MP2 (VDD I1660_G57_54n I1660_G57_50 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I310_XG_MP0 (XI1660_I310_XG_p1 I1660_P57_54n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I310_XG_MP1 (I1660_G57_50 I1660_G53_50n XI1660_I310_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I314_XG_MP2 (VDD I1660_G61_58n I1660_G61_54 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I314_XG_MP0 (XI1660_I314_XG_p1 I1660_P61_58n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I314_XG_MP1 (I1660_G61_54 I1660_G57_54n XI1660_I314_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I312_XG_MP2 (VDD I1660_G59_56n I1660_G59_52 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I312_XG_MP0 (XI1660_I312_XG_p1 I1660_P59_56n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I312_XG_MP1 (I1660_G59_52 I1660_G55_52n XI1660_I312_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I316_XG_MP2 (VDD I1660_G63_60n I1660_G63_56 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I316_XG_MP0 (XI1660_I316_XG_p1 I1660_P63_60n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I316_XG_MP1 (I1660_G63_56 I1660_G59_56n XI1660_I316_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I281_XG_MP2 (VDD I1660_G28_25n I1660_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I281_XG_MP0 (XI1660_I281_XG_p1 I1660_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I281_XG_MP1 (I1660_G28_21 I1660_G24_21n XI1660_I281_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I413_XG_MP2 (VDD I1660_G50_35n I1660_G50_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I413_XG_MP0 (XI1660_I413_XG_p1 I1660_P50_35n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I413_XG_MP1 (I1660_G50_19 I1660_G34_19n XI1660_I413_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I405_XG_MP2 (VDD I1660_G42_27n I1660_G42_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I405_XG_MP0 (XI1660_I405_XG_p1 I1660_P42_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I405_XG_MP1 (I1660_G42_11 I1660_G26_11n XI1660_I405_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I298_XG_MP2 (VDD I1660_G45_42n I1660_G45_38 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I298_XG_MP0 (XI1660_I298_XG_p1 I1660_P45_42n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I298_XG_MP1 (I1660_G45_38 I1660_G41_38n XI1660_I298_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I304_XG_MP2 (VDD I1660_G51_48n I1660_G51_44 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I304_XG_MP0 (XI1660_I304_XG_p1 I1660_P51_48n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I304_XG_MP1 (I1660_G51_44 I1660_G47_44n XI1660_I304_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I308_XG_MP2 (VDD I1660_G55_52n I1660_G55_48 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I308_XG_MP0 (XI1660_I308_XG_p1 I1660_P55_52n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I308_XG_MP1 (I1660_G55_48 I1660_G51_48n XI1660_I308_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I157_XG_MP2 (VDD I1660_gn27 I1660_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I157_XG_MP0 (XI1660_I157_XG_p1 I1660_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I157_XG_MP1 (I1660_G27_26 I1660_gn26 XI1660_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I156_XG_MP2 (VDD I1660_gn26 I1660_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I156_XG_MP0 (XI1660_I156_XG_p1 I1660_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I156_XG_MP1 (I1660_G26_25 I1660_gn25 XI1660_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I403_XG_MP2 (VDD I1660_G40_25n I1660_G40_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I403_XG_MP0 (XI1660_I403_XG_p1 I1660_P40_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I403_XG_MP1 (I1660_G40_9 I1660_G24_9n XI1660_I403_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I279_XG_MP2 (VDD I1660_G26_23n I1660_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I279_XG_MP0 (XI1660_I279_XG_p1 I1660_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I279_XG_MP1 (I1660_G26_19 I1660_G22_19n XI1660_I279_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I389_XG_MP2 (VDD I1660_G26_11n I1660_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I389_XG_MP0 (XI1660_I389_XG_p1 I1660_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I389_XG_MP1 (I1660_G26_0 I1660_G10_0n XI1660_I389_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I424_XG_MP2 (VDD I1660_G61_46n I1660_G61_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I424_XG_MP0 (XI1660_I424_XG_p1 I1660_P61_46n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I424_XG_MP1 (I1660_G61_30 I1660_G45_30n XI1660_I424_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I300_XG_MP2 (VDD I1660_G47_44n I1660_G47_40 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I300_XG_MP0 (XI1660_I300_XG_p1 I1660_P47_44n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I300_XG_MP1 (I1660_G47_40 I1660_G43_40n XI1660_I300_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I155_XG_MP2 (VDD I1660_gn25 I1660_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I155_XG_MP0 (XI1660_I155_XG_p1 I1660_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I155_XG_MP1 (I1660_G25_24 I1660_gn24 XI1660_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I277_XG_MP2 (VDD I1660_G24_21n I1660_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I277_XG_MP0 (XI1660_I277_XG_p1 I1660_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I277_XG_MP1 (I1660_G24_17 I1660_G20_17n XI1660_I277_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I411_XG_MP2 (VDD I1660_G48_33n I1660_G48_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I411_XG_MP0 (XI1660_I411_XG_p1 I1660_P48_33n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I411_XG_MP1 (I1660_G48_17 I1660_G32_17n XI1660_I411_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I401_XG_MP2 (VDD I1660_G38_23n I1660_G38_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I401_XG_MP0 (XI1660_I401_XG_p1 I1660_P38_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I401_XG_MP1 (I1660_G38_7 I1660_G22_7n XI1660_I401_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I294_XG_MP2 (VDD I1660_G41_38n I1660_G41_34 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I294_XG_MP0 (XI1660_I294_XG_p1 I1660_P41_38n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I294_XG_MP1 (I1660_G41_34 I1660_G37_34n XI1660_I294_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I408_XG_MP2 (VDD I1660_G45_30n I1660_G45_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I408_XG_MP0 (XI1660_I408_XG_p1 I1660_P45_30n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I408_XG_MP1 (I1660_G45_14 I1660_G29_14n XI1660_I408_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I296_XG_MP2 (VDD I1660_G43_40n I1660_G43_36 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I296_XG_MP0 (XI1660_I296_XG_p1 I1660_P43_40n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I296_XG_MP1 (I1660_G43_36 I1660_G39_36n XI1660_I296_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I422_XG_MP2 (VDD I1660_G59_44n I1660_G59_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I422_XG_MP0 (XI1660_I422_XG_p1 I1660_P59_44n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I422_XG_MP1 (I1660_G59_28 I1660_G43_28n XI1660_I422_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I153_XG_MP2 (VDD I1660_gn23 I1660_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I153_XG_MP0 (XI1660_I153_XG_p1 I1660_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I153_XG_MP1 (I1660_G23_22 I1660_gn22 XI1660_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I154_XG_MP2 (VDD I1660_gn24 I1660_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I154_XG_MP0 (XI1660_I154_XG_p1 I1660_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I154_XG_MP1 (I1660_G24_23 I1660_gn23 XI1660_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I387_XG_MP2 (VDD I1660_G24_9n I1660_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I387_XG_MP0 (XI1660_I387_XG_p1 I1660_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I387_XG_MP1 (I1660_G24_0 I1660_G8_0n XI1660_I387_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I275_XG_MP2 (VDD I1660_G22_19n I1660_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I275_XG_MP0 (XI1660_I275_XG_p1 I1660_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I275_XG_MP1 (I1660_G22_15 I1660_G18_15n XI1660_I275_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I384_XG_MP2 (VDD I1660_G22_7n I1660_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I384_XG_MP0 (XI1660_I384_XG_p1 I1660_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I384_XG_MP1 (I1660_G22_0 I1660_G6_0n XI1660_I384_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I290_XG_MP2 (VDD I1660_G37_34n I1660_G37_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I290_XG_MP0 (XI1660_I290_XG_p1 I1660_P37_34n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I290_XG_MP1 (I1660_G37_30 I1660_G33_30n XI1660_I290_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I420_XG_MP2 (VDD I1660_G57_42n I1660_G57_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I420_XG_MP0 (XI1660_I420_XG_p1 I1660_P57_42n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I420_XG_MP1 (I1660_G57_26 I1660_G41_26n XI1660_I420_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I292_XG_MP2 (VDD I1660_G39_36n I1660_G39_32 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I292_XG_MP0 (XI1660_I292_XG_p1 I1660_P39_36n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I292_XG_MP1 (I1660_G39_32 I1660_G35_32n XI1660_I292_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I152_XG_MP2 (VDD I1660_gn22 I1660_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I152_XG_MP0 (XI1660_I152_XG_p1 I1660_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I152_XG_MP1 (I1660_G22_21 I1660_gn21 XI1660_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I399_XG_MP2 (VDD I1660_G36_21n I1660_G36_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I399_XG_MP0 (XI1660_I399_XG_p1 I1660_P36_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I399_XG_MP1 (I1660_G36_5 I1660_G20_5n XI1660_I399_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I286_XG_MP2 (VDD I1660_G33_30n I1660_G33_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I286_XG_MP0 (XI1660_I286_XG_p1 I1660_P33_30n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I286_XG_MP1 (I1660_G33_26 I1660_G29_26n XI1660_I286_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I392_XG_MP2 (VDD I1660_G29_14n I1660_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I392_XG_MP0 (XI1660_I392_XG_p1 I1660_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I392_XG_MP1 (I1660_G29_0 I1660_G13_0n XI1660_I392_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I288_XG_MP2 (VDD I1660_G35_32n I1660_G35_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I288_XG_MP0 (XI1660_I288_XG_p1 I1660_P35_32n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I288_XG_MP1 (I1660_G35_28 I1660_G31_28n XI1660_I288_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I426_XG_MP2 (VDD I1660_G63_48n I1660_G63_32 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I426_XG_MP0 (XI1660_I426_XG_p1 I1660_P63_48n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I426_XG_MP1 (I1660_G63_32 I1660_G47_32n XI1660_I426_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I151_XG_MP2 (VDD I1660_gn21 I1660_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I151_XG_MP0 (XI1660_I151_XG_p1 I1660_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I151_XG_MP1 (I1660_G21_20 I1660_gn20 XI1660_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I150_XG_MP2 (VDD I1660_gn20 I1660_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I150_XG_MP0 (XI1660_I150_XG_p1 I1660_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I150_XG_MP1 (I1660_G20_19 I1660_gn19 XI1660_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I273_XG_MP2 (VDD I1660_G20_17n I1660_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I273_XG_MP0 (XI1660_I273_XG_p1 I1660_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I273_XG_MP1 (I1660_G20_13 I1660_G16_13n XI1660_I273_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I380_XG_MP2 (VDD I1660_G20_5n I1660_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I380_XG_MP0 (XI1660_I380_XG_p1 I1660_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I380_XG_MP1 (I1660_G20_0 I1660_G4_0n XI1660_I380_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I397_XG_MP2 (VDD I1660_G34_19n I1660_G34_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I397_XG_MP0 (XI1660_I397_XG_p1 I1660_P34_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I397_XG_MP1 (I1660_G34_3 I1660_G18_3n XI1660_I397_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I282_XG_MP2 (VDD I1660_G29_26n I1660_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I282_XG_MP0 (XI1660_I282_XG_p1 I1660_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I282_XG_MP1 (I1660_G29_22 I1660_G25_22n XI1660_I282_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I416_XG_MP2 (VDD I1660_G53_38n I1660_G53_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I416_XG_MP0 (XI1660_I416_XG_p1 I1660_P53_38n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I416_XG_MP1 (I1660_G53_22 I1660_G37_22n XI1660_I416_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I404_XG_MP2 (VDD I1660_G41_26n I1660_G41_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I404_XG_MP0 (XI1660_I404_XG_p1 I1660_P41_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I404_XG_MP1 (I1660_G41_10 I1660_G25_10n XI1660_I404_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I284_XG_MP2 (VDD I1660_G31_28n I1660_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I284_XG_MP0 (XI1660_I284_XG_p1 I1660_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I284_XG_MP1 (I1660_G31_24 I1660_G27_24n XI1660_I284_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I418_XG_MP2 (VDD I1660_G55_40n I1660_G55_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I418_XG_MP0 (XI1660_I418_XG_p1 I1660_P55_40n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I418_XG_MP1 (I1660_G55_24 I1660_G39_24n XI1660_I418_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I410_XG_MP2 (VDD I1660_G47_32n I1660_G47_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I410_XG_MP0 (XI1660_I410_XG_p1 I1660_P47_32n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I410_XG_MP1 (I1660_G47_16 I1660_G31_16n XI1660_I410_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I149_XG_MP2 (VDD I1660_gn19 I1660_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I149_XG_MP0 (XI1660_I149_XG_p1 I1660_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I149_XG_MP1 (I1660_G19_18 I1660_gn18 XI1660_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I395_XG_MP2 (VDD I1660_G32_17n I1660_G32_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I395_XG_MP0 (XI1660_I395_XG_p1 I1660_P32_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I395_XG_MP1 (I1660_G32_1 I1660_G16_1n XI1660_I395_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I271_XG_MP2 (VDD I1660_G18_15n I1660_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I271_XG_MP0 (XI1660_I271_XG_p1 I1660_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I271_XG_MP1 (I1660_G18_11 I1660_G14_11n XI1660_I271_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I377_XG_MP2 (VDD I1660_G18_3n I1660_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I377_XG_MP0 (XI1660_I377_XG_p1 I1660_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I377_XG_MP1 (I1660_G18_0 I1660_G2_0n XI1660_I377_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I278_XG_MP2 (VDD I1660_G25_22n I1660_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I278_XG_MP0 (XI1660_I278_XG_p1 I1660_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I278_XG_MP1 (I1660_G25_18 I1660_G21_18n XI1660_I278_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I388_XG_MP2 (VDD I1660_G25_10n I1660_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I388_XG_MP0 (XI1660_I388_XG_p1 I1660_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I388_XG_MP1 (I1660_G25_0 I1660_G9_0n XI1660_I388_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I394_XG_MP2 (VDD I1660_G31_16n I1660_G31_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I394_XG_MP0 (XI1660_I394_XG_p1 I1660_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I394_XG_MP1 (I1660_G31_0 I1660_G15_0n XI1660_I394_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I129_XG_MP2 (VDD I1660_gn0 I1660_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I129_XG_MP0 (XI1660_I129_XG_p1 I1660_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I129_XG_MP1 (I1660_G0_0 I1660_cinn XI1660_I129_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I148_XG_MP2 (VDD I1660_gn18 I1660_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I148_XG_MP0 (XI1660_I148_XG_p1 I1660_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I148_XG_MP1 (I1660_G18_17 I1660_gn17 XI1660_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I269_XG_MP2 (VDD I1660_G16_13n I1660_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I269_XG_MP0 (XI1660_I269_XG_p1 I1660_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I269_XG_MP1 (I1660_G16_9 I1660_G12_9n XI1660_I269_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I375_XG_MP2 (VDD I1660_G16_1n I1660_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I375_XG_MP0 (XI1660_I375_XG_p1 I1660_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I375_XG_MP1 (I1660_G16_0 I1660_G0_0n XI1660_I375_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I267_XG_MP2 (VDD I1660_G14_11n I1660_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I267_XG_MP0 (XI1660_I267_XG_p1 I1660_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I267_XG_MP1 (I1660_G14_7 I1660_G10_7n XI1660_I267_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I274_XG_MP2 (VDD I1660_G21_18n I1660_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I274_XG_MP0 (XI1660_I274_XG_p1 I1660_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I274_XG_MP1 (I1660_G21_14 I1660_G17_14n XI1660_I274_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I400_XG_MP2 (VDD I1660_G37_22n I1660_G37_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I400_XG_MP0 (XI1660_I400_XG_p1 I1660_P37_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I400_XG_MP1 (I1660_G37_6 I1660_G21_6n XI1660_I400_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I412_XG_MP2 (VDD I1660_G49_34n I1660_G49_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I412_XG_MP0 (XI1660_I412_XG_p1 I1660_P49_34n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I412_XG_MP1 (I1660_G49_18 I1660_G33_18n XI1660_I412_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I280_XG_MP2 (VDD I1660_G27_24n I1660_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I280_XG_MP0 (XI1660_I280_XG_p1 I1660_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I280_XG_MP1 (I1660_G27_20 I1660_G23_20n XI1660_I280_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I414_XG_MP2 (VDD I1660_G51_36n I1660_G51_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I414_XG_MP0 (XI1660_I414_XG_p1 I1660_P51_36n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I414_XG_MP1 (I1660_G51_20 I1660_G35_20n XI1660_I414_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I406_XG_MP2 (VDD I1660_G43_28n I1660_G43_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I406_XG_MP0 (XI1660_I406_XG_p1 I1660_P43_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I406_XG_MP1 (I1660_G43_12 I1660_G27_12n XI1660_I406_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I146_XG_MP2 (VDD I1660_gn16 I1660_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I146_XG_MP0 (XI1660_I146_XG_p1 I1660_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I146_XG_MP1 (I1660_G16_15 I1660_gn15 XI1660_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I147_XG_MP2 (VDD I1660_gn17 I1660_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I147_XG_MP0 (XI1660_I147_XG_p1 I1660_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I147_XG_MP1 (I1660_G17_16 I1660_gn16 XI1660_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I382_XG_MP2 (VDD I1660_G21_6n I1660_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I382_XG_MP0 (XI1660_I382_XG_p1 I1660_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I382_XG_MP1 (I1660_G21_0 I1660_G5_0n XI1660_I382_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I276_XG_MP2 (VDD I1660_G23_20n I1660_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I276_XG_MP0 (XI1660_I276_XG_p1 I1660_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I276_XG_MP1 (I1660_G23_16 I1660_G19_16n XI1660_I276_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I390_XG_MP2 (VDD I1660_G27_12n I1660_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I390_XG_MP0 (XI1660_I390_XG_p1 I1660_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I390_XG_MP1 (I1660_G27_0 I1660_G11_0n XI1660_I390_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I145_XG_MP2 (VDD I1660_gn15 I1660_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I145_XG_MP0 (XI1660_I145_XG_p1 I1660_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I145_XG_MP1 (I1660_G15_14 I1660_gn14 XI1660_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I144_XG_MP2 (VDD I1660_gn14 I1660_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I144_XG_MP0 (XI1660_I144_XG_p1 I1660_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I144_XG_MP1 (I1660_G14_13 I1660_gn13 XI1660_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I265_XG_MP2 (VDD I1660_G12_9n I1660_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I265_XG_MP0 (XI1660_I265_XG_p1 I1660_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I265_XG_MP1 (I1660_G12_5 I1660_G8_5n XI1660_I265_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I261_XG_MP2 (VDD I1660_G8_5n I1660_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I261_XG_MP0 (XI1660_I261_XG_p1 I1660_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I261_XG_MP1 (I1660_G8_1 I1660_G4_1n XI1660_I261_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I256_XG_MP2 (VDD I1660_G4_1n I1660_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I256_XG_MP0 (XI1660_I256_XG_p1 I1660_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I256_XG_MP1 (I1660_G4_0 I1660_G0_0n XI1660_I256_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I263_XG_MP2 (VDD I1660_G10_7n I1660_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I263_XG_MP0 (XI1660_I263_XG_p1 I1660_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I263_XG_MP1 (I1660_G10_3 I1660_G6_3n XI1660_I263_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I259_XG_MP2 (VDD I1660_G6_3n I1660_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I259_XG_MP0 (XI1660_I259_XG_p1 I1660_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I259_XG_MP1 (I1660_G6_0 I1660_G2_0n XI1660_I259_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I270_XG_MP2 (VDD I1660_G17_14n I1660_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I270_XG_MP0 (XI1660_I270_XG_p1 I1660_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I270_XG_MP1 (I1660_G17_10 I1660_G13_10n XI1660_I270_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I396_XG_MP2 (VDD I1660_G33_18n I1660_G33_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I396_XG_MP0 (XI1660_I396_XG_p1 I1660_P33_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I396_XG_MP1 (I1660_G33_2 I1660_G17_2n XI1660_I396_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I272_XG_MP2 (VDD I1660_G19_16n I1660_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I272_XG_MP0 (XI1660_I272_XG_p1 I1660_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I272_XG_MP1 (I1660_G19_12 I1660_G15_12n XI1660_I272_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I386_XG_MP2 (VDD I1660_G23_8n I1660_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I386_XG_MP0 (XI1660_I386_XG_p1 I1660_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I386_XG_MP1 (I1660_G23_0 I1660_G7_0n XI1660_I386_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I402_XG_MP2 (VDD I1660_G39_24n I1660_G39_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I402_XG_MP0 (XI1660_I402_XG_p1 I1660_P39_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I402_XG_MP1 (I1660_G39_8 I1660_G23_8n XI1660_I402_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I132_XG_MP2 (VDD I1660_gn2 I1660_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I132_XG_MP0 (XI1660_I132_XG_p1 I1660_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I132_XG_MP1 (I1660_G2_1 I1660_gn1 XI1660_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I266_XG_MP2 (VDD I1660_G13_10n I1660_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I266_XG_MP0 (XI1660_I266_XG_p1 I1660_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I266_XG_MP1 (I1660_G13_6 I1660_G9_6n XI1660_I266_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I376_XG_MP2 (VDD I1660_G17_2n I1660_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I376_XG_MP0 (XI1660_I376_XG_p1 I1660_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I376_XG_MP1 (I1660_G17_0 I1660_G1_0n XI1660_I376_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I268_XG_MP2 (VDD I1660_G15_12n I1660_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I268_XG_MP0 (XI1660_I268_XG_p1 I1660_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I268_XG_MP1 (I1660_G15_8 I1660_G11_8n XI1660_I268_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I398_XG_MP2 (VDD I1660_G35_20n I1660_G35_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I398_XG_MP0 (XI1660_I398_XG_p1 I1660_P35_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I398_XG_MP1 (I1660_G35_4 I1660_G19_4n XI1660_I398_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I143_XG_MP2 (VDD I1660_gn13 I1660_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I143_XG_MP0 (XI1660_I143_XG_p1 I1660_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I143_XG_MP1 (I1660_G13_12 I1660_gn12 XI1660_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I142_XG_MP2 (VDD I1660_gn12 I1660_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I142_XG_MP0 (XI1660_I142_XG_p1 I1660_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I142_XG_MP1 (I1660_G12_11 I1660_gn11 XI1660_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I131_XG_MP2 (VDD I1660_gn1 I1660_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I131_XG_MP0 (XI1660_I131_XG_p1 I1660_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I131_XG_MP1 (I1660_G1_0 I1660_G0_0n XI1660_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I262_XG_MP2 (VDD I1660_G9_6n I1660_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I262_XG_MP0 (XI1660_I262_XG_p1 I1660_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I262_XG_MP1 (I1660_G9_2 I1660_G5_2n XI1660_I262_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I264_XG_MP2 (VDD I1660_G11_8n I1660_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I264_XG_MP0 (XI1660_I264_XG_p1 I1660_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I264_XG_MP1 (I1660_G11_4 I1660_G7_4n XI1660_I264_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I378_XG_MP2 (VDD I1660_G19_4n I1660_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I378_XG_MP0 (XI1660_I378_XG_p1 I1660_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I378_XG_MP1 (I1660_G19_0 I1660_G3_0n XI1660_I378_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I140_XG_MP2 (VDD I1660_gn10 I1660_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I140_XG_MP0 (XI1660_I140_XG_p1 I1660_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I140_XG_MP1 (I1660_G10_9 I1660_gn9 XI1660_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I141_XG_MP2 (VDD I1660_gn11 I1660_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I141_XG_MP0 (XI1660_I141_XG_p1 I1660_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I141_XG_MP1 (I1660_G11_10 I1660_gn10 XI1660_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I137_XG_MP2 (VDD I1660_gn7 I1660_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I137_XG_MP0 (XI1660_I137_XG_p1 I1660_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I137_XG_MP1 (I1660_G7_6 I1660_gn6 XI1660_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I136_XG_MP2 (VDD I1660_gn6 I1660_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I136_XG_MP0 (XI1660_I136_XG_p1 I1660_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I136_XG_MP1 (I1660_G6_5 I1660_gn5 XI1660_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I135_XG_MP2 (VDD I1660_gn5 I1660_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I135_XG_MP0 (XI1660_I135_XG_p1 I1660_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I135_XG_MP1 (I1660_G5_4 I1660_gn4 XI1660_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I134_XG_MP2 (VDD I1660_gn4 I1660_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I134_XG_MP0 (XI1660_I134_XG_p1 I1660_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I134_XG_MP1 (I1660_G4_3 I1660_gn3 XI1660_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I133_XG_MP2 (VDD I1660_gn3 I1660_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I133_XG_MP0 (XI1660_I133_XG_p1 I1660_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I133_XG_MP1 (I1660_G3_2 I1660_gn2 XI1660_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I258_XG_MP2 (VDD I1660_G5_2n I1660_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I258_XG_MP0 (XI1660_I258_XG_p1 I1660_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I258_XG_MP1 (I1660_G5_0 I1660_G1_0n XI1660_I258_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I139_XG_MP2 (VDD I1660_gn9 I1660_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I139_XG_MP0 (XI1660_I139_XG_p1 I1660_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I139_XG_MP1 (I1660_G9_8 I1660_gn8 XI1660_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I138_XG_MP2 (VDD I1660_gn8 I1660_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I138_XG_MP0 (XI1660_I138_XG_p1 I1660_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I138_XG_MP1 (I1660_G8_7 I1660_gn7 XI1660_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I260_XG_MP2 (VDD I1660_G7_4n I1660_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1660_I260_XG_MP0 (XI1660_I260_XG_p1 I1660_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1660_I260_XG_MP1 (I1660_G7_0 I1660_G3_0n XI1660_I260_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI917_MP12 (VDD B_15_b3_5 XI917_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI917_MP18 (XI917_xp1 XI917_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI917_MP20 (pp7_29 B_15_b3_5 XI917_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI917_MP19 (XI917_xp1 XI917_xan pp7_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI917_MP17 (VDD XI917_xn XI917_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI917_MP6 (XI917_p1 A_29_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI917_MP8 (XI917_xn A_28_b3_2 XI917_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI917_MP7 (XI917_p1 two7_b3_5 XI917_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI917_MP5 (VDD one7_b3_5 XI917_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI917_MP10 (XI917_xan XI917_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI970_MP12 (VDD B_17_b3_4 XI970_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI970_MP18 (XI970_xp1 XI970_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI970_MP20 (pp8_27 B_17_b3_4 XI970_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI970_MP19 (XI970_xp1 XI970_xan pp8_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI970_MP17 (VDD XI970_xn XI970_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI970_MP6 (XI970_p1 A_27_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI970_MP8 (XI970_xn A_26_b3_3 XI970_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI970_MP7 (XI970_p1 two8_b3_4 XI970_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI970_MP5 (VDD one8_b3_4 XI970_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI970_MP10 (XI970_xan XI970_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI973_MP12 (VDD B_17_b3_5 XI973_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI973_MP18 (XI973_xp1 XI973_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI973_MP20 (pp8_30 B_17_b3_5 XI973_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI973_MP19 (XI973_xp1 XI973_xan pp8_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI973_MP17 (VDD XI973_xn XI973_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI973_MP6 (XI973_p1 A_30_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI973_MP8 (XI973_xn A_29_b3_3 XI973_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI973_MP7 (XI973_p1 two8_b3_5 XI973_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI973_MP5 (VDD one8_b3_5 XI973_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI973_MP10 (XI973_xan XI973_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI975_MP12 (VDD B_17_b3_5 XI975_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI975_MP18 (XI975_xp1 XI975_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI975_MP20 (pp8_32 B_17_b3_5 XI975_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI975_MP19 (XI975_xp1 XI975_xan pp8_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI975_MP17 (VDD XI975_xn XI975_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI975_MP6 (XI975_p1 A_31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI975_MP8 (XI975_xn A_31_b3_4 XI975_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI975_MP7 (XI975_p1 two8_b3_5 XI975_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI975_MP5 (VDD one8_b3_5 XI975_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI975_MP10 (XI975_xan XI975_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1028_MP12 (VDD B_19_b3_5 XI1028_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1028_MP18 (XI1028_xp1 XI1028_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1028_MP20 (pp9_30 B_19_b3_5 XI1028_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1028_MP19 (XI1028_xp1 XI1028_xan pp9_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1028_MP17 (VDD XI1028_xn XI1028_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1028_MP6 (XI1028_p1 A_30_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1028_MP8 (XI1028_xn A_29_b3_3 XI1028_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1028_MP7 (XI1028_p1 two9_b3_5 XI1028_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1028_MP5 (VDD one9_b3_5 XI1028_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1028_MP10 (XI1028_xan XI1028_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1029_MP12 (VDD B_19_b3_5 XI1029_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1029_MP18 (XI1029_xp1 XI1029_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1029_MP20 (pp9_31 B_19_b3_5 XI1029_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1029_MP19 (XI1029_xp1 XI1029_xan pp9_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1029_MP17 (VDD XI1029_xn XI1029_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1029_MP6 (XI1029_p1 A_31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1029_MP8 (XI1029_xn A_30_b3_3 XI1029_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1029_MP7 (XI1029_p1 two9_b3_5 XI1029_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1029_MP5 (VDD one9_b3_5 XI1029_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1029_MP10 (XI1029_xan XI1029_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI916_MP12 (VDD B_15_b3_4 XI916_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI916_MP18 (XI916_xp1 XI916_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI916_MP20 (pp7_28 B_15_b3_4 XI916_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI916_MP19 (XI916_xp1 XI916_xan pp7_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI916_MP17 (VDD XI916_xn XI916_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI916_MP6 (XI916_p1 A_28_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI916_MP8 (XI916_xn A_27_b3_2 XI916_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI916_MP7 (XI916_p1 two7_b3_5 XI916_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI916_MP5 (VDD one7_b3_5 XI916_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI916_MP10 (XI916_xan XI916_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI915_MP12 (VDD B_15_b3_4 XI915_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI915_MP18 (XI915_xp1 XI915_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI915_MP20 (pp7_27 B_15_b3_4 XI915_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI915_MP19 (XI915_xp1 XI915_xan pp7_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI915_MP17 (VDD XI915_xn XI915_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI915_MP6 (XI915_p1 A_27_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI915_MP8 (XI915_xn A_26_b3_2 XI915_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI915_MP7 (XI915_p1 two7_b3_4 XI915_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI915_MP5 (VDD one7_b3_4 XI915_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI915_MP10 (XI915_xan XI915_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI862_MP12 (VDD B_13_b3_5 XI862_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI862_MP18 (XI862_xp1 XI862_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI862_MP20 (pp6_29 B_13_b3_5 XI862_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI862_MP19 (XI862_xp1 XI862_xan pp6_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI862_MP17 (VDD XI862_xn XI862_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI862_MP6 (XI862_p1 A_29_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI862_MP8 (XI862_xn A_28_b3_2 XI862_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI862_MP7 (XI862_p1 two6_b3_5 XI862_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI862_MP5 (VDD one6_b3_5 XI862_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI862_MP10 (XI862_xan XI862_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI918_MP12 (VDD B_15_b3_5 XI918_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI918_MP18 (XI918_xp1 XI918_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI918_MP20 (pp7_30 B_15_b3_5 XI918_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI918_MP19 (XI918_xp1 XI918_xan pp7_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI918_MP17 (VDD XI918_xn XI918_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI918_MP6 (XI918_p1 A_30_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI918_MP8 (XI918_xn A_29_b3_2 XI918_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI918_MP7 (XI918_p1 two7_b3_5 XI918_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI918_MP5 (VDD one7_b3_5 XI918_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI918_MP10 (XI918_xan XI918_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI865_MP12 (VDD B_13_b3_5 XI865_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI865_MP18 (XI865_xp1 XI865_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI865_MP20 (pp6_32 B_13_b3_5 XI865_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI865_MP19 (XI865_xp1 XI865_xan pp6_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI865_MP17 (VDD XI865_xn XI865_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI865_MP6 (XI865_p1 A_31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI865_MP8 (XI865_xn A_31_b3_3 XI865_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI865_MP7 (XI865_p1 two6_b3_5 XI865_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI865_MP5 (VDD one6_b3_5 XI865_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI865_MP10 (XI865_xan XI865_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI864_MP12 (VDD B_13_b3_5 XI864_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI864_MP18 (XI864_xp1 XI864_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI864_MP20 (pp6_31 B_13_b3_5 XI864_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI864_MP19 (XI864_xp1 XI864_xan pp6_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI864_MP17 (VDD XI864_xn XI864_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI864_MP6 (XI864_p1 A_31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI864_MP8 (XI864_xn A_30_b3_2 XI864_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI864_MP7 (XI864_p1 two6_b3_5 XI864_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI864_MP5 (VDD one6_b3_5 XI864_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI864_MP10 (XI864_xan XI864_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI919_MP12 (VDD B_15_b3_5 XI919_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI919_MP18 (XI919_xp1 XI919_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI919_MP20 (pp7_31 B_15_b3_5 XI919_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI919_MP19 (XI919_xp1 XI919_xan pp7_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI919_MP17 (VDD XI919_xn XI919_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI919_MP6 (XI919_p1 A_31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI919_MP8 (XI919_xn A_30_b3_2 XI919_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI919_MP7 (XI919_p1 two7_b3_5 XI919_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI919_MP5 (VDD one7_b3_5 XI919_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI919_MP10 (XI919_xan XI919_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI920_MP12 (VDD B_15_b3_5 XI920_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI920_MP18 (XI920_xp1 XI920_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI920_MP20 (pp7_32 B_15_b3_5 XI920_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI920_MP19 (XI920_xp1 XI920_xan pp7_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI920_MP17 (VDD XI920_xn XI920_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI920_MP6 (XI920_p1 A_31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI920_MP8 (XI920_xn A_31_b3_3 XI920_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI920_MP7 (XI920_p1 two7_b3_5 XI920_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI920_MP5 (VDD one7_b3_5 XI920_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI920_MP10 (XI920_xan XI920_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1017_MP12 (VDD B_19_b3_3 XI1017_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1017_MP18 (XI1017_xp1 XI1017_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1017_MP20 (pp9_19 B_19_b3_3 XI1017_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1017_MP19 (XI1017_xp1 XI1017_xan pp9_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1017_MP17 (VDD XI1017_xn XI1017_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1017_MP6 (XI1017_p1 A_19_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1017_MP8 (XI1017_xn A_18_b3_3 XI1017_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1017_MP7 (XI1017_p1 two9_b3_3 XI1017_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1017_MP5 (VDD one9_b3_3 XI1017_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1017_MP10 (XI1017_xan XI1017_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1018_MP12 (VDD B_19_b3_3 XI1018_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1018_MP18 (XI1018_xp1 XI1018_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1018_MP20 (pp9_20 B_19_b3_3 XI1018_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1018_MP19 (XI1018_xp1 XI1018_xan pp9_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1018_MP17 (VDD XI1018_xn XI1018_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1018_MP6 (XI1018_p1 A_20_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1018_MP8 (XI1018_xn A_19_b3_3 XI1018_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1018_MP7 (XI1018_p1 two9_b3_3 XI1018_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1018_MP5 (VDD one9_b3_3 XI1018_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1018_MP10 (XI1018_xan XI1018_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1016_MP12 (VDD B_19_b3_3 XI1016_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1016_MP18 (XI1016_xp1 XI1016_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1016_MP20 (pp9_18 B_19_b3_3 XI1016_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1016_MP19 (XI1016_xp1 XI1016_xan pp9_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1016_MP17 (VDD XI1016_xn XI1016_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1016_MP6 (XI1016_p1 A_18_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1016_MP8 (XI1016_xn A_17_b3_3 XI1016_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1016_MP7 (XI1016_p1 two9_b3_3 XI1016_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1016_MP5 (VDD one9_b3_3 XI1016_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1016_MP10 (XI1016_xan XI1016_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI966_MP12 (VDD B_17_b3_4 XI966_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI966_MP18 (XI966_xp1 XI966_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI966_MP20 (pp8_23 B_17_b3_4 XI966_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI966_MP19 (XI966_xp1 XI966_xan pp8_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI966_MP17 (VDD XI966_xn XI966_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI966_MP6 (XI966_p1 A_23_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI966_MP8 (XI966_xn A_22_b3_3 XI966_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI966_MP7 (XI966_p1 two8_b3_4 XI966_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI966_MP5 (VDD one8_b3_4 XI966_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI966_MP10 (XI966_xan XI966_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1021_MP12 (VDD B_19_b3_4 XI1021_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1021_MP18 (XI1021_xp1 XI1021_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1021_MP20 (pp9_23 B_19_b3_4 XI1021_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1021_MP19 (XI1021_xp1 XI1021_xan pp9_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1021_MP17 (VDD XI1021_xn XI1021_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1021_MP6 (XI1021_p1 A_23_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1021_MP8 (XI1021_xn A_22_b3_3 XI1021_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1021_MP7 (XI1021_p1 two9_b3_4 XI1021_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1021_MP5 (VDD one9_b3_4 XI1021_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1021_MP10 (XI1021_xan XI1021_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1022_MP12 (VDD B_19_b3_4 XI1022_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1022_MP18 (XI1022_xp1 XI1022_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1022_MP20 (pp9_24 B_19_b3_4 XI1022_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1022_MP19 (XI1022_xp1 XI1022_xan pp9_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1022_MP17 (VDD XI1022_xn XI1022_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1022_MP6 (XI1022_p1 A_24_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1022_MP8 (XI1022_xn A_23_b3_3 XI1022_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1022_MP7 (XI1022_p1 two9_b3_4 XI1022_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1022_MP5 (VDD one9_b3_4 XI1022_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1022_MP10 (XI1022_xan XI1022_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI969_MP12 (VDD B_17_b3_4 XI969_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
