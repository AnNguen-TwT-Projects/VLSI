    I_MXI847_MP8 (XI847_xn A_13_b3_2 XI847_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI847_MP7 (XI847_p1 two6_b3_2 XI847_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI847_MP5 (VDD one6_b3_2 XI847_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI847_MP10 (XI847_xan XI847_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI848_MP12 (VDD B_13_b3_2 XI848_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI848_MP18 (XI848_xp1 XI848_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI848_MP20 (pp6_15 B_13_b3_2 XI848_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI848_MP19 (XI848_xp1 XI848_xan pp6_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI848_MP17 (VDD XI848_xn XI848_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI848_MP6 (XI848_p1 A_15_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI848_MP8 (XI848_xn A_14_b3_2 XI848_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI848_MP7 (XI848_p1 two6_b3_2 XI848_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI848_MP5 (VDD one6_b3_2 XI848_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI848_MP10 (XI848_xan XI848_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI740_MP12 (VDD B_9_b3_3 XI740_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI740_MP18 (XI740_xp1 XI740_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI740_MP20 (pp4_17 B_9_b3_3 XI740_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI740_MP19 (XI740_xp1 XI740_xan pp4_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI740_MP17 (VDD XI740_xn XI740_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI740_MP6 (XI740_p1 A_17_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI740_MP8 (XI740_xn A_16_b3_1 XI740_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI740_MP7 (XI740_p1 two4_b3_3 XI740_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI740_MP5 (VDD one4_b3_3 XI740_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI740_MP10 (XI740_xan XI740_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI529_MP12 (VDD B_1_b3_4 XI529_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI529_MP18 (XI529_xp1 XI529_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI529_MP20 (pp0_26 B_1_b3_4 XI529_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI529_MP19 (XI529_xp1 XI529_xan pp0_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI529_MP17 (VDD XI529_xn XI529_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI529_MP6 (XI529_p1 A_26_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI529_MP8 (XI529_xn A_25_b3_0 XI529_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI529_MP7 (XI529_p1 two0_b3_4 XI529_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI529_MP5 (VDD one0_b3_4 XI529_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI529_MP10 (XI529_xan XI529_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI582_MP12 (VDD B_3_b3_4 XI582_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI582_MP18 (XI582_xp1 XI582_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI582_MP20 (pp1_24 B_3_b3_4 XI582_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI582_MP19 (XI582_xp1 XI582_xan pp1_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI582_MP17 (VDD XI582_xn XI582_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI582_MP6 (XI582_p1 A_24_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI582_MP8 (XI582_xn A_23_b3_0 XI582_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI582_MP7 (XI582_p1 two1_b3_4 XI582_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI582_MP5 (VDD one1_b3_4 XI582_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI582_MP10 (XI582_xan XI582_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1005_MP12 (VDD B_19_b3_1 XI1005_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1005_MP18 (XI1005_xp1 XI1005_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1005_MP20 (pp9_7 B_19_b3_1 XI1005_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1005_MP19 (XI1005_xp1 XI1005_xan pp9_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1005_MP17 (VDD XI1005_xn XI1005_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1005_MP6 (XI1005_p1 A_7_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1005_MP8 (XI1005_xn A_6_b3_3 XI1005_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1005_MP7 (XI1005_p1 two9_b3_1 XI1005_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1005_MP5 (VDD one9_b3_1 XI1005_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1005_MP10 (XI1005_xan XI1005_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1006_MP12 (VDD B_19_b3_1 XI1006_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1006_MP18 (XI1006_xp1 XI1006_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1006_MP20 (pp9_8 B_19_b3_1 XI1006_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1006_MP19 (XI1006_xp1 XI1006_xan pp9_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1006_MP17 (VDD XI1006_xn XI1006_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1006_MP6 (XI1006_p1 A_8_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1006_MP8 (XI1006_xn A_7_b3_3 XI1006_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1006_MP7 (XI1006_p1 two9_b3_1 XI1006_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1006_MP5 (VDD one9_b3_1 XI1006_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1006_MP10 (XI1006_xan XI1006_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1059_MP12 (VDD B_21_b3_1 XI1059_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1059_MP18 (XI1059_xp1 XI1059_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1059_MP20 (pp10_6 B_21_b3_1 XI1059_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1059_MP19 (XI1059_xp1 XI1059_xan pp10_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1059_MP17 (VDD XI1059_xn XI1059_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1059_MP6 (XI1059_p1 A_6_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1059_MP8 (XI1059_xn A_5_b3_3 XI1059_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1059_MP7 (XI1059_p1 two10_b3_1 XI1059_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1059_MP5 (VDD one10_b3_1 XI1059_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1059_MP10 (XI1059_xan XI1059_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1166_MP12 (VDD B_25_b3_0 XI1166_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1166_MP18 (XI1166_xp1 XI1166_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1166_MP20 (pp12_3 B_25_b3_0 XI1166_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1166_MP19 (XI1166_xp1 XI1166_xan pp12_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1166_MP17 (VDD XI1166_xn XI1166_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1166_MP6 (XI1166_p1 A_3_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1166_MP8 (XI1166_xn A_2_b3_4 XI1166_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1166_MP7 (XI1166_p1 two12_b3_0 XI1166_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1166_MP5 (VDD one12_b3_0 XI1166_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1166_MP10 (XI1166_xan XI1166_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1164_MP12 (VDD B_25_b3_0 XI1164_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1164_MP18 (XI1164_xp1 XI1164_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1164_MP20 (pp12_1 B_25_b3_0 XI1164_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1164_MP19 (XI1164_xp1 XI1164_xan pp12_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1164_MP17 (VDD XI1164_xn XI1164_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1164_MP6 (XI1164_p1 A_1_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1164_MP8 (XI1164_xn A_0_b3_4 XI1164_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1164_MP7 (XI1164_p1 two12_b3_0 XI1164_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1164_MP5 (VDD one12_b3_0 XI1164_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1164_MP10 (XI1164_xan XI1164_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1218_MP12 (VDD B_27_b3_0 XI1218_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1218_MP18 (XI1218_xp1 XI1218_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1218_MP20 (pp13_0 B_27_b3_0 XI1218_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1218_MP19 (XI1218_xp1 XI1218_xan pp13_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1218_MP17 (VDD XI1218_xn XI1218_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1218_MP6 (XI1218_p1 A_0_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1218_MP8 (XI1218_xn VSS XI1218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1218_MP7 (XI1218_p1 two13_b3_0 XI1218_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1218_MP5 (VDD one13_b3_0 XI1218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1218_MP10 (XI1218_xan XI1218_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1165_MP12 (VDD B_25_b3_0 XI1165_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1165_MP18 (XI1165_xp1 XI1165_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1165_MP20 (pp12_2 B_25_b3_0 XI1165_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1165_MP19 (XI1165_xp1 XI1165_xan pp12_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1165_MP17 (VDD XI1165_xn XI1165_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1165_MP6 (XI1165_p1 A_2_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1165_MP8 (XI1165_xn A_1_b3_4 XI1165_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1165_MP7 (XI1165_p1 two12_b3_0 XI1165_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1165_MP5 (VDD one12_b3_0 XI1165_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1165_MP10 (XI1165_xan XI1165_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI900_MP12 (VDD B_15_b3_2 XI900_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI900_MP18 (XI900_xp1 XI900_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI900_MP20 (pp7_12 B_15_b3_2 XI900_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI900_MP19 (XI900_xp1 XI900_xan pp7_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI900_MP17 (VDD XI900_xn XI900_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI900_MP6 (XI900_p1 A_12_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI900_MP8 (XI900_xn A_11_b3_2 XI900_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI900_MP7 (XI900_p1 two7_b3_2 XI900_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI900_MP5 (VDD one7_b3_2 XI900_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI900_MP10 (XI900_xan XI900_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI901_MP12 (VDD B_15_b3_2 XI901_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI901_MP18 (XI901_xp1 XI901_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI901_MP20 (pp7_13 B_15_b3_2 XI901_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI901_MP19 (XI901_xp1 XI901_xan pp7_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI901_MP17 (VDD XI901_xn XI901_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI901_MP6 (XI901_p1 A_13_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI901_MP8 (XI901_xn A_12_b3_2 XI901_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI901_MP7 (XI901_p1 two7_b3_2 XI901_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI901_MP5 (VDD one7_b3_2 XI901_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI901_MP10 (XI901_xan XI901_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI581_MP12 (VDD B_3_b3_4 XI581_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI581_MP18 (XI581_xp1 XI581_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI581_MP20 (pp1_23 B_3_b3_4 XI581_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI581_MP19 (XI581_xp1 XI581_xan pp1_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI581_MP17 (VDD XI581_xn XI581_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI581_MP6 (XI581_p1 A_23_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI581_MP8 (XI581_xn A_22_b3_0 XI581_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI581_MP7 (XI581_p1 two1_b3_4 XI581_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI581_MP5 (VDD one1_b3_4 XI581_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI581_MP10 (XI581_xan XI581_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI528_MP12 (VDD B_1_b3_4 XI528_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI528_MP18 (XI528_xp1 XI528_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI528_MP20 (pp0_25 B_1_b3_4 XI528_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI528_MP19 (XI528_xp1 XI528_xan pp0_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI528_MP17 (VDD XI528_xn XI528_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI528_MP6 (XI528_p1 A_25_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI528_MP8 (XI528_xn A_24_b3_0 XI528_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI528_MP7 (XI528_p1 two0_b3_4 XI528_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI528_MP5 (VDD one0_b3_4 XI528_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI528_MP10 (XI528_xan XI528_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI526_MP12 (VDD B_1_b3_4 XI526_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI526_MP18 (XI526_xp1 XI526_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI526_MP20 (pp0_23 B_1_b3_4 XI526_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI526_MP19 (XI526_xp1 XI526_xan pp0_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI526_MP17 (VDD XI526_xn XI526_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI526_MP6 (XI526_p1 A_23_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI526_MP8 (XI526_xn A_22_b3_0 XI526_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI526_MP7 (XI526_p1 two0_b3_4 XI526_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI526_MP5 (VDD one0_b3_4 XI526_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI526_MP10 (XI526_xan XI526_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI527_MP12 (VDD B_1_b3_4 XI527_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI527_MP18 (XI527_xp1 XI527_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI527_MP20 (pp0_24 B_1_b3_4 XI527_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI527_MP19 (XI527_xp1 XI527_xan pp0_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI527_MP17 (VDD XI527_xn XI527_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI527_MP6 (XI527_p1 A_24_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI527_MP8 (XI527_xn A_23_b3_0 XI527_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI527_MP7 (XI527_p1 two0_b3_4 XI527_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI527_MP5 (VDD one0_b3_4 XI527_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI527_MP10 (XI527_xan XI527_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI952_MP12 (VDD B_17_b3_1 XI952_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI952_MP18 (XI952_xp1 XI952_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI952_MP20 (pp8_9 B_17_b3_1 XI952_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI952_MP19 (XI952_xp1 XI952_xan pp8_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI952_MP17 (VDD XI952_xn XI952_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI952_MP6 (XI952_p1 A_9_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI952_MP8 (XI952_xn A_8_b3_3 XI952_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI952_MP7 (XI952_p1 two8_b3_1 XI952_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI952_MP5 (VDD one8_b3_1 XI952_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI952_MP10 (XI952_xan XI952_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI953_MP12 (VDD B_17_b3_1 XI953_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI953_MP18 (XI953_xp1 XI953_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI953_MP20 (pp8_10 B_17_b3_1 XI953_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI953_MP19 (XI953_xp1 XI953_xan pp8_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI953_MP17 (VDD XI953_xn XI953_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI953_MP6 (XI953_p1 A_10_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI953_MP8 (XI953_xn A_9_b3_3 XI953_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI953_MP7 (XI953_p1 two8_b3_1 XI953_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI953_MP5 (VDD one8_b3_1 XI953_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI953_MP10 (XI953_xan XI953_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1058_MP12 (VDD B_21_b3_1 XI1058_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1058_MP18 (XI1058_xp1 XI1058_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1058_MP20 (pp10_5 B_21_b3_1 XI1058_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1058_MP19 (XI1058_xp1 XI1058_xan pp10_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1058_MP17 (VDD XI1058_xn XI1058_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1058_MP6 (XI1058_p1 A_5_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1058_MP8 (XI1058_xn A_4_b3_3 XI1058_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1058_MP7 (XI1058_p1 two10_b3_0 XI1058_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1058_MP5 (VDD one10_b3_0 XI1058_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1058_MP10 (XI1058_xan XI1058_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1004_MP12 (VDD B_19_b3_1 XI1004_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1004_MP18 (XI1004_xp1 XI1004_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1004_MP20 (pp9_6 B_19_b3_1 XI1004_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1004_MP19 (XI1004_xp1 XI1004_xan pp9_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1004_MP17 (VDD XI1004_xn XI1004_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1004_MP6 (XI1004_p1 A_6_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1004_MP8 (XI1004_xn A_5_b3_3 XI1004_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1004_MP7 (XI1004_p1 two9_b3_1 XI1004_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1004_MP5 (VDD one9_b3_1 XI1004_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1004_MP10 (XI1004_xan XI1004_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1111_MP12 (VDD B_23_b3_0 XI1111_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1111_MP18 (XI1111_xp1 XI1111_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1111_MP20 (pp11_3 B_23_b3_0 XI1111_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1111_MP19 (XI1111_xp1 XI1111_xan pp11_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1111_MP17 (VDD XI1111_xn XI1111_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1111_MP6 (XI1111_p1 A_3_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1111_MP8 (XI1111_xn A_2_b3_4 XI1111_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1111_MP7 (XI1111_p1 two11_b3_0 XI1111_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1111_MP5 (VDD one11_b3_0 XI1111_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1111_MP10 (XI1111_xan XI1111_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1163_MP12 (VDD B_25_b3_0 XI1163_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1163_MP18 (XI1163_xp1 XI1163_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1163_MP20 (pp12_0 B_25_b3_0 XI1163_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1163_MP19 (XI1163_xp1 XI1163_xan pp12_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1163_MP17 (VDD XI1163_xn XI1163_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1163_MP6 (XI1163_p1 A_0_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1163_MP8 (XI1163_xn VSS XI1163_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1163_MP7 (XI1163_p1 two12_b3_0 XI1163_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1163_MP5 (VDD one12_b3_0 XI1163_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1163_MP10 (XI1163_xan XI1163_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI899_MP12 (VDD B_15_b3_2 XI899_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI899_MP18 (XI899_xp1 XI899_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI899_MP20 (pp7_11 B_15_b3_2 XI899_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI899_MP19 (XI899_xp1 XI899_xan pp7_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI899_MP17 (VDD XI899_xn XI899_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI899_MP6 (XI899_p1 A_11_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI899_MP8 (XI899_xn A_10_b3_2 XI899_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI899_MP7 (XI899_p1 two7_b3_2 XI899_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI899_MP5 (VDD one7_b3_2 XI899_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI899_MP10 (XI899_xan XI899_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI846_MP12 (VDD B_13_b3_2 XI846_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI846_MP18 (XI846_xp1 XI846_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI846_MP20 (pp6_13 B_13_b3_2 XI846_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI846_MP19 (XI846_xp1 XI846_xan pp6_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI846_MP17 (VDD XI846_xn XI846_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI846_MP6 (XI846_p1 A_13_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI846_MP8 (XI846_xn A_12_b3_2 XI846_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI846_MP7 (XI846_p1 two6_b3_2 XI846_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI846_MP5 (VDD one6_b3_2 XI846_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI846_MP10 (XI846_xan XI846_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI845_MP12 (VDD B_13_b3_2 XI845_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI845_MP18 (XI845_xp1 XI845_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI845_MP20 (pp6_12 B_13_b3_2 XI845_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI845_MP19 (XI845_xp1 XI845_xan pp6_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI845_MP17 (VDD XI845_xn XI845_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI845_MP6 (XI845_p1 A_12_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI845_MP8 (XI845_xn A_11_b3_2 XI845_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI845_MP7 (XI845_p1 two6_b3_2 XI845_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI845_MP5 (VDD one6_b3_2 XI845_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI845_MP10 (XI845_xan XI845_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI793_MP12 (VDD B_11_b3_2 XI793_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI793_MP18 (XI793_xp1 XI793_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI793_MP20 (pp5_15 B_11_b3_2 XI793_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI793_MP19 (XI793_xp1 XI793_xan pp5_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI793_MP17 (VDD XI793_xn XI793_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI793_MP6 (XI793_p1 A_15_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI793_MP8 (XI793_xn A_14_b3_2 XI793_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI793_MP7 (XI793_p1 two5_b3_2 XI793_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI793_MP5 (VDD one5_b3_2 XI793_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI793_MP10 (XI793_xan XI793_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI794_MP12 (VDD B_11_b3_2 XI794_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI794_MP18 (XI794_xp1 XI794_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI794_MP20 (pp5_16 B_11_b3_2 XI794_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI794_MP19 (XI794_xp1 XI794_xan pp5_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI794_MP17 (VDD XI794_xn XI794_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI794_MP6 (XI794_p1 A_16_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI794_MP8 (XI794_xn A_15_b3_2 XI794_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI794_MP7 (XI794_p1 two5_b3_2 XI794_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI794_MP5 (VDD one5_b3_2 XI794_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI794_MP10 (XI794_xan XI794_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI525_MP12 (VDD B_1_b3_3 XI525_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI525_MP18 (XI525_xp1 XI525_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI525_MP20 (pp0_22 B_1_b3_3 XI525_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI525_MP19 (XI525_xp1 XI525_xan pp0_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI525_MP17 (VDD XI525_xn XI525_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI525_MP6 (XI525_p1 A_22_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI525_MP8 (XI525_xn A_21_b3_0 XI525_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI525_MP7 (XI525_p1 two0_b3_4 XI525_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI525_MP5 (VDD one0_b3_4 XI525_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI525_MP10 (XI525_xan XI525_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI580_MP12 (VDD B_3_b3_3 XI580_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI580_MP18 (XI580_xp1 XI580_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI580_MP20 (pp1_22 B_3_b3_3 XI580_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI580_MP19 (XI580_xp1 XI580_xan pp1_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI580_MP17 (VDD XI580_xn XI580_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI580_MP6 (XI580_p1 A_22_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI580_MP8 (XI580_xn A_21_b3_0 XI580_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI580_MP7 (XI580_p1 two1_b3_4 XI580_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI580_MP5 (VDD one1_b3_4 XI580_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI580_MP10 (XI580_xan XI580_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI951_MP12 (VDD B_17_b3_1 XI951_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI951_MP18 (XI951_xp1 XI951_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI951_MP20 (pp8_8 B_17_b3_1 XI951_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI951_MP19 (XI951_xp1 XI951_xan pp8_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI951_MP17 (VDD XI951_xn XI951_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI951_MP6 (XI951_p1 A_8_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI951_MP8 (XI951_xn A_7_b3_3 XI951_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI951_MP7 (XI951_p1 two8_b3_1 XI951_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI951_MP5 (VDD one8_b3_1 XI951_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI951_MP10 (XI951_xan XI951_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI950_MP12 (VDD B_17_b3_1 XI950_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI950_MP18 (XI950_xp1 XI950_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI950_MP20 (pp8_7 B_17_b3_1 XI950_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI950_MP19 (XI950_xp1 XI950_xan pp8_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI950_MP17 (VDD XI950_xn XI950_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI950_MP6 (XI950_p1 A_7_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI950_MP8 (XI950_xn A_6_b3_3 XI950_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI950_MP7 (XI950_p1 two8_b3_1 XI950_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI950_MP5 (VDD one8_b3_1 XI950_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI950_MP10 (XI950_xan XI950_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1109_MP12 (VDD B_23_b3_0 XI1109_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1109_MP18 (XI1109_xp1 XI1109_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1109_MP20 (pp11_1 B_23_b3_0 XI1109_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1109_MP19 (XI1109_xp1 XI1109_xan pp11_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1109_MP17 (VDD XI1109_xn XI1109_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1109_MP6 (XI1109_p1 A_1_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1109_MP8 (XI1109_xn A_0_b3_4 XI1109_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1109_MP7 (XI1109_p1 two11_b3_0 XI1109_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1109_MP5 (VDD one11_b3_0 XI1109_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1109_MP10 (XI1109_xan XI1109_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1110_MP12 (VDD B_23_b3_0 XI1110_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1110_MP18 (XI1110_xp1 XI1110_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1110_MP20 (pp11_2 B_23_b3_0 XI1110_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1110_MP19 (XI1110_xp1 XI1110_xan pp11_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1110_MP17 (VDD XI1110_xn XI1110_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1110_MP6 (XI1110_p1 A_2_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1110_MP8 (XI1110_xn A_1_b3_4 XI1110_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1110_MP7 (XI1110_p1 two11_b3_0 XI1110_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1110_MP5 (VDD one11_b3_0 XI1110_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1110_MP10 (XI1110_xan XI1110_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI844_MP12 (VDD B_13_b3_2 XI844_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI844_MP18 (XI844_xp1 XI844_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI844_MP20 (pp6_11 B_13_b3_2 XI844_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI844_MP19 (XI844_xp1 XI844_xan pp6_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI844_MP17 (VDD XI844_xn XI844_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI844_MP6 (XI844_p1 A_11_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI844_MP8 (XI844_xn A_10_b3_2 XI844_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI844_MP7 (XI844_p1 two6_b3_2 XI844_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI844_MP5 (VDD one6_b3_2 XI844_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI844_MP10 (XI844_xan XI844_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI792_MP12 (VDD B_11_b3_2 XI792_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI792_MP18 (XI792_xp1 XI792_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI792_MP20 (pp5_14 B_11_b3_2 XI792_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI792_MP19 (XI792_xp1 XI792_xan pp5_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI792_MP17 (VDD XI792_xn XI792_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI792_MP6 (XI792_p1 A_14_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI792_MP8 (XI792_xn A_13_b3_2 XI792_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI792_MP7 (XI792_p1 two5_b3_2 XI792_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI792_MP5 (VDD one5_b3_2 XI792_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI792_MP10 (XI792_xan XI792_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI634_MP12 (VDD B_5_b3_3 XI634_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI634_MP18 (XI634_xp1 XI634_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI634_MP20 (pp2_21 B_5_b3_3 XI634_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI634_MP19 (XI634_xp1 XI634_xan pp2_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI634_MP17 (VDD XI634_xn XI634_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI634_MP6 (XI634_p1 A_21_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI634_MP8 (XI634_xn A_20_b3_0 XI634_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI634_MP7 (XI634_p1 two2_b3_3 XI634_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI634_MP5 (VDD one2_b3_3 XI634_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI634_MP10 (XI634_xan XI634_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI633_MP12 (VDD B_5_b3_3 XI633_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI633_MP18 (XI633_xp1 XI633_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI633_MP20 (pp2_20 B_5_b3_3 XI633_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI633_MP19 (XI633_xp1 XI633_xan pp2_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI633_MP17 (VDD XI633_xn XI633_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI633_MP6 (XI633_p1 A_20_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI633_MP8 (XI633_xn A_19_b3_0 XI633_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI633_MP7 (XI633_p1 two2_b3_3 XI633_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI633_MP5 (VDD one2_b3_3 XI633_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI633_MP10 (XI633_xan XI633_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI949_MP12 (VDD B_17_b3_1 XI949_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI949_MP18 (XI949_xp1 XI949_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI949_MP20 (pp8_6 B_17_b3_1 XI949_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI949_MP19 (XI949_xp1 XI949_xan pp8_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI949_MP17 (VDD XI949_xn XI949_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI949_MP6 (XI949_p1 A_6_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI949_MP8 (XI949_xn A_5_b3_3 XI949_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI949_MP7 (XI949_p1 two8_b3_1 XI949_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI949_MP5 (VDD one8_b3_1 XI949_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI949_MP10 (XI949_xan XI949_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1003_MP12 (VDD B_19_b3_1 XI1003_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1003_MP18 (XI1003_xp1 XI1003_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1003_MP20 (pp9_5 B_19_b3_1 XI1003_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1003_MP19 (XI1003_xp1 XI1003_xan pp9_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1003_MP17 (VDD XI1003_xn XI1003_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1003_MP6 (XI1003_p1 A_5_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1003_MP8 (XI1003_xn A_4_b3_3 XI1003_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1003_MP7 (XI1003_p1 two9_b3_0 XI1003_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1003_MP5 (VDD one9_b3_0 XI1003_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1003_MP10 (XI1003_xan XI1003_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1108_MP12 (VDD B_23_b3_0 XI1108_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1108_MP18 (XI1108_xp1 XI1108_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1108_MP20 (pp11_0 B_23_b3_0 XI1108_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1108_MP19 (XI1108_xp1 XI1108_xan pp11_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1108_MP17 (VDD XI1108_xn XI1108_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1108_MP6 (XI1108_p1 A_0_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1108_MP8 (XI1108_xn VSS XI1108_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1108_MP7 (XI1108_p1 two11_b3_0 XI1108_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1108_MP5 (VDD one11_b3_0 XI1108_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1108_MP10 (XI1108_xan XI1108_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI791_MP12 (VDD B_11_b3_2 XI791_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI791_MP18 (XI791_xp1 XI791_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI791_MP20 (pp5_13 B_11_b3_2 XI791_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI791_MP19 (XI791_xp1 XI791_xan pp5_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI791_MP17 (VDD XI791_xn XI791_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI791_MP6 (XI791_p1 A_13_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI791_MP8 (XI791_xn A_12_b3_2 XI791_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI791_MP7 (XI791_p1 two5_b3_2 XI791_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI791_MP5 (VDD one5_b3_2 XI791_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI791_MP10 (XI791_xan XI791_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI631_MP12 (VDD B_5_b3_3 XI631_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI631_MP18 (XI631_xp1 XI631_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI631_MP20 (pp2_18 B_5_b3_3 XI631_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI631_MP19 (XI631_xp1 XI631_xan pp2_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI631_MP17 (VDD XI631_xn XI631_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI631_MP6 (XI631_p1 A_18_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI631_MP8 (XI631_xn A_17_b3_0 XI631_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI631_MP7 (XI631_p1 two2_b3_3 XI631_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI631_MP5 (VDD one2_b3_3 XI631_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI631_MP10 (XI631_xan XI631_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI632_MP12 (VDD B_5_b3_3 XI632_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI632_MP18 (XI632_xp1 XI632_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI632_MP20 (pp2_19 B_5_b3_3 XI632_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI632_MP19 (XI632_xp1 XI632_xan pp2_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI632_MP17 (VDD XI632_xn XI632_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI632_MP6 (XI632_p1 A_19_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI632_MP8 (XI632_xn A_18_b3_0 XI632_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI632_MP7 (XI632_p1 two2_b3_3 XI632_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI632_MP5 (VDD one2_b3_3 XI632_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI632_MP10 (XI632_xan XI632_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI579_MP12 (VDD B_3_b3_3 XI579_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI579_MP18 (XI579_xp1 XI579_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI579_MP20 (pp1_21 B_3_b3_3 XI579_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI579_MP19 (XI579_xp1 XI579_xan pp1_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI579_MP17 (VDD XI579_xn XI579_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI579_MP6 (XI579_p1 A_21_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI579_MP8 (XI579_xn A_20_b3_0 XI579_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI579_MP7 (XI579_p1 two1_b3_3 XI579_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI579_MP5 (VDD one1_b3_3 XI579_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI579_MP10 (XI579_xan XI579_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI578_MP12 (VDD B_3_b3_3 XI578_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI578_MP18 (XI578_xp1 XI578_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI578_MP20 (pp1_20 B_3_b3_3 XI578_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI578_MP19 (XI578_xp1 XI578_xan pp1_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI578_MP17 (VDD XI578_xn XI578_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI578_MP6 (XI578_p1 A_20_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI578_MP8 (XI578_xn A_19_b3_0 XI578_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI578_MP7 (XI578_p1 two1_b3_3 XI578_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI578_MP5 (VDD one1_b3_3 XI578_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI578_MP10 (XI578_xan XI578_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI898_MP12 (VDD B_15_b3_1 XI898_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI898_MP18 (XI898_xp1 XI898_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI898_MP20 (pp7_10 B_15_b3_1 XI898_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI898_MP19 (XI898_xp1 XI898_xan pp7_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI898_MP17 (VDD XI898_xn XI898_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI898_MP6 (XI898_p1 A_10_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI898_MP8 (XI898_xn A_9_b3_2 XI898_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI898_MP7 (XI898_p1 two7_b3_1 XI898_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI898_MP5 (VDD one7_b3_1 XI898_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI898_MP10 (XI898_xan XI898_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI897_MP12 (VDD B_15_b3_1 XI897_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI897_MP18 (XI897_xp1 XI897_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI897_MP20 (pp7_9 B_15_b3_1 XI897_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI897_MP19 (XI897_xp1 XI897_xan pp7_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI897_MP17 (VDD XI897_xn XI897_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI897_MP6 (XI897_p1 A_9_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI897_MP8 (XI897_xn A_8_b3_2 XI897_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI897_MP7 (XI897_p1 two7_b3_1 XI897_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI897_MP5 (VDD one7_b3_1 XI897_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI897_MP10 (XI897_xan XI897_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI789_MP12 (VDD B_11_b3_2 XI789_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI789_MP18 (XI789_xp1 XI789_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI789_MP20 (pp5_11 B_11_b3_2 XI789_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI789_MP19 (XI789_xp1 XI789_xan pp5_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI789_MP17 (VDD XI789_xn XI789_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI789_MP6 (XI789_p1 A_11_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI789_MP8 (XI789_xn A_10_b3_2 XI789_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI789_MP7 (XI789_p1 two5_b3_2 XI789_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI789_MP5 (VDD one5_b3_2 XI789_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI789_MP10 (XI789_xan XI789_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI790_MP12 (VDD B_11_b3_2 XI790_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI790_MP18 (XI790_xp1 XI790_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI790_MP20 (pp5_12 B_11_b3_2 XI790_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI790_MP19 (XI790_xp1 XI790_xan pp5_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI790_MP17 (VDD XI790_xn XI790_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI790_MP6 (XI790_p1 A_12_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI790_MP8 (XI790_xn A_11_b3_2 XI790_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI790_MP7 (XI790_p1 two5_b3_2 XI790_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI790_MP5 (VDD one5_b3_2 XI790_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI790_MP10 (XI790_xan XI790_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI737_MP12 (VDD B_9_b3_2 XI737_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI737_MP18 (XI737_xp1 XI737_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI737_MP20 (pp4_14 B_9_b3_2 XI737_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI737_MP19 (XI737_xp1 XI737_xan pp4_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI737_MP17 (VDD XI737_xn XI737_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI737_MP6 (XI737_p1 A_14_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI737_MP8 (XI737_xn A_13_b3_1 XI737_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI737_MP7 (XI737_p1 two4_b3_2 XI737_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI737_MP5 (VDD one4_b3_2 XI737_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI737_MP10 (XI737_xan XI737_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI739_MP12 (VDD B_9_b3_2 XI739_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI739_MP18 (XI739_xp1 XI739_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI739_MP20 (pp4_16 B_9_b3_2 XI739_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI739_MP19 (XI739_xp1 XI739_xan pp4_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI739_MP17 (VDD XI739_xn XI739_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI739_MP6 (XI739_p1 A_16_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI739_MP8 (XI739_xn A_15_b3_1 XI739_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI739_MP7 (XI739_p1 two4_b3_2 XI739_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI739_MP5 (VDD one4_b3_2 XI739_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI739_MP10 (XI739_xan XI739_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI684_MP12 (VDD B_7_b3_2 XI684_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI684_MP18 (XI684_xp1 XI684_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI684_MP20 (pp3_16 B_7_b3_2 XI684_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI684_MP19 (XI684_xp1 XI684_xan pp3_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI684_MP17 (VDD XI684_xn XI684_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI684_MP6 (XI684_p1 A_16_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI684_MP8 (XI684_xn A_15_b3_1 XI684_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI684_MP7 (XI684_p1 two3_b3_2 XI684_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI684_MP5 (VDD one3_b3_2 XI684_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI684_MP10 (XI684_xan XI684_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI683_MP12 (VDD B_7_b3_2 XI683_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI683_MP18 (XI683_xp1 XI683_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI683_MP20 (pp3_15 B_7_b3_2 XI683_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI683_MP19 (XI683_xp1 XI683_xan pp3_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI683_MP17 (VDD XI683_xn XI683_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI683_MP6 (XI683_p1 A_15_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI683_MP8 (XI683_xn A_14_b3_1 XI683_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI683_MP7 (XI683_p1 two3_b3_2 XI683_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI683_MP5 (VDD one3_b3_2 XI683_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI683_MP10 (XI683_xan XI683_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI630_MP12 (VDD B_5_b3_3 XI630_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI630_MP18 (XI630_xp1 XI630_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI630_MP20 (pp2_17 B_5_b3_3 XI630_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI630_MP19 (XI630_xp1 XI630_xan pp2_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI630_MP17 (VDD XI630_xn XI630_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI630_MP6 (XI630_p1 A_17_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI630_MP8 (XI630_xn A_16_b3_0 XI630_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI630_MP7 (XI630_p1 two2_b3_3 XI630_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI630_MP5 (VDD one2_b3_3 XI630_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI630_MP10 (XI630_xan XI630_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI524_MP12 (VDD B_1_b3_3 XI524_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI524_MP18 (XI524_xp1 XI524_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI524_MP20 (pp0_21 B_1_b3_3 XI524_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI524_MP19 (XI524_xp1 XI524_xan pp0_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI524_MP17 (VDD XI524_xn XI524_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI524_MP6 (XI524_p1 A_21_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI524_MP8 (XI524_xn A_20_b3_0 XI524_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI524_MP7 (XI524_p1 two0_b3_3 XI524_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI524_MP5 (VDD one0_b3_3 XI524_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI524_MP10 (XI524_xan XI524_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI577_MP12 (VDD B_3_b3_3 XI577_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI577_MP18 (XI577_xp1 XI577_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI577_MP20 (pp1_19 B_3_b3_3 XI577_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI577_MP19 (XI577_xp1 XI577_xan pp1_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI577_MP17 (VDD XI577_xn XI577_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI577_MP6 (XI577_p1 A_19_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI577_MP8 (XI577_xn A_18_b3_0 XI577_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI577_MP7 (XI577_p1 two1_b3_3 XI577_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI577_MP5 (VDD one1_b3_3 XI577_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI577_MP10 (XI577_xan XI577_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI947_MP12 (VDD B_17_b3_0 XI947_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI947_MP18 (XI947_xp1 XI947_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI947_MP20 (pp8_4 B_17_b3_0 XI947_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI947_MP19 (XI947_xp1 XI947_xan pp8_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI947_MP17 (VDD XI947_xn XI947_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI947_MP6 (XI947_p1 A_4_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI947_MP8 (XI947_xn A_3_b3_3 XI947_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI947_MP7 (XI947_p1 two8_b3_0 XI947_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI947_MP5 (VDD one8_b3_0 XI947_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI947_MP10 (XI947_xan XI947_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI948_MP12 (VDD B_17_b3_1 XI948_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI948_MP18 (XI948_xp1 XI948_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI948_MP20 (pp8_5 B_17_b3_1 XI948_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI948_MP19 (XI948_xp1 XI948_xan pp8_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI948_MP17 (VDD XI948_xn XI948_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI948_MP6 (XI948_p1 A_5_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI948_MP8 (XI948_xn A_4_b3_3 XI948_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI948_MP7 (XI948_p1 two8_b3_0 XI948_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI948_MP5 (VDD one8_b3_0 XI948_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI948_MP10 (XI948_xan XI948_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1057_MP12 (VDD B_21_b3_0 XI1057_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1057_MP18 (XI1057_xp1 XI1057_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1057_MP20 (pp10_4 B_21_b3_0 XI1057_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1057_MP19 (XI1057_xp1 XI1057_xan pp10_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1057_MP17 (VDD XI1057_xn XI1057_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1057_MP6 (XI1057_p1 A_4_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1057_MP8 (XI1057_xn A_3_b3_3 XI1057_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1057_MP7 (XI1057_p1 two10_b3_0 XI1057_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1057_MP5 (VDD one10_b3_0 XI1057_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1057_MP10 (XI1057_xan XI1057_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1002_MP12 (VDD B_19_b3_0 XI1002_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1002_MP18 (XI1002_xp1 XI1002_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1002_MP20 (pp9_4 B_19_b3_0 XI1002_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1002_MP19 (XI1002_xp1 XI1002_xan pp9_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1002_MP17 (VDD XI1002_xn XI1002_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1002_MP6 (XI1002_p1 A_4_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1002_MP8 (XI1002_xn A_3_b3_3 XI1002_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1002_MP7 (XI1002_p1 two9_b3_0 XI1002_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1002_MP5 (VDD one9_b3_0 XI1002_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1002_MP10 (XI1002_xan XI1002_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI896_MP12 (VDD B_15_b3_1 XI896_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI896_MP18 (XI896_xp1 XI896_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI896_MP20 (pp7_8 B_15_b3_1 XI896_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI896_MP19 (XI896_xp1 XI896_xan pp7_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI896_MP17 (VDD XI896_xn XI896_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI896_MP6 (XI896_p1 A_8_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI896_MP8 (XI896_xn A_7_b3_2 XI896_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI896_MP7 (XI896_p1 two7_b3_1 XI896_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI896_MP5 (VDD one7_b3_1 XI896_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI896_MP10 (XI896_xan XI896_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI843_MP12 (VDD B_13_b3_1 XI843_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI843_MP18 (XI843_xp1 XI843_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI843_MP20 (pp6_10 B_13_b3_1 XI843_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI843_MP19 (XI843_xp1 XI843_xan pp6_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI843_MP17 (VDD XI843_xn XI843_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI843_MP6 (XI843_p1 A_10_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI843_MP8 (XI843_xn A_9_b3_2 XI843_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI843_MP7 (XI843_p1 two6_b3_1 XI843_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI843_MP5 (VDD one6_b3_1 XI843_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI843_MP10 (XI843_xan XI843_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI736_MP12 (VDD B_9_b3_2 XI736_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI736_MP18 (XI736_xp1 XI736_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI736_MP20 (pp4_13 B_9_b3_2 XI736_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI736_MP19 (XI736_xp1 XI736_xan pp4_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI736_MP17 (VDD XI736_xn XI736_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI736_MP6 (XI736_p1 A_13_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI736_MP8 (XI736_xn A_12_b3_1 XI736_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI736_MP7 (XI736_p1 two4_b3_2 XI736_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI736_MP5 (VDD one4_b3_2 XI736_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI736_MP10 (XI736_xan XI736_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI738_MP12 (VDD B_9_b3_2 XI738_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI738_MP18 (XI738_xp1 XI738_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI738_MP20 (pp4_15 B_9_b3_2 XI738_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI738_MP19 (XI738_xp1 XI738_xan pp4_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI738_MP17 (VDD XI738_xn XI738_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI738_MP6 (XI738_p1 A_15_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI738_MP8 (XI738_xn A_14_b3_1 XI738_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI738_MP7 (XI738_p1 two4_b3_2 XI738_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI738_MP5 (VDD one4_b3_2 XI738_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI738_MP10 (XI738_xan XI738_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI681_MP12 (VDD B_7_b3_2 XI681_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI681_MP18 (XI681_xp1 XI681_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI681_MP20 (pp3_13 B_7_b3_2 XI681_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI681_MP19 (XI681_xp1 XI681_xan pp3_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI681_MP17 (VDD XI681_xn XI681_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI681_MP6 (XI681_p1 A_13_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI681_MP8 (XI681_xn A_12_b3_1 XI681_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI681_MP7 (XI681_p1 two3_b3_2 XI681_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI681_MP5 (VDD one3_b3_2 XI681_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI681_MP10 (XI681_xan XI681_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI682_MP12 (VDD B_7_b3_2 XI682_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI682_MP18 (XI682_xp1 XI682_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI682_MP20 (pp3_14 B_7_b3_2 XI682_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI682_MP19 (XI682_xp1 XI682_xan pp3_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI682_MP17 (VDD XI682_xn XI682_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI682_MP6 (XI682_p1 A_14_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI682_MP8 (XI682_xn A_13_b3_1 XI682_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI682_MP7 (XI682_p1 two3_b3_2 XI682_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI682_MP5 (VDD one3_b3_2 XI682_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI682_MP10 (XI682_xan XI682_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI521_MP12 (VDD B_1_b3_3 XI521_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI521_MP18 (XI521_xp1 XI521_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI521_MP20 (pp0_18 B_1_b3_3 XI521_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI521_MP19 (XI521_xp1 XI521_xan pp0_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI521_MP17 (VDD XI521_xn XI521_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI521_MP6 (XI521_p1 A_18_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI521_MP8 (XI521_xn A_17_b3_0 XI521_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI521_MP7 (XI521_p1 two0_b3_3 XI521_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI521_MP5 (VDD one0_b3_3 XI521_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI521_MP10 (XI521_xan XI521_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI523_MP12 (VDD B_1_b3_3 XI523_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI523_MP18 (XI523_xp1 XI523_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI523_MP20 (pp0_20 B_1_b3_3 XI523_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI523_MP19 (XI523_xp1 XI523_xan pp0_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI523_MP17 (VDD XI523_xn XI523_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI523_MP6 (XI523_p1 A_20_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI523_MP8 (XI523_xn A_19_b3_0 XI523_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI523_MP7 (XI523_p1 two0_b3_3 XI523_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI523_MP5 (VDD one0_b3_3 XI523_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI523_MP10 (XI523_xan XI523_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI576_MP12 (VDD B_3_b3_3 XI576_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI576_MP18 (XI576_xp1 XI576_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI576_MP20 (pp1_18 B_3_b3_3 XI576_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI576_MP19 (XI576_xp1 XI576_xan pp1_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI576_MP17 (VDD XI576_xn XI576_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI576_MP6 (XI576_p1 A_18_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI576_MP8 (XI576_xn A_17_b3_0 XI576_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI576_MP7 (XI576_p1 two1_b3_3 XI576_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI576_MP5 (VDD one1_b3_3 XI576_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI576_MP10 (XI576_xan XI576_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1054_MP12 (VDD B_21_b3_0 XI1054_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1054_MP18 (XI1054_xp1 XI1054_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1054_MP20 (pp10_1 B_21_b3_0 XI1054_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1054_MP19 (XI1054_xp1 XI1054_xan pp10_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1054_MP17 (VDD XI1054_xn XI1054_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1054_MP6 (XI1054_p1 A_1_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1054_MP8 (XI1054_xn A_0_b3_3 XI1054_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1054_MP7 (XI1054_p1 two10_b3_0 XI1054_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1054_MP5 (VDD one10_b3_0 XI1054_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1054_MP10 (XI1054_xan XI1054_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1053_MP12 (VDD B_21_b3_0 XI1053_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1053_MP18 (XI1053_xp1 XI1053_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1053_MP20 (pp10_0 B_21_b3_0 XI1053_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1053_MP19 (XI1053_xp1 XI1053_xan pp10_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1053_MP17 (VDD XI1053_xn XI1053_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1053_MP6 (XI1053_p1 A_0_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1053_MP8 (XI1053_xn VSS XI1053_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1053_MP7 (XI1053_p1 two10_b3_0 XI1053_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1053_MP5 (VDD one10_b3_0 XI1053_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1053_MP10 (XI1053_xan XI1053_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1055_MP12 (VDD B_21_b3_0 XI1055_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1055_MP18 (XI1055_xp1 XI1055_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1055_MP20 (pp10_2 B_21_b3_0 XI1055_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1055_MP19 (XI1055_xp1 XI1055_xan pp10_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1055_MP17 (VDD XI1055_xn XI1055_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1055_MP6 (XI1055_p1 A_2_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1055_MP8 (XI1055_xn A_1_b3_3 XI1055_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1055_MP7 (XI1055_p1 two10_b3_0 XI1055_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1055_MP5 (VDD one10_b3_0 XI1055_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1055_MP10 (XI1055_xan XI1055_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1056_MP12 (VDD B_21_b3_0 XI1056_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1056_MP18 (XI1056_xp1 XI1056_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1056_MP20 (pp10_3 B_21_b3_0 XI1056_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1056_MP19 (XI1056_xp1 XI1056_xan pp10_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1056_MP17 (VDD XI1056_xn XI1056_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1056_MP6 (XI1056_p1 A_3_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1056_MP8 (XI1056_xn A_2_b3_3 XI1056_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1056_MP7 (XI1056_p1 two10_b3_0 XI1056_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1056_MP5 (VDD one10_b3_0 XI1056_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1056_MP10 (XI1056_xan XI1056_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI894_MP12 (VDD B_15_b3_1 XI894_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI894_MP18 (XI894_xp1 XI894_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI894_MP20 (pp7_6 B_15_b3_1 XI894_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI894_MP19 (XI894_xp1 XI894_xan pp7_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI894_MP17 (VDD XI894_xn XI894_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI894_MP6 (XI894_p1 A_6_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI894_MP8 (XI894_xn A_5_b3_2 XI894_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI894_MP7 (XI894_p1 two7_b3_1 XI894_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI894_MP5 (VDD one7_b3_1 XI894_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI894_MP10 (XI894_xan XI894_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI895_MP12 (VDD B_15_b3_1 XI895_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI895_MP18 (XI895_xp1 XI895_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI895_MP20 (pp7_7 B_15_b3_1 XI895_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI895_MP19 (XI895_xp1 XI895_xan pp7_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI895_MP17 (VDD XI895_xn XI895_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI895_MP6 (XI895_p1 A_7_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI895_MP8 (XI895_xn A_6_b3_2 XI895_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI895_MP7 (XI895_p1 two7_b3_1 XI895_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI895_MP5 (VDD one7_b3_1 XI895_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI895_MP10 (XI895_xan XI895_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI842_MP12 (VDD B_13_b3_1 XI842_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI842_MP18 (XI842_xp1 XI842_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI842_MP20 (pp6_9 B_13_b3_1 XI842_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI842_MP19 (XI842_xp1 XI842_xan pp6_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI842_MP17 (VDD XI842_xn XI842_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI842_MP6 (XI842_p1 A_9_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI842_MP8 (XI842_xn A_8_b3_2 XI842_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI842_MP7 (XI842_p1 two6_b3_1 XI842_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI842_MP5 (VDD one6_b3_1 XI842_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI842_MP10 (XI842_xan XI842_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI735_MP12 (VDD B_9_b3_2 XI735_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI735_MP18 (XI735_xp1 XI735_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI735_MP20 (pp4_12 B_9_b3_2 XI735_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI735_MP19 (XI735_xp1 XI735_xan pp4_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI735_MP17 (VDD XI735_xn XI735_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI735_MP6 (XI735_p1 A_12_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI735_MP8 (XI735_xn A_11_b3_1 XI735_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI735_MP7 (XI735_p1 two4_b3_2 XI735_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI735_MP5 (VDD one4_b3_2 XI735_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI735_MP10 (XI735_xan XI735_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI679_MP12 (VDD B_7_b3_2 XI679_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI679_MP18 (XI679_xp1 XI679_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI679_MP20 (pp3_11 B_7_b3_2 XI679_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI679_MP19 (XI679_xp1 XI679_xan pp3_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI679_MP17 (VDD XI679_xn XI679_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI679_MP6 (XI679_p1 A_11_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI679_MP8 (XI679_xn A_10_b3_1 XI679_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI679_MP7 (XI679_p1 two3_b3_2 XI679_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI679_MP5 (VDD one3_b3_2 XI679_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI679_MP10 (XI679_xan XI679_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI680_MP12 (VDD B_7_b3_2 XI680_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI680_MP18 (XI680_xp1 XI680_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI680_MP20 (pp3_12 B_7_b3_2 XI680_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI680_MP19 (XI680_xp1 XI680_xan pp3_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI680_MP17 (VDD XI680_xn XI680_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI680_MP6 (XI680_p1 A_12_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI680_MP8 (XI680_xn A_11_b3_1 XI680_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI680_MP7 (XI680_p1 two3_b3_2 XI680_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI680_MP5 (VDD one3_b3_2 XI680_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI680_MP10 (XI680_xan XI680_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI520_MP12 (VDD B_1_b3_3 XI520_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI520_MP18 (XI520_xp1 XI520_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI520_MP20 (pp0_17 B_1_b3_3 XI520_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI520_MP19 (XI520_xp1 XI520_xan pp0_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI520_MP17 (VDD XI520_xn XI520_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI520_MP6 (XI520_p1 A_17_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI520_MP8 (XI520_xn A_16_b3_0 XI520_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI520_MP7 (XI520_p1 two0_b3_3 XI520_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI520_MP5 (VDD one0_b3_3 XI520_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI520_MP10 (XI520_xan XI520_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI522_MP12 (VDD B_1_b3_3 XI522_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI522_MP18 (XI522_xp1 XI522_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI522_MP20 (pp0_19 B_1_b3_3 XI522_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI522_MP19 (XI522_xp1 XI522_xan pp0_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI522_MP17 (VDD XI522_xn XI522_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI522_MP6 (XI522_p1 A_19_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI522_MP8 (XI522_xn A_18_b3_0 XI522_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI522_MP7 (XI522_p1 two0_b3_3 XI522_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI522_MP5 (VDD one0_b3_3 XI522_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI522_MP10 (XI522_xan XI522_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI575_MP12 (VDD B_3_b3_3 XI575_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI575_MP18 (XI575_xp1 XI575_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI575_MP20 (pp1_17 B_3_b3_3 XI575_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI575_MP19 (XI575_xp1 XI575_xan pp1_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI575_MP17 (VDD XI575_xn XI575_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI575_MP6 (XI575_p1 A_17_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI575_MP8 (XI575_xn A_16_b3_0 XI575_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI575_MP7 (XI575_p1 two1_b3_3 XI575_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI575_MP5 (VDD one1_b3_3 XI575_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI575_MP10 (XI575_xan XI575_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1001_MP12 (VDD B_19_b3_0 XI1001_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1001_MP18 (XI1001_xp1 XI1001_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1001_MP20 (pp9_3 B_19_b3_0 XI1001_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1001_MP19 (XI1001_xp1 XI1001_xan pp9_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1001_MP17 (VDD XI1001_xn XI1001_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1001_MP6 (XI1001_p1 A_3_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1001_MP8 (XI1001_xn A_2_b3_3 XI1001_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1001_MP7 (XI1001_p1 two9_b3_0 XI1001_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1001_MP5 (VDD one9_b3_0 XI1001_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1001_MP10 (XI1001_xan XI1001_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1000_MP12 (VDD B_19_b3_0 XI1000_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1000_MP18 (XI1000_xp1 XI1000_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1000_MP20 (pp9_2 B_19_b3_0 XI1000_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1000_MP19 (XI1000_xp1 XI1000_xan pp9_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1000_MP17 (VDD XI1000_xn XI1000_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1000_MP6 (XI1000_p1 A_2_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1000_MP8 (XI1000_xn A_1_b3_3 XI1000_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1000_MP7 (XI1000_p1 two9_b3_0 XI1000_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1000_MP5 (VDD one9_b3_0 XI1000_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1000_MP10 (XI1000_xan XI1000_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI841_MP12 (VDD B_13_b3_1 XI841_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI841_MP18 (XI841_xp1 XI841_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI841_MP20 (pp6_8 B_13_b3_1 XI841_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI841_MP19 (XI841_xp1 XI841_xan pp6_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI841_MP17 (VDD XI841_xn XI841_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI841_MP6 (XI841_p1 A_8_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI841_MP8 (XI841_xn A_7_b3_2 XI841_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI841_MP7 (XI841_p1 two6_b3_1 XI841_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI841_MP5 (VDD one6_b3_1 XI841_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI841_MP10 (XI841_xan XI841_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI734_MP12 (VDD B_9_b3_2 XI734_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI734_MP18 (XI734_xp1 XI734_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI734_MP20 (pp4_11 B_9_b3_2 XI734_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI734_MP19 (XI734_xp1 XI734_xan pp4_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI734_MP17 (VDD XI734_xn XI734_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI734_MP6 (XI734_p1 A_11_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI734_MP8 (XI734_xn A_10_b3_1 XI734_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI734_MP7 (XI734_p1 two4_b3_2 XI734_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI734_MP5 (VDD one4_b3_2 XI734_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI734_MP10 (XI734_xan XI734_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI946_MP12 (VDD B_17_b3_0 XI946_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI946_MP18 (XI946_xp1 XI946_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI946_MP20 (pp8_3 B_17_b3_0 XI946_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI946_MP19 (XI946_xp1 XI946_xan pp8_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI946_MP17 (VDD XI946_xn XI946_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI946_MP6 (XI946_p1 A_3_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI946_MP8 (XI946_xn A_2_b3_3 XI946_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI946_MP7 (XI946_p1 two8_b3_0 XI946_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI946_MP5 (VDD one8_b3_0 XI946_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI946_MP10 (XI946_xan XI946_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI998_MP12 (VDD B_19_b3_0 XI998_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI998_MP18 (XI998_xp1 XI998_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI998_MP20 (pp9_0 B_19_b3_0 XI998_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI998_MP19 (XI998_xp1 XI998_xan pp9_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI998_MP17 (VDD XI998_xn XI998_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI998_MP6 (XI998_p1 A_0_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI998_MP8 (XI998_xn VSS XI998_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI998_MP7 (XI998_p1 two9_b3_0 XI998_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI998_MP5 (VDD one9_b3_0 XI998_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI998_MP10 (XI998_xan XI998_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI999_MP12 (VDD B_19_b3_0 XI999_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI999_MP18 (XI999_xp1 XI999_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI999_MP20 (pp9_1 B_19_b3_0 XI999_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI999_MP19 (XI999_xp1 XI999_xan pp9_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI999_MP17 (VDD XI999_xn XI999_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI999_MP6 (XI999_p1 A_1_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI999_MP8 (XI999_xn A_0_b3_3 XI999_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI999_MP7 (XI999_p1 two9_b3_0 XI999_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI999_MP5 (VDD one9_b3_0 XI999_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI999_MP10 (XI999_xan XI999_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI893_MP12 (VDD B_15_b3_1 XI893_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI893_MP18 (XI893_xp1 XI893_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI893_MP20 (pp7_5 B_15_b3_1 XI893_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI893_MP19 (XI893_xp1 XI893_xan pp7_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI893_MP17 (VDD XI893_xn XI893_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI893_MP6 (XI893_p1 A_5_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI893_MP8 (XI893_xn A_4_b3_2 XI893_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI893_MP7 (XI893_p1 two7_b3_0 XI893_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI893_MP5 (VDD one7_b3_0 XI893_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI893_MP10 (XI893_xan XI893_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI840_MP12 (VDD B_13_b3_1 XI840_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI840_MP18 (XI840_xp1 XI840_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI840_MP20 (pp6_7 B_13_b3_1 XI840_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI840_MP19 (XI840_xp1 XI840_xan pp6_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI840_MP17 (VDD XI840_xn XI840_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI840_MP6 (XI840_p1 A_7_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI840_MP8 (XI840_xn A_6_b3_2 XI840_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI840_MP7 (XI840_p1 two6_b3_1 XI840_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI840_MP5 (VDD one6_b3_1 XI840_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI840_MP10 (XI840_xan XI840_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI839_MP12 (VDD B_13_b3_1 XI839_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI839_MP18 (XI839_xp1 XI839_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI839_MP20 (pp6_6 B_13_b3_1 XI839_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI839_MP19 (XI839_xp1 XI839_xan pp6_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI839_MP17 (VDD XI839_xn XI839_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI839_MP6 (XI839_p1 A_6_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI839_MP8 (XI839_xn A_5_b3_2 XI839_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI839_MP7 (XI839_p1 two6_b3_1 XI839_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI839_MP5 (VDD one6_b3_1 XI839_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI839_MP10 (XI839_xan XI839_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI788_MP12 (VDD B_11_b3_1 XI788_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI788_MP18 (XI788_xp1 XI788_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI788_MP20 (pp5_10 B_11_b3_1 XI788_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI788_MP19 (XI788_xp1 XI788_xan pp5_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI788_MP17 (VDD XI788_xn XI788_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI788_MP6 (XI788_p1 A_10_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI788_MP8 (XI788_xn A_9_b3_2 XI788_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI788_MP7 (XI788_p1 two5_b3_1 XI788_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI788_MP5 (VDD one5_b3_1 XI788_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI788_MP10 (XI788_xan XI788_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI574_MP12 (VDD B_3_b3_2 XI574_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI574_MP18 (XI574_xp1 XI574_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI574_MP20 (pp1_16 B_3_b3_2 XI574_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI574_MP19 (XI574_xp1 XI574_xan pp1_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI574_MP17 (VDD XI574_xn XI574_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI574_MP6 (XI574_p1 A_16_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI574_MP8 (XI574_xn A_15_b3_0 XI574_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI574_MP7 (XI574_p1 two1_b3_2 XI574_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI574_MP5 (VDD one1_b3_2 XI574_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI574_MP10 (XI574_xan XI574_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI628_MP12 (VDD B_5_b3_2 XI628_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI628_MP18 (XI628_xp1 XI628_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI628_MP20 (pp2_15 B_5_b3_2 XI628_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI628_MP19 (XI628_xp1 XI628_xan pp2_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI628_MP17 (VDD XI628_xn XI628_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI628_MP6 (XI628_p1 A_15_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI628_MP8 (XI628_xn A_14_b3_0 XI628_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI628_MP7 (XI628_p1 two2_b3_2 XI628_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI628_MP5 (VDD one2_b3_2 XI628_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI628_MP10 (XI628_xan XI628_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI626_MP12 (VDD B_5_b3_2 XI626_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI626_MP18 (XI626_xp1 XI626_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI626_MP20 (pp2_13 B_5_b3_2 XI626_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI626_MP19 (XI626_xp1 XI626_xan pp2_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI626_MP17 (VDD XI626_xn XI626_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI626_MP6 (XI626_p1 A_13_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI626_MP8 (XI626_xn A_12_b3_0 XI626_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI626_MP7 (XI626_p1 two2_b3_2 XI626_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI626_MP5 (VDD one2_b3_2 XI626_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI626_MP10 (XI626_xan XI626_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI629_MP12 (VDD B_5_b3_2 XI629_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI629_MP18 (XI629_xp1 XI629_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI629_MP20 (pp2_16 B_5_b3_2 XI629_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI629_MP19 (XI629_xp1 XI629_xan pp2_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI629_MP17 (VDD XI629_xn XI629_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI629_MP6 (XI629_p1 A_16_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI629_MP8 (XI629_xn A_15_b3_0 XI629_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI629_MP7 (XI629_p1 two2_b3_2 XI629_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI629_MP5 (VDD one2_b3_2 XI629_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI629_MP10 (XI629_xan XI629_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI944_MP12 (VDD B_17_b3_0 XI944_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI944_MP18 (XI944_xp1 XI944_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI944_MP20 (pp8_1 B_17_b3_0 XI944_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI944_MP19 (XI944_xp1 XI944_xan pp8_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI944_MP17 (VDD XI944_xn XI944_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI944_MP6 (XI944_p1 A_1_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI944_MP8 (XI944_xn A_0_b3_3 XI944_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI944_MP7 (XI944_p1 two8_b3_0 XI944_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI944_MP5 (VDD one8_b3_0 XI944_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI944_MP10 (XI944_xan XI944_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI945_MP12 (VDD B_17_b3_0 XI945_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI945_MP18 (XI945_xp1 XI945_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI945_MP20 (pp8_2 B_17_b3_0 XI945_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI945_MP19 (XI945_xp1 XI945_xan pp8_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI945_MP17 (VDD XI945_xn XI945_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI945_MP6 (XI945_p1 A_2_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI945_MP8 (XI945_xn A_1_b3_3 XI945_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI945_MP7 (XI945_p1 two8_b3_0 XI945_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI945_MP5 (VDD one8_b3_0 XI945_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI945_MP10 (XI945_xan XI945_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI787_MP12 (VDD B_11_b3_1 XI787_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI787_MP18 (XI787_xp1 XI787_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI787_MP20 (pp5_9 B_11_b3_1 XI787_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI787_MP19 (XI787_xp1 XI787_xan pp5_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI787_MP17 (VDD XI787_xn XI787_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI787_MP6 (XI787_p1 A_9_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI787_MP8 (XI787_xn A_8_b3_2 XI787_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI787_MP7 (XI787_p1 two5_b3_1 XI787_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI787_MP5 (VDD one5_b3_1 XI787_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI787_MP10 (XI787_xan XI787_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI573_MP12 (VDD B_3_b3_2 XI573_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI573_MP18 (XI573_xp1 XI573_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI573_MP20 (pp1_15 B_3_b3_2 XI573_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI573_MP19 (XI573_xp1 XI573_xan pp1_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI573_MP17 (VDD XI573_xn XI573_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI573_MP6 (XI573_p1 A_15_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI573_MP8 (XI573_xn A_14_b3_0 XI573_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI573_MP7 (XI573_p1 two1_b3_2 XI573_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI573_MP5 (VDD one1_b3_2 XI573_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI573_MP10 (XI573_xan XI573_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI625_MP12 (VDD B_5_b3_2 XI625_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI625_MP18 (XI625_xp1 XI625_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI625_MP20 (pp2_12 B_5_b3_2 XI625_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI625_MP19 (XI625_xp1 XI625_xan pp2_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI625_MP17 (VDD XI625_xn XI625_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI625_MP6 (XI625_p1 A_12_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI625_MP8 (XI625_xn A_11_b3_0 XI625_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI625_MP7 (XI625_p1 two2_b3_2 XI625_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI625_MP5 (VDD one2_b3_2 XI625_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI625_MP10 (XI625_xan XI625_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI627_MP12 (VDD B_5_b3_2 XI627_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI627_MP18 (XI627_xp1 XI627_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI627_MP20 (pp2_14 B_5_b3_2 XI627_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI627_MP19 (XI627_xp1 XI627_xan pp2_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI627_MP17 (VDD XI627_xn XI627_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI627_MP6 (XI627_p1 A_14_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI627_MP8 (XI627_xn A_13_b3_0 XI627_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI627_MP7 (XI627_p1 two2_b3_2 XI627_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI627_MP5 (VDD one2_b3_2 XI627_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI627_MP10 (XI627_xan XI627_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI624_MP12 (VDD B_5_b3_2 XI624_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI624_MP18 (XI624_xp1 XI624_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI624_MP20 (pp2_11 B_5_b3_2 XI624_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI624_MP19 (XI624_xp1 XI624_xan pp2_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI624_MP17 (VDD XI624_xn XI624_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI624_MP6 (XI624_p1 A_11_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI624_MP8 (XI624_xn A_10_b3_0 XI624_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI624_MP7 (XI624_p1 two2_b3_2 XI624_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI624_MP5 (VDD one2_b3_2 XI624_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI624_MP10 (XI624_xan XI624_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI943_MP12 (VDD B_17_b3_0 XI943_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI943_MP18 (XI943_xp1 XI943_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI943_MP20 (pp8_0 B_17_b3_0 XI943_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI943_MP19 (XI943_xp1 XI943_xan pp8_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI943_MP17 (VDD XI943_xn XI943_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI943_MP6 (XI943_p1 A_0_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI943_MP8 (XI943_xn VSS XI943_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI943_MP7 (XI943_p1 two8_b3_0 XI943_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI943_MP5 (VDD one8_b3_0 XI943_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI943_MP10 (XI943_xan XI943_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI838_MP12 (VDD B_13_b3_1 XI838_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI838_MP18 (XI838_xp1 XI838_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI838_MP20 (pp6_5 B_13_b3_1 XI838_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI838_MP19 (XI838_xp1 XI838_xan pp6_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI838_MP17 (VDD XI838_xn XI838_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI838_MP6 (XI838_p1 A_5_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI838_MP8 (XI838_xn A_4_b3_2 XI838_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI838_MP7 (XI838_p1 two6_b3_0 XI838_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI838_MP5 (VDD one6_b3_0 XI838_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI838_MP10 (XI838_xan XI838_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI786_MP12 (VDD B_11_b3_1 XI786_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI786_MP18 (XI786_xp1 XI786_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI786_MP20 (pp5_8 B_11_b3_1 XI786_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI786_MP19 (XI786_xp1 XI786_xan pp5_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI786_MP17 (VDD XI786_xn XI786_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI786_MP6 (XI786_p1 A_8_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI786_MP8 (XI786_xn A_7_b3_2 XI786_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI786_MP7 (XI786_p1 two5_b3_1 XI786_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI786_MP5 (VDD one5_b3_1 XI786_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI786_MP10 (XI786_xan XI786_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI518_MP12 (VDD B_1_b3_2 XI518_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI518_MP18 (XI518_xp1 XI518_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI518_MP20 (pp0_15 B_1_b3_2 XI518_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI518_MP19 (XI518_xp1 XI518_xan pp0_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI518_MP17 (VDD XI518_xn XI518_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI518_MP6 (XI518_p1 A_15_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI518_MP8 (XI518_xn A_14_b3_0 XI518_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI518_MP7 (XI518_p1 two0_b3_2 XI518_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI518_MP5 (VDD one0_b3_2 XI518_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI518_MP10 (XI518_xan XI518_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI519_MP12 (VDD B_1_b3_2 XI519_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI519_MP18 (XI519_xp1 XI519_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI519_MP20 (pp0_16 B_1_b3_2 XI519_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI519_MP19 (XI519_xp1 XI519_xan pp0_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI519_MP17 (VDD XI519_xn XI519_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI519_MP6 (XI519_p1 A_16_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI519_MP8 (XI519_xn A_15_b3_0 XI519_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI519_MP7 (XI519_p1 two0_b3_2 XI519_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI519_MP5 (VDD one0_b3_2 XI519_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI519_MP10 (XI519_xan XI519_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI892_MP12 (VDD B_15_b3_0 XI892_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI892_MP18 (XI892_xp1 XI892_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI892_MP20 (pp7_4 B_15_b3_0 XI892_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI892_MP19 (XI892_xp1 XI892_xan pp7_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI892_MP17 (VDD XI892_xn XI892_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI892_MP6 (XI892_p1 A_4_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI892_MP8 (XI892_xn A_3_b3_2 XI892_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI892_MP7 (XI892_p1 two7_b3_0 XI892_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI892_MP5 (VDD one7_b3_0 XI892_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI892_MP10 (XI892_xan XI892_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI837_MP12 (VDD B_13_b3_0 XI837_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI837_MP18 (XI837_xp1 XI837_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI837_MP20 (pp6_4 B_13_b3_0 XI837_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI837_MP19 (XI837_xp1 XI837_xan pp6_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI837_MP17 (VDD XI837_xn XI837_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI837_MP6 (XI837_p1 A_4_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI837_MP8 (XI837_xn A_3_b3_2 XI837_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI837_MP7 (XI837_p1 two6_b3_0 XI837_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI837_MP5 (VDD one6_b3_0 XI837_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI837_MP10 (XI837_xan XI837_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI784_MP12 (VDD B_11_b3_1 XI784_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI784_MP18 (XI784_xp1 XI784_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI784_MP20 (pp5_6 B_11_b3_1 XI784_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI784_MP19 (XI784_xp1 XI784_xan pp5_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI784_MP17 (VDD XI784_xn XI784_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI784_MP6 (XI784_p1 A_6_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI784_MP8 (XI784_xn A_5_b3_2 XI784_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI784_MP7 (XI784_p1 two5_b3_1 XI784_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI784_MP5 (VDD one5_b3_1 XI784_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI784_MP10 (XI784_xan XI784_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI785_MP12 (VDD B_11_b3_1 XI785_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI785_MP18 (XI785_xp1 XI785_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI785_MP20 (pp5_7 B_11_b3_1 XI785_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI785_MP19 (XI785_xp1 XI785_xan pp5_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI785_MP17 (VDD XI785_xn XI785_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI785_MP6 (XI785_p1 A_7_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI785_MP8 (XI785_xn A_6_b3_2 XI785_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI785_MP7 (XI785_p1 two5_b3_1 XI785_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI785_MP5 (VDD one5_b3_1 XI785_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI785_MP10 (XI785_xan XI785_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI732_MP12 (VDD B_9_b3_1 XI732_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI732_MP18 (XI732_xp1 XI732_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI732_MP20 (pp4_9 B_9_b3_1 XI732_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI732_MP19 (XI732_xp1 XI732_xan pp4_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI732_MP17 (VDD XI732_xn XI732_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI732_MP6 (XI732_p1 A_9_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI732_MP8 (XI732_xn A_8_b3_1 XI732_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI732_MP7 (XI732_p1 two4_b3_1 XI732_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI732_MP5 (VDD one4_b3_1 XI732_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI732_MP10 (XI732_xan XI732_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI733_MP12 (VDD B_9_b3_1 XI733_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI733_MP18 (XI733_xp1 XI733_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI733_MP20 (pp4_10 B_9_b3_1 XI733_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI733_MP19 (XI733_xp1 XI733_xan pp4_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI733_MP17 (VDD XI733_xn XI733_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI733_MP6 (XI733_p1 A_10_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI733_MP8 (XI733_xn A_9_b3_1 XI733_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI733_MP7 (XI733_p1 two4_b3_1 XI733_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI733_MP5 (VDD one4_b3_1 XI733_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI733_MP10 (XI733_xan XI733_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI677_MP12 (VDD B_7_b3_1 XI677_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI677_MP18 (XI677_xp1 XI677_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI677_MP20 (pp3_9 B_7_b3_1 XI677_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI677_MP19 (XI677_xp1 XI677_xan pp3_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI677_MP17 (VDD XI677_xn XI677_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI677_MP6 (XI677_p1 A_9_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI677_MP8 (XI677_xn A_8_b3_1 XI677_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI677_MP7 (XI677_p1 two3_b3_1 XI677_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI677_MP5 (VDD one3_b3_1 XI677_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI677_MP10 (XI677_xan XI677_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI678_MP12 (VDD B_7_b3_1 XI678_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI678_MP18 (XI678_xp1 XI678_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI678_MP20 (pp3_10 B_7_b3_1 XI678_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI678_MP19 (XI678_xp1 XI678_xan pp3_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI678_MP17 (VDD XI678_xn XI678_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI678_MP6 (XI678_p1 A_10_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI678_MP8 (XI678_xn A_9_b3_1 XI678_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI678_MP7 (XI678_p1 two3_b3_1 XI678_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI678_MP5 (VDD one3_b3_1 XI678_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI678_MP10 (XI678_xan XI678_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI572_MP12 (VDD B_3_b3_2 XI572_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI572_MP18 (XI572_xp1 XI572_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI572_MP20 (pp1_14 B_3_b3_2 XI572_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI572_MP19 (XI572_xp1 XI572_xan pp1_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI572_MP17 (VDD XI572_xn XI572_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI572_MP6 (XI572_p1 A_14_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI572_MP8 (XI572_xn A_13_b3_0 XI572_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI572_MP7 (XI572_p1 two1_b3_2 XI572_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI572_MP5 (VDD one1_b3_2 XI572_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI572_MP10 (XI572_xan XI572_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI571_MP12 (VDD B_3_b3_2 XI571_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI571_MP18 (XI571_xp1 XI571_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI571_MP20 (pp1_13 B_3_b3_2 XI571_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI571_MP19 (XI571_xp1 XI571_xan pp1_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI571_MP17 (VDD XI571_xn XI571_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI571_MP6 (XI571_p1 A_13_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI571_MP8 (XI571_xn A_12_b3_0 XI571_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI571_MP7 (XI571_p1 two1_b3_2 XI571_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI571_MP5 (VDD one1_b3_2 XI571_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI571_MP10 (XI571_xan XI571_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI517_MP12 (VDD B_1_b3_2 XI517_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI517_MP18 (XI517_xp1 XI517_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI517_MP20 (pp0_14 B_1_b3_2 XI517_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI517_MP19 (XI517_xp1 XI517_xan pp0_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI517_MP17 (VDD XI517_xn XI517_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI517_MP6 (XI517_p1 A_14_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI517_MP8 (XI517_xn A_13_b3_0 XI517_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI517_MP7 (XI517_p1 two0_b3_2 XI517_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI517_MP5 (VDD one0_b3_2 XI517_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI517_MP10 (XI517_xan XI517_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI516_MP12 (VDD B_1_b3_2 XI516_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI516_MP18 (XI516_xp1 XI516_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI516_MP20 (pp0_13 B_1_b3_2 XI516_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI516_MP19 (XI516_xp1 XI516_xan pp0_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI516_MP17 (VDD XI516_xn XI516_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI516_MP6 (XI516_p1 A_13_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI516_MP8 (XI516_xn A_12_b3_0 XI516_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI516_MP7 (XI516_p1 two0_b3_2 XI516_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI516_MP5 (VDD one0_b3_2 XI516_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI516_MP10 (XI516_xan XI516_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI570_MP12 (VDD B_3_b3_2 XI570_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI570_MP18 (XI570_xp1 XI570_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI570_MP20 (pp1_12 B_3_b3_2 XI570_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI570_MP19 (XI570_xp1 XI570_xan pp1_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI570_MP17 (VDD XI570_xn XI570_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI570_MP6 (XI570_p1 A_12_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI570_MP8 (XI570_xn A_11_b3_0 XI570_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI570_MP7 (XI570_p1 two1_b3_2 XI570_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI570_MP5 (VDD one1_b3_2 XI570_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI570_MP10 (XI570_xan XI570_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI514_MP12 (VDD B_1_b3_2 XI514_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI514_MP18 (XI514_xp1 XI514_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI514_MP20 (pp0_11 B_1_b3_2 XI514_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI514_MP19 (XI514_xp1 XI514_xan pp0_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI514_MP17 (VDD XI514_xn XI514_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI514_MP6 (XI514_p1 A_11_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI514_MP8 (XI514_xn A_10_b3_0 XI514_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI514_MP7 (XI514_p1 two0_b3_2 XI514_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI514_MP5 (VDD one0_b3_2 XI514_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI514_MP10 (XI514_xan XI514_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI891_MP12 (VDD B_15_b3_0 XI891_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI891_MP18 (XI891_xp1 XI891_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI891_MP20 (pp7_3 B_15_b3_0 XI891_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI891_MP19 (XI891_xp1 XI891_xan pp7_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI891_MP17 (VDD XI891_xn XI891_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI891_MP6 (XI891_p1 A_3_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI891_MP8 (XI891_xn A_2_b3_2 XI891_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI891_MP7 (XI891_p1 two7_b3_0 XI891_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI891_MP5 (VDD one7_b3_0 XI891_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI891_MP10 (XI891_xan XI891_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI890_MP12 (VDD B_15_b3_0 XI890_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI890_MP18 (XI890_xp1 XI890_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI890_MP20 (pp7_2 B_15_b3_0 XI890_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI890_MP19 (XI890_xp1 XI890_xan pp7_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI890_MP17 (VDD XI890_xn XI890_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI890_MP6 (XI890_p1 A_2_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI890_MP8 (XI890_xn A_1_b3_2 XI890_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI890_MP7 (XI890_p1 two7_b3_0 XI890_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI890_MP5 (VDD one7_b3_0 XI890_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI890_MP10 (XI890_xan XI890_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI731_MP12 (VDD B_9_b3_1 XI731_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI731_MP18 (XI731_xp1 XI731_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI731_MP20 (pp4_8 B_9_b3_1 XI731_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI731_MP19 (XI731_xp1 XI731_xan pp4_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI731_MP17 (VDD XI731_xn XI731_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI731_MP6 (XI731_p1 A_8_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI731_MP8 (XI731_xn A_7_b3_1 XI731_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI731_MP7 (XI731_p1 two4_b3_1 XI731_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI731_MP5 (VDD one4_b3_1 XI731_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI731_MP10 (XI731_xan XI731_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI676_MP12 (VDD B_7_b3_1 XI676_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI676_MP18 (XI676_xp1 XI676_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI676_MP20 (pp3_8 B_7_b3_1 XI676_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI676_MP19 (XI676_xp1 XI676_xan pp3_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI676_MP17 (VDD XI676_xn XI676_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI676_MP6 (XI676_p1 A_8_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI676_MP8 (XI676_xn A_7_b3_1 XI676_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI676_MP7 (XI676_p1 two3_b3_1 XI676_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI676_MP5 (VDD one3_b3_1 XI676_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI676_MP10 (XI676_xan XI676_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI515_MP12 (VDD B_1_b3_2 XI515_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI515_MP18 (XI515_xp1 XI515_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI515_MP20 (pp0_12 B_1_b3_2 XI515_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI515_MP19 (XI515_xp1 XI515_xan pp0_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI515_MP17 (VDD XI515_xn XI515_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI515_MP6 (XI515_p1 A_12_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI515_MP8 (XI515_xn A_11_b3_0 XI515_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI515_MP7 (XI515_p1 two0_b3_2 XI515_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI515_MP5 (VDD one0_b3_2 XI515_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI515_MP10 (XI515_xan XI515_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI569_MP12 (VDD B_3_b3_2 XI569_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI569_MP18 (XI569_xp1 XI569_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI569_MP20 (pp1_11 B_3_b3_2 XI569_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI569_MP19 (XI569_xp1 XI569_xan pp1_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI569_MP17 (VDD XI569_xn XI569_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI569_MP6 (XI569_p1 A_11_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI569_MP8 (XI569_xn A_10_b3_0 XI569_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI569_MP7 (XI569_p1 two1_b3_2 XI569_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI569_MP5 (VDD one1_b3_2 XI569_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI569_MP10 (XI569_xan XI569_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI503_MP12 (VDD B_1_b3_0 XI503_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI503_MP18 (XI503_xp1 XI503_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI503_MP20 (pp0_0 B_1_b3_0 XI503_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI503_MP19 (XI503_xp1 XI503_xan pp0_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI503_MP17 (VDD XI503_xn XI503_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI503_MP6 (XI503_p1 A_0_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI503_MP8 (XI503_xn VSS XI503_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI503_MP7 (XI503_p1 two0_b3_0 XI503_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI503_MP5 (VDD one0_b3_0 XI503_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI503_MP10 (XI503_xan XI503_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI889_MP12 (VDD B_15_b3_0 XI889_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI889_MP18 (XI889_xp1 XI889_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI889_MP20 (pp7_1 B_15_b3_0 XI889_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI889_MP19 (XI889_xp1 XI889_xan pp7_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI889_MP17 (VDD XI889_xn XI889_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI889_MP6 (XI889_p1 A_1_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI889_MP8 (XI889_xn A_0_b3_2 XI889_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI889_MP7 (XI889_p1 two7_b3_0 XI889_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI889_MP5 (VDD one7_b3_0 XI889_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI889_MP10 (XI889_xan XI889_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI783_MP12 (VDD B_11_b3_1 XI783_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI783_MP18 (XI783_xp1 XI783_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI783_MP20 (pp5_5 B_11_b3_1 XI783_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI783_MP19 (XI783_xp1 XI783_xan pp5_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI783_MP17 (VDD XI783_xn XI783_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI783_MP6 (XI783_p1 A_5_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI783_MP8 (XI783_xn A_4_b3_2 XI783_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI783_MP7 (XI783_p1 two5_b3_0 XI783_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI783_MP5 (VDD one5_b3_0 XI783_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI783_MP10 (XI783_xan XI783_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI729_MP12 (VDD B_9_b3_1 XI729_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI729_MP18 (XI729_xp1 XI729_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI729_MP20 (pp4_6 B_9_b3_1 XI729_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI729_MP19 (XI729_xp1 XI729_xan pp4_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI729_MP17 (VDD XI729_xn XI729_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI729_MP6 (XI729_p1 A_6_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI729_MP8 (XI729_xn A_5_b3_1 XI729_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI729_MP7 (XI729_p1 two4_b3_1 XI729_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI729_MP5 (VDD one4_b3_1 XI729_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI729_MP10 (XI729_xan XI729_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI730_MP12 (VDD B_9_b3_1 XI730_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI730_MP18 (XI730_xp1 XI730_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI730_MP20 (pp4_7 B_9_b3_1 XI730_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI730_MP19 (XI730_xp1 XI730_xan pp4_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI730_MP17 (VDD XI730_xn XI730_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI730_MP6 (XI730_p1 A_7_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI730_MP8 (XI730_xn A_6_b3_1 XI730_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI730_MP7 (XI730_p1 two4_b3_1 XI730_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI730_MP5 (VDD one4_b3_1 XI730_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI730_MP10 (XI730_xan XI730_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI675_MP12 (VDD B_7_b3_1 XI675_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI675_MP18 (XI675_xp1 XI675_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI675_MP20 (pp3_7 B_7_b3_1 XI675_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI675_MP19 (XI675_xp1 XI675_xan pp3_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI675_MP17 (VDD XI675_xn XI675_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI675_MP6 (XI675_p1 A_7_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI675_MP8 (XI675_xn A_6_b3_1 XI675_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI675_MP7 (XI675_p1 two3_b3_1 XI675_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI675_MP5 (VDD one3_b3_1 XI675_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI675_MP10 (XI675_xan XI675_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI622_MP12 (VDD B_5_b3_1 XI622_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI622_MP18 (XI622_xp1 XI622_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI622_MP20 (pp2_9 B_5_b3_1 XI622_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI622_MP19 (XI622_xp1 XI622_xan pp2_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI622_MP17 (VDD XI622_xn XI622_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI622_MP6 (XI622_p1 A_9_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI622_MP8 (XI622_xn A_8_b3_0 XI622_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI622_MP7 (XI622_p1 two2_b3_1 XI622_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI622_MP5 (VDD one2_b3_1 XI622_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI622_MP10 (XI622_xan XI622_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI623_MP12 (VDD B_5_b3_1 XI623_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI623_MP18 (XI623_xp1 XI623_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI623_MP20 (pp2_10 B_5_b3_1 XI623_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI623_MP19 (XI623_xp1 XI623_xan pp2_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI623_MP17 (VDD XI623_xn XI623_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI623_MP6 (XI623_p1 A_10_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI623_MP8 (XI623_xn A_9_b3_0 XI623_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI623_MP7 (XI623_p1 two2_b3_1 XI623_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI623_MP5 (VDD one2_b3_1 XI623_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI623_MP10 (XI623_xan XI623_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI505_MP12 (VDD B_1_b3_0 XI505_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI505_MP18 (XI505_xp1 XI505_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI505_MP20 (pp0_2 B_1_b3_0 XI505_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI505_MP19 (XI505_xp1 XI505_xan pp0_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI505_MP17 (VDD XI505_xn XI505_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI505_MP6 (XI505_p1 A_2_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI505_MP8 (XI505_xn A_1_b3_0 XI505_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI505_MP7 (XI505_p1 two0_b3_0 XI505_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI505_MP5 (VDD one0_b3_0 XI505_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI505_MP10 (XI505_xan XI505_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI504_MP12 (VDD B_1_b3_0 XI504_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI504_MP18 (XI504_xp1 XI504_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI504_MP20 (pp0_1 B_1_b3_0 XI504_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI504_MP19 (XI504_xp1 XI504_xan pp0_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI504_MP17 (VDD XI504_xn XI504_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI504_MP6 (XI504_p1 A_1_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI504_MP8 (XI504_xn A_0_b3_0 XI504_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI504_MP7 (XI504_p1 two0_b3_0 XI504_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI504_MP5 (VDD one0_b3_0 XI504_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI504_MP10 (XI504_xan XI504_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI558_MP12 (VDD B_3_b3_0 XI558_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI558_MP18 (XI558_xp1 XI558_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI558_MP20 (pp1_0 B_3_b3_0 XI558_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI558_MP19 (XI558_xp1 XI558_xan pp1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI558_MP17 (VDD XI558_xn XI558_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI558_MP6 (XI558_p1 A_0_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI558_MP8 (XI558_xn VSS XI558_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI558_MP7 (XI558_p1 two1_b3_0 XI558_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI558_MP5 (VDD one1_b3_0 XI558_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI558_MP10 (XI558_xan XI558_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI559_MP12 (VDD B_3_b3_0 XI559_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI559_MP18 (XI559_xp1 XI559_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI559_MP20 (pp1_1 B_3_b3_0 XI559_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI559_MP19 (XI559_xp1 XI559_xan pp1_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI559_MP17 (VDD XI559_xn XI559_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI559_MP6 (XI559_p1 A_1_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI559_MP8 (XI559_xn A_0_b3_0 XI559_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI559_MP7 (XI559_p1 two1_b3_0 XI559_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI559_MP5 (VDD one1_b3_0 XI559_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI559_MP10 (XI559_xan XI559_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI888_MP12 (VDD B_15_b3_0 XI888_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI888_MP18 (XI888_xp1 XI888_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI888_MP20 (pp7_0 B_15_b3_0 XI888_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI888_MP19 (XI888_xp1 XI888_xan pp7_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI888_MP17 (VDD XI888_xn XI888_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI888_MP6 (XI888_p1 A_0_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI888_MP8 (XI888_xn VSS XI888_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI888_MP7 (XI888_p1 two7_b3_0 XI888_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI888_MP5 (VDD one7_b3_0 XI888_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI888_MP10 (XI888_xan XI888_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI836_MP12 (VDD B_13_b3_0 XI836_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI836_MP18 (XI836_xp1 XI836_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI836_MP20 (pp6_3 B_13_b3_0 XI836_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI836_MP19 (XI836_xp1 XI836_xan pp6_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI836_MP17 (VDD XI836_xn XI836_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI836_MP6 (XI836_p1 A_3_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI836_MP8 (XI836_xn A_2_b3_2 XI836_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI836_MP7 (XI836_p1 two6_b3_0 XI836_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI836_MP5 (VDD one6_b3_0 XI836_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI836_MP10 (XI836_xan XI836_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI674_MP12 (VDD B_7_b3_1 XI674_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI674_MP18 (XI674_xp1 XI674_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI674_MP20 (pp3_6 B_7_b3_1 XI674_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI674_MP19 (XI674_xp1 XI674_xan pp3_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI674_MP17 (VDD XI674_xn XI674_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI674_MP6 (XI674_p1 A_6_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI674_MP8 (XI674_xn A_5_b3_1 XI674_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI674_MP7 (XI674_p1 two3_b3_1 XI674_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI674_MP5 (VDD one3_b3_1 XI674_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI674_MP10 (XI674_xan XI674_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI621_MP12 (VDD B_5_b3_1 XI621_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI621_MP18 (XI621_xp1 XI621_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI621_MP20 (pp2_8 B_5_b3_1 XI621_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI621_MP19 (XI621_xp1 XI621_xan pp2_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI621_MP17 (VDD XI621_xn XI621_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI621_MP6 (XI621_p1 A_8_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI621_MP8 (XI621_xn A_7_b3_0 XI621_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI621_MP7 (XI621_p1 two2_b3_1 XI621_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI621_MP5 (VDD one2_b3_1 XI621_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI621_MP10 (XI621_xan XI621_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI619_MP12 (VDD B_5_b3_1 XI619_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI619_MP18 (XI619_xp1 XI619_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI619_MP20 (pp2_6 B_5_b3_1 XI619_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI619_MP19 (XI619_xp1 XI619_xan pp2_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI619_MP17 (VDD XI619_xn XI619_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI619_MP6 (XI619_p1 A_6_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI619_MP8 (XI619_xn A_5_b3_0 XI619_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI619_MP7 (XI619_p1 two2_b3_1 XI619_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI619_MP5 (VDD one2_b3_1 XI619_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI619_MP10 (XI619_xan XI619_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI620_MP12 (VDD B_5_b3_1 XI620_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI620_MP18 (XI620_xp1 XI620_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI620_MP20 (pp2_7 B_5_b3_1 XI620_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI620_MP19 (XI620_xp1 XI620_xan pp2_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI620_MP17 (VDD XI620_xn XI620_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI620_MP6 (XI620_p1 A_7_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI620_MP8 (XI620_xn A_6_b3_0 XI620_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI620_MP7 (XI620_p1 two2_b3_1 XI620_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI620_MP5 (VDD one2_b3_1 XI620_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI620_MP10 (XI620_xan XI620_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI618_MP12 (VDD B_5_b3_1 XI618_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI618_MP18 (XI618_xp1 XI618_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI618_MP20 (pp2_5 B_5_b3_1 XI618_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI618_MP19 (XI618_xp1 XI618_xan pp2_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI618_MP17 (VDD XI618_xn XI618_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI618_MP6 (XI618_p1 A_5_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI618_MP8 (XI618_xn A_4_b3_0 XI618_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI618_MP7 (XI618_p1 two2_b3_0 XI618_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI618_MP5 (VDD one2_b3_0 XI618_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI618_MP10 (XI618_xan XI618_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI508_MP12 (VDD B_1_b3_1 XI508_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI508_MP18 (XI508_xp1 XI508_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI508_MP20 (pp0_5 B_1_b3_1 XI508_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI508_MP19 (XI508_xp1 XI508_xan pp0_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI508_MP17 (VDD XI508_xn XI508_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI508_MP6 (XI508_p1 A_5_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI508_MP8 (XI508_xn A_4_b3_0 XI508_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI508_MP7 (XI508_p1 two0_b3_0 XI508_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI508_MP5 (VDD one0_b3_0 XI508_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI508_MP10 (XI508_xan XI508_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI562_MP12 (VDD B_3_b3_0 XI562_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI562_MP18 (XI562_xp1 XI562_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI562_MP20 (pp1_4 B_3_b3_0 XI562_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI562_MP19 (XI562_xp1 XI562_xan pp1_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI562_MP17 (VDD XI562_xn XI562_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI562_MP6 (XI562_p1 A_4_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI562_MP8 (XI562_xn A_3_b3_0 XI562_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI562_MP7 (XI562_p1 two1_b3_0 XI562_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI562_MP5 (VDD one1_b3_0 XI562_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI562_MP10 (XI562_xan XI562_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI507_MP12 (VDD B_1_b3_0 XI507_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI507_MP18 (XI507_xp1 XI507_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI507_MP20 (pp0_4 B_1_b3_0 XI507_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI507_MP19 (XI507_xp1 XI507_xan pp0_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI507_MP17 (VDD XI507_xn XI507_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI507_MP6 (XI507_p1 A_4_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI507_MP8 (XI507_xn A_3_b3_0 XI507_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI507_MP7 (XI507_p1 two0_b3_0 XI507_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI507_MP5 (VDD one0_b3_0 XI507_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI507_MP10 (XI507_xan XI507_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI506_MP12 (VDD B_1_b3_0 XI506_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI506_MP18 (XI506_xp1 XI506_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI506_MP20 (pp0_3 B_1_b3_0 XI506_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI506_MP19 (XI506_xp1 XI506_xan pp0_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI506_MP17 (VDD XI506_xn XI506_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI506_MP6 (XI506_p1 A_3_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI506_MP8 (XI506_xn A_2_b3_0 XI506_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI506_MP7 (XI506_p1 two0_b3_0 XI506_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI506_MP5 (VDD one0_b3_0 XI506_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI506_MP10 (XI506_xan XI506_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI561_MP12 (VDD B_3_b3_0 XI561_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI561_MP18 (XI561_xp1 XI561_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI561_MP20 (pp1_3 B_3_b3_0 XI561_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI561_MP19 (XI561_xp1 XI561_xan pp1_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI561_MP17 (VDD XI561_xn XI561_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI561_MP6 (XI561_p1 A_3_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI561_MP8 (XI561_xn A_2_b3_0 XI561_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI561_MP7 (XI561_p1 two1_b3_0 XI561_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI561_MP5 (VDD one1_b3_0 XI561_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI561_MP10 (XI561_xan XI561_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI834_MP12 (VDD B_13_b3_0 XI834_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI834_MP18 (XI834_xp1 XI834_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI834_MP20 (pp6_1 B_13_b3_0 XI834_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI834_MP19 (XI834_xp1 XI834_xan pp6_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI834_MP17 (VDD XI834_xn XI834_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI834_MP6 (XI834_p1 A_1_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI834_MP8 (XI834_xn A_0_b3_2 XI834_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI834_MP7 (XI834_p1 two6_b3_0 XI834_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI834_MP5 (VDD one6_b3_0 XI834_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI834_MP10 (XI834_xan XI834_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI835_MP12 (VDD B_13_b3_0 XI835_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI835_MP18 (XI835_xp1 XI835_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI835_MP20 (pp6_2 B_13_b3_0 XI835_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI835_MP19 (XI835_xp1 XI835_xan pp6_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI835_MP17 (VDD XI835_xn XI835_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI835_MP6 (XI835_p1 A_2_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI835_MP8 (XI835_xn A_1_b3_2 XI835_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI835_MP7 (XI835_p1 two6_b3_0 XI835_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI835_MP5 (VDD one6_b3_0 XI835_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI835_MP10 (XI835_xan XI835_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI781_MP12 (VDD B_11_b3_0 XI781_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI781_MP18 (XI781_xp1 XI781_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI781_MP20 (pp5_3 B_11_b3_0 XI781_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI781_MP19 (XI781_xp1 XI781_xan pp5_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI781_MP17 (VDD XI781_xn XI781_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI781_MP6 (XI781_p1 A_3_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI781_MP8 (XI781_xn A_2_b3_2 XI781_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI781_MP7 (XI781_p1 two5_b3_0 XI781_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI781_MP5 (VDD one5_b3_0 XI781_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI781_MP10 (XI781_xan XI781_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI782_MP12 (VDD B_11_b3_0 XI782_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI782_MP18 (XI782_xp1 XI782_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI782_MP20 (pp5_4 B_11_b3_0 XI782_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI782_MP19 (XI782_xp1 XI782_xan pp5_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI782_MP17 (VDD XI782_xn XI782_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI782_MP6 (XI782_p1 A_4_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI782_MP8 (XI782_xn A_3_b3_2 XI782_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI782_MP7 (XI782_p1 two5_b3_0 XI782_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI782_MP5 (VDD one5_b3_0 XI782_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI782_MP10 (XI782_xan XI782_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI728_MP12 (VDD B_9_b3_1 XI728_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI728_MP18 (XI728_xp1 XI728_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI728_MP20 (pp4_5 B_9_b3_1 XI728_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI728_MP19 (XI728_xp1 XI728_xan pp4_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI728_MP17 (VDD XI728_xn XI728_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI728_MP6 (XI728_p1 A_5_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI728_MP8 (XI728_xn A_4_b3_1 XI728_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI728_MP7 (XI728_p1 two4_b3_0 XI728_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI728_MP5 (VDD one4_b3_0 XI728_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI728_MP10 (XI728_xan XI728_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI672_MP12 (VDD B_7_b3_0 XI672_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI672_MP18 (XI672_xp1 XI672_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI672_MP20 (pp3_4 B_7_b3_0 XI672_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI672_MP19 (XI672_xp1 XI672_xan pp3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI672_MP17 (VDD XI672_xn XI672_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI672_MP6 (XI672_p1 A_4_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI672_MP8 (XI672_xn A_3_b3_1 XI672_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI672_MP7 (XI672_p1 two3_b3_0 XI672_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI672_MP5 (VDD one3_b3_0 XI672_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI672_MP10 (XI672_xan XI672_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI673_MP12 (VDD B_7_b3_1 XI673_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI673_MP18 (XI673_xp1 XI673_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI673_MP20 (pp3_5 B_7_b3_1 XI673_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI673_MP19 (XI673_xp1 XI673_xan pp3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI673_MP17 (VDD XI673_xn XI673_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI673_MP6 (XI673_p1 A_5_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI673_MP8 (XI673_xn A_4_b3_1 XI673_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI673_MP7 (XI673_p1 two3_b3_0 XI673_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI673_MP5 (VDD one3_b3_0 XI673_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI673_MP10 (XI673_xan XI673_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI567_MP12 (VDD B_3_b3_1 XI567_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI567_MP18 (XI567_xp1 XI567_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI567_MP20 (pp1_9 B_3_b3_1 XI567_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI567_MP19 (XI567_xp1 XI567_xan pp1_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI567_MP17 (VDD XI567_xn XI567_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI567_MP6 (XI567_p1 A_9_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI567_MP8 (XI567_xn A_8_b3_0 XI567_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI567_MP7 (XI567_p1 two1_b3_1 XI567_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI567_MP5 (VDD one1_b3_1 XI567_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI567_MP10 (XI567_xan XI567_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI568_MP12 (VDD B_3_b3_1 XI568_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI568_MP18 (XI568_xp1 XI568_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI568_MP20 (pp1_10 B_3_b3_1 XI568_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI568_MP19 (XI568_xp1 XI568_xan pp1_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI568_MP17 (VDD XI568_xn XI568_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI568_MP6 (XI568_p1 A_10_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI568_MP8 (XI568_xn A_9_b3_0 XI568_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI568_MP7 (XI568_p1 two1_b3_1 XI568_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI568_MP5 (VDD one1_b3_1 XI568_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI568_MP10 (XI568_xan XI568_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI513_MP12 (VDD B_1_b3_1 XI513_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI513_MP18 (XI513_xp1 XI513_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI513_MP20 (pp0_10 B_1_b3_1 XI513_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI513_MP19 (XI513_xp1 XI513_xan pp0_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI513_MP17 (VDD XI513_xn XI513_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI513_MP6 (XI513_p1 A_10_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI513_MP8 (XI513_xn A_9_b3_0 XI513_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI513_MP7 (XI513_p1 two0_b3_1 XI513_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI513_MP5 (VDD one0_b3_1 XI513_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI513_MP10 (XI513_xan XI513_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI564_MP12 (VDD B_3_b3_1 XI564_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI564_MP18 (XI564_xp1 XI564_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI564_MP20 (pp1_6 B_3_b3_1 XI564_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI564_MP19 (XI564_xp1 XI564_xan pp1_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI564_MP17 (VDD XI564_xn XI564_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI564_MP6 (XI564_p1 A_6_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI564_MP8 (XI564_xn A_5_b3_0 XI564_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI564_MP7 (XI564_p1 two1_b3_1 XI564_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI564_MP5 (VDD one1_b3_1 XI564_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI564_MP10 (XI564_xan XI564_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI563_MP12 (VDD B_3_b3_1 XI563_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI563_MP18 (XI563_xp1 XI563_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI563_MP20 (pp1_5 B_3_b3_1 XI563_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI563_MP19 (XI563_xp1 XI563_xan pp1_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI563_MP17 (VDD XI563_xn XI563_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI563_MP6 (XI563_p1 A_5_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI563_MP8 (XI563_xn A_4_b3_0 XI563_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI563_MP7 (XI563_p1 two1_b3_0 XI563_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI563_MP5 (VDD one1_b3_0 XI563_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI563_MP10 (XI563_xan XI563_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI509_MP12 (VDD B_1_b3_1 XI509_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI509_MP18 (XI509_xp1 XI509_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI509_MP20 (pp0_6 B_1_b3_1 XI509_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI509_MP19 (XI509_xp1 XI509_xan pp0_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI509_MP17 (VDD XI509_xn XI509_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI509_MP6 (XI509_p1 A_6_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI509_MP8 (XI509_xn A_5_b3_0 XI509_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI509_MP7 (XI509_p1 two0_b3_1 XI509_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI509_MP5 (VDD one0_b3_1 XI509_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI509_MP10 (XI509_xan XI509_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI510_MP12 (VDD B_1_b3_1 XI510_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI510_MP18 (XI510_xp1 XI510_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI510_MP20 (pp0_7 B_1_b3_1 XI510_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI510_MP19 (XI510_xp1 XI510_xan pp0_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI510_MP17 (VDD XI510_xn XI510_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI510_MP6 (XI510_p1 A_7_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI510_MP8 (XI510_xn A_6_b3_0 XI510_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI510_MP7 (XI510_p1 two0_b3_1 XI510_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI510_MP5 (VDD one0_b3_1 XI510_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI510_MP10 (XI510_xan XI510_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI617_MP12 (VDD B_5_b3_0 XI617_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI617_MP18 (XI617_xp1 XI617_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI617_MP20 (pp2_4 B_5_b3_0 XI617_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI617_MP19 (XI617_xp1 XI617_xan pp2_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI617_MP17 (VDD XI617_xn XI617_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI617_MP6 (XI617_p1 A_4_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI617_MP8 (XI617_xn A_3_b3_0 XI617_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI617_MP7 (XI617_p1 two2_b3_0 XI617_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI617_MP5 (VDD one2_b3_0 XI617_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI617_MP10 (XI617_xan XI617_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI616_MP12 (VDD B_5_b3_0 XI616_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI616_MP18 (XI616_xp1 XI616_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI616_MP20 (pp2_3 B_5_b3_0 XI616_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI616_MP19 (XI616_xp1 XI616_xan pp2_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI616_MP17 (VDD XI616_xn XI616_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI616_MP6 (XI616_p1 A_3_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI616_MP8 (XI616_xn A_2_b3_0 XI616_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI616_MP7 (XI616_p1 two2_b3_0 XI616_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI616_MP5 (VDD one2_b3_0 XI616_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI616_MP10 (XI616_xan XI616_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI615_MP12 (VDD B_5_b3_0 XI615_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI615_MP18 (XI615_xp1 XI615_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI615_MP20 (pp2_2 B_5_b3_0 XI615_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI615_MP19 (XI615_xp1 XI615_xan pp2_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI615_MP17 (VDD XI615_xn XI615_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI615_MP6 (XI615_p1 A_2_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI615_MP8 (XI615_xn A_1_b3_0 XI615_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI615_MP7 (XI615_p1 two2_b3_0 XI615_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI615_MP5 (VDD one2_b3_0 XI615_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI615_MP10 (XI615_xan XI615_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI613_MP12 (VDD B_5_b3_0 XI613_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI613_MP18 (XI613_xp1 XI613_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI613_MP20 (pp2_0 B_5_b3_0 XI613_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI613_MP19 (XI613_xp1 XI613_xan pp2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI613_MP17 (VDD XI613_xn XI613_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI613_MP6 (XI613_p1 A_0_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI613_MP8 (XI613_xn VSS XI613_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI613_MP7 (XI613_p1 two2_b3_0 XI613_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI613_MP5 (VDD one2_b3_0 XI613_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI613_MP10 (XI613_xan XI613_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI614_MP12 (VDD B_5_b3_0 XI614_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI614_MP18 (XI614_xp1 XI614_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI614_MP20 (pp2_1 B_5_b3_0 XI614_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI614_MP19 (XI614_xp1 XI614_xan pp2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI614_MP17 (VDD XI614_xn XI614_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI614_MP6 (XI614_p1 A_1_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI614_MP8 (XI614_xn A_0_b3_0 XI614_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI614_MP7 (XI614_p1 two2_b3_0 XI614_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI614_MP5 (VDD one2_b3_0 XI614_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI614_MP10 (XI614_xan XI614_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI560_MP12 (VDD B_3_b3_0 XI560_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI560_MP18 (XI560_xp1 XI560_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI560_MP20 (pp1_2 B_3_b3_0 XI560_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI560_MP19 (XI560_xp1 XI560_xan pp1_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI560_MP17 (VDD XI560_xn XI560_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI560_MP6 (XI560_p1 A_2_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI560_MP8 (XI560_xn A_1_b3_0 XI560_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI560_MP7 (XI560_p1 two1_b3_0 XI560_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI560_MP5 (VDD one1_b3_0 XI560_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI560_MP10 (XI560_xan XI560_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI833_MP12 (VDD B_13_b3_0 XI833_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI833_MP18 (XI833_xp1 XI833_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI833_MP20 (pp6_0 B_13_b3_0 XI833_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI833_MP19 (XI833_xp1 XI833_xan pp6_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI833_MP17 (VDD XI833_xn XI833_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI833_MP6 (XI833_p1 A_0_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI833_MP8 (XI833_xn VSS XI833_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI833_MP7 (XI833_p1 two6_b3_0 XI833_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI833_MP5 (VDD one6_b3_0 XI833_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI833_MP10 (XI833_xan XI833_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI780_MP12 (VDD B_11_b3_0 XI780_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI780_MP18 (XI780_xp1 XI780_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI780_MP20 (pp5_2 B_11_b3_0 XI780_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI780_MP19 (XI780_xp1 XI780_xan pp5_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI780_MP17 (VDD XI780_xn XI780_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI780_MP6 (XI780_p1 A_2_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI780_MP8 (XI780_xn A_1_b3_2 XI780_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI780_MP7 (XI780_p1 two5_b3_0 XI780_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI780_MP5 (VDD one5_b3_0 XI780_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI780_MP10 (XI780_xan XI780_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI727_MP12 (VDD B_9_b3_0 XI727_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI727_MP18 (XI727_xp1 XI727_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI727_MP20 (pp4_4 B_9_b3_0 XI727_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI727_MP19 (XI727_xp1 XI727_xan pp4_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI727_MP17 (VDD XI727_xn XI727_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI727_MP6 (XI727_p1 A_4_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI727_MP8 (XI727_xn A_3_b3_1 XI727_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI727_MP7 (XI727_p1 two4_b3_0 XI727_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI727_MP5 (VDD one4_b3_0 XI727_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI727_MP10 (XI727_xan XI727_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI726_MP12 (VDD B_9_b3_0 XI726_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI726_MP18 (XI726_xp1 XI726_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI726_MP20 (pp4_3 B_9_b3_0 XI726_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI726_MP19 (XI726_xp1 XI726_xan pp4_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI726_MP17 (VDD XI726_xn XI726_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI726_MP6 (XI726_p1 A_3_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI726_MP8 (XI726_xn A_2_b3_1 XI726_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI726_MP7 (XI726_p1 two4_b3_0 XI726_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI726_MP5 (VDD one4_b3_0 XI726_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI726_MP10 (XI726_xan XI726_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI669_MP12 (VDD B_7_b3_0 XI669_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI669_MP18 (XI669_xp1 XI669_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI669_MP20 (pp3_1 B_7_b3_0 XI669_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI669_MP19 (XI669_xp1 XI669_xan pp3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI669_MP17 (VDD XI669_xn XI669_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI669_MP6 (XI669_p1 A_1_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI669_MP8 (XI669_xn A_0_b3_1 XI669_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI669_MP7 (XI669_p1 two3_b3_0 XI669_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI669_MP5 (VDD one3_b3_0 XI669_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI669_MP10 (XI669_xan XI669_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI668_MP12 (VDD B_7_b3_0 XI668_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI668_MP18 (XI668_xp1 XI668_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI668_MP20 (pp3_0 B_7_b3_0 XI668_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI668_MP19 (XI668_xp1 XI668_xan pp3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI668_MP17 (VDD XI668_xn XI668_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI668_MP6 (XI668_p1 A_0_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI668_MP8 (XI668_xn VSS XI668_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI668_MP7 (XI668_p1 two3_b3_0 XI668_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI668_MP5 (VDD one3_b3_0 XI668_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI668_MP10 (XI668_xan XI668_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI566_MP12 (VDD B_3_b3_1 XI566_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI566_MP18 (XI566_xp1 XI566_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI566_MP20 (pp1_8 B_3_b3_1 XI566_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI566_MP19 (XI566_xp1 XI566_xan pp1_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI566_MP17 (VDD XI566_xn XI566_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI566_MP6 (XI566_p1 A_8_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI566_MP8 (XI566_xn A_7_b3_0 XI566_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI566_MP7 (XI566_p1 two1_b3_1 XI566_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI566_MP5 (VDD one1_b3_1 XI566_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI566_MP10 (XI566_xan XI566_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI512_MP12 (VDD B_1_b3_1 XI512_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI512_MP18 (XI512_xp1 XI512_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI512_MP20 (pp0_9 B_1_b3_1 XI512_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI512_MP19 (XI512_xp1 XI512_xan pp0_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI512_MP17 (VDD XI512_xn XI512_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI512_MP6 (XI512_p1 A_9_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI512_MP8 (XI512_xn A_8_b3_0 XI512_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI512_MP7 (XI512_p1 two0_b3_1 XI512_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI512_MP5 (VDD one0_b3_1 XI512_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI512_MP10 (XI512_xan XI512_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI565_MP12 (VDD B_3_b3_1 XI565_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI565_MP18 (XI565_xp1 XI565_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI565_MP20 (pp1_7 B_3_b3_1 XI565_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI565_MP19 (XI565_xp1 XI565_xan pp1_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI565_MP17 (VDD XI565_xn XI565_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI565_MP6 (XI565_p1 A_7_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI565_MP8 (XI565_xn A_6_b3_0 XI565_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI565_MP7 (XI565_p1 two1_b3_1 XI565_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI565_MP5 (VDD one1_b3_1 XI565_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI565_MP10 (XI565_xan XI565_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI511_MP12 (VDD B_1_b3_1 XI511_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI511_MP18 (XI511_xp1 XI511_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI511_MP20 (pp0_8 B_1_b3_1 XI511_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI511_MP19 (XI511_xp1 XI511_xan pp0_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI511_MP17 (VDD XI511_xn XI511_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI511_MP6 (XI511_p1 A_8_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI511_MP8 (XI511_xn A_7_b3_0 XI511_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI511_MP7 (XI511_p1 two0_b3_1 XI511_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI511_MP5 (VDD one0_b3_1 XI511_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI511_MP10 (XI511_xan XI511_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI778_MP12 (VDD B_11_b3_0 XI778_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI778_MP18 (XI778_xp1 XI778_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI778_MP20 (pp5_0 B_11_b3_0 XI778_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI778_MP19 (XI778_xp1 XI778_xan pp5_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI778_MP17 (VDD XI778_xn XI778_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI778_MP6 (XI778_p1 A_0_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI778_MP8 (XI778_xn VSS XI778_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI778_MP7 (XI778_p1 two5_b3_0 XI778_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI778_MP5 (VDD one5_b3_0 XI778_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI778_MP10 (XI778_xan XI778_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI779_MP12 (VDD B_11_b3_0 XI779_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI779_MP18 (XI779_xp1 XI779_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI779_MP20 (pp5_1 B_11_b3_0 XI779_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI779_MP19 (XI779_xp1 XI779_xan pp5_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI779_MP17 (VDD XI779_xn XI779_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI779_MP6 (XI779_p1 A_1_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI779_MP8 (XI779_xn A_0_b3_2 XI779_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI779_MP7 (XI779_p1 two5_b3_0 XI779_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI779_MP5 (VDD one5_b3_0 XI779_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI779_MP10 (XI779_xan XI779_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI725_MP12 (VDD B_9_b3_0 XI725_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI725_MP18 (XI725_xp1 XI725_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI725_MP20 (pp4_2 B_9_b3_0 XI725_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI725_MP19 (XI725_xp1 XI725_xan pp4_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI725_MP17 (VDD XI725_xn XI725_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI725_MP6 (XI725_p1 A_2_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI725_MP8 (XI725_xn A_1_b3_1 XI725_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI725_MP7 (XI725_p1 two4_b3_0 XI725_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI725_MP5 (VDD one4_b3_0 XI725_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI725_MP10 (XI725_xan XI725_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI724_MP12 (VDD B_9_b3_0 XI724_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI724_MP18 (XI724_xp1 XI724_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI724_MP20 (pp4_1 B_9_b3_0 XI724_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI724_MP19 (XI724_xp1 XI724_xan pp4_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI724_MP17 (VDD XI724_xn XI724_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI724_MP6 (XI724_p1 A_1_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI724_MP8 (XI724_xn A_0_b3_1 XI724_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI724_MP7 (XI724_p1 two4_b3_0 XI724_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI724_MP5 (VDD one4_b3_0 XI724_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI724_MP10 (XI724_xan XI724_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI723_MP12 (VDD B_9_b3_0 XI723_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI723_MP18 (XI723_xp1 XI723_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI723_MP20 (pp4_0 B_9_b3_0 XI723_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI723_MP19 (XI723_xp1 XI723_xan pp4_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI723_MP17 (VDD XI723_xn XI723_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI723_MP6 (XI723_p1 A_0_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI723_MP8 (XI723_xn VSS XI723_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI723_MP7 (XI723_p1 two4_b3_0 XI723_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI723_MP5 (VDD one4_b3_0 XI723_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI723_MP10 (XI723_xan XI723_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI670_MP12 (VDD B_7_b3_0 XI670_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI670_MP18 (XI670_xp1 XI670_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI670_MP20 (pp3_2 B_7_b3_0 XI670_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI670_MP19 (XI670_xp1 XI670_xan pp3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI670_MP17 (VDD XI670_xn XI670_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI670_MP6 (XI670_p1 A_2_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI670_MP8 (XI670_xn A_1_b3_1 XI670_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI670_MP7 (XI670_p1 two3_b3_0 XI670_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI670_MP5 (VDD one3_b3_0 XI670_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI670_MP10 (XI670_xan XI670_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI671_MP12 (VDD B_7_b3_0 XI671_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI671_MP18 (XI671_xp1 XI671_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI671_MP20 (pp3_3 B_7_b3_0 XI671_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI671_MP19 (XI671_xp1 XI671_xan pp3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI671_MP17 (VDD XI671_xn XI671_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI671_MP6 (XI671_p1 A_3_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI671_MP8 (XI671_xn A_2_b3_1 XI671_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI671_MP7 (XI671_p1 two3_b3_0 XI671_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI671_MP5 (VDD one3_b3_0 XI671_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI671_MP10 (XI671_xan XI671_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I55_MP1 (I1660_gn55 fa245_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I55_MP0 (VDD fa296_1 I1660_gn55 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I38_MP1 (I1660_gn38 ha282_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I38_MP0 (VDD fa281_1 I1660_gn38 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I40_MP1 (I1660_gn40 ha284_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I40_MP0 (VDD fa283_1 I1660_gn40 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I43_MP1 (I1660_gn43 fa287_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I43_MP0 (VDD ha286_1 I1660_gn43 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I46_MP1 (I1660_gn46 ha290_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I46_MP0 (VDD fa289_1 I1660_gn46 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I57_MP1 (I1660_gn57 fa246_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I57_MP0 (VDD fa297_1 I1660_gn57 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I39_MP1 (I1660_gn39 fa283_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I39_MP0 (VDD ha282_1 I1660_gn39 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I41_MP1 (I1660_gn41 fa285_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I41_MP0 (VDD ha284_1 I1660_gn41 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I42_MP1 (I1660_gn42 ha286_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I42_MP0 (VDD fa285_1 I1660_gn42 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I44_MP1 (I1660_gn44 ha288_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I44_MP0 (VDD fa287_1 I1660_gn44 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I45_MP1 (I1660_gn45 fa289_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I45_MP0 (VDD ha288_1 I1660_gn45 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I47_MP1 (I1660_gn47 fa291_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I47_MP0 (VDD ha290_1 I1660_gn47 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I53_MP1 (I1660_gn53 fa244_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I53_MP0 (VDD fa295_1 I1660_gn53 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I54_MP1 (I1660_gn54 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I54_MP0 (VDD fa296_0 I1660_gn54 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I36_MP1 (I1660_gn36 fa280_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I36_MP0 (VDD ha279_1 I1660_gn36 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I37_MP1 (I1660_gn37 fa281_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I37_MP0 (VDD fa280_1 I1660_gn37 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I48_MP1 (I1660_gn48 ha292_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I48_MP0 (VDD fa291_1 I1660_gn48 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I49_MP1 (I1660_gn49 fa293_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I49_MP0 (VDD ha292_1 I1660_gn49 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I51_MP1 (I1660_gn51 fa243_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I51_MP0 (VDD ha294_1 I1660_gn51 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I59_MP1 (I1660_gn59 fa207_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I59_MP0 (VDD fa298_1 I1660_gn59 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I52_MP1 (I1660_gn52 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I52_MP0 (VDD fa295_0 I1660_gn52 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I35_MP1 (I1660_gn35 ha279_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I35_MP0 (VDD ha278_1 I1660_gn35 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I50_MP1 (I1660_gn50 ha294_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I50_MP0 (VDD fa293_1 I1660_gn50 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I61_MP1 (I1660_gn61 fa208_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I61_MP0 (VDD fa247_1 I1660_gn61 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I58_MP1 (I1660_gn58 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I58_MP0 (VDD fa298_0 I1660_gn58 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I56_MP1 (I1660_gn56 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I56_MP0 (VDD fa297_0 I1660_gn56 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I34_MP1 (I1660_gn34 ha278_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I34_MP0 (VDD ha277_1 I1660_gn34 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I232_XP_MP1 (I1660_P40_37n I1660_P38_37 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I232_XP_MP0 (VDD I1660_P40_39 I1660_P40_37n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I234_XP_MP1 (I1660_P42_39n I1660_P40_39 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I234_XP_MP0 (VDD I1660_P42_41 I1660_P42_39n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I236_XP_MP1 (I1660_P44_41n I1660_P42_41 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I236_XP_MP0 (VDD I1660_P44_43 I1660_P44_41n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I238_XP_MP1 (I1660_P46_43n I1660_P44_43 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I238_XP_MP0 (VDD I1660_P46_45 I1660_P46_43n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I240_XP_MP1 (I1660_P48_45n I1660_P46_45 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I240_XP_MP0 (VDD I1660_P48_47 I1660_P48_45n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I242_XP_MP1 (I1660_P50_47n I1660_P48_47 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I242_XP_MP0 (VDD I1660_P50_49 I1660_P50_47n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I244_XP_MP1 (I1660_P52_49n I1660_P50_49 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I244_XP_MP0 (VDD I1660_P52_51 I1660_P52_49n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I60_MP1 (I1660_gn60 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I60_MP0 (VDD fa247_0 I1660_gn60 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I32_MP1 (I1660_gn32 ha276_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I32_MP0 (VDD ha275_1 I1660_gn32 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I33_MP1 (I1660_gn33 ha277_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I33_MP0 (VDD ha276_1 I1660_gn33 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I371_XP_MP1 (I1660_P60_45n I1660_P52_45 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I371_XP_MP0 (VDD I1660_P60_53 I1660_P60_45n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I246_XP_MP1 (I1660_P54_51n I1660_P52_51 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I246_XP_MP0 (VDD I1660_P54_53 I1660_P54_51n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I252_XP_MP1 (I1660_P60_57n I1660_P58_57 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I252_XP_MP0 (VDD I1660_P60_59 I1660_P60_57n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I248_XP_MP1 (I1660_P56_53n I1660_P54_53 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I248_XP_MP0 (VDD I1660_P56_55 I1660_P56_53n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I31_MP1 (I1660_gn31 ha275_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I31_MP0 (VDD ha274_1 I1660_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I230_XP_MP1 (I1660_P38_35n I1660_P36_35 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I230_XP_MP0 (VDD I1660_P38_37 I1660_P38_35n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I363_XP_MP1 (I1660_P52_37n I1660_P44_37 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I363_XP_MP0 (VDD I1660_P52_45 I1660_P52_37n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I367_XP_MP1 (I1660_P56_41n I1660_P48_41 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I367_XP_MP0 (VDD I1660_P56_49 I1660_P56_41n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I250_XP_MP1 (I1660_P58_55n I1660_P56_55 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I250_XP_MP0 (VDD I1660_P58_57 I1660_P58_55n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I254_XP_MP1 (I1660_P62_59n I1660_P60_59 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I254_XP_MP0 (VDD I1660_P62_61 I1660_P62_59n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I62_MP1 (I1660_gn62 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I62_MP0 (VDD fa248_0 I1660_gn62 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I63_MP1 (I1660_gn63 sn15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I63_MP0 (VDD fa248_1 I1660_gn63 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I228_XP_MP1 (I1660_P36_33n I1660_P34_33 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I228_XP_MP0 (VDD I1660_P36_35 I1660_P36_33n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I355_XP_MP1 (I1660_P44_29n I1660_P36_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I355_XP_MP0 (VDD I1660_P44_37 I1660_P44_29n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I373_XP_MP1 (I1660_P62_47n I1660_P54_47 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I373_XP_MP0 (VDD I1660_P62_55 I1660_P62_47n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I255_XP_MP1 (I1660_P63_60n I1660_P61_60 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I255_XP_MP0 (VDD I1660_P63_62 I1660_P63_60n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I30_MP1 (I1660_gn30 ha274_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I30_MP0 (VDD ha273_1 I1660_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I226_XP_MP1 (I1660_P34_31n I1660_P32_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I226_XP_MP0 (VDD I1660_P34_33 I1660_P34_31n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I359_XP_MP1 (I1660_P48_33n I1660_P40_33 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I359_XP_MP0 (VDD I1660_P48_41 I1660_P48_33n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I361_XP_MP1 (I1660_P50_35n I1660_P42_35 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I361_XP_MP0 (VDD I1660_P50_43 I1660_P50_35n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I357_XP_MP1 (I1660_P46_31n I1660_P38_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I357_XP_MP0 (VDD I1660_P46_39 I1660_P46_31n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I365_XP_MP1 (I1660_P54_39n I1660_P46_39 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I365_XP_MP0 (VDD I1660_P54_47 I1660_P54_39n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I369_XP_MP1 (I1660_P58_43n I1660_P50_43 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I369_XP_MP0 (VDD I1660_P58_51 I1660_P58_43n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I253_XP_MP1 (I1660_P61_58n I1660_P59_58 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I253_XP_MP0 (VDD I1660_P61_60 I1660_P61_58n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I29_MP1 (I1660_gn29 ha273_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I29_MP0 (VDD ha272_1 I1660_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I224_XP_MP1 (I1660_P32_29n I1660_P30_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I224_XP_MP0 (VDD I1660_P32_31 I1660_P32_29n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I239_XP_MP1 (I1660_P47_44n I1660_P45_44 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I239_XP_MP0 (VDD I1660_P47_46 I1660_P47_44n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I241_XP_MP1 (I1660_P49_46n I1660_P47_46 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I241_XP_MP0 (VDD I1660_P49_48 I1660_P49_46n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I243_XP_MP1 (I1660_P51_48n I1660_P49_48 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I243_XP_MP0 (VDD I1660_P51_50 I1660_P51_48n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I245_XP_MP1 (I1660_P53_50n I1660_P51_50 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I245_XP_MP0 (VDD I1660_P53_52 I1660_P53_50n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I247_XP_MP1 (I1660_P55_52n I1660_P53_52 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I247_XP_MP0 (VDD I1660_P55_54 I1660_P55_52n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I28_MP1 (I1660_gn28 ha272_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I28_MP0 (VDD ha271_1 I1660_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I222_XP_MP1 (I1660_P30_27n I1660_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I222_XP_MP0 (VDD I1660_P30_29 I1660_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I351_XP_MP1 (I1660_P40_25n I1660_P32_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I351_XP_MP0 (VDD I1660_P40_33 I1660_P40_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I353_XP_MP1 (I1660_P42_27n I1660_P34_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I353_XP_MP0 (VDD I1660_P42_35 I1660_P42_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I349_XP_MP1 (I1660_P38_23n I1660_P30_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I349_XP_MP0 (VDD I1660_P38_31 I1660_P38_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I237_XP_MP1 (I1660_P45_42n I1660_P43_42 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I237_XP_MP0 (VDD I1660_P45_44 I1660_P45_42n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I249_XP_MP1 (I1660_P57_54n I1660_P55_54 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I249_XP_MP0 (VDD I1660_P57_56 I1660_P57_54n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I251_XP_MP1 (I1660_P59_56n I1660_P57_56 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I251_XP_MP0 (VDD I1660_P59_58 I1660_P59_56n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I26_MP1 (I1660_gn26 ha270_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I26_MP0 (VDD ha269_1 I1660_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I27_MP1 (I1660_gn27 ha271_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I27_MP0 (VDD ha270_1 I1660_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I347_XP_MP1 (I1660_P36_21n I1660_P28_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I347_XP_MP0 (VDD I1660_P36_29 I1660_P36_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I341_XP_MP1 (I1660_P30_15n I1660_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I341_XP_MP0 (VDD I1660_P30_23 I1660_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I372_XP_MP1 (I1660_P61_46n I1660_P53_46 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I372_XP_MP0 (VDD I1660_P61_54 I1660_P61_46n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I25_MP1 (I1660_gn25 ha269_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I25_MP0 (VDD ha268_1 I1660_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I220_XP_MP1 (I1660_P28_25n I1660_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I220_XP_MP0 (VDD I1660_P28_27 I1660_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I339_XP_MP1 (I1660_P28_13n I1660_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I339_XP_MP0 (VDD I1660_P28_21 I1660_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I345_XP_MP1 (I1660_P34_19n I1660_P26_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I345_XP_MP0 (VDD I1660_P34_27 I1660_P34_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I235_XP_MP1 (I1660_P43_40n I1660_P41_40 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I235_XP_MP0 (VDD I1660_P43_42 I1660_P43_40n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I233_XP_MP1 (I1660_P41_38n I1660_P39_38 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I233_XP_MP0 (VDD I1660_P41_40 I1660_P41_38n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I364_XP_MP1 (I1660_P53_38n I1660_P45_38 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I364_XP_MP0 (VDD I1660_P53_46 I1660_P53_38n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I24_MP1 (I1660_gn24 ha268_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I24_MP0 (VDD ha267_1 I1660_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I23_MP1 (I1660_gn23 ha267_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I23_MP0 (VDD ha266_1 I1660_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I218_XP_MP1 (I1660_P26_23n I1660_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I218_XP_MP0 (VDD I1660_P26_25 I1660_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I343_XP_MP1 (I1660_P32_17n I1660_P24_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I343_XP_MP0 (VDD I1660_P32_25 I1660_P32_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I337_XP_MP1 (I1660_P26_11n I1660_P18_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I337_XP_MP0 (VDD I1660_P26_19 I1660_P26_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I231_XP_MP1 (I1660_P39_36n I1660_P37_36 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I231_XP_MP0 (VDD I1660_P39_38 I1660_P39_36n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I356_XP_MP1 (I1660_P45_30n I1660_P37_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I356_XP_MP0 (VDD I1660_P45_38 I1660_P45_30n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I368_XP_MP1 (I1660_P57_42n I1660_P49_42 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I368_XP_MP0 (VDD I1660_P57_50 I1660_P57_42n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I370_XP_MP1 (I1660_P59_44n I1660_P51_44 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I370_XP_MP0 (VDD I1660_P59_52 I1660_P59_44n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I374_XP_MP1 (I1660_P63_48n I1660_P55_48 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I374_XP_MP0 (VDD I1660_P63_56 I1660_P63_48n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I22_MP1 (I1660_gn22 ha266_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I22_MP0 (VDD ha265_1 I1660_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I216_XP_MP1 (I1660_P24_21n I1660_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I216_XP_MP0 (VDD I1660_P24_23 I1660_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I335_XP_MP1 (I1660_P24_9n I1660_P16_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I335_XP_MP0 (VDD I1660_P24_17 I1660_P24_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I227_XP_MP1 (I1660_P35_32n I1660_P33_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I227_XP_MP0 (VDD I1660_P35_34 I1660_P35_32n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I229_XP_MP1 (I1660_P37_34n I1660_P35_34 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I229_XP_MP0 (VDD I1660_P37_36 I1660_P37_34n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I366_XP_MP1 (I1660_P55_40n I1660_P47_40 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I366_XP_MP0 (VDD I1660_P55_48 I1660_P55_40n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I21_MP1 (I1660_gn21 ha265_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I21_MP0 (VDD ha264_1 I1660_gn21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I214_XP_MP1 (I1660_P22_19n I1660_P20_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I214_XP_MP0 (VDD I1660_P22_21 I1660_P22_19n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I333_XP_MP1 (I1660_P22_7n I1660_P14_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I333_XP_MP0 (VDD I1660_P22_15 I1660_P22_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I223_XP_MP1 (I1660_P31_28n I1660_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I223_XP_MP0 (VDD I1660_P31_30 I1660_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I225_XP_MP1 (I1660_P33_30n I1660_P31_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I225_XP_MP0 (VDD I1660_P33_32 I1660_P33_30n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I352_XP_MP1 (I1660_P41_26n I1660_P33_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I352_XP_MP0 (VDD I1660_P41_34 I1660_P41_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I360_XP_MP1 (I1660_P49_34n I1660_P41_34 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I360_XP_MP0 (VDD I1660_P49_42 I1660_P49_34n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I362_XP_MP1 (I1660_P51_36n I1660_P43_36 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I362_XP_MP0 (VDD I1660_P51_44 I1660_P51_36n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I358_XP_MP1 (I1660_P47_32n I1660_P39_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I358_XP_MP0 (VDD I1660_P47_40 I1660_P47_32n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I20_MP1 (I1660_gn20 ha264_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I20_MP0 (VDD ha263_1 I1660_gn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I19_MP1 (I1660_gn19 ha263_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I19_MP0 (VDD ha262_1 I1660_gn19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I331_XP_MP1 (I1660_P20_5n I1660_P12_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I331_XP_MP0 (VDD I1660_P20_13 I1660_P20_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I219_XP_MP1 (I1660_P27_24n I1660_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I219_XP_MP0 (VDD I1660_P27_26 I1660_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I221_XP_MP1 (I1660_P29_26n I1660_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I221_XP_MP0 (VDD I1660_P29_28 I1660_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I354_XP_MP1 (I1660_P43_28n I1660_P35_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I354_XP_MP0 (VDD I1660_P43_36 I1660_P43_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I18_MP1 (I1660_gn18 ha262_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I18_MP0 (VDD ha261_1 I1660_gn18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I212_XP_MP1 (I1660_P20_17n I1660_P18_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I212_XP_MP0 (VDD I1660_P20_19 I1660_P20_17n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I217_XP_MP1 (I1660_P25_22n I1660_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I217_XP_MP0 (VDD I1660_P25_24 I1660_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I215_XP_MP1 (I1660_P23_20n I1660_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I215_XP_MP0 (VDD I1660_P23_22 I1660_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I348_XP_MP1 (I1660_P37_22n I1660_P29_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I348_XP_MP0 (VDD I1660_P37_30 I1660_P37_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I350_XP_MP1 (I1660_P39_24n I1660_P31_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I350_XP_MP0 (VDD I1660_P39_32 I1660_P39_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I342_XP_MP1 (I1660_P31_16n I1660_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I342_XP_MP0 (VDD I1660_P31_24 I1660_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I0_MP1 (I1660_gn0 B_1_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I0_MP0 (VDD pp0_0 I1660_gn0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I17_MP1 (I1660_gn17 ha261_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I17_MP0 (VDD ha260_1 I1660_gn17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I210_XP_MP1 (I1660_P18_15n I1660_P16_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I210_XP_MP0 (VDD I1660_P18_17 I1660_P18_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I327_XP_MP1 (I1660_P16_1n I1660_P8_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I327_XP_MP0 (VDD I1660_P16_9 I1660_P16_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I329_XP_MP1 (I1660_P18_3n I1660_P10_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I329_XP_MP0 (VDD I1660_P18_11 I1660_P18_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I213_XP_MP1 (I1660_P21_18n I1660_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I213_XP_MP0 (VDD I1660_P21_20 I1660_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I340_XP_MP1 (I1660_P29_14n I1660_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I340_XP_MP0 (VDD I1660_P29_22 I1660_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I16_MP1 (I1660_gn16 ha260_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I16_MP0 (VDD ha259_1 I1660_gn16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I208_XP_MP1 (I1660_P16_13n I1660_P14_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I208_XP_MP0 (VDD I1660_P16_15 I1660_P16_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I211_XP_MP1 (I1660_P19_16n I1660_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I211_XP_MP0 (VDD I1660_P19_18 I1660_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I344_XP_MP1 (I1660_P33_18n I1660_P25_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I344_XP_MP0 (VDD I1660_P33_26 I1660_P33_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I336_XP_MP1 (I1660_P25_10n I1660_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I336_XP_MP0 (VDD I1660_P25_18 I1660_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I346_XP_MP1 (I1660_P35_20n I1660_P27_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I346_XP_MP0 (VDD I1660_P35_28 I1660_P35_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I338_XP_MP1 (I1660_P27_12n I1660_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I338_XP_MP0 (VDD I1660_P27_20 I1660_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I15_MP1 (I1660_gn15 ha259_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I15_MP0 (VDD ha258_1 I1660_gn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I202_XP_MP1 (I1660_P10_7n I1660_P8_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I202_XP_MP0 (VDD I1660_P10_9 I1660_P10_7n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I200_XP_MP1 (I1660_P8_5n I1660_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I200_XP_MP0 (VDD I1660_P8_7 I1660_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I196_XP_MP1 (I1660_P4_1n I1660_P2_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I196_XP_MP0 (VDD I1660_P4_3 I1660_P4_1n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I198_XP_MP1 (I1660_P6_3n I1660_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I198_XP_MP0 (VDD I1660_P6_5 I1660_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I209_XP_MP1 (I1660_P17_14n I1660_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I209_XP_MP0 (VDD I1660_P17_16 I1660_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I332_XP_MP1 (I1660_P21_6n I1660_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I332_XP_MP0 (VDD I1660_P21_14 I1660_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I334_XP_MP1 (I1660_P23_8n I1660_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I334_XP_MP0 (VDD I1660_P23_16 I1660_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I14_MP1 (I1660_gn14 ha258_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I14_MP0 (VDD ha257_1 I1660_gn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I206_XP_MP1 (I1660_P14_11n I1660_P12_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I206_XP_MP0 (VDD I1660_P14_13 I1660_P14_11n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I204_XP_MP1 (I1660_P12_9n I1660_P10_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I204_XP_MP0 (VDD I1660_P12_11 I1660_P12_9n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I1_MP1 (I1660_gn1 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I1_MP0 (VDD pp0_1 I1660_gn1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I207_XP_MP1 (I1660_P15_12n I1660_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I207_XP_MP0 (VDD I1660_P15_14 I1660_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I328_XP_MP1 (I1660_P17_2n I1660_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I328_XP_MP0 (VDD I1660_P17_10 I1660_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I13_MP1 (I1660_gn13 ha257_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I13_MP0 (VDD ha256_1 I1660_gn13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I6_MP1 (I1660_gn6 ha250_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I6_MP0 (VDD fa249_1 I1660_gn6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I2_MP1 (I1660_gn2 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I2_MP0 (VDD fa1_0 I1660_gn2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I3_MP1 (I1660_gn3 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I3_MP0 (VDD fa137_0 I1660_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I205_XP_MP1 (I1660_P13_10n I1660_P11_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I205_XP_MP0 (VDD I1660_P13_12 I1660_P13_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I203_XP_MP1 (I1660_P11_8n I1660_P9_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I203_XP_MP0 (VDD I1660_P11_10 I1660_P11_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I330_XP_MP1 (I1660_P19_4n I1660_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I330_XP_MP0 (VDD I1660_P19_12 I1660_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I12_MP1 (I1660_gn12 ha256_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I12_MP0 (VDD ha255_1 I1660_gn12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I11_MP1 (I1660_gn11 ha255_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I11_MP0 (VDD ha254_1 I1660_gn11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I7_MP1 (I1660_gn7 ha251_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I7_MP0 (VDD ha250_1 I1660_gn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I5_MP1 (I1660_gn5 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I5_MP0 (VDD fa249_0 I1660_gn5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I4_MP1 (I1660_gn4 VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I4_MP0 (VDD fa209_0 I1660_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I201_XP_MP1 (I1660_P9_6n I1660_P7_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I201_XP_MP0 (VDD I1660_P9_8 I1660_P9_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I199_XP_MP1 (I1660_P7_4n I1660_P5_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I199_XP_MP0 (VDD I1660_P7_6 I1660_P7_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I10_MP1 (I1660_gn10 ha254_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I10_MP0 (VDD ha253_1 I1660_gn10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I9_MP1 (I1660_gn9 ha253_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I9_MP0 (VDD ha252_1 I1660_gn9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I8_MP1 (I1660_gn8 ha252_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I8_MP0 (VDD ha251_1 I1660_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I197_XP_MP1 (I1660_P5_2n I1660_P3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I197_XP_MP0 (VDD I1660_P5_4 I1660_P5_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I170_XP_MP0 (XI1660_I170_XP_p1 I1660_pn40 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I170_XP_MP1 (I1660_P40_39 I1660_pn39 XI1660_I170_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I172_XP_MP0 (XI1660_I172_XP_p1 I1660_pn42 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I172_XP_MP1 (I1660_P42_41 I1660_pn41 XI1660_I172_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I174_XP_MP0 (XI1660_I174_XP_p1 I1660_pn44 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I174_XP_MP1 (I1660_P44_43 I1660_pn43 XI1660_I174_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I176_XP_MP0 (XI1660_I176_XP_p1 I1660_pn46 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I176_XP_MP1 (I1660_P46_45 I1660_pn45 XI1660_I176_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I178_XP_MP0 (XI1660_I178_XP_p1 I1660_pn48 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I178_XP_MP1 (I1660_P48_47 I1660_pn47 XI1660_I178_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I180_XP_MP0 (XI1660_I180_XP_p1 I1660_pn50 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I180_XP_MP1 (I1660_P50_49 I1660_pn49 XI1660_I180_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I182_XP_MP0 (XI1660_I182_XP_p1 I1660_pn52 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I182_XP_MP1 (I1660_P52_51 I1660_pn51 XI1660_I182_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I168_XP_MP0 (XI1660_I168_XP_p1 I1660_pn38 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I168_XP_MP1 (I1660_P38_37 I1660_pn37 XI1660_I168_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I297_XP_MP0 (XI1660_I297_XP_p1 I1660_P44_41n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I297_XP_MP1 (I1660_P44_37 I1660_P40_37n XI1660_I297_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I301_XP_MP0 (XI1660_I301_XP_p1 I1660_P48_45n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I301_XP_MP1 (I1660_P48_41 I1660_P44_41n XI1660_I301_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I305_XP_MP0 (XI1660_I305_XP_p1 I1660_P52_49n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I305_XP_MP1 (I1660_P52_45 I1660_P48_45n XI1660_I305_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I309_XP_MP0 (XI1660_I309_XP_p1 I1660_P56_53n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I309_XP_MP1 (I1660_P56_49 I1660_P52_49n XI1660_I309_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I313_XP_MP0 (XI1660_I313_XP_p1 I1660_P60_57n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I313_XP_MP1 (I1660_P60_53 I1660_P56_53n XI1660_I313_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I184_XP_MP0 (XI1660_I184_XP_p1 I1660_pn54 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I184_XP_MP1 (I1660_P54_53 I1660_pn53 XI1660_I184_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I186_XP_MP0 (XI1660_I186_XP_p1 I1660_pn56 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I186_XP_MP1 (I1660_P56_55 I1660_pn55 XI1660_I186_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I166_XP_MP0 (XI1660_I166_XP_p1 I1660_pn36 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I166_XP_MP1 (I1660_P36_35 I1660_pn35 XI1660_I166_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I299_XP_MP0 (XI1660_I299_XP_p1 I1660_P46_43n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I299_XP_MP1 (I1660_P46_39 I1660_P42_39n XI1660_I299_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I303_XP_MP0 (XI1660_I303_XP_p1 I1660_P50_47n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I303_XP_MP1 (I1660_P50_43 I1660_P46_43n XI1660_I303_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I307_XP_MP0 (XI1660_I307_XP_p1 I1660_P54_51n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I307_XP_MP1 (I1660_P54_47 I1660_P50_47n XI1660_I307_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I311_XP_MP0 (XI1660_I311_XP_p1 I1660_P58_55n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I311_XP_MP1 (I1660_P58_51 I1660_P54_51n XI1660_I311_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I315_XP_MP0 (XI1660_I315_XP_p1 I1660_P62_59n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I315_XP_MP1 (I1660_P62_55 I1660_P58_55n XI1660_I315_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I190_XP_MP0 (XI1660_I190_XP_p1 I1660_pn60 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I190_XP_MP1 (I1660_P60_59 I1660_pn59 XI1660_I190_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I188_XP_MP0 (XI1660_I188_XP_p1 I1660_pn58 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I188_XP_MP1 (I1660_P58_57 I1660_pn57 XI1660_I188_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I293_XP_MP0 (XI1660_I293_XP_p1 I1660_P40_37n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I293_XP_MP1 (I1660_P40_33 I1660_P36_33n XI1660_I293_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I295_XP_MP0 (XI1660_I295_XP_p1 I1660_P42_39n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I295_XP_MP1 (I1660_P42_35 I1660_P38_35n XI1660_I295_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I423_XP_MP0 (XI1660_I423_XP_p1 I1660_P60_45n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I423_XP_MP1 (I1660_P60_29 I1660_P44_29n XI1660_I423_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I175_XP_MP0 (XI1660_I175_XP_p1 I1660_pn45 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I175_XP_MP1 (I1660_P45_44 I1660_pn44 XI1660_I175_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I181_XP_MP0 (XI1660_I181_XP_p1 I1660_pn51 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I181_XP_MP1 (I1660_P51_50 I1660_pn50 XI1660_I181_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I191_XP_MP0 (XI1660_I191_XP_p1 I1660_pn61 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I191_XP_MP1 (I1660_P61_60 I1660_pn60 XI1660_I191_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I192_XP_MP0 (XI1660_I192_XP_p1 I1660_pn62 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I192_XP_MP1 (I1660_P62_61 I1660_pn61 XI1660_I192_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I193_XP_MP0 (XI1660_I193_XP_p1 I1660_pn63 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I193_XP_MP1 (I1660_P63_62 I1660_pn62 XI1660_I193_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I164_XP_MP0 (XI1660_I164_XP_p1 I1660_pn34 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I164_XP_MP1 (I1660_P34_33 I1660_pn33 XI1660_I164_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I407_XP_MP0 (XI1660_I407_XP_p1 I1660_P44_29n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I407_XP_MP1 (I1660_P44_13 I1660_P28_13n XI1660_I407_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I291_XP_MP0 (XI1660_I291_XP_p1 I1660_P38_35n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I291_XP_MP1 (I1660_P38_31 I1660_P34_31n XI1660_I291_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I425_XP_MP0 (XI1660_I425_XP_p1 I1660_P62_47n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I425_XP_MP1 (I1660_P62_31 I1660_P46_31n XI1660_I425_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I179_XP_MP0 (XI1660_I179_XP_p1 I1660_pn49 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I179_XP_MP1 (I1660_P49_48 I1660_pn48 XI1660_I179_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I183_XP_MP0 (XI1660_I183_XP_p1 I1660_pn53 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I183_XP_MP1 (I1660_P53_52 I1660_pn52 XI1660_I183_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I160_XP_MP0 (XI1660_I160_XP_p1 I1660_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I160_XP_MP1 (I1660_P30_29 I1660_pn29 XI1660_I160_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I162_XP_MP0 (XI1660_I162_XP_p1 I1660_pn32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I162_XP_MP1 (I1660_P32_31 I1660_pn31 XI1660_I162_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I289_XP_MP0 (XI1660_I289_XP_p1 I1660_P36_33n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I289_XP_MP1 (I1660_P36_29 I1660_P32_29n XI1660_I289_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I419_XP_MP0 (XI1660_I419_XP_p1 I1660_P56_41n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I419_XP_MP1 (I1660_P56_25 I1660_P40_25n XI1660_I419_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I409_XP_MP0 (XI1660_I409_XP_p1 I1660_P46_31n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I409_XP_MP1 (I1660_P46_15 I1660_P30_15n XI1660_I409_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I177_XP_MP0 (XI1660_I177_XP_p1 I1660_pn47 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I177_XP_MP1 (I1660_P47_46 I1660_pn46 XI1660_I177_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I189_XP_MP0 (XI1660_I189_XP_p1 I1660_pn59 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I189_XP_MP1 (I1660_P59_58 I1660_pn58 XI1660_I189_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I187_XP_MP0 (XI1660_I187_XP_p1 I1660_pn57 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I187_XP_MP1 (I1660_P57_56 I1660_pn56 XI1660_I187_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I185_XP_MP0 (XI1660_I185_XP_p1 I1660_pn55 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I185_XP_MP1 (I1660_P55_54 I1660_pn54 XI1660_I185_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I287_XP_MP0 (XI1660_I287_XP_p1 I1660_P34_31n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I287_XP_MP1 (I1660_P34_27 I1660_P30_27n XI1660_I287_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I417_XP_MP0 (XI1660_I417_XP_p1 I1660_P54_39n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I417_XP_MP1 (I1660_P54_23 I1660_P38_23n XI1660_I417_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I159_XP_MP0 (XI1660_I159_XP_p1 I1660_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I159_XP_MP1 (I1660_P29_28 I1660_pn28 XI1660_I159_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I161_XP_MP0 (XI1660_I161_XP_p1 I1660_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I161_XP_MP1 (I1660_P31_30 I1660_pn30 XI1660_I161_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I421_XP_MP0 (XI1660_I421_XP_p1 I1660_P58_43n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I421_XP_MP1 (I1660_P58_27 I1660_P42_27n XI1660_I421_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I173_XP_MP0 (XI1660_I173_XP_p1 I1660_pn43 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I173_XP_MP1 (I1660_P43_42 I1660_pn42 XI1660_I173_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I310_XP_MP0 (XI1660_I310_XP_p1 I1660_P57_54n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I310_XP_MP1 (I1660_P57_50 I1660_P53_50n XI1660_I310_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I314_XP_MP0 (XI1660_I314_XP_p1 I1660_P61_58n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I314_XP_MP1 (I1660_P61_54 I1660_P57_54n XI1660_I314_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I158_XP_MP0 (XI1660_I158_XP_p1 I1660_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I158_XP_MP1 (I1660_P28_27 I1660_pn27 XI1660_I158_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I285_XP_MP0 (XI1660_I285_XP_p1 I1660_P32_29n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I285_XP_MP1 (I1660_P32_25 I1660_P28_25n XI1660_I285_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I415_XP_MP0 (XI1660_I415_XP_p1 I1660_P52_37n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I415_XP_MP1 (I1660_P52_21 I1660_P36_21n XI1660_I415_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I283_XP_MP0 (XI1660_I283_XP_p1 I1660_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I283_XP_MP1 (I1660_P30_23 I1660_P26_23n XI1660_I283_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I405_XP_MP0 (XI1660_I405_XP_p1 I1660_P42_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I405_XP_MP1 (I1660_P42_11 I1660_P26_11n XI1660_I405_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I171_XP_MP0 (XI1660_I171_XP_p1 I1660_pn41 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I171_XP_MP1 (I1660_P41_40 I1660_pn40 XI1660_I171_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I306_XP_MP0 (XI1660_I306_XP_p1 I1660_P53_50n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I306_XP_MP1 (I1660_P53_46 I1660_P49_46n XI1660_I306_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I312_XP_MP0 (XI1660_I312_XP_p1 I1660_P59_56n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I312_XP_MP1 (I1660_P59_52 I1660_P55_52n XI1660_I312_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I316_XP_MP0 (XI1660_I316_XP_p1 I1660_P63_60n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I316_XP_MP1 (I1660_P63_56 I1660_P59_56n XI1660_I316_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I281_XP_MP0 (XI1660_I281_XP_p1 I1660_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I281_XP_MP1 (I1660_P28_21 I1660_P24_21n XI1660_I281_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I413_XP_MP0 (XI1660_I413_XP_p1 I1660_P50_35n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I413_XP_MP1 (I1660_P50_19 I1660_P34_19n XI1660_I413_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I169_XP_MP0 (XI1660_I169_XP_p1 I1660_pn39 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I169_XP_MP1 (I1660_P39_38 I1660_pn38 XI1660_I169_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I298_XP_MP0 (XI1660_I298_XP_p1 I1660_P45_42n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I298_XP_MP1 (I1660_P45_38 I1660_P41_38n XI1660_I298_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I302_XP_MP0 (XI1660_I302_XP_p1 I1660_P49_46n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I302_XP_MP1 (I1660_P49_42 I1660_P45_42n XI1660_I302_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I424_XP_MP0 (XI1660_I424_XP_p1 I1660_P61_46n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I424_XP_MP1 (I1660_P61_30 I1660_P45_30n XI1660_I424_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I304_XP_MP0 (XI1660_I304_XP_p1 I1660_P51_48n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I304_XP_MP1 (I1660_P51_44 I1660_P47_44n XI1660_I304_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I308_XP_MP0 (XI1660_I308_XP_p1 I1660_P55_52n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I308_XP_MP1 (I1660_P55_48 I1660_P51_48n XI1660_I308_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I156_XP_MP0 (XI1660_I156_XP_p1 I1660_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I156_XP_MP1 (I1660_P26_25 I1660_pn25 XI1660_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I403_XP_MP0 (XI1660_I403_XP_p1 I1660_P40_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I403_XP_MP1 (I1660_P40_9 I1660_P24_9n XI1660_I403_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I411_XP_MP0 (XI1660_I411_XP_p1 I1660_P48_33n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I411_XP_MP1 (I1660_P48_17 I1660_P32_17n XI1660_I411_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I279_XP_MP0 (XI1660_I279_XP_p1 I1660_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I279_XP_MP1 (I1660_P26_19 I1660_P22_19n XI1660_I279_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I401_XP_MP0 (XI1660_I401_XP_p1 I1660_P38_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I401_XP_MP1 (I1660_P38_7 I1660_P22_7n XI1660_I401_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I167_XP_MP0 (XI1660_I167_XP_p1 I1660_pn37 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I167_XP_MP1 (I1660_P37_36 I1660_pn36 XI1660_I167_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I157_XP_MP0 (XI1660_I157_XP_p1 I1660_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I157_XP_MP1 (I1660_P27_26 I1660_pn26 XI1660_I157_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I300_XP_MP0 (XI1660_I300_XP_p1 I1660_P47_44n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I300_XP_MP1 (I1660_P47_40 I1660_P43_40n XI1660_I300_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I154_XP_MP0 (XI1660_I154_XP_p1 I1660_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I154_XP_MP1 (I1660_P24_23 I1660_pn23 XI1660_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I163_XP_MP0 (XI1660_I163_XP_p1 I1660_pn33 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I163_XP_MP1 (I1660_P33_32 I1660_pn32 XI1660_I163_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I165_XP_MP0 (XI1660_I165_XP_p1 I1660_pn35 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I165_XP_MP1 (I1660_P35_34 I1660_pn34 XI1660_I165_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I294_XP_MP0 (XI1660_I294_XP_p1 I1660_P41_38n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I294_XP_MP1 (I1660_P41_34 I1660_P37_34n XI1660_I294_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I408_XP_MP0 (XI1660_I408_XP_p1 I1660_P45_30n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I408_XP_MP1 (I1660_P45_14 I1660_P29_14n XI1660_I408_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I296_XP_MP0 (XI1660_I296_XP_p1 I1660_P43_40n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I296_XP_MP1 (I1660_P43_36 I1660_P39_36n XI1660_I296_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I422_XP_MP0 (XI1660_I422_XP_p1 I1660_P59_44n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I422_XP_MP1 (I1660_P59_28 I1660_P43_28n XI1660_I422_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I152_XP_MP0 (XI1660_I152_XP_p1 I1660_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I152_XP_MP1 (I1660_P22_21 I1660_pn21 XI1660_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I277_XP_MP0 (XI1660_I277_XP_p1 I1660_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I277_XP_MP1 (I1660_P24_17 I1660_P20_17n XI1660_I277_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I399_XP_MP0 (XI1660_I399_XP_p1 I1660_P36_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I399_XP_MP1 (I1660_P36_5 I1660_P20_5n XI1660_I399_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I275_XP_MP0 (XI1660_I275_XP_p1 I1660_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I275_XP_MP1 (I1660_P22_15 I1660_P18_15n XI1660_I275_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I155_XP_MP0 (XI1660_I155_XP_p1 I1660_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I155_XP_MP1 (I1660_P25_24 I1660_pn24 XI1660_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I153_XP_MP0 (XI1660_I153_XP_p1 I1660_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I153_XP_MP1 (I1660_P23_22 I1660_pn22 XI1660_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I290_XP_MP0 (XI1660_I290_XP_p1 I1660_P37_34n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I290_XP_MP1 (I1660_P37_30 I1660_P33_30n XI1660_I290_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I420_XP_MP0 (XI1660_I420_XP_p1 I1660_P57_42n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I420_XP_MP1 (I1660_P57_26 I1660_P41_26n XI1660_I420_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I292_XP_MP0 (XI1660_I292_XP_p1 I1660_P39_36n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I292_XP_MP1 (I1660_P39_32 I1660_P35_32n XI1660_I292_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I426_XP_MP0 (XI1660_I426_XP_p1 I1660_P63_48n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I426_XP_MP1 (I1660_P63_32 I1660_P47_32n XI1660_I426_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I150_XP_MP0 (XI1660_I150_XP_p1 I1660_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I150_XP_MP1 (I1660_P20_19 I1660_pn19 XI1660_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I273_XP_MP0 (XI1660_I273_XP_p1 I1660_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I273_XP_MP1 (I1660_P20_13 I1660_P16_13n XI1660_I273_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I397_XP_MP0 (XI1660_I397_XP_p1 I1660_P34_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I397_XP_MP1 (I1660_P34_3 I1660_P18_3n XI1660_I397_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I286_XP_MP0 (XI1660_I286_XP_p1 I1660_P33_30n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I286_XP_MP1 (I1660_P33_26 I1660_P29_26n XI1660_I286_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I288_XP_MP0 (XI1660_I288_XP_p1 I1660_P35_32n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I288_XP_MP1 (I1660_P35_28 I1660_P31_28n XI1660_I288_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I395_XP_MP0 (XI1660_I395_XP_p1 I1660_P32_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I395_XP_MP1 (I1660_P32_1 I1660_P16_1n XI1660_I395_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I151_XP_MP0 (XI1660_I151_XP_p1 I1660_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I151_XP_MP1 (I1660_P21_20 I1660_pn20 XI1660_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I282_XP_MP0 (XI1660_I282_XP_p1 I1660_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I282_XP_MP1 (I1660_P29_22 I1660_P25_22n XI1660_I282_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I416_XP_MP0 (XI1660_I416_XP_p1 I1660_P53_38n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I416_XP_MP1 (I1660_P53_22 I1660_P37_22n XI1660_I416_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I404_XP_MP0 (XI1660_I404_XP_p1 I1660_P41_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I404_XP_MP1 (I1660_P41_10 I1660_P25_10n XI1660_I404_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I284_XP_MP0 (XI1660_I284_XP_p1 I1660_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I284_XP_MP1 (I1660_P31_24 I1660_P27_24n XI1660_I284_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I418_XP_MP0 (XI1660_I418_XP_p1 I1660_P55_40n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I418_XP_MP1 (I1660_P55_24 I1660_P39_24n XI1660_I418_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I410_XP_MP0 (XI1660_I410_XP_p1 I1660_P47_32n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I410_XP_MP1 (I1660_P47_16 I1660_P31_16n XI1660_I410_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I148_XP_MP0 (XI1660_I148_XP_p1 I1660_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I148_XP_MP1 (I1660_P18_17 I1660_pn17 XI1660_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I271_XP_MP0 (XI1660_I271_XP_p1 I1660_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I271_XP_MP1 (I1660_P18_11 I1660_P14_11n XI1660_I271_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I149_XP_MP0 (XI1660_I149_XP_p1 I1660_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I149_XP_MP1 (I1660_P19_18 I1660_pn18 XI1660_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I278_XP_MP0 (XI1660_I278_XP_p1 I1660_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I278_XP_MP1 (I1660_P25_18 I1660_P21_18n XI1660_I278_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I280_XP_MP0 (XI1660_I280_XP_p1 I1660_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I280_XP_MP1 (I1660_P27_20 I1660_P23_20n XI1660_I280_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I146_XP_MP0 (XI1660_I146_XP_p1 I1660_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I146_XP_MP1 (I1660_P16_15 I1660_pn15 XI1660_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I269_XP_MP0 (XI1660_I269_XP_p1 I1660_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I269_XP_MP1 (I1660_P16_9 I1660_P12_9n XI1660_I269_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I265_XP_MP0 (XI1660_I265_XP_p1 I1660_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I265_XP_MP1 (I1660_P12_5 I1660_P8_5n XI1660_I265_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I261_XP_MP0 (XI1660_I261_XP_p1 I1660_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I261_XP_MP1 (I1660_P8_1 I1660_P4_1n XI1660_I261_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I267_XP_MP0 (XI1660_I267_XP_p1 I1660_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I267_XP_MP1 (I1660_P14_7 I1660_P10_7n XI1660_I267_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I263_XP_MP0 (XI1660_I263_XP_p1 I1660_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I263_XP_MP1 (I1660_P10_3 I1660_P6_3n XI1660_I263_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I147_XP_MP0 (XI1660_I147_XP_p1 I1660_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I147_XP_MP1 (I1660_P17_16 I1660_pn16 XI1660_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I274_XP_MP0 (XI1660_I274_XP_p1 I1660_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I274_XP_MP1 (I1660_P21_14 I1660_P17_14n XI1660_I274_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I400_XP_MP0 (XI1660_I400_XP_p1 I1660_P37_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I400_XP_MP1 (I1660_P37_6 I1660_P21_6n XI1660_I400_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I412_XP_MP0 (XI1660_I412_XP_p1 I1660_P49_34n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I412_XP_MP1 (I1660_P49_18 I1660_P33_18n XI1660_I412_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I414_XP_MP0 (XI1660_I414_XP_p1 I1660_P51_36n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I414_XP_MP1 (I1660_P51_20 I1660_P35_20n XI1660_I414_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I406_XP_MP0 (XI1660_I406_XP_p1 I1660_P43_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I406_XP_MP1 (I1660_P43_12 I1660_P27_12n XI1660_I406_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I276_XP_MP0 (XI1660_I276_XP_p1 I1660_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I276_XP_MP1 (I1660_P23_16 I1660_P19_16n XI1660_I276_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I402_XP_MP0 (XI1660_I402_XP_p1 I1660_P39_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I402_XP_MP1 (I1660_P39_8 I1660_P23_8n XI1660_I402_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I144_XP_MP0 (XI1660_I144_XP_p1 I1660_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I144_XP_MP1 (I1660_P14_13 I1660_pn13 XI1660_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I132_XP_MP0 (XI1660_I132_XP_p1 I1660_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I132_XP_MP1 (I1660_P2_1 I1660_pn1 XI1660_I132_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I145_XP_MP0 (XI1660_I145_XP_p1 I1660_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I145_XP_MP1 (I1660_P15_14 I1660_pn14 XI1660_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I270_XP_MP0 (XI1660_I270_XP_p1 I1660_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I270_XP_MP1 (I1660_P17_10 I1660_P13_10n XI1660_I270_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I272_XP_MP0 (XI1660_I272_XP_p1 I1660_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I272_XP_MP1 (I1660_P19_12 I1660_P15_12n XI1660_I272_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I142_XP_MP0 (XI1660_I142_XP_p1 I1660_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I142_XP_MP1 (I1660_P12_11 I1660_pn11 XI1660_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I143_XP_MP0 (XI1660_I143_XP_p1 I1660_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I143_XP_MP1 (I1660_P13_12 I1660_pn12 XI1660_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I266_XP_MP0 (XI1660_I266_XP_p1 I1660_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I266_XP_MP1 (I1660_P13_6 I1660_P9_6n XI1660_I266_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I396_XP_MP0 (XI1660_I396_XP_p1 I1660_P33_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I396_XP_MP1 (I1660_P33_2 I1660_P17_2n XI1660_I396_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I268_XP_MP0 (XI1660_I268_XP_p1 I1660_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I268_XP_MP1 (I1660_P15_8 I1660_P11_8n XI1660_I268_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I398_XP_MP0 (XI1660_I398_XP_p1 I1660_P35_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I398_XP_MP1 (I1660_P35_4 I1660_P19_4n XI1660_I398_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I134_XP_MP0 (XI1660_I134_XP_p1 I1660_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I134_XP_MP1 (I1660_P4_3 I1660_pn3 XI1660_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I141_XP_MP0 (XI1660_I141_XP_p1 I1660_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I141_XP_MP1 (I1660_P11_10 I1660_pn10 XI1660_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I137_XP_MP0 (XI1660_I137_XP_p1 I1660_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I137_XP_MP1 (I1660_P7_6 I1660_pn6 XI1660_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I262_XP_MP0 (XI1660_I262_XP_p1 I1660_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I262_XP_MP1 (I1660_P9_2 I1660_P5_2n XI1660_I262_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I264_XP_MP0 (XI1660_I264_XP_p1 I1660_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I264_XP_MP1 (I1660_P11_4 I1660_P7_4n XI1660_I264_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I140_XP_MP0 (XI1660_I140_XP_p1 I1660_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I140_XP_MP1 (I1660_P10_9 I1660_pn9 XI1660_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I138_XP_MP0 (XI1660_I138_XP_p1 I1660_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I138_XP_MP1 (I1660_P8_7 I1660_pn7 XI1660_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I136_XP_MP0 (XI1660_I136_XP_p1 I1660_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I136_XP_MP1 (I1660_P6_5 I1660_pn5 XI1660_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I133_XP_MP0 (XI1660_I133_XP_p1 I1660_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I133_XP_MP1 (I1660_P3_2 I1660_pn2 XI1660_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I139_XP_MP0 (XI1660_I139_XP_p1 I1660_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I139_XP_MP1 (I1660_P9_8 I1660_pn8 XI1660_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1660_I135_XP_MP0 (XI1660_I135_XP_p1 I1660_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1660_I135_XP_MP1 (I1660_P5_4 I1660_pn4 XI1660_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1468_MP50 (VDD XI1468_s1 XI1468_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1468_MP47 (XI1468_bp3 pp8_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1468_MP49 (XI1468_bsn XI1468_bcon XI1468_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1468_MP52 (XI1468_bp5 cm104_2 XI1468_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1468_MP51 (XI1468_bp4 pp8_27 XI1468_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1468_MP51_1 (XI1468_bp5 pp8_27 XI1468_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1468_MP52_1 (XI1468_bsn cm104_2 XI1468_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1468_MP54 (VDD XI1468_bsn cm107_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1468_MP41 (XI1468_bp1 XI1468_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1468_MP42 (XI1468_bcon pp8_27 XI1468_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1468_MP45 (XI1468_bp2 cm104_2 XI1468_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1468_MP43 (VDD XI1468_s1 XI1468_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1468_MP44 (XI1468_bp2 pp8_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1468_MP56 (VDD XI1468_bcon cm107_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1468_MP46 (XI1468_bp3 XI1468_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1468_MP48 (VDD cm104_2 XI1468_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1468_MP50_1 (XI1468_bp4 XI1468_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1468_MP26 (VDD XI1468_asn XI1468_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1468_MP18 (XI1468_ap3 sn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1468_MP21 (XI1468_asn XI1468_acon XI1468_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1468_MP24 (XI1468_ap5 pp7_29 XI1468_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1468_MP23 (XI1468_ap4 pp6_31 XI1468_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1468_MP22 (VDD sn5 XI1468_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1468_MP22_1 (XI1468_ap4 sn5 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1468_MP23_1 (XI1468_ap5 pp6_31 XI1468_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1468_MP24_1 (XI1468_asn pp7_29 XI1468_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1468_MP17 (XI1468_acon pp7_29 XI1468_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1468_MP14 (XI1468_ap1 pp6_31 XI1468_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1468_MP13 (VDD sn5 XI1468_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1468_MP15 (XI1468_ap2 sn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1468_MP16 (VDD pp6_31 XI1468_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1468_MP28 (cm107_2 XI1468_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1468_MP19 (XI1468_ap3 pp6_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1468_MP20 (VDD pp7_29 XI1468_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1471_MP50 (VDD XI1471_s1 XI1471_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1471_MP47 (XI1471_bp3 pp8_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1471_MP49 (XI1471_bsn XI1471_bcon XI1471_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1471_MP52 (XI1471_bp5 cm107_2 XI1471_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1471_MP51 (XI1471_bp4 pp8_28 XI1471_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1471_MP51_1 (XI1471_bp5 pp8_28 XI1471_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1471_MP52_1 (XI1471_bsn cm107_2 XI1471_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1471_MP54 (VDD XI1471_bsn cm110_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1471_MP41 (XI1471_bp1 XI1471_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1471_MP42 (XI1471_bcon pp8_28 XI1471_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1471_MP45 (XI1471_bp2 cm107_2 XI1471_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1471_MP43 (VDD XI1471_s1 XI1471_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1471_MP44 (XI1471_bp2 pp8_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1471_MP56 (VDD XI1471_bcon cm110_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1471_MP46 (XI1471_bp3 XI1471_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1471_MP48 (VDD cm107_2 XI1471_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1471_MP50_1 (XI1471_bp4 XI1471_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1471_MP26 (VDD XI1471_asn XI1471_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1471_MP18 (XI1471_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1471_MP21 (XI1471_asn XI1471_acon XI1471_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1471_MP24 (XI1471_ap5 pp7_30 XI1471_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1471_MP23 (XI1471_ap4 pp6_32 XI1471_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1471_MP22 (VDD VDD XI1471_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1471_MP22_1 (XI1471_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1471_MP23_1 (XI1471_ap5 pp6_32 XI1471_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1471_MP24_1 (XI1471_asn pp7_30 XI1471_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1471_MP17 (XI1471_acon pp7_30 XI1471_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1471_MP14 (XI1471_ap1 pp6_32 XI1471_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1471_MP13 (VDD VDD XI1471_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1471_MP15 (XI1471_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1471_MP16 (VDD pp6_32 XI1471_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1471_MP28 (cm110_2 XI1471_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1471_MP19 (XI1471_ap3 pp6_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1471_MP20 (VDD pp7_30 XI1471_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1482_MP50 (VDD XI1482_s1 XI1482_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1482_MP47 (XI1482_bp3 pp11_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1482_MP49 (XI1482_bsn XI1482_bcon XI1482_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1482_MP52 (XI1482_bp5 cm119_2 XI1482_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1482_MP51 (XI1482_bp4 pp11_27 XI1482_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1482_MP51_1 (XI1482_bp5 pp11_27 XI1482_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1482_MP52_1 (XI1482_bsn cm119_2 XI1482_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1482_MP54 (VDD XI1482_bsn cm121_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1482_MP41 (XI1482_bp1 XI1482_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1482_MP42 (XI1482_bcon pp11_27 XI1482_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1482_MP45 (XI1482_bp2 cm119_2 XI1482_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1482_MP43 (VDD XI1482_s1 XI1482_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1482_MP44 (XI1482_bp2 pp11_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1482_MP56 (VDD XI1482_bcon cm121_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1482_MP46 (XI1482_bp3 XI1482_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1482_MP48 (VDD cm119_2 XI1482_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1482_MP50_1 (XI1482_bp4 XI1482_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1482_MP26 (VDD XI1482_asn XI1482_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1482_MP18 (XI1482_ap3 sn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1482_MP21 (XI1482_asn XI1482_acon XI1482_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1482_MP24 (XI1482_ap5 pp10_29 XI1482_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1482_MP23 (XI1482_ap4 pp9_31 XI1482_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1482_MP22 (VDD sn8 XI1482_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1482_MP22_1 (XI1482_ap4 sn8 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1482_MP23_1 (XI1482_ap5 pp9_31 XI1482_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1482_MP24_1 (XI1482_asn pp10_29 XI1482_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1482_MP17 (XI1482_acon pp10_29 XI1482_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1482_MP14 (XI1482_ap1 pp9_31 XI1482_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1482_MP13 (VDD sn8 XI1482_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1482_MP15 (XI1482_ap2 sn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1482_MP16 (VDD pp9_31 XI1482_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1482_MP28 (cm121_2 XI1482_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1482_MP19 (XI1482_ap3 pp9_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1482_MP20 (VDD pp10_29 XI1482_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1474_MP50 (VDD XI1474_s1 XI1474_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1474_MP47 (XI1474_bp3 pp9_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1474_MP49 (XI1474_bsn XI1474_bcon XI1474_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1474_MP52 (XI1474_bp5 cm110_2 XI1474_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1474_MP51 (XI1474_bp4 pp9_27 XI1474_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1474_MP51_1 (XI1474_bp5 pp9_27 XI1474_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1474_MP52_1 (XI1474_bsn cm110_2 XI1474_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1474_MP54 (VDD XI1474_bsn cm113_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1474_MP41 (XI1474_bp1 XI1474_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1474_MP42 (XI1474_bcon pp9_27 XI1474_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1474_MP45 (XI1474_bp2 cm110_2 XI1474_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1474_MP43 (VDD XI1474_s1 XI1474_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1474_MP44 (XI1474_bp2 pp9_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1474_MP56 (VDD XI1474_bcon cm113_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1474_MP46 (XI1474_bp3 XI1474_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1474_MP48 (VDD cm110_2 XI1474_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1474_MP50_1 (XI1474_bp4 XI1474_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1474_MP26 (VDD XI1474_asn XI1474_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1474_MP18 (XI1474_ap3 sn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1474_MP21 (XI1474_asn XI1474_acon XI1474_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1474_MP24 (XI1474_ap5 pp8_29 XI1474_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1474_MP23 (XI1474_ap4 pp7_31 XI1474_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1474_MP22 (VDD sn6 XI1474_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1474_MP22_1 (XI1474_ap4 sn6 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1474_MP23_1 (XI1474_ap5 pp7_31 XI1474_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1474_MP24_1 (XI1474_asn pp8_29 XI1474_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1474_MP17 (XI1474_acon pp8_29 XI1474_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1474_MP14 (XI1474_ap1 pp7_31 XI1474_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1474_MP13 (VDD sn6 XI1474_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1474_MP15 (XI1474_ap2 sn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1474_MP16 (VDD pp7_31 XI1474_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1474_MP28 (cm113_2 XI1474_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1474_MP19 (XI1474_ap3 pp7_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1474_MP20 (VDD pp8_29 XI1474_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1478_MP50 (VDD XI1478_s1 XI1478_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1478_MP47 (XI1478_bp3 pp10_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1478_MP49 (XI1478_bsn XI1478_bcon XI1478_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1478_MP52 (XI1478_bp5 cm115_2 XI1478_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1478_MP51 (XI1478_bp4 pp10_27 XI1478_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1478_MP51_1 (XI1478_bp5 pp10_27 XI1478_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1478_MP52_1 (XI1478_bsn cm115_2 XI1478_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1478_MP54 (VDD XI1478_bsn cm117_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1478_MP41 (XI1478_bp1 XI1478_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1478_MP42 (XI1478_bcon pp10_27 XI1478_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1478_MP45 (XI1478_bp2 cm115_2 XI1478_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1478_MP43 (VDD XI1478_s1 XI1478_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1478_MP44 (XI1478_bp2 pp10_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1478_MP56 (VDD XI1478_bcon cm117_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1478_MP46 (XI1478_bp3 XI1478_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1478_MP48 (VDD cm115_2 XI1478_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1478_MP50_1 (XI1478_bp4 XI1478_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1478_MP26 (VDD XI1478_asn XI1478_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1478_MP18 (XI1478_ap3 sn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1478_MP21 (XI1478_asn XI1478_acon XI1478_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1478_MP24 (XI1478_ap5 pp9_29 XI1478_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1478_MP23 (XI1478_ap4 pp8_31 XI1478_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1478_MP22 (VDD sn7 XI1478_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1478_MP22_1 (XI1478_ap4 sn7 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1478_MP23_1 (XI1478_ap5 pp8_31 XI1478_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1478_MP24_1 (XI1478_asn pp9_29 XI1478_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1478_MP17 (XI1478_acon pp9_29 XI1478_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1478_MP14 (XI1478_ap1 pp8_31 XI1478_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1478_MP13 (VDD sn7 XI1478_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1478_MP15 (XI1478_ap2 sn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1478_MP16 (VDD pp8_31 XI1478_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1478_MP28 (cm117_2 XI1478_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1478_MP19 (XI1478_ap3 pp8_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1478_MP20 (VDD pp9_29 XI1478_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1480_MP50 (VDD XI1480_s1 XI1480_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1480_MP47 (XI1480_bp3 pp10_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1480_MP49 (XI1480_bsn XI1480_bcon XI1480_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1480_MP52 (XI1480_bp5 cm117_2 XI1480_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1480_MP51 (XI1480_bp4 pp10_28 XI1480_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1480_MP51_1 (XI1480_bp5 pp10_28 XI1480_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1480_MP52_1 (XI1480_bsn cm117_2 XI1480_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1480_MP54 (VDD XI1480_bsn cm119_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1480_MP41 (XI1480_bp1 XI1480_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1480_MP42 (XI1480_bcon pp10_28 XI1480_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1480_MP45 (XI1480_bp2 cm117_2 XI1480_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1480_MP43 (VDD XI1480_s1 XI1480_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1480_MP44 (XI1480_bp2 pp10_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1480_MP56 (VDD XI1480_bcon cm119_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1480_MP46 (XI1480_bp3 XI1480_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1480_MP48 (VDD cm117_2 XI1480_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1480_MP50_1 (XI1480_bp4 XI1480_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1480_MP26 (VDD XI1480_asn XI1480_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1480_MP18 (XI1480_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1480_MP21 (XI1480_asn XI1480_acon XI1480_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1480_MP24 (XI1480_ap5 pp9_30 XI1480_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1480_MP23 (XI1480_ap4 pp8_32 XI1480_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1480_MP22 (VDD VDD XI1480_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1480_MP22_1 (XI1480_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1480_MP23_1 (XI1480_ap5 pp8_32 XI1480_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1480_MP24_1 (XI1480_asn pp9_30 XI1480_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1480_MP17 (XI1480_acon pp9_30 XI1480_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1480_MP14 (XI1480_ap1 pp8_32 XI1480_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1480_MP13 (VDD VDD XI1480_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1480_MP15 (XI1480_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1480_MP16 (VDD pp8_32 XI1480_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1480_MP28 (cm119_2 XI1480_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1480_MP19 (XI1480_ap3 pp8_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1480_MP20 (VDD pp9_30 XI1480_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1560_MP50 (VDD XI1560_s1 XI1560_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1560_MP47 (XI1560_bp3 cm122_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1560_MP49 (XI1560_bsn XI1560_bcon XI1560_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1560_MP52 (XI1560_bp5 cm198_2 XI1560_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1560_MP51 (XI1560_bp4 cm122_0 XI1560_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1560_MP51_1 (XI1560_bp5 cm122_0 XI1560_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1560_MP52_1 (XI1560_bsn cm198_2 XI1560_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1560_MP54 (VDD XI1560_bsn cm199_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1560_MP41 (XI1560_bp1 XI1560_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1560_MP42 (XI1560_bcon cm122_0 XI1560_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1560_MP45 (XI1560_bp2 cm198_2 XI1560_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1560_MP43 (VDD XI1560_s1 XI1560_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1560_MP44 (XI1560_bp2 cm122_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1560_MP56 (VDD XI1560_bcon cm199_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1560_MP46 (XI1560_bp3 XI1560_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1560_MP48 (VDD cm198_2 XI1560_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1560_MP50_1 (XI1560_bp4 XI1560_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1560_MP26 (VDD XI1560_asn XI1560_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1560_MP18 (XI1560_ap3 cm119_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1560_MP21 (XI1560_asn XI1560_acon XI1560_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1560_MP24 (XI1560_ap5 cm121_0 XI1560_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1560_MP23 (XI1560_ap4 cm120_1 XI1560_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1560_MP22 (VDD cm119_1 XI1560_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1560_MP22_1 (XI1560_ap4 cm119_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1560_MP23_1 (XI1560_ap5 cm120_1 XI1560_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1560_MP24_1 (XI1560_asn cm121_0 XI1560_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1560_MP17 (XI1560_acon cm121_0 XI1560_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1560_MP14 (XI1560_ap1 cm120_1 XI1560_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1560_MP13 (VDD cm119_1 XI1560_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1560_MP15 (XI1560_ap2 cm119_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1560_MP16 (VDD cm120_1 XI1560_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1560_MP28 (cm199_2 XI1560_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1560_MP19 (XI1560_ap3 cm120_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1560_MP20 (VDD cm121_0 XI1560_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1465_MP50 (VDD XI1465_s1 XI1465_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1465_MP47 (XI1465_bp3 pp7_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1465_MP49 (XI1465_bsn XI1465_bcon XI1465_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1465_MP52 (XI1465_bp5 cm101_2 XI1465_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1465_MP51 (XI1465_bp4 pp7_28 XI1465_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1465_MP51_1 (XI1465_bp5 pp7_28 XI1465_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1465_MP52_1 (XI1465_bsn cm101_2 XI1465_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1465_MP54 (VDD XI1465_bsn cm104_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1465_MP41 (XI1465_bp1 XI1465_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1465_MP42 (XI1465_bcon pp7_28 XI1465_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1465_MP45 (XI1465_bp2 cm101_2 XI1465_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1465_MP43 (VDD XI1465_s1 XI1465_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1465_MP44 (XI1465_bp2 pp7_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1465_MP56 (VDD XI1465_bcon cm104_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1465_MP46 (XI1465_bp3 XI1465_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1465_MP48 (VDD cm101_2 XI1465_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1465_MP50_1 (XI1465_bp4 XI1465_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1465_MP26 (VDD XI1465_asn XI1465_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1465_MP18 (XI1465_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1465_MP21 (XI1465_asn XI1465_acon XI1465_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1465_MP24 (XI1465_ap5 pp6_30 XI1465_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1465_MP23 (XI1465_ap4 pp5_32 XI1465_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1465_MP22 (VDD VDD XI1465_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1465_MP22_1 (XI1465_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1465_MP23_1 (XI1465_ap5 pp5_32 XI1465_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1465_MP24_1 (XI1465_asn pp6_30 XI1465_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1465_MP17 (XI1465_acon pp6_30 XI1465_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1465_MP14 (XI1465_ap1 pp5_32 XI1465_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1465_MP13 (VDD VDD XI1465_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1465_MP15 (XI1465_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1465_MP16 (VDD pp5_32 XI1465_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1465_MP28 (cm104_2 XI1465_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1465_MP19 (XI1465_ap3 pp5_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1465_MP20 (VDD pp6_30 XI1465_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1462_MP50 (VDD XI1462_s1 XI1462_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1462_MP47 (XI1462_bp3 pp7_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1462_MP49 (XI1462_bsn XI1462_bcon XI1462_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1462_MP52 (XI1462_bp5 cm98_2 XI1462_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1462_MP51 (XI1462_bp4 pp7_27 XI1462_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1462_MP51_1 (XI1462_bp5 pp7_27 XI1462_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1462_MP52_1 (XI1462_bsn cm98_2 XI1462_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1462_MP54 (VDD XI1462_bsn cm101_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1462_MP41 (XI1462_bp1 XI1462_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1462_MP42 (XI1462_bcon pp7_27 XI1462_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1462_MP45 (XI1462_bp2 cm98_2 XI1462_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1462_MP43 (VDD XI1462_s1 XI1462_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1462_MP44 (XI1462_bp2 pp7_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1462_MP56 (VDD XI1462_bcon cm101_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1462_MP46 (XI1462_bp3 XI1462_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1462_MP48 (VDD cm98_2 XI1462_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1462_MP50_1 (XI1462_bp4 XI1462_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1462_MP26 (VDD XI1462_asn XI1462_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1462_MP18 (XI1462_ap3 sn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1462_MP21 (XI1462_asn XI1462_acon XI1462_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1462_MP24 (XI1462_ap5 pp6_29 XI1462_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1462_MP23 (XI1462_ap4 pp5_31 XI1462_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1462_MP22 (VDD sn4 XI1462_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1462_MP22_1 (XI1462_ap4 sn4 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1462_MP23_1 (XI1462_ap5 pp5_31 XI1462_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1462_MP24_1 (XI1462_asn pp6_29 XI1462_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1462_MP17 (XI1462_acon pp6_29 XI1462_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1462_MP14 (XI1462_ap1 pp5_31 XI1462_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1462_MP13 (VDD sn4 XI1462_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1462_MP15 (XI1462_ap2 sn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1462_MP16 (VDD pp5_31 XI1462_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1462_MP28 (cm101_2 XI1462_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1462_MP19 (XI1462_ap3 pp5_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1462_MP20 (VDD pp6_29 XI1462_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1457_MP50 (VDD XI1457_s1 XI1457_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1457_MP47 (XI1457_bp3 pp10_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1457_MP49 (XI1457_bsn XI1457_bcon XI1457_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1457_MP52 (XI1457_bp5 cm93_2 XI1457_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1457_MP51 (XI1457_bp4 pp10_19 XI1457_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1457_MP51_1 (XI1457_bp5 pp10_19 XI1457_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1457_MP52_1 (XI1457_bsn cm93_2 XI1457_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1457_MP54 (VDD XI1457_bsn cm96_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1457_MP41 (XI1457_bp1 XI1457_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1457_MP42 (XI1457_bcon pp10_19 XI1457_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1457_MP45 (XI1457_bp2 cm93_2 XI1457_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1457_MP43 (VDD XI1457_s1 XI1457_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1457_MP44 (XI1457_bp2 pp10_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1457_MP56 (VDD XI1457_bcon cm96_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1457_MP46 (XI1457_bp3 XI1457_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1457_MP48 (VDD cm93_2 XI1457_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1457_MP50_1 (XI1457_bp4 XI1457_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1457_MP26 (VDD XI1457_asn XI1457_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1457_MP18 (XI1457_ap3 pp7_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1457_MP21 (XI1457_asn XI1457_acon XI1457_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1457_MP24 (XI1457_ap5 pp9_21 XI1457_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1457_MP23 (XI1457_ap4 pp8_23 XI1457_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1457_MP22 (VDD pp7_25 XI1457_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1457_MP22_1 (XI1457_ap4 pp7_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1457_MP23_1 (XI1457_ap5 pp8_23 XI1457_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1457_MP24_1 (XI1457_asn pp9_21 XI1457_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1457_MP17 (XI1457_acon pp9_21 XI1457_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1457_MP14 (XI1457_ap1 pp8_23 XI1457_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1457_MP13 (VDD pp7_25 XI1457_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1457_MP15 (XI1457_ap2 pp7_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1457_MP16 (VDD pp8_23 XI1457_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1457_MP28 (cm96_2 XI1457_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1457_MP19 (XI1457_ap3 pp8_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1457_MP20 (VDD pp9_21 XI1457_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1460_MP50 (VDD XI1460_s1 XI1460_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1460_MP47 (XI1460_bp3 pp10_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1460_MP49 (XI1460_bsn XI1460_bcon XI1460_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1460_MP52 (XI1460_bp5 cm96_2 XI1460_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1460_MP51 (XI1460_bp4 pp10_20 XI1460_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1460_MP51_1 (XI1460_bp5 pp10_20 XI1460_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1460_MP52_1 (XI1460_bsn cm96_2 XI1460_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1460_MP54 (VDD XI1460_bsn cm99_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1460_MP41 (XI1460_bp1 XI1460_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1460_MP42 (XI1460_bcon pp10_20 XI1460_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1460_MP45 (XI1460_bp2 cm96_2 XI1460_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1460_MP43 (VDD XI1460_s1 XI1460_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1460_MP44 (XI1460_bp2 pp10_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1460_MP56 (VDD XI1460_bcon cm99_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1460_MP46 (XI1460_bp3 XI1460_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1460_MP48 (VDD cm96_2 XI1460_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1460_MP50_1 (XI1460_bp4 XI1460_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1460_MP26 (VDD XI1460_asn XI1460_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1460_MP18 (XI1460_ap3 pp7_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1460_MP21 (XI1460_asn XI1460_acon XI1460_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1460_MP24 (XI1460_ap5 pp9_22 XI1460_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1460_MP23 (XI1460_ap4 pp8_24 XI1460_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1460_MP22 (VDD pp7_26 XI1460_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1460_MP22_1 (XI1460_ap4 pp7_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1460_MP23_1 (XI1460_ap5 pp8_24 XI1460_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1460_MP24_1 (XI1460_asn pp9_22 XI1460_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1460_MP17 (XI1460_acon pp9_22 XI1460_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1460_MP14 (XI1460_ap1 pp8_24 XI1460_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1460_MP13 (VDD pp7_26 XI1460_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1460_MP15 (XI1460_ap2 pp7_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1460_MP16 (VDD pp8_24 XI1460_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1460_MP28 (cm99_2 XI1460_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1460_MP19 (XI1460_ap3 pp8_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1460_MP20 (VDD pp9_22 XI1460_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1558_MP50 (VDD XI1558_s1 XI1558_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1558_MP47 (XI1558_bp3 cm118_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1558_MP49 (XI1558_bsn XI1558_bcon XI1558_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1558_MP52 (XI1558_bp5 cm196_2 XI1558_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1558_MP51 (XI1558_bp4 cm118_0 XI1558_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1558_MP51_1 (XI1558_bp5 cm118_0 XI1558_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1558_MP52_1 (XI1558_bsn cm196_2 XI1558_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1558_MP54 (VDD XI1558_bsn cm197_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1558_MP41 (XI1558_bp1 XI1558_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1558_MP42 (XI1558_bcon cm118_0 XI1558_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1558_MP45 (XI1558_bp2 cm196_2 XI1558_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1558_MP43 (VDD XI1558_s1 XI1558_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1558_MP44 (XI1558_bp2 cm118_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1558_MP56 (VDD XI1558_bcon cm197_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1558_MP46 (XI1558_bp3 XI1558_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1558_MP48 (VDD cm196_2 XI1558_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1558_MP50_1 (XI1558_bp4 XI1558_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1558_MP26 (VDD XI1558_asn XI1558_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1558_MP18 (XI1558_ap3 cm115_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1558_MP21 (XI1558_asn XI1558_acon XI1558_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1558_MP24 (XI1558_ap5 cm117_0 XI1558_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1558_MP23 (XI1558_ap4 cm116_1 XI1558_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1558_MP22 (VDD cm115_1 XI1558_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1558_MP22_1 (XI1558_ap4 cm115_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1558_MP23_1 (XI1558_ap5 cm116_1 XI1558_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1558_MP24_1 (XI1558_asn cm117_0 XI1558_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1558_MP17 (XI1558_acon cm117_0 XI1558_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1558_MP14 (XI1558_ap1 cm116_1 XI1558_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1558_MP13 (VDD cm115_1 XI1558_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1558_MP15 (XI1558_ap2 cm115_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1558_MP16 (VDD cm116_1 XI1558_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1558_MP28 (cm197_2 XI1558_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1558_MP19 (XI1558_ap3 cm116_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1558_MP20 (VDD cm117_0 XI1558_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1476_MP50 (VDD XI1476_s1 XI1476_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1476_MP47 (XI1476_bp3 pp9_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1476_MP49 (XI1476_bsn XI1476_bcon XI1476_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1476_MP52 (XI1476_bp5 cm113_2 XI1476_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1476_MP51 (XI1476_bp4 pp9_28 XI1476_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1476_MP51_1 (XI1476_bp5 pp9_28 XI1476_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1476_MP52_1 (XI1476_bsn cm113_2 XI1476_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1476_MP54 (VDD XI1476_bsn cm115_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1476_MP41 (XI1476_bp1 XI1476_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1476_MP42 (XI1476_bcon pp9_28 XI1476_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1476_MP45 (XI1476_bp2 cm113_2 XI1476_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1476_MP43 (VDD XI1476_s1 XI1476_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1476_MP44 (XI1476_bp2 pp9_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1476_MP56 (VDD XI1476_bcon cm115_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1476_MP46 (XI1476_bp3 XI1476_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1476_MP48 (VDD cm113_2 XI1476_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1476_MP50_1 (XI1476_bp4 XI1476_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1476_MP26 (VDD XI1476_asn XI1476_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1476_MP18 (XI1476_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1476_MP21 (XI1476_asn XI1476_acon XI1476_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1476_MP24 (XI1476_ap5 pp8_30 XI1476_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1476_MP23 (XI1476_ap4 pp7_32 XI1476_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1476_MP22 (VDD VDD XI1476_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1476_MP22_1 (XI1476_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1476_MP23_1 (XI1476_ap5 pp7_32 XI1476_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1476_MP24_1 (XI1476_asn pp8_30 XI1476_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1476_MP17 (XI1476_acon pp8_30 XI1476_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1476_MP14 (XI1476_ap1 pp7_32 XI1476_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1476_MP13 (VDD VDD XI1476_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1476_MP15 (XI1476_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1476_MP16 (VDD pp7_32 XI1476_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1476_MP28 (cm115_2 XI1476_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1476_MP19 (XI1476_ap3 pp7_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1476_MP20 (VDD pp8_30 XI1476_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1559_MP50 (VDD XI1559_s1 XI1559_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1559_MP47 (XI1559_bp3 cm120_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1559_MP49 (XI1559_bsn XI1559_bcon XI1559_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1559_MP52 (XI1559_bp5 cm197_2 XI1559_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1559_MP51 (XI1559_bp4 cm120_0 XI1559_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1559_MP51_1 (XI1559_bp5 cm120_0 XI1559_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1559_MP52_1 (XI1559_bsn cm197_2 XI1559_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1559_MP54 (VDD XI1559_bsn cm198_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1559_MP41 (XI1559_bp1 XI1559_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1559_MP42 (XI1559_bcon cm120_0 XI1559_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1559_MP45 (XI1559_bp2 cm197_2 XI1559_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1559_MP43 (VDD XI1559_s1 XI1559_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1559_MP44 (XI1559_bp2 cm120_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1559_MP56 (VDD XI1559_bcon cm198_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1559_MP46 (XI1559_bp3 XI1559_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1559_MP48 (VDD cm197_2 XI1559_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1559_MP50_1 (XI1559_bp4 XI1559_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1559_MP26 (VDD XI1559_asn XI1559_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1559_MP18 (XI1559_ap3 cm117_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1559_MP21 (XI1559_asn XI1559_acon XI1559_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1559_MP24 (XI1559_ap5 cm119_0 XI1559_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1559_MP23 (XI1559_ap4 cm118_1 XI1559_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1559_MP22 (VDD cm117_1 XI1559_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1559_MP22_1 (XI1559_ap4 cm117_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1559_MP23_1 (XI1559_ap5 cm118_1 XI1559_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1559_MP24_1 (XI1559_asn cm119_0 XI1559_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1559_MP17 (XI1559_acon cm119_0 XI1559_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1559_MP14 (XI1559_ap1 cm118_1 XI1559_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1559_MP13 (VDD cm117_1 XI1559_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1559_MP15 (XI1559_ap2 cm117_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1559_MP16 (VDD cm118_1 XI1559_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1559_MP28 (cm198_2 XI1559_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1559_MP19 (XI1559_ap3 cm118_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1559_MP20 (VDD cm119_0 XI1559_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1484_MP50 (VDD XI1484_s1 XI1484_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1484_MP47 (XI1484_bp3 pp11_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1484_MP49 (XI1484_bsn XI1484_bcon XI1484_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1484_MP52 (XI1484_bp5 cm121_2 XI1484_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1484_MP51 (XI1484_bp4 pp11_28 XI1484_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1484_MP51_1 (XI1484_bp5 pp11_28 XI1484_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1484_MP52_1 (XI1484_bsn cm121_2 XI1484_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1484_MP54 (VDD XI1484_bsn cm123_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1484_MP41 (XI1484_bp1 XI1484_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1484_MP42 (XI1484_bcon pp11_28 XI1484_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1484_MP45 (XI1484_bp2 cm121_2 XI1484_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1484_MP43 (VDD XI1484_s1 XI1484_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1484_MP44 (XI1484_bp2 pp11_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1484_MP56 (VDD XI1484_bcon cm123_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1484_MP46 (XI1484_bp3 XI1484_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1484_MP48 (VDD cm121_2 XI1484_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1484_MP50_1 (XI1484_bp4 XI1484_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1484_MP26 (VDD XI1484_asn XI1484_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1484_MP18 (XI1484_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1484_MP21 (XI1484_asn XI1484_acon XI1484_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1484_MP24 (XI1484_ap5 pp10_30 XI1484_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1484_MP23 (XI1484_ap4 pp9_32 XI1484_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1484_MP22 (VDD VDD XI1484_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1484_MP22_1 (XI1484_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1484_MP23_1 (XI1484_ap5 pp9_32 XI1484_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1484_MP24_1 (XI1484_asn pp10_30 XI1484_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1484_MP17 (XI1484_acon pp10_30 XI1484_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1484_MP14 (XI1484_ap1 pp9_32 XI1484_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1484_MP13 (VDD VDD XI1484_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1484_MP15 (XI1484_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1484_MP16 (VDD pp9_32 XI1484_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1484_MP28 (cm123_2 XI1484_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1484_MP19 (XI1484_ap3 pp9_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1484_MP20 (VDD pp10_30 XI1484_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1459_MP50 (VDD XI1459_s1 XI1459_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1459_MP47 (XI1459_bp3 pp6_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1459_MP49 (XI1459_bsn XI1459_bcon XI1459_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1459_MP52 (XI1459_bp5 cm95_2 XI1459_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1459_MP51 (XI1459_bp4 pp6_28 XI1459_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1459_MP51_1 (XI1459_bp5 pp6_28 XI1459_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1459_MP52_1 (XI1459_bsn cm95_2 XI1459_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1459_MP54 (VDD XI1459_bsn cm98_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1459_MP41 (XI1459_bp1 XI1459_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1459_MP42 (XI1459_bcon pp6_28 XI1459_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1459_MP45 (XI1459_bp2 cm95_2 XI1459_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1459_MP43 (VDD XI1459_s1 XI1459_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1459_MP44 (XI1459_bp2 pp6_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1459_MP56 (VDD XI1459_bcon cm98_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1459_MP46 (XI1459_bp3 XI1459_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1459_MP48 (VDD cm95_2 XI1459_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1459_MP50_1 (XI1459_bp4 XI1459_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1459_MP26 (VDD XI1459_asn XI1459_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1459_MP18 (XI1459_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1459_MP21 (XI1459_asn XI1459_acon XI1459_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1459_MP24 (XI1459_ap5 pp5_30 XI1459_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1459_MP23 (XI1459_ap4 pp4_32 XI1459_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1459_MP22 (VDD VDD XI1459_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1459_MP22_1 (XI1459_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1459_MP23_1 (XI1459_ap5 pp4_32 XI1459_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1459_MP24_1 (XI1459_asn pp5_30 XI1459_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1459_MP17 (XI1459_acon pp5_30 XI1459_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1459_MP14 (XI1459_ap1 pp4_32 XI1459_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1459_MP13 (VDD VDD XI1459_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1459_MP15 (XI1459_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1459_MP16 (VDD pp4_32 XI1459_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1459_MP28 (cm98_2 XI1459_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1459_MP19 (XI1459_ap3 pp4_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1459_MP20 (VDD pp5_30 XI1459_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1451_MP50 (VDD XI1451_s1 XI1451_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1451_MP47 (XI1451_bp3 pp9_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1451_MP49 (XI1451_bsn XI1451_bcon XI1451_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1451_MP52 (XI1451_bp5 cm86_2 XI1451_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1451_MP51 (XI1451_bp4 pp9_19 XI1451_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1451_MP51_1 (XI1451_bp5 pp9_19 XI1451_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1451_MP52_1 (XI1451_bsn cm86_2 XI1451_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1451_MP54 (VDD XI1451_bsn cm90_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1451_MP41 (XI1451_bp1 XI1451_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1451_MP42 (XI1451_bcon pp9_19 XI1451_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1451_MP45 (XI1451_bp2 cm86_2 XI1451_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1451_MP43 (VDD XI1451_s1 XI1451_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1451_MP44 (XI1451_bp2 pp9_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1451_MP56 (VDD XI1451_bcon cm90_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1451_MP46 (XI1451_bp3 XI1451_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1451_MP48 (VDD cm86_2 XI1451_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1451_MP50_1 (XI1451_bp4 XI1451_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
