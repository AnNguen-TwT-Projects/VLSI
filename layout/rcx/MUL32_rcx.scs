    I_MXI511_MN16 (XI511_xn2 B_1_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI511_MN15 (pp0_8 XI511_xan XI511_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI511_MN13 (XI511_xn1 XI511_xn pp0_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI511_MN2 (VSS A_8_b3_0 XI511_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI511_MN4 (XI511_n2 A_7_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI511_MN3 (XI511_xn two0_b3_1 XI511_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI511_MN1 (XI511_n1 one0_b3_1 XI511_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI511_MN9 (VSS XI511_xn XI511_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI778_MN11 (VSS B_11_b3_0 XI778_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI778_MN14 (VSS XI778_xbn XI778_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI778_MN16 (XI778_xn2 B_11_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI778_MN15 (pp5_0 XI778_xan XI778_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI778_MN13 (XI778_xn1 XI778_xn pp5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI778_MN2 (VSS A_0_b3_1 XI778_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI778_MN4 (XI778_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI778_MN3 (XI778_xn two5_b3_0 XI778_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI778_MN1 (XI778_n1 one5_b3_0 XI778_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI778_MN9 (VSS XI778_xn XI778_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI779_MN11 (VSS B_11_b3_0 XI779_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI779_MN14 (VSS XI779_xbn XI779_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI779_MN16 (XI779_xn2 B_11_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI779_MN15 (pp5_1 XI779_xan XI779_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI779_MN13 (XI779_xn1 XI779_xn pp5_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI779_MN2 (VSS A_1_b3_1 XI779_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI779_MN4 (XI779_n2 A_0_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI779_MN3 (XI779_xn two5_b3_0 XI779_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI779_MN1 (XI779_n1 one5_b3_0 XI779_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI779_MN9 (VSS XI779_xn XI779_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI725_MN11 (VSS B_9_b3_0 XI725_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI725_MN14 (VSS XI725_xbn XI725_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI725_MN16 (XI725_xn2 B_9_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI725_MN15 (pp4_2 XI725_xan XI725_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI725_MN13 (XI725_xn1 XI725_xn pp4_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI725_MN2 (VSS A_2_b3_1 XI725_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI725_MN4 (XI725_n2 A_1_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI725_MN3 (XI725_xn two4_b3_0 XI725_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI725_MN1 (XI725_n1 one4_b3_0 XI725_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI725_MN9 (VSS XI725_xn XI725_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI724_MN11 (VSS B_9_b3_0 XI724_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI724_MN14 (VSS XI724_xbn XI724_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI724_MN16 (XI724_xn2 B_9_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI724_MN15 (pp4_1 XI724_xan XI724_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI724_MN13 (XI724_xn1 XI724_xn pp4_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI724_MN2 (VSS A_1_b3_1 XI724_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI724_MN4 (XI724_n2 A_0_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI724_MN3 (XI724_xn two4_b3_0 XI724_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI724_MN1 (XI724_n1 one4_b3_0 XI724_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI724_MN9 (VSS XI724_xn XI724_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI723_MN11 (VSS B_9_b3_0 XI723_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI723_MN14 (VSS XI723_xbn XI723_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI723_MN16 (XI723_xn2 B_9_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI723_MN15 (pp4_0 XI723_xan XI723_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI723_MN13 (XI723_xn1 XI723_xn pp4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI723_MN2 (VSS A_0_b3_1 XI723_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI723_MN4 (XI723_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI723_MN3 (XI723_xn two4_b3_0 XI723_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI723_MN1 (XI723_n1 one4_b3_0 XI723_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI723_MN9 (VSS XI723_xn XI723_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI670_MN11 (VSS B_7_b3_0 XI670_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI670_MN14 (VSS XI670_xbn XI670_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI670_MN16 (XI670_xn2 B_7_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI670_MN15 (pp3_2 XI670_xan XI670_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI670_MN13 (XI670_xn1 XI670_xn pp3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI670_MN2 (VSS A_2_b3_1 XI670_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI670_MN4 (XI670_n2 A_1_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI670_MN3 (XI670_xn two3_b3_0 XI670_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI670_MN1 (XI670_n1 one3_b3_0 XI670_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI670_MN9 (VSS XI670_xn XI670_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI671_MN11 (VSS B_7_b3_0 XI671_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI671_MN14 (VSS XI671_xbn XI671_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI671_MN16 (XI671_xn2 B_7_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI671_MN15 (pp3_3 XI671_xan XI671_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI671_MN13 (XI671_xn1 XI671_xn pp3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI671_MN2 (VSS A_3_b3_1 XI671_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI671_MN4 (XI671_n2 A_2_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI671_MN3 (XI671_xn two3_b3_0 XI671_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI671_MN1 (XI671_n1 one3_b3_0 XI671_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI671_MN9 (VSS XI671_xn XI671_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1660_I55_MN1 (XI1660_I55_n1 fa245_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I55_MN0 (I1660_gn55 fa296_1 XI1660_I55_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I38_MN1 (XI1660_I38_n1 ha282_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I38_MN0 (I1660_gn38 fa281_1 XI1660_I38_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I40_MN1 (XI1660_I40_n1 ha284_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I40_MN0 (I1660_gn40 fa283_1 XI1660_I40_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I43_MN1 (XI1660_I43_n1 fa287_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I43_MN0 (I1660_gn43 ha286_1 XI1660_I43_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I46_MN1 (XI1660_I46_n1 ha290_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I46_MN0 (I1660_gn46 fa289_1 XI1660_I46_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I57_MN1 (XI1660_I57_n1 fa246_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I57_MN0 (I1660_gn57 fa297_1 XI1660_I57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I39_MN1 (XI1660_I39_n1 fa283_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I39_MN0 (I1660_gn39 ha282_1 XI1660_I39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I41_MN1 (XI1660_I41_n1 fa285_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I41_MN0 (I1660_gn41 ha284_1 XI1660_I41_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I42_MN1 (XI1660_I42_n1 ha286_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I42_MN0 (I1660_gn42 fa285_1 XI1660_I42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I44_MN1 (XI1660_I44_n1 ha288_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I44_MN0 (I1660_gn44 fa287_1 XI1660_I44_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I45_MN1 (XI1660_I45_n1 fa289_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I45_MN0 (I1660_gn45 ha288_1 XI1660_I45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I47_MN1 (XI1660_I47_n1 fa291_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I47_MN0 (I1660_gn47 ha290_1 XI1660_I47_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I53_MN1 (XI1660_I53_n1 fa244_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I53_MN0 (I1660_gn53 fa295_1 XI1660_I53_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I54_MN1 (XI1660_I54_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I54_MN0 (I1660_gn54 fa296_0 XI1660_I54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I36_MN1 (XI1660_I36_n1 fa280_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I36_MN0 (I1660_gn36 ha279_1 XI1660_I36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I37_MN1 (XI1660_I37_n1 fa281_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I37_MN0 (I1660_gn37 fa280_1 XI1660_I37_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I48_MN1 (XI1660_I48_n1 ha292_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I48_MN0 (I1660_gn48 fa291_1 XI1660_I48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I49_MN1 (XI1660_I49_n1 fa293_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I49_MN0 (I1660_gn49 ha292_1 XI1660_I49_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I51_MN1 (XI1660_I51_n1 fa243_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I51_MN0 (I1660_gn51 ha294_1 XI1660_I51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I59_MN1 (XI1660_I59_n1 fa207_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I59_MN0 (I1660_gn59 fa298_1 XI1660_I59_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I52_MN1 (XI1660_I52_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I52_MN0 (I1660_gn52 fa295_0 XI1660_I52_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I35_MN1 (XI1660_I35_n1 ha279_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I35_MN0 (I1660_gn35 ha278_1 XI1660_I35_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I50_MN1 (XI1660_I50_n1 ha294_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I50_MN0 (I1660_gn50 fa293_1 XI1660_I50_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I61_MN1 (XI1660_I61_n1 fa208_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I61_MN0 (I1660_gn61 fa247_1 XI1660_I61_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I58_MN1 (XI1660_I58_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I58_MN0 (I1660_gn58 fa298_0 XI1660_I58_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I56_MN1 (XI1660_I56_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I56_MN0 (I1660_gn56 fa297_0 XI1660_I56_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I34_MN1 (XI1660_I34_n1 ha278_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I34_MN0 (I1660_gn34 ha277_1 XI1660_I34_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I232_XP_MN1 (XI1660_I232_XP_n1 I1660_P38_37 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I232_XP_MN0 (I1660_P40_37n I1660_P40_39 XI1660_I232_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I234_XP_MN1 (XI1660_I234_XP_n1 I1660_P40_39 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I234_XP_MN0 (I1660_P42_39n I1660_P42_41 XI1660_I234_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I236_XP_MN1 (XI1660_I236_XP_n1 I1660_P42_41 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I236_XP_MN0 (I1660_P44_41n I1660_P44_43 XI1660_I236_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I238_XP_MN1 (XI1660_I238_XP_n1 I1660_P44_43 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I238_XP_MN0 (I1660_P46_43n I1660_P46_45 XI1660_I238_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I240_XP_MN1 (XI1660_I240_XP_n1 I1660_P46_45 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I240_XP_MN0 (I1660_P48_45n I1660_P48_47 XI1660_I240_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I242_XP_MN1 (XI1660_I242_XP_n1 I1660_P48_47 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I242_XP_MN0 (I1660_P50_47n I1660_P50_49 XI1660_I242_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I244_XP_MN1 (XI1660_I244_XP_n1 I1660_P50_49 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I244_XP_MN0 (I1660_P52_49n I1660_P52_51 XI1660_I244_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I60_MN1 (XI1660_I60_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I60_MN0 (I1660_gn60 fa247_0 XI1660_I60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I32_MN1 (XI1660_I32_n1 ha276_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I32_MN0 (I1660_gn32 ha275_1 XI1660_I32_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I33_MN1 (XI1660_I33_n1 ha277_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I33_MN0 (I1660_gn33 ha276_1 XI1660_I33_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I371_XP_MN1 (XI1660_I371_XP_n1 I1660_P52_45 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I371_XP_MN0 (I1660_P60_45n I1660_P60_53 XI1660_I371_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I246_XP_MN1 (XI1660_I246_XP_n1 I1660_P52_51 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I246_XP_MN0 (I1660_P54_51n I1660_P54_53 XI1660_I246_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I252_XP_MN1 (XI1660_I252_XP_n1 I1660_P58_57 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I252_XP_MN0 (I1660_P60_57n I1660_P60_59 XI1660_I252_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I248_XP_MN1 (XI1660_I248_XP_n1 I1660_P54_53 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I248_XP_MN0 (I1660_P56_53n I1660_P56_55 XI1660_I248_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I31_MN1 (XI1660_I31_n1 ha275_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I31_MN0 (I1660_gn31 ha274_1 XI1660_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I230_XP_MN1 (XI1660_I230_XP_n1 I1660_P36_35 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I230_XP_MN0 (I1660_P38_35n I1660_P38_37 XI1660_I230_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I363_XP_MN1 (XI1660_I363_XP_n1 I1660_P44_37 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I363_XP_MN0 (I1660_P52_37n I1660_P52_45 XI1660_I363_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I367_XP_MN1 (XI1660_I367_XP_n1 I1660_P48_41 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I367_XP_MN0 (I1660_P56_41n I1660_P56_49 XI1660_I367_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I250_XP_MN1 (XI1660_I250_XP_n1 I1660_P56_55 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I250_XP_MN0 (I1660_P58_55n I1660_P58_57 XI1660_I250_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I254_XP_MN1 (XI1660_I254_XP_n1 I1660_P60_59 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I254_XP_MN0 (I1660_P62_59n I1660_P62_61 XI1660_I254_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I62_MN1 (XI1660_I62_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I62_MN0 (I1660_gn62 fa248_0 XI1660_I62_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I63_MN1 (XI1660_I63_n1 sn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I63_MN0 (I1660_gn63 fa248_1 XI1660_I63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I228_XP_MN1 (XI1660_I228_XP_n1 I1660_P34_33 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I228_XP_MN0 (I1660_P36_33n I1660_P36_35 XI1660_I228_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I355_XP_MN1 (XI1660_I355_XP_n1 I1660_P36_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I355_XP_MN0 (I1660_P44_29n I1660_P44_37 XI1660_I355_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I373_XP_MN1 (XI1660_I373_XP_n1 I1660_P54_47 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I373_XP_MN0 (I1660_P62_47n I1660_P62_55 XI1660_I373_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I255_XP_MN1 (XI1660_I255_XP_n1 I1660_P61_60 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I255_XP_MN0 (I1660_P63_60n I1660_P63_62 XI1660_I255_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I30_MN1 (XI1660_I30_n1 ha274_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I30_MN0 (I1660_gn30 ha273_1 XI1660_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I226_XP_MN1 (XI1660_I226_XP_n1 I1660_P32_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I226_XP_MN0 (I1660_P34_31n I1660_P34_33 XI1660_I226_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I359_XP_MN1 (XI1660_I359_XP_n1 I1660_P40_33 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I359_XP_MN0 (I1660_P48_33n I1660_P48_41 XI1660_I359_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I361_XP_MN1 (XI1660_I361_XP_n1 I1660_P42_35 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I361_XP_MN0 (I1660_P50_35n I1660_P50_43 XI1660_I361_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I357_XP_MN1 (XI1660_I357_XP_n1 I1660_P38_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I357_XP_MN0 (I1660_P46_31n I1660_P46_39 XI1660_I357_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I365_XP_MN1 (XI1660_I365_XP_n1 I1660_P46_39 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I365_XP_MN0 (I1660_P54_39n I1660_P54_47 XI1660_I365_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I369_XP_MN1 (XI1660_I369_XP_n1 I1660_P50_43 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I369_XP_MN0 (I1660_P58_43n I1660_P58_51 XI1660_I369_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I253_XP_MN1 (XI1660_I253_XP_n1 I1660_P59_58 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I253_XP_MN0 (I1660_P61_58n I1660_P61_60 XI1660_I253_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I29_MN1 (XI1660_I29_n1 ha273_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I29_MN0 (I1660_gn29 ha272_1 XI1660_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I224_XP_MN1 (XI1660_I224_XP_n1 I1660_P30_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I224_XP_MN0 (I1660_P32_29n I1660_P32_31 XI1660_I224_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I239_XP_MN1 (XI1660_I239_XP_n1 I1660_P45_44 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I239_XP_MN0 (I1660_P47_44n I1660_P47_46 XI1660_I239_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I241_XP_MN1 (XI1660_I241_XP_n1 I1660_P47_46 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I241_XP_MN0 (I1660_P49_46n I1660_P49_48 XI1660_I241_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I243_XP_MN1 (XI1660_I243_XP_n1 I1660_P49_48 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I243_XP_MN0 (I1660_P51_48n I1660_P51_50 XI1660_I243_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I245_XP_MN1 (XI1660_I245_XP_n1 I1660_P51_50 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I245_XP_MN0 (I1660_P53_50n I1660_P53_52 XI1660_I245_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I247_XP_MN1 (XI1660_I247_XP_n1 I1660_P53_52 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I247_XP_MN0 (I1660_P55_52n I1660_P55_54 XI1660_I247_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I28_MN1 (XI1660_I28_n1 ha272_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I28_MN0 (I1660_gn28 ha271_1 XI1660_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I222_XP_MN1 (XI1660_I222_XP_n1 I1660_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I222_XP_MN0 (I1660_P30_27n I1660_P30_29 XI1660_I222_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I351_XP_MN1 (XI1660_I351_XP_n1 I1660_P32_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I351_XP_MN0 (I1660_P40_25n I1660_P40_33 XI1660_I351_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I353_XP_MN1 (XI1660_I353_XP_n1 I1660_P34_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I353_XP_MN0 (I1660_P42_27n I1660_P42_35 XI1660_I353_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I349_XP_MN1 (XI1660_I349_XP_n1 I1660_P30_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I349_XP_MN0 (I1660_P38_23n I1660_P38_31 XI1660_I349_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I237_XP_MN1 (XI1660_I237_XP_n1 I1660_P43_42 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I237_XP_MN0 (I1660_P45_42n I1660_P45_44 XI1660_I237_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I249_XP_MN1 (XI1660_I249_XP_n1 I1660_P55_54 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I249_XP_MN0 (I1660_P57_54n I1660_P57_56 XI1660_I249_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I251_XP_MN1 (XI1660_I251_XP_n1 I1660_P57_56 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I251_XP_MN0 (I1660_P59_56n I1660_P59_58 XI1660_I251_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I26_MN1 (XI1660_I26_n1 ha270_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I26_MN0 (I1660_gn26 ha269_1 XI1660_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I27_MN1 (XI1660_I27_n1 ha271_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I27_MN0 (I1660_gn27 ha270_1 XI1660_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I347_XP_MN1 (XI1660_I347_XP_n1 I1660_P28_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I347_XP_MN0 (I1660_P36_21n I1660_P36_29 XI1660_I347_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I341_XP_MN1 (XI1660_I341_XP_n1 I1660_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I341_XP_MN0 (I1660_P30_15n I1660_P30_23 XI1660_I341_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I372_XP_MN1 (XI1660_I372_XP_n1 I1660_P53_46 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I372_XP_MN0 (I1660_P61_46n I1660_P61_54 XI1660_I372_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I25_MN1 (XI1660_I25_n1 ha269_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I25_MN0 (I1660_gn25 ha268_1 XI1660_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I220_XP_MN1 (XI1660_I220_XP_n1 I1660_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I220_XP_MN0 (I1660_P28_25n I1660_P28_27 XI1660_I220_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I339_XP_MN1 (XI1660_I339_XP_n1 I1660_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I339_XP_MN0 (I1660_P28_13n I1660_P28_21 XI1660_I339_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I345_XP_MN1 (XI1660_I345_XP_n1 I1660_P26_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I345_XP_MN0 (I1660_P34_19n I1660_P34_27 XI1660_I345_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I235_XP_MN1 (XI1660_I235_XP_n1 I1660_P41_40 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I235_XP_MN0 (I1660_P43_40n I1660_P43_42 XI1660_I235_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I233_XP_MN1 (XI1660_I233_XP_n1 I1660_P39_38 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I233_XP_MN0 (I1660_P41_38n I1660_P41_40 XI1660_I233_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I364_XP_MN1 (XI1660_I364_XP_n1 I1660_P45_38 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I364_XP_MN0 (I1660_P53_38n I1660_P53_46 XI1660_I364_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I24_MN1 (XI1660_I24_n1 ha268_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I24_MN0 (I1660_gn24 ha267_1 XI1660_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I23_MN1 (XI1660_I23_n1 ha267_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I23_MN0 (I1660_gn23 ha266_1 XI1660_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I218_XP_MN1 (XI1660_I218_XP_n1 I1660_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I218_XP_MN0 (I1660_P26_23n I1660_P26_25 XI1660_I218_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I343_XP_MN1 (XI1660_I343_XP_n1 I1660_P24_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I343_XP_MN0 (I1660_P32_17n I1660_P32_25 XI1660_I343_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I337_XP_MN1 (XI1660_I337_XP_n1 I1660_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I337_XP_MN0 (I1660_P26_11n I1660_P26_19 XI1660_I337_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I231_XP_MN1 (XI1660_I231_XP_n1 I1660_P37_36 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I231_XP_MN0 (I1660_P39_36n I1660_P39_38 XI1660_I231_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I356_XP_MN1 (XI1660_I356_XP_n1 I1660_P37_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I356_XP_MN0 (I1660_P45_30n I1660_P45_38 XI1660_I356_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I368_XP_MN1 (XI1660_I368_XP_n1 I1660_P49_42 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I368_XP_MN0 (I1660_P57_42n I1660_P57_50 XI1660_I368_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I370_XP_MN1 (XI1660_I370_XP_n1 I1660_P51_44 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I370_XP_MN0 (I1660_P59_44n I1660_P59_52 XI1660_I370_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I374_XP_MN1 (XI1660_I374_XP_n1 I1660_P55_48 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I374_XP_MN0 (I1660_P63_48n I1660_P63_56 XI1660_I374_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I22_MN1 (XI1660_I22_n1 ha266_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I22_MN0 (I1660_gn22 ha265_1 XI1660_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I216_XP_MN1 (XI1660_I216_XP_n1 I1660_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I216_XP_MN0 (I1660_P24_21n I1660_P24_23 XI1660_I216_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I335_XP_MN1 (XI1660_I335_XP_n1 I1660_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I335_XP_MN0 (I1660_P24_9n I1660_P24_17 XI1660_I335_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I227_XP_MN1 (XI1660_I227_XP_n1 I1660_P33_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I227_XP_MN0 (I1660_P35_32n I1660_P35_34 XI1660_I227_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I229_XP_MN1 (XI1660_I229_XP_n1 I1660_P35_34 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I229_XP_MN0 (I1660_P37_34n I1660_P37_36 XI1660_I229_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I366_XP_MN1 (XI1660_I366_XP_n1 I1660_P47_40 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I366_XP_MN0 (I1660_P55_40n I1660_P55_48 XI1660_I366_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I21_MN1 (XI1660_I21_n1 ha265_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I21_MN0 (I1660_gn21 ha264_1 XI1660_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I214_XP_MN1 (XI1660_I214_XP_n1 I1660_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I214_XP_MN0 (I1660_P22_19n I1660_P22_21 XI1660_I214_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I333_XP_MN1 (XI1660_I333_XP_n1 I1660_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I333_XP_MN0 (I1660_P22_7n I1660_P22_15 XI1660_I333_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I223_XP_MN1 (XI1660_I223_XP_n1 I1660_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I223_XP_MN0 (I1660_P31_28n I1660_P31_30 XI1660_I223_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I225_XP_MN1 (XI1660_I225_XP_n1 I1660_P31_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I225_XP_MN0 (I1660_P33_30n I1660_P33_32 XI1660_I225_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I352_XP_MN1 (XI1660_I352_XP_n1 I1660_P33_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I352_XP_MN0 (I1660_P41_26n I1660_P41_34 XI1660_I352_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I360_XP_MN1 (XI1660_I360_XP_n1 I1660_P41_34 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I360_XP_MN0 (I1660_P49_34n I1660_P49_42 XI1660_I360_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I362_XP_MN1 (XI1660_I362_XP_n1 I1660_P43_36 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I362_XP_MN0 (I1660_P51_36n I1660_P51_44 XI1660_I362_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I358_XP_MN1 (XI1660_I358_XP_n1 I1660_P39_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I358_XP_MN0 (I1660_P47_32n I1660_P47_40 XI1660_I358_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I20_MN1 (XI1660_I20_n1 ha264_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I20_MN0 (I1660_gn20 ha263_1 XI1660_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I19_MN1 (XI1660_I19_n1 ha263_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I19_MN0 (I1660_gn19 ha262_1 XI1660_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I331_XP_MN1 (XI1660_I331_XP_n1 I1660_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I331_XP_MN0 (I1660_P20_5n I1660_P20_13 XI1660_I331_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I219_XP_MN1 (XI1660_I219_XP_n1 I1660_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I219_XP_MN0 (I1660_P27_24n I1660_P27_26 XI1660_I219_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I221_XP_MN1 (XI1660_I221_XP_n1 I1660_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I221_XP_MN0 (I1660_P29_26n I1660_P29_28 XI1660_I221_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I354_XP_MN1 (XI1660_I354_XP_n1 I1660_P35_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I354_XP_MN0 (I1660_P43_28n I1660_P43_36 XI1660_I354_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I18_MN1 (XI1660_I18_n1 ha262_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I18_MN0 (I1660_gn18 ha261_1 XI1660_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I212_XP_MN1 (XI1660_I212_XP_n1 I1660_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I212_XP_MN0 (I1660_P20_17n I1660_P20_19 XI1660_I212_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I217_XP_MN1 (XI1660_I217_XP_n1 I1660_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I217_XP_MN0 (I1660_P25_22n I1660_P25_24 XI1660_I217_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I215_XP_MN1 (XI1660_I215_XP_n1 I1660_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I215_XP_MN0 (I1660_P23_20n I1660_P23_22 XI1660_I215_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I348_XP_MN1 (XI1660_I348_XP_n1 I1660_P29_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I348_XP_MN0 (I1660_P37_22n I1660_P37_30 XI1660_I348_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I350_XP_MN1 (XI1660_I350_XP_n1 I1660_P31_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I350_XP_MN0 (I1660_P39_24n I1660_P39_32 XI1660_I350_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I342_XP_MN1 (XI1660_I342_XP_n1 I1660_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I342_XP_MN0 (I1660_P31_16n I1660_P31_24 XI1660_I342_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I0_MN1 (XI1660_I0_n1 B_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I0_MN0 (I1660_gn0 pp0_0 XI1660_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I17_MN1 (XI1660_I17_n1 ha261_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I17_MN0 (I1660_gn17 ha260_1 XI1660_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I210_XP_MN1 (XI1660_I210_XP_n1 I1660_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I210_XP_MN0 (I1660_P18_15n I1660_P18_17 XI1660_I210_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I327_XP_MN1 (XI1660_I327_XP_n1 I1660_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I327_XP_MN0 (I1660_P16_1n I1660_P16_9 XI1660_I327_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I329_XP_MN1 (XI1660_I329_XP_n1 I1660_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I329_XP_MN0 (I1660_P18_3n I1660_P18_11 XI1660_I329_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I213_XP_MN1 (XI1660_I213_XP_n1 I1660_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I213_XP_MN0 (I1660_P21_18n I1660_P21_20 XI1660_I213_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I340_XP_MN1 (XI1660_I340_XP_n1 I1660_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I340_XP_MN0 (I1660_P29_14n I1660_P29_22 XI1660_I340_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I16_MN1 (XI1660_I16_n1 ha260_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I16_MN0 (I1660_gn16 ha259_1 XI1660_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I208_XP_MN1 (XI1660_I208_XP_n1 I1660_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I208_XP_MN0 (I1660_P16_13n I1660_P16_15 XI1660_I208_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I211_XP_MN1 (XI1660_I211_XP_n1 I1660_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I211_XP_MN0 (I1660_P19_16n I1660_P19_18 XI1660_I211_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I344_XP_MN1 (XI1660_I344_XP_n1 I1660_P25_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I344_XP_MN0 (I1660_P33_18n I1660_P33_26 XI1660_I344_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I336_XP_MN1 (XI1660_I336_XP_n1 I1660_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I336_XP_MN0 (I1660_P25_10n I1660_P25_18 XI1660_I336_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I346_XP_MN1 (XI1660_I346_XP_n1 I1660_P27_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I346_XP_MN0 (I1660_P35_20n I1660_P35_28 XI1660_I346_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I338_XP_MN1 (XI1660_I338_XP_n1 I1660_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I338_XP_MN0 (I1660_P27_12n I1660_P27_20 XI1660_I338_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I15_MN1 (XI1660_I15_n1 ha259_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I15_MN0 (I1660_gn15 ha258_1 XI1660_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I202_XP_MN1 (XI1660_I202_XP_n1 I1660_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I202_XP_MN0 (I1660_P10_7n I1660_P10_9 XI1660_I202_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I200_XP_MN1 (XI1660_I200_XP_n1 I1660_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I200_XP_MN0 (I1660_P8_5n I1660_P8_7 XI1660_I200_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I196_XP_MN1 (XI1660_I196_XP_n1 I1660_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I196_XP_MN0 (I1660_P4_1n I1660_P4_3 XI1660_I196_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I198_XP_MN1 (XI1660_I198_XP_n1 I1660_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I198_XP_MN0 (I1660_P6_3n I1660_P6_5 XI1660_I198_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I209_XP_MN1 (XI1660_I209_XP_n1 I1660_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I209_XP_MN0 (I1660_P17_14n I1660_P17_16 XI1660_I209_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I332_XP_MN1 (XI1660_I332_XP_n1 I1660_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I332_XP_MN0 (I1660_P21_6n I1660_P21_14 XI1660_I332_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I334_XP_MN1 (XI1660_I334_XP_n1 I1660_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I334_XP_MN0 (I1660_P23_8n I1660_P23_16 XI1660_I334_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I14_MN1 (XI1660_I14_n1 ha258_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I14_MN0 (I1660_gn14 ha257_1 XI1660_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I206_XP_MN1 (XI1660_I206_XP_n1 I1660_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I206_XP_MN0 (I1660_P14_11n I1660_P14_13 XI1660_I206_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I204_XP_MN1 (XI1660_I204_XP_n1 I1660_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I204_XP_MN0 (I1660_P12_9n I1660_P12_11 XI1660_I204_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I1_MN1 (XI1660_I1_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I1_MN0 (I1660_gn1 pp0_1 XI1660_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I207_XP_MN1 (XI1660_I207_XP_n1 I1660_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I207_XP_MN0 (I1660_P15_12n I1660_P15_14 XI1660_I207_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I328_XP_MN1 (XI1660_I328_XP_n1 I1660_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I328_XP_MN0 (I1660_P17_2n I1660_P17_10 XI1660_I328_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I13_MN1 (XI1660_I13_n1 ha257_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I13_MN0 (I1660_gn13 ha256_1 XI1660_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I6_MN1 (XI1660_I6_n1 ha250_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I6_MN0 (I1660_gn6 fa249_1 XI1660_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I2_MN1 (XI1660_I2_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I2_MN0 (I1660_gn2 fa1_0 XI1660_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I3_MN1 (XI1660_I3_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I3_MN0 (I1660_gn3 fa137_0 XI1660_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I205_XP_MN1 (XI1660_I205_XP_n1 I1660_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I205_XP_MN0 (I1660_P13_10n I1660_P13_12 XI1660_I205_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I203_XP_MN1 (XI1660_I203_XP_n1 I1660_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I203_XP_MN0 (I1660_P11_8n I1660_P11_10 XI1660_I203_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I330_XP_MN1 (XI1660_I330_XP_n1 I1660_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I330_XP_MN0 (I1660_P19_4n I1660_P19_12 XI1660_I330_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I12_MN1 (XI1660_I12_n1 ha256_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I12_MN0 (I1660_gn12 ha255_1 XI1660_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I11_MN1 (XI1660_I11_n1 ha255_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I11_MN0 (I1660_gn11 ha254_1 XI1660_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I7_MN1 (XI1660_I7_n1 ha251_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I7_MN0 (I1660_gn7 ha250_1 XI1660_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I5_MN1 (XI1660_I5_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I5_MN0 (I1660_gn5 fa249_0 XI1660_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I4_MN1 (XI1660_I4_n1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I4_MN0 (I1660_gn4 fa209_0 XI1660_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I201_XP_MN1 (XI1660_I201_XP_n1 I1660_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I201_XP_MN0 (I1660_P9_6n I1660_P9_8 XI1660_I201_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I199_XP_MN1 (XI1660_I199_XP_n1 I1660_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I199_XP_MN0 (I1660_P7_4n I1660_P7_6 XI1660_I199_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I10_MN1 (XI1660_I10_n1 ha254_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I10_MN0 (I1660_gn10 ha253_1 XI1660_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I9_MN1 (XI1660_I9_n1 ha253_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I9_MN0 (I1660_gn9 ha252_1 XI1660_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I8_MN1 (XI1660_I8_n1 ha252_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I8_MN0 (I1660_gn8 ha251_1 XI1660_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I197_XP_MN1 (XI1660_I197_XP_n1 I1660_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1660_I197_XP_MN0 (I1660_P5_2n I1660_P5_4 XI1660_I197_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1660_I170_XP_MN0 (I1660_P40_39 I1660_pn40 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I170_XP_MN1 (VSS I1660_pn39 I1660_P40_39 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I172_XP_MN0 (I1660_P42_41 I1660_pn42 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I172_XP_MN1 (VSS I1660_pn41 I1660_P42_41 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I174_XP_MN0 (I1660_P44_43 I1660_pn44 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I174_XP_MN1 (VSS I1660_pn43 I1660_P44_43 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I176_XP_MN0 (I1660_P46_45 I1660_pn46 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I176_XP_MN1 (VSS I1660_pn45 I1660_P46_45 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I178_XP_MN0 (I1660_P48_47 I1660_pn48 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I178_XP_MN1 (VSS I1660_pn47 I1660_P48_47 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I180_XP_MN0 (I1660_P50_49 I1660_pn50 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I180_XP_MN1 (VSS I1660_pn49 I1660_P50_49 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I182_XP_MN0 (I1660_P52_51 I1660_pn52 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I182_XP_MN1 (VSS I1660_pn51 I1660_P52_51 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I168_XP_MN0 (I1660_P38_37 I1660_pn38 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I168_XP_MN1 (VSS I1660_pn37 I1660_P38_37 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I297_XP_MN0 (I1660_P44_37 I1660_P44_41n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I297_XP_MN1 (VSS I1660_P40_37n I1660_P44_37 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I301_XP_MN0 (I1660_P48_41 I1660_P48_45n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I301_XP_MN1 (VSS I1660_P44_41n I1660_P48_41 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I305_XP_MN0 (I1660_P52_45 I1660_P52_49n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I305_XP_MN1 (VSS I1660_P48_45n I1660_P52_45 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I309_XP_MN0 (I1660_P56_49 I1660_P56_53n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I309_XP_MN1 (VSS I1660_P52_49n I1660_P56_49 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I313_XP_MN0 (I1660_P60_53 I1660_P60_57n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I313_XP_MN1 (VSS I1660_P56_53n I1660_P60_53 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I184_XP_MN0 (I1660_P54_53 I1660_pn54 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I184_XP_MN1 (VSS I1660_pn53 I1660_P54_53 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I186_XP_MN0 (I1660_P56_55 I1660_pn56 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I186_XP_MN1 (VSS I1660_pn55 I1660_P56_55 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I166_XP_MN0 (I1660_P36_35 I1660_pn36 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I166_XP_MN1 (VSS I1660_pn35 I1660_P36_35 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I299_XP_MN0 (I1660_P46_39 I1660_P46_43n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I299_XP_MN1 (VSS I1660_P42_39n I1660_P46_39 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I303_XP_MN0 (I1660_P50_43 I1660_P50_47n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I303_XP_MN1 (VSS I1660_P46_43n I1660_P50_43 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I307_XP_MN0 (I1660_P54_47 I1660_P54_51n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I307_XP_MN1 (VSS I1660_P50_47n I1660_P54_47 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I311_XP_MN0 (I1660_P58_51 I1660_P58_55n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I311_XP_MN1 (VSS I1660_P54_51n I1660_P58_51 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I315_XP_MN0 (I1660_P62_55 I1660_P62_59n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I315_XP_MN1 (VSS I1660_P58_55n I1660_P62_55 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I190_XP_MN0 (I1660_P60_59 I1660_pn60 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I190_XP_MN1 (VSS I1660_pn59 I1660_P60_59 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I188_XP_MN0 (I1660_P58_57 I1660_pn58 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I188_XP_MN1 (VSS I1660_pn57 I1660_P58_57 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I293_XP_MN0 (I1660_P40_33 I1660_P40_37n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I293_XP_MN1 (VSS I1660_P36_33n I1660_P40_33 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I295_XP_MN0 (I1660_P42_35 I1660_P42_39n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I295_XP_MN1 (VSS I1660_P38_35n I1660_P42_35 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I423_XP_MN0 (I1660_P60_29 I1660_P60_45n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I423_XP_MN1 (VSS I1660_P44_29n I1660_P60_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I175_XP_MN0 (I1660_P45_44 I1660_pn45 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I175_XP_MN1 (VSS I1660_pn44 I1660_P45_44 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I181_XP_MN0 (I1660_P51_50 I1660_pn51 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I181_XP_MN1 (VSS I1660_pn50 I1660_P51_50 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I191_XP_MN0 (I1660_P61_60 I1660_pn61 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I191_XP_MN1 (VSS I1660_pn60 I1660_P61_60 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I192_XP_MN0 (I1660_P62_61 I1660_pn62 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I192_XP_MN1 (VSS I1660_pn61 I1660_P62_61 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I193_XP_MN0 (I1660_P63_62 I1660_pn63 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I193_XP_MN1 (VSS I1660_pn62 I1660_P63_62 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I164_XP_MN0 (I1660_P34_33 I1660_pn34 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I164_XP_MN1 (VSS I1660_pn33 I1660_P34_33 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I407_XP_MN0 (I1660_P44_13 I1660_P44_29n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I407_XP_MN1 (VSS I1660_P28_13n I1660_P44_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I291_XP_MN0 (I1660_P38_31 I1660_P38_35n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I291_XP_MN1 (VSS I1660_P34_31n I1660_P38_31 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I425_XP_MN0 (I1660_P62_31 I1660_P62_47n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I425_XP_MN1 (VSS I1660_P46_31n I1660_P62_31 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I179_XP_MN0 (I1660_P49_48 I1660_pn49 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I179_XP_MN1 (VSS I1660_pn48 I1660_P49_48 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I183_XP_MN0 (I1660_P53_52 I1660_pn53 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I183_XP_MN1 (VSS I1660_pn52 I1660_P53_52 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I160_XP_MN0 (I1660_P30_29 I1660_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I160_XP_MN1 (VSS I1660_pn29 I1660_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I162_XP_MN0 (I1660_P32_31 I1660_pn32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I162_XP_MN1 (VSS I1660_pn31 I1660_P32_31 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I289_XP_MN0 (I1660_P36_29 I1660_P36_33n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I289_XP_MN1 (VSS I1660_P32_29n I1660_P36_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I419_XP_MN0 (I1660_P56_25 I1660_P56_41n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I419_XP_MN1 (VSS I1660_P40_25n I1660_P56_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I409_XP_MN0 (I1660_P46_15 I1660_P46_31n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I409_XP_MN1 (VSS I1660_P30_15n I1660_P46_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I177_XP_MN0 (I1660_P47_46 I1660_pn47 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I177_XP_MN1 (VSS I1660_pn46 I1660_P47_46 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I189_XP_MN0 (I1660_P59_58 I1660_pn59 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I189_XP_MN1 (VSS I1660_pn58 I1660_P59_58 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I187_XP_MN0 (I1660_P57_56 I1660_pn57 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I187_XP_MN1 (VSS I1660_pn56 I1660_P57_56 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I185_XP_MN0 (I1660_P55_54 I1660_pn55 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I185_XP_MN1 (VSS I1660_pn54 I1660_P55_54 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I287_XP_MN0 (I1660_P34_27 I1660_P34_31n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I287_XP_MN1 (VSS I1660_P30_27n I1660_P34_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I417_XP_MN0 (I1660_P54_23 I1660_P54_39n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I417_XP_MN1 (VSS I1660_P38_23n I1660_P54_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I159_XP_MN0 (I1660_P29_28 I1660_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I159_XP_MN1 (VSS I1660_pn28 I1660_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I161_XP_MN0 (I1660_P31_30 I1660_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I161_XP_MN1 (VSS I1660_pn30 I1660_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I421_XP_MN0 (I1660_P58_27 I1660_P58_43n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I421_XP_MN1 (VSS I1660_P42_27n I1660_P58_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I173_XP_MN0 (I1660_P43_42 I1660_pn43 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I173_XP_MN1 (VSS I1660_pn42 I1660_P43_42 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I310_XP_MN0 (I1660_P57_50 I1660_P57_54n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I310_XP_MN1 (VSS I1660_P53_50n I1660_P57_50 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I314_XP_MN0 (I1660_P61_54 I1660_P61_58n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I314_XP_MN1 (VSS I1660_P57_54n I1660_P61_54 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I158_XP_MN0 (I1660_P28_27 I1660_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I158_XP_MN1 (VSS I1660_pn27 I1660_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I285_XP_MN0 (I1660_P32_25 I1660_P32_29n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I285_XP_MN1 (VSS I1660_P28_25n I1660_P32_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I415_XP_MN0 (I1660_P52_21 I1660_P52_37n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I415_XP_MN1 (VSS I1660_P36_21n I1660_P52_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I283_XP_MN0 (I1660_P30_23 I1660_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I283_XP_MN1 (VSS I1660_P26_23n I1660_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I405_XP_MN0 (I1660_P42_11 I1660_P42_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I405_XP_MN1 (VSS I1660_P26_11n I1660_P42_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I171_XP_MN0 (I1660_P41_40 I1660_pn41 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I171_XP_MN1 (VSS I1660_pn40 I1660_P41_40 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I306_XP_MN0 (I1660_P53_46 I1660_P53_50n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I306_XP_MN1 (VSS I1660_P49_46n I1660_P53_46 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I312_XP_MN0 (I1660_P59_52 I1660_P59_56n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I312_XP_MN1 (VSS I1660_P55_52n I1660_P59_52 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I316_XP_MN0 (I1660_P63_56 I1660_P63_60n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I316_XP_MN1 (VSS I1660_P59_56n I1660_P63_56 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I281_XP_MN0 (I1660_P28_21 I1660_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I281_XP_MN1 (VSS I1660_P24_21n I1660_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I413_XP_MN0 (I1660_P50_19 I1660_P50_35n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I413_XP_MN1 (VSS I1660_P34_19n I1660_P50_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I169_XP_MN0 (I1660_P39_38 I1660_pn39 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I169_XP_MN1 (VSS I1660_pn38 I1660_P39_38 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I298_XP_MN0 (I1660_P45_38 I1660_P45_42n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I298_XP_MN1 (VSS I1660_P41_38n I1660_P45_38 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I302_XP_MN0 (I1660_P49_42 I1660_P49_46n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I302_XP_MN1 (VSS I1660_P45_42n I1660_P49_42 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I424_XP_MN0 (I1660_P61_30 I1660_P61_46n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I424_XP_MN1 (VSS I1660_P45_30n I1660_P61_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I304_XP_MN0 (I1660_P51_44 I1660_P51_48n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I304_XP_MN1 (VSS I1660_P47_44n I1660_P51_44 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I308_XP_MN0 (I1660_P55_48 I1660_P55_52n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I308_XP_MN1 (VSS I1660_P51_48n I1660_P55_48 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I156_XP_MN0 (I1660_P26_25 I1660_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I156_XP_MN1 (VSS I1660_pn25 I1660_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I403_XP_MN0 (I1660_P40_9 I1660_P40_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I403_XP_MN1 (VSS I1660_P24_9n I1660_P40_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I411_XP_MN0 (I1660_P48_17 I1660_P48_33n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I411_XP_MN1 (VSS I1660_P32_17n I1660_P48_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I279_XP_MN0 (I1660_P26_19 I1660_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I279_XP_MN1 (VSS I1660_P22_19n I1660_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I401_XP_MN0 (I1660_P38_7 I1660_P38_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I401_XP_MN1 (VSS I1660_P22_7n I1660_P38_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I167_XP_MN0 (I1660_P37_36 I1660_pn37 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I167_XP_MN1 (VSS I1660_pn36 I1660_P37_36 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I157_XP_MN0 (I1660_P27_26 I1660_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I157_XP_MN1 (VSS I1660_pn26 I1660_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I300_XP_MN0 (I1660_P47_40 I1660_P47_44n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I300_XP_MN1 (VSS I1660_P43_40n I1660_P47_40 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I154_XP_MN0 (I1660_P24_23 I1660_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I154_XP_MN1 (VSS I1660_pn23 I1660_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I163_XP_MN0 (I1660_P33_32 I1660_pn33 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I163_XP_MN1 (VSS I1660_pn32 I1660_P33_32 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I165_XP_MN0 (I1660_P35_34 I1660_pn35 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I165_XP_MN1 (VSS I1660_pn34 I1660_P35_34 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I294_XP_MN0 (I1660_P41_34 I1660_P41_38n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I294_XP_MN1 (VSS I1660_P37_34n I1660_P41_34 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I408_XP_MN0 (I1660_P45_14 I1660_P45_30n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I408_XP_MN1 (VSS I1660_P29_14n I1660_P45_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I296_XP_MN0 (I1660_P43_36 I1660_P43_40n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I296_XP_MN1 (VSS I1660_P39_36n I1660_P43_36 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I422_XP_MN0 (I1660_P59_28 I1660_P59_44n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I422_XP_MN1 (VSS I1660_P43_28n I1660_P59_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I152_XP_MN0 (I1660_P22_21 I1660_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I152_XP_MN1 (VSS I1660_pn21 I1660_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I277_XP_MN0 (I1660_P24_17 I1660_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I277_XP_MN1 (VSS I1660_P20_17n I1660_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I399_XP_MN0 (I1660_P36_5 I1660_P36_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I399_XP_MN1 (VSS I1660_P20_5n I1660_P36_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I275_XP_MN0 (I1660_P22_15 I1660_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I275_XP_MN1 (VSS I1660_P18_15n I1660_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I155_XP_MN0 (I1660_P25_24 I1660_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I155_XP_MN1 (VSS I1660_pn24 I1660_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I153_XP_MN0 (I1660_P23_22 I1660_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I153_XP_MN1 (VSS I1660_pn22 I1660_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I290_XP_MN0 (I1660_P37_30 I1660_P37_34n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I290_XP_MN1 (VSS I1660_P33_30n I1660_P37_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I420_XP_MN0 (I1660_P57_26 I1660_P57_42n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I420_XP_MN1 (VSS I1660_P41_26n I1660_P57_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I292_XP_MN0 (I1660_P39_32 I1660_P39_36n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I292_XP_MN1 (VSS I1660_P35_32n I1660_P39_32 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I426_XP_MN0 (I1660_P63_32 I1660_P63_48n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I426_XP_MN1 (VSS I1660_P47_32n I1660_P63_32 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I150_XP_MN0 (I1660_P20_19 I1660_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I150_XP_MN1 (VSS I1660_pn19 I1660_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I273_XP_MN0 (I1660_P20_13 I1660_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I273_XP_MN1 (VSS I1660_P16_13n I1660_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I397_XP_MN0 (I1660_P34_3 I1660_P34_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I397_XP_MN1 (VSS I1660_P18_3n I1660_P34_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I286_XP_MN0 (I1660_P33_26 I1660_P33_30n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I286_XP_MN1 (VSS I1660_P29_26n I1660_P33_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I288_XP_MN0 (I1660_P35_28 I1660_P35_32n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I288_XP_MN1 (VSS I1660_P31_28n I1660_P35_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I395_XP_MN0 (I1660_P32_1 I1660_P32_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I395_XP_MN1 (VSS I1660_P16_1n I1660_P32_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I151_XP_MN0 (I1660_P21_20 I1660_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I151_XP_MN1 (VSS I1660_pn20 I1660_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I282_XP_MN0 (I1660_P29_22 I1660_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I282_XP_MN1 (VSS I1660_P25_22n I1660_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I416_XP_MN0 (I1660_P53_22 I1660_P53_38n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I416_XP_MN1 (VSS I1660_P37_22n I1660_P53_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I404_XP_MN0 (I1660_P41_10 I1660_P41_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I404_XP_MN1 (VSS I1660_P25_10n I1660_P41_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I284_XP_MN0 (I1660_P31_24 I1660_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I284_XP_MN1 (VSS I1660_P27_24n I1660_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I418_XP_MN0 (I1660_P55_24 I1660_P55_40n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I418_XP_MN1 (VSS I1660_P39_24n I1660_P55_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I410_XP_MN0 (I1660_P47_16 I1660_P47_32n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I410_XP_MN1 (VSS I1660_P31_16n I1660_P47_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I148_XP_MN0 (I1660_P18_17 I1660_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I148_XP_MN1 (VSS I1660_pn17 I1660_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I271_XP_MN0 (I1660_P18_11 I1660_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I271_XP_MN1 (VSS I1660_P14_11n I1660_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I149_XP_MN0 (I1660_P19_18 I1660_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I149_XP_MN1 (VSS I1660_pn18 I1660_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I278_XP_MN0 (I1660_P25_18 I1660_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I278_XP_MN1 (VSS I1660_P21_18n I1660_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I280_XP_MN0 (I1660_P27_20 I1660_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I280_XP_MN1 (VSS I1660_P23_20n I1660_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I146_XP_MN0 (I1660_P16_15 I1660_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I146_XP_MN1 (VSS I1660_pn15 I1660_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I269_XP_MN0 (I1660_P16_9 I1660_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I269_XP_MN1 (VSS I1660_P12_9n I1660_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I265_XP_MN0 (I1660_P12_5 I1660_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I265_XP_MN1 (VSS I1660_P8_5n I1660_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I261_XP_MN0 (I1660_P8_1 I1660_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I261_XP_MN1 (VSS I1660_P4_1n I1660_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I267_XP_MN0 (I1660_P14_7 I1660_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I267_XP_MN1 (VSS I1660_P10_7n I1660_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I263_XP_MN0 (I1660_P10_3 I1660_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I263_XP_MN1 (VSS I1660_P6_3n I1660_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I147_XP_MN0 (I1660_P17_16 I1660_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I147_XP_MN1 (VSS I1660_pn16 I1660_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I274_XP_MN0 (I1660_P21_14 I1660_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I274_XP_MN1 (VSS I1660_P17_14n I1660_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I400_XP_MN0 (I1660_P37_6 I1660_P37_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I400_XP_MN1 (VSS I1660_P21_6n I1660_P37_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I412_XP_MN0 (I1660_P49_18 I1660_P49_34n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I412_XP_MN1 (VSS I1660_P33_18n I1660_P49_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I414_XP_MN0 (I1660_P51_20 I1660_P51_36n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I414_XP_MN1 (VSS I1660_P35_20n I1660_P51_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I406_XP_MN0 (I1660_P43_12 I1660_P43_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I406_XP_MN1 (VSS I1660_P27_12n I1660_P43_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I276_XP_MN0 (I1660_P23_16 I1660_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I276_XP_MN1 (VSS I1660_P19_16n I1660_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I402_XP_MN0 (I1660_P39_8 I1660_P39_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I402_XP_MN1 (VSS I1660_P23_8n I1660_P39_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I144_XP_MN0 (I1660_P14_13 I1660_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I144_XP_MN1 (VSS I1660_pn13 I1660_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I132_XP_MN0 (I1660_P2_1 I1660_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I132_XP_MN1 (VSS I1660_pn1 I1660_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I145_XP_MN0 (I1660_P15_14 I1660_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I145_XP_MN1 (VSS I1660_pn14 I1660_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I270_XP_MN0 (I1660_P17_10 I1660_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I270_XP_MN1 (VSS I1660_P13_10n I1660_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I272_XP_MN0 (I1660_P19_12 I1660_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I272_XP_MN1 (VSS I1660_P15_12n I1660_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I142_XP_MN0 (I1660_P12_11 I1660_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I142_XP_MN1 (VSS I1660_pn11 I1660_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I143_XP_MN0 (I1660_P13_12 I1660_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I143_XP_MN1 (VSS I1660_pn12 I1660_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I266_XP_MN0 (I1660_P13_6 I1660_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I266_XP_MN1 (VSS I1660_P9_6n I1660_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I396_XP_MN0 (I1660_P33_2 I1660_P33_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I396_XP_MN1 (VSS I1660_P17_2n I1660_P33_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I268_XP_MN0 (I1660_P15_8 I1660_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I268_XP_MN1 (VSS I1660_P11_8n I1660_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I398_XP_MN0 (I1660_P35_4 I1660_P35_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I398_XP_MN1 (VSS I1660_P19_4n I1660_P35_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I134_XP_MN0 (I1660_P4_3 I1660_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I134_XP_MN1 (VSS I1660_pn3 I1660_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I141_XP_MN0 (I1660_P11_10 I1660_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I141_XP_MN1 (VSS I1660_pn10 I1660_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I137_XP_MN0 (I1660_P7_6 I1660_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I137_XP_MN1 (VSS I1660_pn6 I1660_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I262_XP_MN0 (I1660_P9_2 I1660_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I262_XP_MN1 (VSS I1660_P5_2n I1660_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I264_XP_MN0 (I1660_P11_4 I1660_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I264_XP_MN1 (VSS I1660_P7_4n I1660_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I140_XP_MN0 (I1660_P10_9 I1660_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I140_XP_MN1 (VSS I1660_pn9 I1660_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I138_XP_MN0 (I1660_P8_7 I1660_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I138_XP_MN1 (VSS I1660_pn7 I1660_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I136_XP_MN0 (I1660_P6_5 I1660_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I136_XP_MN1 (VSS I1660_pn5 I1660_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I133_XP_MN0 (I1660_P3_2 I1660_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I133_XP_MN1 (VSS I1660_pn2 I1660_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I139_XP_MN0 (I1660_P9_8 I1660_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I139_XP_MN1 (VSS I1660_pn8 I1660_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1660_I135_XP_MN0 (I1660_P5_4 I1660_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1660_I135_XP_MN1 (VSS I1660_pn4 I1660_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15999u ps=0.67999u
    I_MXI1468_MN34 (XI1468_bn3 XI1468_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1468_MN35 (VSS pp8_27 XI1468_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1468_MN36 (XI1468_bn3 cm104_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1468_MN37 (XI1468_bsn XI1468_bcon XI1468_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1468_MN40 (XI1468_bn5 cm104_2 XI1468_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1468_MN39 (XI1468_bn4 pp8_27 XI1468_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1468_MN39_1 (XI1468_bn5 pp8_27 XI1468_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1468_MN40_1 (XI1468_bsn cm104_2 XI1468_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1468_MN53 (VSS XI1468_bsn cm107_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1468_MN29 (XI1468_bn1 XI1468_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1468_MN30 (XI1468_bcon pp8_27 XI1468_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1468_MN33 (XI1468_bn2 cm104_2 XI1468_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1468_MN31 (VSS XI1468_s1 XI1468_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1468_MN32 (XI1468_bn2 pp8_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1468_MN55 (VSS XI1468_bcon cm107_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1468_MN38 (XI1468_bn4 XI1468_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1468_MN38_1 (VSS XI1468_s1 XI1468_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1468_MN25 (VSS XI1468_asn XI1468_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1468_MN10 (VSS sn5 XI1468_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1468_MN6 (XI1468_an3 sn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1468_MN9 (XI1468_asn XI1468_acon XI1468_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1468_MN12 (XI1468_an5 pp7_29 XI1468_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1468_MN11 (XI1468_an4 pp6_31 XI1468_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1468_MN11_1 (XI1468_an5 pp6_31 XI1468_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1468_MN12_1 (XI1468_asn pp7_29 XI1468_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1468_MN10_1 (XI1468_an4 sn5 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1468_MN5 (XI1468_acon pp7_29 XI1468_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1468_MN2 (XI1468_an1 pp6_31 XI1468_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1468_MN1 (VSS sn5 XI1468_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1468_MN3 (XI1468_an2 sn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1468_MN4 (VSS pp6_31 XI1468_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1468_MN27 (cm107_2 XI1468_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1468_MN7 (XI1468_an3 pp6_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1468_MN8 (VSS pp7_29 XI1468_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1471_MN34 (XI1471_bn3 XI1471_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1471_MN35 (VSS pp8_28 XI1471_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1471_MN36 (XI1471_bn3 cm107_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1471_MN37 (XI1471_bsn XI1471_bcon XI1471_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1471_MN40 (XI1471_bn5 cm107_2 XI1471_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1471_MN39 (XI1471_bn4 pp8_28 XI1471_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1471_MN39_1 (XI1471_bn5 pp8_28 XI1471_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1471_MN40_1 (XI1471_bsn cm107_2 XI1471_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1471_MN53 (VSS XI1471_bsn cm110_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1471_MN29 (XI1471_bn1 XI1471_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1471_MN30 (XI1471_bcon pp8_28 XI1471_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1471_MN33 (XI1471_bn2 cm107_2 XI1471_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1471_MN31 (VSS XI1471_s1 XI1471_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1471_MN32 (XI1471_bn2 pp8_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1471_MN55 (VSS XI1471_bcon cm110_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1471_MN38 (XI1471_bn4 XI1471_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1471_MN38_1 (VSS XI1471_s1 XI1471_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1471_MN25 (VSS XI1471_asn XI1471_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1471_MN10 (VSS VDD XI1471_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1471_MN6 (XI1471_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1471_MN9 (XI1471_asn XI1471_acon XI1471_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1471_MN12 (XI1471_an5 pp7_30 XI1471_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1471_MN11 (XI1471_an4 pp6_32 XI1471_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1471_MN11_1 (XI1471_an5 pp6_32 XI1471_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1471_MN12_1 (XI1471_asn pp7_30 XI1471_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1471_MN10_1 (XI1471_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1471_MN5 (XI1471_acon pp7_30 XI1471_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1471_MN2 (XI1471_an1 pp6_32 XI1471_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1471_MN1 (VSS VDD XI1471_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1471_MN3 (XI1471_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1471_MN4 (VSS pp6_32 XI1471_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1471_MN27 (cm110_2 XI1471_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1471_MN7 (XI1471_an3 pp6_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1471_MN8 (VSS pp7_30 XI1471_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1482_MN34 (XI1482_bn3 XI1482_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1482_MN35 (VSS pp11_27 XI1482_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1482_MN36 (XI1482_bn3 cm119_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1482_MN37 (XI1482_bsn XI1482_bcon XI1482_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1482_MN40 (XI1482_bn5 cm119_2 XI1482_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1482_MN39 (XI1482_bn4 pp11_27 XI1482_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1482_MN39_1 (XI1482_bn5 pp11_27 XI1482_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1482_MN40_1 (XI1482_bsn cm119_2 XI1482_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1482_MN53 (VSS XI1482_bsn cm121_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1482_MN29 (XI1482_bn1 XI1482_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1482_MN30 (XI1482_bcon pp11_27 XI1482_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1482_MN33 (XI1482_bn2 cm119_2 XI1482_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1482_MN31 (VSS XI1482_s1 XI1482_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1482_MN32 (XI1482_bn2 pp11_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1482_MN55 (VSS XI1482_bcon cm121_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1482_MN38 (XI1482_bn4 XI1482_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1482_MN38_1 (VSS XI1482_s1 XI1482_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1482_MN25 (VSS XI1482_asn XI1482_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1482_MN10 (VSS sn8 XI1482_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1482_MN6 (XI1482_an3 sn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1482_MN9 (XI1482_asn XI1482_acon XI1482_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1482_MN12 (XI1482_an5 pp10_29 XI1482_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1482_MN11 (XI1482_an4 pp9_31 XI1482_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1482_MN11_1 (XI1482_an5 pp9_31 XI1482_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1482_MN12_1 (XI1482_asn pp10_29 XI1482_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1482_MN10_1 (XI1482_an4 sn8 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1482_MN5 (XI1482_acon pp10_29 XI1482_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1482_MN2 (XI1482_an1 pp9_31 XI1482_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1482_MN1 (VSS sn8 XI1482_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1482_MN3 (XI1482_an2 sn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1482_MN4 (VSS pp9_31 XI1482_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1482_MN27 (cm121_2 XI1482_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1482_MN7 (XI1482_an3 pp9_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1482_MN8 (VSS pp10_29 XI1482_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1474_MN34 (XI1474_bn3 XI1474_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1474_MN35 (VSS pp9_27 XI1474_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1474_MN36 (XI1474_bn3 cm110_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1474_MN37 (XI1474_bsn XI1474_bcon XI1474_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1474_MN40 (XI1474_bn5 cm110_2 XI1474_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1474_MN39 (XI1474_bn4 pp9_27 XI1474_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1474_MN39_1 (XI1474_bn5 pp9_27 XI1474_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1474_MN40_1 (XI1474_bsn cm110_2 XI1474_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1474_MN53 (VSS XI1474_bsn cm113_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1474_MN29 (XI1474_bn1 XI1474_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1474_MN30 (XI1474_bcon pp9_27 XI1474_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1474_MN33 (XI1474_bn2 cm110_2 XI1474_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1474_MN31 (VSS XI1474_s1 XI1474_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1474_MN32 (XI1474_bn2 pp9_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1474_MN55 (VSS XI1474_bcon cm113_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1474_MN38 (XI1474_bn4 XI1474_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1474_MN38_1 (VSS XI1474_s1 XI1474_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1474_MN25 (VSS XI1474_asn XI1474_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1474_MN10 (VSS sn6 XI1474_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1474_MN6 (XI1474_an3 sn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1474_MN9 (XI1474_asn XI1474_acon XI1474_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1474_MN12 (XI1474_an5 pp8_29 XI1474_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1474_MN11 (XI1474_an4 pp7_31 XI1474_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1474_MN11_1 (XI1474_an5 pp7_31 XI1474_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1474_MN12_1 (XI1474_asn pp8_29 XI1474_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1474_MN10_1 (XI1474_an4 sn6 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1474_MN5 (XI1474_acon pp8_29 XI1474_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1474_MN2 (XI1474_an1 pp7_31 XI1474_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1474_MN1 (VSS sn6 XI1474_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1474_MN3 (XI1474_an2 sn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1474_MN4 (VSS pp7_31 XI1474_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1474_MN27 (cm113_2 XI1474_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1474_MN7 (XI1474_an3 pp7_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1474_MN8 (VSS pp8_29 XI1474_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1478_MN34 (XI1478_bn3 XI1478_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1478_MN35 (VSS pp10_27 XI1478_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1478_MN36 (XI1478_bn3 cm115_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1478_MN37 (XI1478_bsn XI1478_bcon XI1478_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1478_MN40 (XI1478_bn5 cm115_2 XI1478_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1478_MN39 (XI1478_bn4 pp10_27 XI1478_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1478_MN39_1 (XI1478_bn5 pp10_27 XI1478_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1478_MN40_1 (XI1478_bsn cm115_2 XI1478_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1478_MN53 (VSS XI1478_bsn cm117_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1478_MN29 (XI1478_bn1 XI1478_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1478_MN30 (XI1478_bcon pp10_27 XI1478_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1478_MN33 (XI1478_bn2 cm115_2 XI1478_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1478_MN31 (VSS XI1478_s1 XI1478_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1478_MN32 (XI1478_bn2 pp10_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1478_MN55 (VSS XI1478_bcon cm117_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1478_MN38 (XI1478_bn4 XI1478_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1478_MN38_1 (VSS XI1478_s1 XI1478_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1478_MN25 (VSS XI1478_asn XI1478_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1478_MN10 (VSS sn7 XI1478_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1478_MN6 (XI1478_an3 sn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1478_MN9 (XI1478_asn XI1478_acon XI1478_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1478_MN12 (XI1478_an5 pp9_29 XI1478_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1478_MN11 (XI1478_an4 pp8_31 XI1478_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1478_MN11_1 (XI1478_an5 pp8_31 XI1478_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1478_MN12_1 (XI1478_asn pp9_29 XI1478_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1478_MN10_1 (XI1478_an4 sn7 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1478_MN5 (XI1478_acon pp9_29 XI1478_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1478_MN2 (XI1478_an1 pp8_31 XI1478_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1478_MN1 (VSS sn7 XI1478_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1478_MN3 (XI1478_an2 sn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1478_MN4 (VSS pp8_31 XI1478_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1478_MN27 (cm117_2 XI1478_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1478_MN7 (XI1478_an3 pp8_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1478_MN8 (VSS pp9_29 XI1478_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1480_MN34 (XI1480_bn3 XI1480_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1480_MN35 (VSS pp10_28 XI1480_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1480_MN36 (XI1480_bn3 cm117_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1480_MN37 (XI1480_bsn XI1480_bcon XI1480_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1480_MN40 (XI1480_bn5 cm117_2 XI1480_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1480_MN39 (XI1480_bn4 pp10_28 XI1480_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1480_MN39_1 (XI1480_bn5 pp10_28 XI1480_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1480_MN40_1 (XI1480_bsn cm117_2 XI1480_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1480_MN53 (VSS XI1480_bsn cm119_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1480_MN29 (XI1480_bn1 XI1480_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1480_MN30 (XI1480_bcon pp10_28 XI1480_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1480_MN33 (XI1480_bn2 cm117_2 XI1480_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1480_MN31 (VSS XI1480_s1 XI1480_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1480_MN32 (XI1480_bn2 pp10_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1480_MN55 (VSS XI1480_bcon cm119_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1480_MN38 (XI1480_bn4 XI1480_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1480_MN38_1 (VSS XI1480_s1 XI1480_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1480_MN25 (VSS XI1480_asn XI1480_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1480_MN10 (VSS VDD XI1480_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1480_MN6 (XI1480_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1480_MN9 (XI1480_asn XI1480_acon XI1480_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1480_MN12 (XI1480_an5 pp9_30 XI1480_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1480_MN11 (XI1480_an4 pp8_32 XI1480_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1480_MN11_1 (XI1480_an5 pp8_32 XI1480_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1480_MN12_1 (XI1480_asn pp9_30 XI1480_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1480_MN10_1 (XI1480_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1480_MN5 (XI1480_acon pp9_30 XI1480_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1480_MN2 (XI1480_an1 pp8_32 XI1480_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1480_MN1 (VSS VDD XI1480_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1480_MN3 (XI1480_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1480_MN4 (VSS pp8_32 XI1480_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1480_MN27 (cm119_2 XI1480_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1480_MN7 (XI1480_an3 pp8_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1480_MN8 (VSS pp9_30 XI1480_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1560_MN34 (XI1560_bn3 XI1560_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1560_MN35 (VSS cm122_0 XI1560_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1560_MN36 (XI1560_bn3 cm198_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1560_MN37 (XI1560_bsn XI1560_bcon XI1560_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1560_MN40 (XI1560_bn5 cm198_2 XI1560_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1560_MN39 (XI1560_bn4 cm122_0 XI1560_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1560_MN39_1 (XI1560_bn5 cm122_0 XI1560_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1560_MN40_1 (XI1560_bsn cm198_2 XI1560_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1560_MN53 (VSS XI1560_bsn cm199_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1560_MN29 (XI1560_bn1 XI1560_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1560_MN30 (XI1560_bcon cm122_0 XI1560_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1560_MN33 (XI1560_bn2 cm198_2 XI1560_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1560_MN31 (VSS XI1560_s1 XI1560_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1560_MN32 (XI1560_bn2 cm122_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1560_MN55 (VSS XI1560_bcon cm199_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1560_MN38 (XI1560_bn4 XI1560_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1560_MN38_1 (VSS XI1560_s1 XI1560_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1560_MN25 (VSS XI1560_asn XI1560_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1560_MN10 (VSS cm119_1 XI1560_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1560_MN6 (XI1560_an3 cm119_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1560_MN9 (XI1560_asn XI1560_acon XI1560_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1560_MN12 (XI1560_an5 cm121_0 XI1560_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1560_MN11 (XI1560_an4 cm120_1 XI1560_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1560_MN11_1 (XI1560_an5 cm120_1 XI1560_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1560_MN12_1 (XI1560_asn cm121_0 XI1560_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1560_MN10_1 (XI1560_an4 cm119_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1560_MN5 (XI1560_acon cm121_0 XI1560_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1560_MN2 (XI1560_an1 cm120_1 XI1560_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1560_MN1 (VSS cm119_1 XI1560_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1560_MN3 (XI1560_an2 cm119_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1560_MN4 (VSS cm120_1 XI1560_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1560_MN27 (cm199_2 XI1560_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1560_MN7 (XI1560_an3 cm120_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1560_MN8 (VSS cm121_0 XI1560_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1465_MN34 (XI1465_bn3 XI1465_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1465_MN35 (VSS pp7_28 XI1465_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1465_MN36 (XI1465_bn3 cm101_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1465_MN37 (XI1465_bsn XI1465_bcon XI1465_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1465_MN40 (XI1465_bn5 cm101_2 XI1465_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1465_MN39 (XI1465_bn4 pp7_28 XI1465_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1465_MN39_1 (XI1465_bn5 pp7_28 XI1465_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1465_MN40_1 (XI1465_bsn cm101_2 XI1465_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1465_MN53 (VSS XI1465_bsn cm104_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1465_MN29 (XI1465_bn1 XI1465_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1465_MN30 (XI1465_bcon pp7_28 XI1465_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1465_MN33 (XI1465_bn2 cm101_2 XI1465_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1465_MN31 (VSS XI1465_s1 XI1465_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1465_MN32 (XI1465_bn2 pp7_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1465_MN55 (VSS XI1465_bcon cm104_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1465_MN38 (XI1465_bn4 XI1465_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1465_MN38_1 (VSS XI1465_s1 XI1465_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1465_MN25 (VSS XI1465_asn XI1465_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1465_MN10 (VSS VDD XI1465_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1465_MN6 (XI1465_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1465_MN9 (XI1465_asn XI1465_acon XI1465_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1465_MN12 (XI1465_an5 pp6_30 XI1465_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1465_MN11 (XI1465_an4 pp5_32 XI1465_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1465_MN11_1 (XI1465_an5 pp5_32 XI1465_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1465_MN12_1 (XI1465_asn pp6_30 XI1465_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1465_MN10_1 (XI1465_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1465_MN5 (XI1465_acon pp6_30 XI1465_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1465_MN2 (XI1465_an1 pp5_32 XI1465_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1465_MN1 (VSS VDD XI1465_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1465_MN3 (XI1465_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1465_MN4 (VSS pp5_32 XI1465_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1465_MN27 (cm104_2 XI1465_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1465_MN7 (XI1465_an3 pp5_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1465_MN8 (VSS pp6_30 XI1465_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1462_MN34 (XI1462_bn3 XI1462_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1462_MN35 (VSS pp7_27 XI1462_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1462_MN36 (XI1462_bn3 cm98_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1462_MN37 (XI1462_bsn XI1462_bcon XI1462_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1462_MN40 (XI1462_bn5 cm98_2 XI1462_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1462_MN39 (XI1462_bn4 pp7_27 XI1462_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1462_MN39_1 (XI1462_bn5 pp7_27 XI1462_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1462_MN40_1 (XI1462_bsn cm98_2 XI1462_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1462_MN53 (VSS XI1462_bsn cm101_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1462_MN29 (XI1462_bn1 XI1462_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1462_MN30 (XI1462_bcon pp7_27 XI1462_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1462_MN33 (XI1462_bn2 cm98_2 XI1462_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1462_MN31 (VSS XI1462_s1 XI1462_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1462_MN32 (XI1462_bn2 pp7_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1462_MN55 (VSS XI1462_bcon cm101_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1462_MN38 (XI1462_bn4 XI1462_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1462_MN38_1 (VSS XI1462_s1 XI1462_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1462_MN25 (VSS XI1462_asn XI1462_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1462_MN10 (VSS sn4 XI1462_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1462_MN6 (XI1462_an3 sn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1462_MN9 (XI1462_asn XI1462_acon XI1462_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1462_MN12 (XI1462_an5 pp6_29 XI1462_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1462_MN11 (XI1462_an4 pp5_31 XI1462_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1462_MN11_1 (XI1462_an5 pp5_31 XI1462_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1462_MN12_1 (XI1462_asn pp6_29 XI1462_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1462_MN10_1 (XI1462_an4 sn4 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1462_MN5 (XI1462_acon pp6_29 XI1462_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1462_MN2 (XI1462_an1 pp5_31 XI1462_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1462_MN1 (VSS sn4 XI1462_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1462_MN3 (XI1462_an2 sn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1462_MN4 (VSS pp5_31 XI1462_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1462_MN27 (cm101_2 XI1462_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1462_MN7 (XI1462_an3 pp5_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1462_MN8 (VSS pp6_29 XI1462_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1457_MN34 (XI1457_bn3 XI1457_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1457_MN35 (VSS pp10_19 XI1457_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1457_MN36 (XI1457_bn3 cm93_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1457_MN37 (XI1457_bsn XI1457_bcon XI1457_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1457_MN40 (XI1457_bn5 cm93_2 XI1457_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1457_MN39 (XI1457_bn4 pp10_19 XI1457_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1457_MN39_1 (XI1457_bn5 pp10_19 XI1457_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1457_MN40_1 (XI1457_bsn cm93_2 XI1457_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1457_MN53 (VSS XI1457_bsn cm96_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1457_MN29 (XI1457_bn1 XI1457_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1457_MN30 (XI1457_bcon pp10_19 XI1457_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1457_MN33 (XI1457_bn2 cm93_2 XI1457_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1457_MN31 (VSS XI1457_s1 XI1457_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1457_MN32 (XI1457_bn2 pp10_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1457_MN55 (VSS XI1457_bcon cm96_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1457_MN38 (XI1457_bn4 XI1457_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1457_MN38_1 (VSS XI1457_s1 XI1457_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1457_MN25 (VSS XI1457_asn XI1457_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1457_MN10 (VSS pp7_25 XI1457_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1457_MN6 (XI1457_an3 pp7_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1457_MN9 (XI1457_asn XI1457_acon XI1457_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1457_MN12 (XI1457_an5 pp9_21 XI1457_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1457_MN11 (XI1457_an4 pp8_23 XI1457_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1457_MN11_1 (XI1457_an5 pp8_23 XI1457_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1457_MN12_1 (XI1457_asn pp9_21 XI1457_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1457_MN10_1 (XI1457_an4 pp7_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1457_MN5 (XI1457_acon pp9_21 XI1457_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1457_MN2 (XI1457_an1 pp8_23 XI1457_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1457_MN1 (VSS pp7_25 XI1457_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1457_MN3 (XI1457_an2 pp7_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1457_MN4 (VSS pp8_23 XI1457_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1457_MN27 (cm96_2 XI1457_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1457_MN7 (XI1457_an3 pp8_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1457_MN8 (VSS pp9_21 XI1457_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1460_MN34 (XI1460_bn3 XI1460_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1460_MN35 (VSS pp10_20 XI1460_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1460_MN36 (XI1460_bn3 cm96_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1460_MN37 (XI1460_bsn XI1460_bcon XI1460_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1460_MN40 (XI1460_bn5 cm96_2 XI1460_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1460_MN39 (XI1460_bn4 pp10_20 XI1460_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1460_MN39_1 (XI1460_bn5 pp10_20 XI1460_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1460_MN40_1 (XI1460_bsn cm96_2 XI1460_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1460_MN53 (VSS XI1460_bsn cm99_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1460_MN29 (XI1460_bn1 XI1460_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1460_MN30 (XI1460_bcon pp10_20 XI1460_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1460_MN33 (XI1460_bn2 cm96_2 XI1460_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1460_MN31 (VSS XI1460_s1 XI1460_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1460_MN32 (XI1460_bn2 pp10_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1460_MN55 (VSS XI1460_bcon cm99_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1460_MN38 (XI1460_bn4 XI1460_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1460_MN38_1 (VSS XI1460_s1 XI1460_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1460_MN25 (VSS XI1460_asn XI1460_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1460_MN10 (VSS pp7_26 XI1460_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1460_MN6 (XI1460_an3 pp7_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1460_MN9 (XI1460_asn XI1460_acon XI1460_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1460_MN12 (XI1460_an5 pp9_22 XI1460_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1460_MN11 (XI1460_an4 pp8_24 XI1460_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1460_MN11_1 (XI1460_an5 pp8_24 XI1460_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1460_MN12_1 (XI1460_asn pp9_22 XI1460_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1460_MN10_1 (XI1460_an4 pp7_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1460_MN5 (XI1460_acon pp9_22 XI1460_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1460_MN2 (XI1460_an1 pp8_24 XI1460_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1460_MN1 (VSS pp7_26 XI1460_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1460_MN3 (XI1460_an2 pp7_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1460_MN4 (VSS pp8_24 XI1460_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1460_MN27 (cm99_2 XI1460_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1460_MN7 (XI1460_an3 pp8_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1460_MN8 (VSS pp9_22 XI1460_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1558_MN34 (XI1558_bn3 XI1558_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1558_MN35 (VSS cm118_0 XI1558_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1558_MN36 (XI1558_bn3 cm196_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1558_MN37 (XI1558_bsn XI1558_bcon XI1558_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1558_MN40 (XI1558_bn5 cm196_2 XI1558_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1558_MN39 (XI1558_bn4 cm118_0 XI1558_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1558_MN39_1 (XI1558_bn5 cm118_0 XI1558_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1558_MN40_1 (XI1558_bsn cm196_2 XI1558_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1558_MN53 (VSS XI1558_bsn cm197_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1558_MN29 (XI1558_bn1 XI1558_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1558_MN30 (XI1558_bcon cm118_0 XI1558_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1558_MN33 (XI1558_bn2 cm196_2 XI1558_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1558_MN31 (VSS XI1558_s1 XI1558_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1558_MN32 (XI1558_bn2 cm118_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1558_MN55 (VSS XI1558_bcon cm197_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1558_MN38 (XI1558_bn4 XI1558_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1558_MN38_1 (VSS XI1558_s1 XI1558_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1558_MN25 (VSS XI1558_asn XI1558_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1558_MN10 (VSS cm115_1 XI1558_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1558_MN6 (XI1558_an3 cm115_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1558_MN9 (XI1558_asn XI1558_acon XI1558_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1558_MN12 (XI1558_an5 cm117_0 XI1558_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1558_MN11 (XI1558_an4 cm116_1 XI1558_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1558_MN11_1 (XI1558_an5 cm116_1 XI1558_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1558_MN12_1 (XI1558_asn cm117_0 XI1558_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1558_MN10_1 (XI1558_an4 cm115_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1558_MN5 (XI1558_acon cm117_0 XI1558_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1558_MN2 (XI1558_an1 cm116_1 XI1558_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1558_MN1 (VSS cm115_1 XI1558_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1558_MN3 (XI1558_an2 cm115_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1558_MN4 (VSS cm116_1 XI1558_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1558_MN27 (cm197_2 XI1558_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1558_MN7 (XI1558_an3 cm116_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1558_MN8 (VSS cm117_0 XI1558_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1476_MN34 (XI1476_bn3 XI1476_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1476_MN35 (VSS pp9_28 XI1476_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1476_MN36 (XI1476_bn3 cm113_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1476_MN37 (XI1476_bsn XI1476_bcon XI1476_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1476_MN40 (XI1476_bn5 cm113_2 XI1476_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1476_MN39 (XI1476_bn4 pp9_28 XI1476_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1476_MN39_1 (XI1476_bn5 pp9_28 XI1476_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1476_MN40_1 (XI1476_bsn cm113_2 XI1476_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1476_MN53 (VSS XI1476_bsn cm115_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1476_MN29 (XI1476_bn1 XI1476_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1476_MN30 (XI1476_bcon pp9_28 XI1476_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1476_MN33 (XI1476_bn2 cm113_2 XI1476_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1476_MN31 (VSS XI1476_s1 XI1476_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1476_MN32 (XI1476_bn2 pp9_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1476_MN55 (VSS XI1476_bcon cm115_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1476_MN38 (XI1476_bn4 XI1476_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1476_MN38_1 (VSS XI1476_s1 XI1476_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1476_MN25 (VSS XI1476_asn XI1476_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1476_MN10 (VSS VDD XI1476_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1476_MN6 (XI1476_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1476_MN9 (XI1476_asn XI1476_acon XI1476_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1476_MN12 (XI1476_an5 pp8_30 XI1476_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1476_MN11 (XI1476_an4 pp7_32 XI1476_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1476_MN11_1 (XI1476_an5 pp7_32 XI1476_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1476_MN12_1 (XI1476_asn pp8_30 XI1476_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1476_MN10_1 (XI1476_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1476_MN5 (XI1476_acon pp8_30 XI1476_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1476_MN2 (XI1476_an1 pp7_32 XI1476_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1476_MN1 (VSS VDD XI1476_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1476_MN3 (XI1476_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1476_MN4 (VSS pp7_32 XI1476_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1476_MN27 (cm115_2 XI1476_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1476_MN7 (XI1476_an3 pp7_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1476_MN8 (VSS pp8_30 XI1476_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1559_MN34 (XI1559_bn3 XI1559_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1559_MN35 (VSS cm120_0 XI1559_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1559_MN36 (XI1559_bn3 cm197_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1559_MN37 (XI1559_bsn XI1559_bcon XI1559_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1559_MN40 (XI1559_bn5 cm197_2 XI1559_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1559_MN39 (XI1559_bn4 cm120_0 XI1559_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1559_MN39_1 (XI1559_bn5 cm120_0 XI1559_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1559_MN40_1 (XI1559_bsn cm197_2 XI1559_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1559_MN53 (VSS XI1559_bsn cm198_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1559_MN29 (XI1559_bn1 XI1559_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1559_MN30 (XI1559_bcon cm120_0 XI1559_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1559_MN33 (XI1559_bn2 cm197_2 XI1559_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1559_MN31 (VSS XI1559_s1 XI1559_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1559_MN32 (XI1559_bn2 cm120_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1559_MN55 (VSS XI1559_bcon cm198_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1559_MN38 (XI1559_bn4 XI1559_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1559_MN38_1 (VSS XI1559_s1 XI1559_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1559_MN25 (VSS XI1559_asn XI1559_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1559_MN10 (VSS cm117_1 XI1559_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1559_MN6 (XI1559_an3 cm117_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1559_MN9 (XI1559_asn XI1559_acon XI1559_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1559_MN12 (XI1559_an5 cm119_0 XI1559_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1559_MN11 (XI1559_an4 cm118_1 XI1559_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1559_MN11_1 (XI1559_an5 cm118_1 XI1559_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1559_MN12_1 (XI1559_asn cm119_0 XI1559_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1559_MN10_1 (XI1559_an4 cm117_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1559_MN5 (XI1559_acon cm119_0 XI1559_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1559_MN2 (XI1559_an1 cm118_1 XI1559_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1559_MN1 (VSS cm117_1 XI1559_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1559_MN3 (XI1559_an2 cm117_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1559_MN4 (VSS cm118_1 XI1559_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1559_MN27 (cm198_2 XI1559_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1559_MN7 (XI1559_an3 cm118_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1559_MN8 (VSS cm119_0 XI1559_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1484_MN34 (XI1484_bn3 XI1484_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1484_MN35 (VSS pp11_28 XI1484_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1484_MN36 (XI1484_bn3 cm121_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1484_MN37 (XI1484_bsn XI1484_bcon XI1484_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1484_MN40 (XI1484_bn5 cm121_2 XI1484_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1484_MN39 (XI1484_bn4 pp11_28 XI1484_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1484_MN39_1 (XI1484_bn5 pp11_28 XI1484_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1484_MN40_1 (XI1484_bsn cm121_2 XI1484_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1484_MN53 (VSS XI1484_bsn cm123_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1484_MN29 (XI1484_bn1 XI1484_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1484_MN30 (XI1484_bcon pp11_28 XI1484_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1484_MN33 (XI1484_bn2 cm121_2 XI1484_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1484_MN31 (VSS XI1484_s1 XI1484_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1484_MN32 (XI1484_bn2 pp11_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1484_MN55 (VSS XI1484_bcon cm123_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1484_MN38 (XI1484_bn4 XI1484_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1484_MN38_1 (VSS XI1484_s1 XI1484_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1484_MN25 (VSS XI1484_asn XI1484_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1484_MN10 (VSS VDD XI1484_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1484_MN6 (XI1484_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1484_MN9 (XI1484_asn XI1484_acon XI1484_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1484_MN12 (XI1484_an5 pp10_30 XI1484_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1484_MN11 (XI1484_an4 pp9_32 XI1484_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1484_MN11_1 (XI1484_an5 pp9_32 XI1484_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1484_MN12_1 (XI1484_asn pp10_30 XI1484_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1484_MN10_1 (XI1484_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1484_MN5 (XI1484_acon pp10_30 XI1484_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1484_MN2 (XI1484_an1 pp9_32 XI1484_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1484_MN1 (VSS VDD XI1484_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1484_MN3 (XI1484_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1484_MN4 (VSS pp9_32 XI1484_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1484_MN27 (cm123_2 XI1484_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1484_MN7 (XI1484_an3 pp9_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1484_MN8 (VSS pp10_30 XI1484_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1459_MN34 (XI1459_bn3 XI1459_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1459_MN35 (VSS pp6_28 XI1459_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1459_MN36 (XI1459_bn3 cm95_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1459_MN37 (XI1459_bsn XI1459_bcon XI1459_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1459_MN40 (XI1459_bn5 cm95_2 XI1459_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1459_MN39 (XI1459_bn4 pp6_28 XI1459_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1459_MN39_1 (XI1459_bn5 pp6_28 XI1459_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1459_MN40_1 (XI1459_bsn cm95_2 XI1459_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1459_MN53 (VSS XI1459_bsn cm98_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1459_MN29 (XI1459_bn1 XI1459_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1459_MN30 (XI1459_bcon pp6_28 XI1459_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1459_MN33 (XI1459_bn2 cm95_2 XI1459_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1459_MN31 (VSS XI1459_s1 XI1459_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1459_MN32 (XI1459_bn2 pp6_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1459_MN55 (VSS XI1459_bcon cm98_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1459_MN38 (XI1459_bn4 XI1459_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1459_MN38_1 (VSS XI1459_s1 XI1459_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1459_MN25 (VSS XI1459_asn XI1459_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1459_MN10 (VSS VDD XI1459_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1459_MN6 (XI1459_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1459_MN9 (XI1459_asn XI1459_acon XI1459_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1459_MN12 (XI1459_an5 pp5_30 XI1459_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1459_MN11 (XI1459_an4 pp4_32 XI1459_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1459_MN11_1 (XI1459_an5 pp4_32 XI1459_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1459_MN12_1 (XI1459_asn pp5_30 XI1459_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1459_MN10_1 (XI1459_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1459_MN5 (XI1459_acon pp5_30 XI1459_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1459_MN2 (XI1459_an1 pp4_32 XI1459_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1459_MN1 (VSS VDD XI1459_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1459_MN3 (XI1459_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1459_MN4 (VSS pp4_32 XI1459_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1459_MN27 (cm98_2 XI1459_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1459_MN7 (XI1459_an3 pp4_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1459_MN8 (VSS pp5_30 XI1459_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1451_MN34 (XI1451_bn3 XI1451_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1451_MN35 (VSS pp9_19 XI1451_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1451_MN36 (XI1451_bn3 cm86_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1451_MN37 (XI1451_bsn XI1451_bcon XI1451_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1451_MN40 (XI1451_bn5 cm86_2 XI1451_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1451_MN39 (XI1451_bn4 pp9_19 XI1451_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1451_MN39_1 (XI1451_bn5 pp9_19 XI1451_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1451_MN40_1 (XI1451_bsn cm86_2 XI1451_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1451_MN53 (VSS XI1451_bsn cm90_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1451_MN29 (XI1451_bn1 XI1451_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1451_MN30 (XI1451_bcon pp9_19 XI1451_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1451_MN33 (XI1451_bn2 cm86_2 XI1451_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1451_MN31 (VSS XI1451_s1 XI1451_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1451_MN32 (XI1451_bn2 pp9_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1451_MN55 (VSS XI1451_bcon cm90_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1451_MN38 (XI1451_bn4 XI1451_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1451_MN38_1 (VSS XI1451_s1 XI1451_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1451_MN25 (VSS XI1451_asn XI1451_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1451_MN10 (VSS pp6_25 XI1451_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1451_MN6 (XI1451_an3 pp6_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1451_MN9 (XI1451_asn XI1451_acon XI1451_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1451_MN12 (XI1451_an5 pp8_21 XI1451_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1451_MN11 (XI1451_an4 pp7_23 XI1451_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1451_MN11_1 (XI1451_an5 pp7_23 XI1451_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1451_MN12_1 (XI1451_asn pp8_21 XI1451_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1451_MN10_1 (XI1451_an4 pp6_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1451_MN5 (XI1451_acon pp8_21 XI1451_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1451_MN2 (XI1451_an1 pp7_23 XI1451_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1451_MN1 (VSS pp6_25 XI1451_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1451_MN3 (XI1451_an2 pp6_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1451_MN4 (VSS pp7_23 XI1451_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1451_MN27 (cm90_2 XI1451_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1451_MN7 (XI1451_an3 pp7_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1451_MN8 (VSS pp8_21 XI1451_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1454_MN34 (XI1454_bn3 XI1454_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1454_MN35 (VSS pp9_20 XI1454_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1454_MN36 (XI1454_bn3 cm90_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1454_MN37 (XI1454_bsn XI1454_bcon XI1454_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1454_MN40 (XI1454_bn5 cm90_2 XI1454_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1454_MN39 (XI1454_bn4 pp9_20 XI1454_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1454_MN39_1 (XI1454_bn5 pp9_20 XI1454_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1454_MN40_1 (XI1454_bsn cm90_2 XI1454_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1454_MN53 (VSS XI1454_bsn cm93_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1454_MN29 (XI1454_bn1 XI1454_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1454_MN30 (XI1454_bcon pp9_20 XI1454_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1454_MN33 (XI1454_bn2 cm90_2 XI1454_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1454_MN31 (VSS XI1454_s1 XI1454_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1454_MN32 (XI1454_bn2 pp9_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1454_MN55 (VSS XI1454_bcon cm93_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1454_MN38 (XI1454_bn4 XI1454_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1454_MN38_1 (VSS XI1454_s1 XI1454_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1454_MN25 (VSS XI1454_asn XI1454_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1454_MN10 (VSS pp6_26 XI1454_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1454_MN6 (XI1454_an3 pp6_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1454_MN9 (XI1454_asn XI1454_acon XI1454_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1454_MN12 (XI1454_an5 pp8_22 XI1454_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1454_MN11 (XI1454_an4 pp7_24 XI1454_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1454_MN11_1 (XI1454_an5 pp7_24 XI1454_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1454_MN12_1 (XI1454_asn pp8_22 XI1454_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1454_MN10_1 (XI1454_an4 pp6_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1454_MN5 (XI1454_acon pp8_22 XI1454_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1454_MN2 (XI1454_an1 pp7_24 XI1454_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1454_MN1 (VSS pp6_26 XI1454_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1454_MN3 (XI1454_an2 pp6_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1454_MN4 (VSS pp7_24 XI1454_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1454_MN27 (cm93_2 XI1454_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1454_MN7 (XI1454_an3 pp7_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1454_MN8 (VSS pp8_22 XI1454_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1472_MN34 (XI1472_bn3 XI1472_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1472_MN35 (VSS pp12_20 XI1472_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1472_MN36 (XI1472_bn3 cm108_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1472_MN37 (XI1472_bsn XI1472_bcon XI1472_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1472_MN40 (XI1472_bn5 cm108_2 XI1472_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1472_MN39 (XI1472_bn4 pp12_20 XI1472_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1472_MN39_1 (XI1472_bn5 pp12_20 XI1472_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1472_MN40_1 (XI1472_bsn cm108_2 XI1472_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1472_MN53 (VSS XI1472_bsn cm111_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1472_MN29 (XI1472_bn1 XI1472_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1472_MN30 (XI1472_bcon pp12_20 XI1472_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1472_MN33 (XI1472_bn2 cm108_2 XI1472_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1472_MN31 (VSS XI1472_s1 XI1472_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1472_MN32 (XI1472_bn2 pp12_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1472_MN55 (VSS XI1472_bcon cm111_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1472_MN38 (XI1472_bn4 XI1472_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1472_MN38_1 (VSS XI1472_s1 XI1472_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1472_MN25 (VSS XI1472_asn XI1472_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1472_MN10 (VSS pp9_26 XI1472_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1472_MN6 (XI1472_an3 pp9_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1472_MN9 (XI1472_asn XI1472_acon XI1472_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1472_MN12 (XI1472_an5 pp11_22 XI1472_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1472_MN11 (XI1472_an4 pp10_24 XI1472_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1472_MN11_1 (XI1472_an5 pp10_24 XI1472_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1472_MN12_1 (XI1472_asn pp11_22 XI1472_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1472_MN10_1 (XI1472_an4 pp9_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1472_MN5 (XI1472_acon pp11_22 XI1472_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1472_MN2 (XI1472_an1 pp10_24 XI1472_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1472_MN1 (VSS pp9_26 XI1472_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1472_MN3 (XI1472_an2 pp9_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1472_MN4 (VSS pp10_24 XI1472_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1472_MN27 (cm111_2 XI1472_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1472_MN7 (XI1472_an3 pp10_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1472_MN8 (VSS pp11_22 XI1472_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1557_MN34 (XI1557_bn3 XI1557_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1557_MN35 (VSS cm116_0 XI1557_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1557_MN36 (XI1557_bn3 cm194_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1557_MN37 (XI1557_bsn XI1557_bcon XI1557_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1557_MN40 (XI1557_bn5 cm194_2 XI1557_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1557_MN39 (XI1557_bn4 cm116_0 XI1557_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1557_MN39_1 (XI1557_bn5 cm116_0 XI1557_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1557_MN40_1 (XI1557_bsn cm194_2 XI1557_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1557_MN53 (VSS XI1557_bsn cm196_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1557_MN29 (XI1557_bn1 XI1557_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1557_MN30 (XI1557_bcon cm116_0 XI1557_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1557_MN33 (XI1557_bn2 cm194_2 XI1557_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1557_MN31 (VSS XI1557_s1 XI1557_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1557_MN32 (XI1557_bn2 cm116_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1557_MN55 (VSS XI1557_bcon cm196_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1557_MN38 (XI1557_bn4 XI1557_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1557_MN38_1 (VSS XI1557_s1 XI1557_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1557_MN25 (VSS XI1557_asn XI1557_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1557_MN10 (VSS cm113_1 XI1557_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1557_MN6 (XI1557_an3 cm113_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1557_MN9 (XI1557_asn XI1557_acon XI1557_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1557_MN12 (XI1557_an5 cm115_0 XI1557_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1557_MN11 (XI1557_an4 cm114_1 XI1557_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1557_MN11_1 (XI1557_an5 cm114_1 XI1557_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1557_MN12_1 (XI1557_asn cm115_0 XI1557_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1557_MN10_1 (XI1557_an4 cm113_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1557_MN5 (XI1557_acon cm115_0 XI1557_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1557_MN2 (XI1557_an1 cm114_1 XI1557_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1557_MN1 (VSS cm113_1 XI1557_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1557_MN3 (XI1557_an2 cm113_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1557_MN4 (VSS cm114_1 XI1557_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1557_MN27 (cm196_2 XI1557_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1557_MN7 (XI1557_an3 cm114_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1557_MN8 (VSS cm115_0 XI1557_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1479_MN34 (XI1479_bn3 XI1479_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1479_MN35 (VSS pp14_19 XI1479_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1479_MN36 (XI1479_bn3 cm116_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1479_MN37 (XI1479_bsn XI1479_bcon XI1479_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1479_MN40 (XI1479_bn5 cm116_2 XI1479_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1479_MN39 (XI1479_bn4 pp14_19 XI1479_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1479_MN39_1 (XI1479_bn5 pp14_19 XI1479_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1479_MN40_1 (XI1479_bsn cm116_2 XI1479_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1479_MN53 (VSS XI1479_bsn cm118_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1479_MN29 (XI1479_bn1 XI1479_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1479_MN30 (XI1479_bcon pp14_19 XI1479_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1479_MN33 (XI1479_bn2 cm116_2 XI1479_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1479_MN31 (VSS XI1479_s1 XI1479_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1479_MN32 (XI1479_bn2 pp14_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1479_MN55 (VSS XI1479_bcon cm118_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1479_MN38 (XI1479_bn4 XI1479_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1479_MN38_1 (VSS XI1479_s1 XI1479_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1479_MN25 (VSS XI1479_asn XI1479_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1479_MN10 (VSS pp11_25 XI1479_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1479_MN6 (XI1479_an3 pp11_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1479_MN9 (XI1479_asn XI1479_acon XI1479_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1479_MN12 (XI1479_an5 pp13_21 XI1479_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1479_MN11 (XI1479_an4 pp12_23 XI1479_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1479_MN11_1 (XI1479_an5 pp12_23 XI1479_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1479_MN12_1 (XI1479_asn pp13_21 XI1479_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1479_MN10_1 (XI1479_an4 pp11_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1479_MN5 (XI1479_acon pp13_21 XI1479_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1479_MN2 (XI1479_an1 pp12_23 XI1479_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1479_MN1 (VSS pp11_25 XI1479_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1479_MN3 (XI1479_an2 pp11_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1479_MN4 (VSS pp12_23 XI1479_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1479_MN27 (cm118_2 XI1479_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1479_MN7 (XI1479_an3 pp12_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1479_MN8 (VSS pp13_21 XI1479_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1561_MN34 (XI1561_bn3 XI1561_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1561_MN35 (VSS cm124_0 XI1561_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1561_MN36 (XI1561_bn3 cm199_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1561_MN37 (XI1561_bsn XI1561_bcon XI1561_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1561_MN40 (XI1561_bn5 cm199_2 XI1561_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1561_MN39 (XI1561_bn4 cm124_0 XI1561_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1561_MN39_1 (XI1561_bn5 cm124_0 XI1561_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1561_MN40_1 (XI1561_bsn cm199_2 XI1561_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1561_MN53 (VSS XI1561_bsn cm200_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1561_MN29 (XI1561_bn1 XI1561_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1561_MN30 (XI1561_bcon cm124_0 XI1561_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1561_MN33 (XI1561_bn2 cm199_2 XI1561_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1561_MN31 (VSS XI1561_s1 XI1561_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1561_MN32 (XI1561_bn2 cm124_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1561_MN55 (VSS XI1561_bcon cm200_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1561_MN38 (XI1561_bn4 XI1561_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1561_MN38_1 (VSS XI1561_s1 XI1561_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1561_MN25 (VSS XI1561_asn XI1561_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1561_MN10 (VSS cm121_1 XI1561_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1561_MN6 (XI1561_an3 cm121_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1561_MN9 (XI1561_asn XI1561_acon XI1561_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1561_MN12 (XI1561_an5 cm123_0 XI1561_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1561_MN11 (XI1561_an4 cm122_1 XI1561_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1561_MN11_1 (XI1561_an5 cm122_1 XI1561_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1561_MN12_1 (XI1561_asn cm123_0 XI1561_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1561_MN10_1 (XI1561_an4 cm121_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1561_MN5 (XI1561_acon cm123_0 XI1561_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1561_MN2 (XI1561_an1 cm122_1 XI1561_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1561_MN1 (VSS cm121_1 XI1561_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1561_MN3 (XI1561_an2 cm121_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1561_MN4 (VSS cm122_1 XI1561_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1561_MN27 (cm200_2 XI1561_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1561_MN7 (XI1561_an3 cm122_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1561_MN8 (VSS cm123_0 XI1561_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1481_MN34 (XI1481_bn3 XI1481_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1481_MN35 (VSS pp14_20 XI1481_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1481_MN36 (XI1481_bn3 cm118_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1481_MN37 (XI1481_bsn XI1481_bcon XI1481_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1481_MN40 (XI1481_bn5 cm118_2 XI1481_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1481_MN39 (XI1481_bn4 pp14_20 XI1481_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1481_MN39_1 (XI1481_bn5 pp14_20 XI1481_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1481_MN40_1 (XI1481_bsn cm118_2 XI1481_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1481_MN53 (VSS XI1481_bsn cm120_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1481_MN29 (XI1481_bn1 XI1481_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1481_MN30 (XI1481_bcon pp14_20 XI1481_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1481_MN33 (XI1481_bn2 cm118_2 XI1481_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1481_MN31 (VSS XI1481_s1 XI1481_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1481_MN32 (XI1481_bn2 pp14_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1481_MN55 (VSS XI1481_bcon cm120_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1481_MN38 (XI1481_bn4 XI1481_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1481_MN38_1 (VSS XI1481_s1 XI1481_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1481_MN25 (VSS XI1481_asn XI1481_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1481_MN10 (VSS pp11_26 XI1481_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1481_MN6 (XI1481_an3 pp11_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1481_MN9 (XI1481_asn XI1481_acon XI1481_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1481_MN12 (XI1481_an5 pp13_22 XI1481_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1481_MN11 (XI1481_an4 pp12_24 XI1481_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1481_MN11_1 (XI1481_an5 pp12_24 XI1481_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1481_MN12_1 (XI1481_asn pp13_22 XI1481_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1481_MN10_1 (XI1481_an4 pp11_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1481_MN5 (XI1481_acon pp13_22 XI1481_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1481_MN2 (XI1481_an1 pp12_24 XI1481_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1481_MN1 (VSS pp11_26 XI1481_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1481_MN3 (XI1481_an2 pp11_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1481_MN4 (VSS pp12_24 XI1481_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1481_MN27 (cm120_2 XI1481_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1481_MN7 (XI1481_an3 pp12_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1481_MN8 (VSS pp13_22 XI1481_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1483_MN34 (XI1483_bn3 XI1483_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1483_MN35 (VSS pp15_19 XI1483_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1483_MN36 (XI1483_bn3 cm120_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1483_MN37 (XI1483_bsn XI1483_bcon XI1483_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1483_MN40 (XI1483_bn5 cm120_2 XI1483_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1483_MN39 (XI1483_bn4 pp15_19 XI1483_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1483_MN39_1 (XI1483_bn5 pp15_19 XI1483_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1483_MN40_1 (XI1483_bsn cm120_2 XI1483_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1483_MN53 (VSS XI1483_bsn cm122_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1483_MN29 (XI1483_bn1 XI1483_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1483_MN30 (XI1483_bcon pp15_19 XI1483_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1483_MN33 (XI1483_bn2 cm120_2 XI1483_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1483_MN31 (VSS XI1483_s1 XI1483_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1483_MN32 (XI1483_bn2 pp15_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1483_MN55 (VSS XI1483_bcon cm122_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1483_MN38 (XI1483_bn4 XI1483_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1483_MN38_1 (VSS XI1483_s1 XI1483_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1483_MN25 (VSS XI1483_asn XI1483_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1483_MN10 (VSS pp12_25 XI1483_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1483_MN6 (XI1483_an3 pp12_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1483_MN9 (XI1483_asn XI1483_acon XI1483_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1483_MN12 (XI1483_an5 pp14_21 XI1483_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1483_MN11 (XI1483_an4 pp13_23 XI1483_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1483_MN11_1 (XI1483_an5 pp13_23 XI1483_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1483_MN12_1 (XI1483_asn pp14_21 XI1483_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1483_MN10_1 (XI1483_an4 pp12_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1483_MN5 (XI1483_acon pp14_21 XI1483_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1483_MN2 (XI1483_an1 pp13_23 XI1483_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1483_MN1 (VSS pp12_25 XI1483_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1483_MN3 (XI1483_an2 pp12_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1483_MN4 (VSS pp13_23 XI1483_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1483_MN27 (cm122_2 XI1483_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1483_MN7 (XI1483_an3 pp13_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1483_MN8 (VSS pp14_21 XI1483_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1447_MN34 (XI1447_bn3 XI1447_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1447_MN35 (VSS pp8_20 XI1447_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1447_MN36 (XI1447_bn3 cm82_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1447_MN37 (XI1447_bsn XI1447_bcon XI1447_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1447_MN40 (XI1447_bn5 cm82_2 XI1447_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1447_MN39 (XI1447_bn4 pp8_20 XI1447_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1447_MN39_1 (XI1447_bn5 pp8_20 XI1447_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1447_MN40_1 (XI1447_bsn cm82_2 XI1447_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1447_MN53 (VSS XI1447_bsn cm86_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1447_MN29 (XI1447_bn1 XI1447_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1447_MN30 (XI1447_bcon pp8_20 XI1447_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1447_MN33 (XI1447_bn2 cm82_2 XI1447_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1447_MN31 (VSS XI1447_s1 XI1447_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1447_MN32 (XI1447_bn2 pp8_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1447_MN55 (VSS XI1447_bcon cm86_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1447_MN38 (XI1447_bn4 XI1447_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1447_MN38_1 (VSS XI1447_s1 XI1447_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1447_MN25 (VSS XI1447_asn XI1447_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1447_MN10 (VSS pp5_26 XI1447_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1447_MN6 (XI1447_an3 pp5_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1447_MN9 (XI1447_asn XI1447_acon XI1447_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1447_MN12 (XI1447_an5 pp7_22 XI1447_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1447_MN11 (XI1447_an4 pp6_24 XI1447_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1447_MN11_1 (XI1447_an5 pp6_24 XI1447_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1447_MN12_1 (XI1447_asn pp7_22 XI1447_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1447_MN10_1 (XI1447_an4 pp5_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1447_MN5 (XI1447_acon pp7_22 XI1447_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1447_MN2 (XI1447_an1 pp6_24 XI1447_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1447_MN1 (VSS pp5_26 XI1447_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1447_MN3 (XI1447_an2 pp5_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1447_MN4 (VSS pp6_24 XI1447_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1447_MN27 (cm86_2 XI1447_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1447_MN7 (XI1447_an3 pp6_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1447_MN8 (VSS pp7_22 XI1447_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1463_MN34 (XI1463_bn3 XI1463_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1463_MN35 (VSS pp11_19 XI1463_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1463_MN36 (XI1463_bn3 cm99_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1463_MN37 (XI1463_bsn XI1463_bcon XI1463_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1463_MN40 (XI1463_bn5 cm99_2 XI1463_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1463_MN39 (XI1463_bn4 pp11_19 XI1463_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1463_MN39_1 (XI1463_bn5 pp11_19 XI1463_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1463_MN40_1 (XI1463_bsn cm99_2 XI1463_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1463_MN53 (VSS XI1463_bsn cm102_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1463_MN29 (XI1463_bn1 XI1463_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1463_MN30 (XI1463_bcon pp11_19 XI1463_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1463_MN33 (XI1463_bn2 cm99_2 XI1463_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1463_MN31 (VSS XI1463_s1 XI1463_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1463_MN32 (XI1463_bn2 pp11_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1463_MN55 (VSS XI1463_bcon cm102_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1463_MN38 (XI1463_bn4 XI1463_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1463_MN38_1 (VSS XI1463_s1 XI1463_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1463_MN25 (VSS XI1463_asn XI1463_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1463_MN10 (VSS pp8_25 XI1463_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1463_MN6 (XI1463_an3 pp8_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1463_MN9 (XI1463_asn XI1463_acon XI1463_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1463_MN12 (XI1463_an5 pp10_21 XI1463_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1463_MN11 (XI1463_an4 pp9_23 XI1463_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1463_MN11_1 (XI1463_an5 pp9_23 XI1463_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1463_MN12_1 (XI1463_asn pp10_21 XI1463_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1463_MN10_1 (XI1463_an4 pp8_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1463_MN5 (XI1463_acon pp10_21 XI1463_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1463_MN2 (XI1463_an1 pp9_23 XI1463_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1463_MN1 (VSS pp8_25 XI1463_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1463_MN3 (XI1463_an2 pp8_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1463_MN4 (VSS pp9_23 XI1463_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1463_MN27 (cm102_2 XI1463_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1463_MN7 (XI1463_an3 pp9_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1463_MN8 (VSS pp10_21 XI1463_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1550_MN34 (XI1550_bn3 XI1550_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1550_MN35 (VSS cm101_0 XI1550_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1550_MN36 (XI1550_bn3 cm187_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1550_MN37 (XI1550_bsn XI1550_bcon XI1550_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1550_MN40 (XI1550_bn5 cm187_2 XI1550_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1550_MN39 (XI1550_bn4 cm101_0 XI1550_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1550_MN39_1 (XI1550_bn5 cm101_0 XI1550_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1550_MN40_1 (XI1550_bsn cm187_2 XI1550_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1550_MN53 (VSS XI1550_bsn cm189_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1550_MN29 (XI1550_bn1 XI1550_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1550_MN30 (XI1550_bcon cm101_0 XI1550_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1550_MN33 (XI1550_bn2 cm187_2 XI1550_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1550_MN31 (VSS XI1550_s1 XI1550_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1550_MN32 (XI1550_bn2 cm101_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1550_MN55 (VSS XI1550_bcon cm189_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1550_MN38 (XI1550_bn4 XI1550_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1550_MN38_1 (VSS XI1550_s1 XI1550_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1550_MN25 (VSS XI1550_asn XI1550_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1550_MN10 (VSS cm98_1 XI1550_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1550_MN6 (XI1550_an3 cm98_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1550_MN9 (XI1550_asn XI1550_acon XI1550_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1550_MN12 (XI1550_an5 cm100_1 XI1550_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1550_MN11 (XI1550_an4 cm99_1 XI1550_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1550_MN11_1 (XI1550_an5 cm99_1 XI1550_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1550_MN12_1 (XI1550_asn cm100_1 XI1550_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1550_MN10_1 (XI1550_an4 cm98_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1550_MN5 (XI1550_acon cm100_1 XI1550_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1550_MN2 (XI1550_an1 cm99_1 XI1550_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1550_MN1 (VSS cm98_1 XI1550_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1550_MN3 (XI1550_an2 cm98_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1550_MN4 (VSS cm99_1 XI1550_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1550_MN27 (cm189_2 XI1550_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1550_MN7 (XI1550_an3 cm99_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1550_MN8 (VSS cm100_1 XI1550_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1469_MN34 (XI1469_bn3 XI1469_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1469_MN35 (VSS pp12_19 XI1469_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1469_MN36 (XI1469_bn3 cm105_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1469_MN37 (XI1469_bsn XI1469_bcon XI1469_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1469_MN40 (XI1469_bn5 cm105_2 XI1469_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1469_MN39 (XI1469_bn4 pp12_19 XI1469_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1469_MN39_1 (XI1469_bn5 pp12_19 XI1469_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1469_MN40_1 (XI1469_bsn cm105_2 XI1469_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1469_MN53 (VSS XI1469_bsn cm108_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1469_MN29 (XI1469_bn1 XI1469_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1469_MN30 (XI1469_bcon pp12_19 XI1469_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1469_MN33 (XI1469_bn2 cm105_2 XI1469_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1469_MN31 (VSS XI1469_s1 XI1469_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1469_MN32 (XI1469_bn2 pp12_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1469_MN55 (VSS XI1469_bcon cm108_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1469_MN38 (XI1469_bn4 XI1469_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1469_MN38_1 (VSS XI1469_s1 XI1469_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1469_MN25 (VSS XI1469_asn XI1469_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1469_MN10 (VSS pp9_25 XI1469_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1469_MN6 (XI1469_an3 pp9_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1469_MN9 (XI1469_asn XI1469_acon XI1469_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1469_MN12 (XI1469_an5 pp11_21 XI1469_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1469_MN11 (XI1469_an4 pp10_23 XI1469_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1469_MN11_1 (XI1469_an5 pp10_23 XI1469_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1469_MN12_1 (XI1469_asn pp11_21 XI1469_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1469_MN10_1 (XI1469_an4 pp9_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1469_MN5 (XI1469_acon pp11_21 XI1469_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1469_MN2 (XI1469_an1 pp10_23 XI1469_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1469_MN1 (VSS pp9_25 XI1469_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1469_MN3 (XI1469_an2 pp9_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1469_MN4 (VSS pp10_23 XI1469_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1469_MN27 (cm108_2 XI1469_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1469_MN7 (XI1469_an3 pp10_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1469_MN8 (VSS pp11_21 XI1469_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1466_MN34 (XI1466_bn3 XI1466_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1466_MN35 (VSS pp11_20 XI1466_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1466_MN36 (XI1466_bn3 cm102_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1466_MN37 (XI1466_bsn XI1466_bcon XI1466_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1466_MN40 (XI1466_bn5 cm102_2 XI1466_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1466_MN39 (XI1466_bn4 pp11_20 XI1466_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1466_MN39_1 (XI1466_bn5 pp11_20 XI1466_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1466_MN40_1 (XI1466_bsn cm102_2 XI1466_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1466_MN53 (VSS XI1466_bsn cm105_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1466_MN29 (XI1466_bn1 XI1466_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1466_MN30 (XI1466_bcon pp11_20 XI1466_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1466_MN33 (XI1466_bn2 cm102_2 XI1466_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1466_MN31 (VSS XI1466_s1 XI1466_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1466_MN32 (XI1466_bn2 pp11_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1466_MN55 (VSS XI1466_bcon cm105_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1466_MN38 (XI1466_bn4 XI1466_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1466_MN38_1 (VSS XI1466_s1 XI1466_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1466_MN25 (VSS XI1466_asn XI1466_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1466_MN10 (VSS pp8_26 XI1466_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1466_MN6 (XI1466_an3 pp8_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1466_MN9 (XI1466_asn XI1466_acon XI1466_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1466_MN12 (XI1466_an5 pp10_22 XI1466_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1466_MN11 (XI1466_an4 pp9_24 XI1466_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1466_MN11_1 (XI1466_an5 pp9_24 XI1466_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1466_MN12_1 (XI1466_asn pp10_22 XI1466_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1466_MN10_1 (XI1466_an4 pp8_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1466_MN5 (XI1466_acon pp10_22 XI1466_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1466_MN2 (XI1466_an1 pp9_24 XI1466_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1466_MN1 (VSS pp8_26 XI1466_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1466_MN3 (XI1466_an2 pp8_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1466_MN4 (VSS pp9_24 XI1466_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1466_MN27 (cm105_2 XI1466_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1466_MN7 (XI1466_an3 pp9_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1466_MN8 (VSS pp10_22 XI1466_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1555_MN34 (XI1555_bn3 XI1555_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1555_MN35 (VSS cm113_0 XI1555_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1555_MN36 (XI1555_bn3 cm193_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1555_MN37 (XI1555_bsn XI1555_bcon XI1555_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1555_MN40 (XI1555_bn5 cm193_2 XI1555_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1555_MN39 (XI1555_bn4 cm113_0 XI1555_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1555_MN39_1 (XI1555_bn5 cm113_0 XI1555_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1555_MN40_1 (XI1555_bsn cm193_2 XI1555_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1555_MN53 (VSS XI1555_bsn cm194_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1555_MN29 (XI1555_bn1 XI1555_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1555_MN30 (XI1555_bcon cm113_0 XI1555_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1555_MN33 (XI1555_bn2 cm193_2 XI1555_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1555_MN31 (VSS XI1555_s1 XI1555_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1555_MN32 (XI1555_bn2 cm113_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1555_MN55 (VSS XI1555_bcon cm194_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1555_MN38 (XI1555_bn4 XI1555_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1555_MN38_1 (VSS XI1555_s1 XI1555_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1555_MN25 (VSS XI1555_asn XI1555_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1555_MN10 (VSS cm110_1 XI1555_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1555_MN6 (XI1555_an3 cm110_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1555_MN9 (XI1555_asn XI1555_acon XI1555_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1555_MN12 (XI1555_an5 fa112_1 XI1555_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1555_MN11 (XI1555_an4 cm111_1 XI1555_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1555_MN11_1 (XI1555_an5 cm111_1 XI1555_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1555_MN12_1 (XI1555_asn fa112_1 XI1555_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1555_MN10_1 (XI1555_an4 cm110_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1555_MN5 (XI1555_acon fa112_1 XI1555_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1555_MN2 (XI1555_an1 cm111_1 XI1555_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1555_MN1 (VSS cm110_1 XI1555_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1555_MN3 (XI1555_an2 cm110_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1555_MN4 (VSS cm111_1 XI1555_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1555_MN27 (cm194_2 XI1555_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1555_MN7 (XI1555_an3 cm111_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1555_MN8 (VSS fa112_1 XI1555_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1475_MN34 (XI1475_bn3 XI1475_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1475_MN35 (VSS pp13_19 XI1475_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1475_MN36 (XI1475_bn3 cm111_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1475_MN37 (XI1475_bsn XI1475_bcon XI1475_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1475_MN40 (XI1475_bn5 cm111_2 XI1475_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1475_MN39 (XI1475_bn4 pp13_19 XI1475_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1475_MN39_1 (XI1475_bn5 pp13_19 XI1475_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1475_MN40_1 (XI1475_bsn cm111_2 XI1475_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1475_MN53 (VSS XI1475_bsn cm114_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1475_MN29 (XI1475_bn1 XI1475_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1475_MN30 (XI1475_bcon pp13_19 XI1475_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1475_MN33 (XI1475_bn2 cm111_2 XI1475_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1475_MN31 (VSS XI1475_s1 XI1475_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1475_MN32 (XI1475_bn2 pp13_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1475_MN55 (VSS XI1475_bcon cm114_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1475_MN38 (XI1475_bn4 XI1475_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1475_MN38_1 (VSS XI1475_s1 XI1475_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1475_MN25 (VSS XI1475_asn XI1475_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1475_MN10 (VSS pp10_25 XI1475_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1475_MN6 (XI1475_an3 pp10_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1475_MN9 (XI1475_asn XI1475_acon XI1475_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1475_MN12 (XI1475_an5 pp12_21 XI1475_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1475_MN11 (XI1475_an4 pp11_23 XI1475_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1475_MN11_1 (XI1475_an5 pp11_23 XI1475_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1475_MN12_1 (XI1475_asn pp12_21 XI1475_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1475_MN10_1 (XI1475_an4 pp10_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1475_MN5 (XI1475_acon pp12_21 XI1475_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1475_MN2 (XI1475_an1 pp11_23 XI1475_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1475_MN1 (VSS pp10_25 XI1475_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1475_MN3 (XI1475_an2 pp10_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1475_MN4 (VSS pp11_23 XI1475_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1475_MN27 (cm114_2 XI1475_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1475_MN7 (XI1475_an3 pp11_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1475_MN8 (VSS pp12_21 XI1475_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1477_MN34 (XI1477_bn3 XI1477_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1477_MN35 (VSS pp13_20 XI1477_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1477_MN36 (XI1477_bn3 cm114_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1477_MN37 (XI1477_bsn XI1477_bcon XI1477_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1477_MN40 (XI1477_bn5 cm114_2 XI1477_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1477_MN39 (XI1477_bn4 pp13_20 XI1477_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1477_MN39_1 (XI1477_bn5 pp13_20 XI1477_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1477_MN40_1 (XI1477_bsn cm114_2 XI1477_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1477_MN53 (VSS XI1477_bsn cm116_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1477_MN29 (XI1477_bn1 XI1477_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1477_MN30 (XI1477_bcon pp13_20 XI1477_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1477_MN33 (XI1477_bn2 cm114_2 XI1477_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1477_MN31 (VSS XI1477_s1 XI1477_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1477_MN32 (XI1477_bn2 pp13_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1477_MN55 (VSS XI1477_bcon cm116_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1477_MN38 (XI1477_bn4 XI1477_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1477_MN38_1 (VSS XI1477_s1 XI1477_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1477_MN25 (VSS XI1477_asn XI1477_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1477_MN10 (VSS pp10_26 XI1477_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1477_MN6 (XI1477_an3 pp10_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1477_MN9 (XI1477_asn XI1477_acon XI1477_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1477_MN12 (XI1477_an5 pp12_22 XI1477_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1477_MN11 (XI1477_an4 pp11_24 XI1477_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1477_MN11_1 (XI1477_an5 pp11_24 XI1477_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1477_MN12_1 (XI1477_asn pp12_22 XI1477_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1477_MN10_1 (XI1477_an4 pp10_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1477_MN5 (XI1477_acon pp12_22 XI1477_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1477_MN2 (XI1477_an1 pp11_24 XI1477_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1477_MN1 (VSS pp10_26 XI1477_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1477_MN3 (XI1477_an2 pp10_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1477_MN4 (VSS pp11_24 XI1477_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1477_MN27 (cm116_2 XI1477_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1477_MN7 (XI1477_an3 pp11_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1477_MN8 (VSS pp12_22 XI1477_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1486_MN34 (XI1486_bn3 XI1486_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1486_MN35 (VSS pp12_27 XI1486_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1486_MN36 (XI1486_bn3 cm123_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1486_MN37 (XI1486_bsn XI1486_bcon XI1486_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1486_MN40 (XI1486_bn5 cm123_2 XI1486_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1486_MN39 (XI1486_bn4 pp12_27 XI1486_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1486_MN39_1 (XI1486_bn5 pp12_27 XI1486_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1486_MN40_1 (XI1486_bsn cm123_2 XI1486_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1486_MN53 (VSS XI1486_bsn cm125_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1486_MN29 (XI1486_bn1 XI1486_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1486_MN30 (XI1486_bcon pp12_27 XI1486_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1486_MN33 (XI1486_bn2 cm123_2 XI1486_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1486_MN31 (VSS XI1486_s1 XI1486_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1486_MN32 (XI1486_bn2 pp12_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1486_MN55 (VSS XI1486_bcon cm125_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1486_MN38 (XI1486_bn4 XI1486_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1486_MN38_1 (VSS XI1486_s1 XI1486_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1486_MN25 (VSS XI1486_asn XI1486_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1486_MN10 (VSS sn9 XI1486_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1486_MN6 (XI1486_an3 sn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1486_MN9 (XI1486_asn XI1486_acon XI1486_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1486_MN12 (XI1486_an5 pp11_29 XI1486_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1486_MN11 (XI1486_an4 pp10_31 XI1486_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1486_MN11_1 (XI1486_an5 pp10_31 XI1486_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1486_MN12_1 (XI1486_asn pp11_29 XI1486_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1486_MN10_1 (XI1486_an4 sn9 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1486_MN5 (XI1486_acon pp11_29 XI1486_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1486_MN2 (XI1486_an1 pp10_31 XI1486_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1486_MN1 (VSS sn9 XI1486_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1486_MN3 (XI1486_an2 sn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1486_MN4 (VSS pp10_31 XI1486_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1486_MN27 (cm125_2 XI1486_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1486_MN7 (XI1486_an3 pp10_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1486_MN8 (VSS pp11_29 XI1486_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1562_MN34 (XI1562_bn3 XI1562_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1562_MN35 (VSS fa126_0 XI1562_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1562_MN36 (XI1562_bn3 cm200_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1562_MN37 (XI1562_bsn XI1562_bcon XI1562_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1562_MN40 (XI1562_bn5 cm200_2 XI1562_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1562_MN39 (XI1562_bn4 fa126_0 XI1562_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1562_MN39_1 (XI1562_bn5 fa126_0 XI1562_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1562_MN40_1 (XI1562_bsn cm200_2 XI1562_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1562_MN53 (VSS XI1562_bsn cm201_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1562_MN29 (XI1562_bn1 XI1562_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1562_MN30 (XI1562_bcon fa126_0 XI1562_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1562_MN33 (XI1562_bn2 cm200_2 XI1562_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1562_MN31 (VSS XI1562_s1 XI1562_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1562_MN32 (XI1562_bn2 fa126_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1562_MN55 (VSS XI1562_bcon cm201_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1562_MN38 (XI1562_bn4 XI1562_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1562_MN38_1 (VSS XI1562_s1 XI1562_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1562_MN25 (VSS XI1562_asn XI1562_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1562_MN10 (VSS cm123_1 XI1562_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1562_MN6 (XI1562_an3 cm123_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1562_MN9 (XI1562_asn XI1562_acon XI1562_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1562_MN12 (XI1562_an5 cm125_0 XI1562_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1562_MN11 (XI1562_an4 cm124_1 XI1562_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1562_MN11_1 (XI1562_an5 cm124_1 XI1562_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1562_MN12_1 (XI1562_asn cm125_0 XI1562_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1562_MN10_1 (XI1562_an4 cm123_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1562_MN5 (XI1562_acon cm125_0 XI1562_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1562_MN2 (XI1562_an1 cm124_1 XI1562_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1562_MN1 (VSS cm123_1 XI1562_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1562_MN3 (XI1562_an2 cm123_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1562_MN4 (VSS cm124_1 XI1562_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1562_MN27 (cm201_2 XI1562_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1562_MN7 (XI1562_an3 cm124_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1562_MN8 (VSS cm125_0 XI1562_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1456_MN34 (XI1456_bn3 XI1456_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1456_MN35 (VSS pp6_27 XI1456_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1456_MN36 (XI1456_bn3 cm92_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1456_MN37 (XI1456_bsn XI1456_bcon XI1456_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1456_MN40 (XI1456_bn5 cm92_2 XI1456_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1456_MN39 (XI1456_bn4 pp6_27 XI1456_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1456_MN39_1 (XI1456_bn5 pp6_27 XI1456_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1456_MN40_1 (XI1456_bsn cm92_2 XI1456_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1456_MN53 (VSS XI1456_bsn cm95_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1456_MN29 (XI1456_bn1 XI1456_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1456_MN30 (XI1456_bcon pp6_27 XI1456_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1456_MN33 (XI1456_bn2 cm92_2 XI1456_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1456_MN31 (VSS XI1456_s1 XI1456_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1456_MN32 (XI1456_bn2 pp6_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1456_MN55 (VSS XI1456_bcon cm95_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1456_MN38 (XI1456_bn4 XI1456_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1456_MN38_1 (VSS XI1456_s1 XI1456_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1456_MN25 (VSS XI1456_asn XI1456_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1456_MN10 (VSS sn3 XI1456_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1456_MN6 (XI1456_an3 sn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1456_MN9 (XI1456_asn XI1456_acon XI1456_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1456_MN12 (XI1456_an5 pp5_29 XI1456_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1456_MN11 (XI1456_an4 pp4_31 XI1456_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1456_MN11_1 (XI1456_an5 pp4_31 XI1456_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1456_MN12_1 (XI1456_asn pp5_29 XI1456_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1456_MN10_1 (XI1456_an4 sn3 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1456_MN5 (XI1456_acon pp5_29 XI1456_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1456_MN2 (XI1456_an1 pp4_31 XI1456_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1456_MN1 (VSS sn3 XI1456_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1456_MN3 (XI1456_an2 sn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1456_MN4 (VSS pp4_31 XI1456_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1456_MN27 (cm95_2 XI1456_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1456_MN7 (XI1456_an3 pp4_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1456_MN8 (VSS pp5_29 XI1456_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1544_MN34 (XI1544_bn3 XI1544_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1544_MN35 (VSS cm92_0 XI1544_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1544_MN36 (XI1544_bn3 cm181_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1544_MN37 (XI1544_bsn XI1544_bcon XI1544_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1544_MN40 (XI1544_bn5 cm181_2 XI1544_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1544_MN39 (XI1544_bn4 cm92_0 XI1544_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1544_MN39_1 (XI1544_bn5 cm92_0 XI1544_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1544_MN40_1 (XI1544_bsn cm181_2 XI1544_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1544_MN53 (VSS XI1544_bsn cm183_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1544_MN29 (XI1544_bn1 XI1544_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1544_MN30 (XI1544_bcon cm92_0 XI1544_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1544_MN33 (XI1544_bn2 cm181_2 XI1544_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1544_MN31 (VSS XI1544_s1 XI1544_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1544_MN32 (XI1544_bn2 cm92_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1544_MN55 (VSS XI1544_bcon cm183_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1544_MN38 (XI1544_bn4 XI1544_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1544_MN38_1 (VSS XI1544_s1 XI1544_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1544_MN25 (VSS XI1544_asn XI1544_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1544_MN10 (VSS cm89_1 XI1544_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1544_MN6 (XI1544_an3 cm89_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1544_MN9 (XI1544_asn XI1544_acon XI1544_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1544_MN12 (XI1544_an5 cm91_1 XI1544_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1544_MN11 (XI1544_an4 cm90_1 XI1544_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1544_MN11_1 (XI1544_an5 cm90_1 XI1544_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1544_MN12_1 (XI1544_asn cm91_1 XI1544_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1544_MN10_1 (XI1544_an4 cm89_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1544_MN5 (XI1544_acon cm91_1 XI1544_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1544_MN2 (XI1544_an1 cm90_1 XI1544_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1544_MN1 (VSS cm89_1 XI1544_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1544_MN3 (XI1544_an2 cm89_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1544_MN4 (VSS cm90_1 XI1544_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1544_MN27 (cm183_2 XI1544_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1544_MN7 (XI1544_an3 cm90_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1544_MN8 (VSS cm91_1 XI1544_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1546_MN34 (XI1546_bn3 XI1546_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1546_MN35 (VSS cm95_0 XI1546_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1546_MN36 (XI1546_bn3 cm183_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1546_MN37 (XI1546_bsn XI1546_bcon XI1546_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1546_MN40 (XI1546_bn5 cm183_2 XI1546_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1546_MN39 (XI1546_bn4 cm95_0 XI1546_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1546_MN39_1 (XI1546_bn5 cm95_0 XI1546_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1546_MN40_1 (XI1546_bsn cm183_2 XI1546_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1546_MN53 (VSS XI1546_bsn cm185_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1546_MN29 (XI1546_bn1 XI1546_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1546_MN30 (XI1546_bcon cm95_0 XI1546_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1546_MN33 (XI1546_bn2 cm183_2 XI1546_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1546_MN31 (VSS XI1546_s1 XI1546_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1546_MN32 (XI1546_bn2 cm95_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1546_MN55 (VSS XI1546_bcon cm185_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1546_MN38 (XI1546_bn4 XI1546_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1546_MN38_1 (VSS XI1546_s1 XI1546_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1546_MN25 (VSS XI1546_asn XI1546_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1546_MN10 (VSS cm92_1 XI1546_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1546_MN6 (XI1546_an3 cm92_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1546_MN9 (XI1546_asn XI1546_acon XI1546_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1546_MN12 (XI1546_an5 cm94_1 XI1546_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1546_MN11 (XI1546_an4 cm93_1 XI1546_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1546_MN11_1 (XI1546_an5 cm93_1 XI1546_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1546_MN12_1 (XI1546_asn cm94_1 XI1546_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1546_MN10_1 (XI1546_an4 cm92_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1546_MN5 (XI1546_acon cm94_1 XI1546_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1546_MN2 (XI1546_an1 cm93_1 XI1546_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1546_MN1 (VSS cm92_1 XI1546_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1546_MN3 (XI1546_an2 cm92_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1546_MN4 (VSS cm93_1 XI1546_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1546_MN27 (cm185_2 XI1546_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1546_MN7 (XI1546_an3 cm93_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1546_MN8 (VSS cm94_1 XI1546_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1595_MN34 (XI1595_bn3 XI1595_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1595_MN35 (VSS fa188_0 XI1595_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1595_MN36 (XI1595_bn3 cm233_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1595_MN37 (XI1595_bsn XI1595_bcon XI1595_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1595_MN40 (XI1595_bn5 cm233_2 XI1595_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1595_MN39 (XI1595_bn4 fa188_0 XI1595_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1595_MN39_1 (XI1595_bn5 fa188_0 XI1595_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1595_MN40_1 (XI1595_bsn cm233_2 XI1595_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1595_MN53 (VSS XI1595_bsn cm234_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1595_MN29 (XI1595_bn1 XI1595_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1595_MN30 (XI1595_bcon fa188_0 XI1595_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1595_MN33 (XI1595_bn2 cm233_2 XI1595_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1595_MN31 (VSS XI1595_s1 XI1595_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1595_MN32 (XI1595_bn2 fa188_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1595_MN55 (VSS XI1595_bcon cm234_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1595_MN38 (XI1595_bn4 XI1595_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1595_MN38_1 (VSS XI1595_s1 XI1595_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1595_MN25 (VSS XI1595_asn XI1595_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1595_MN10 (VSS cm185_1 XI1595_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1595_MN6 (XI1595_an3 cm185_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1595_MN9 (XI1595_asn XI1595_acon XI1595_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1595_MN12 (XI1595_an5 cm187_0 XI1595_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1595_MN11 (XI1595_an4 fa186_1 XI1595_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1595_MN11_1 (XI1595_an5 fa186_1 XI1595_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1595_MN12_1 (XI1595_asn cm187_0 XI1595_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1595_MN10_1 (XI1595_an4 cm185_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1595_MN5 (XI1595_acon cm187_0 XI1595_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1595_MN2 (XI1595_an1 fa186_1 XI1595_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1595_MN1 (VSS cm185_1 XI1595_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1595_MN3 (XI1595_an2 cm185_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1595_MN4 (VSS fa186_1 XI1595_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1595_MN27 (cm234_2 XI1595_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1595_MN7 (XI1595_an3 fa186_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1595_MN8 (VSS cm187_0 XI1595_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1552_MN34 (XI1552_bn3 XI1552_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1552_MN35 (VSS cm107_0 XI1552_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1552_MN36 (XI1552_bn3 cm190_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1552_MN37 (XI1552_bsn XI1552_bcon XI1552_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1552_MN40 (XI1552_bn5 cm190_2 XI1552_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1552_MN39 (XI1552_bn4 cm107_0 XI1552_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1552_MN39_1 (XI1552_bn5 cm107_0 XI1552_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1552_MN40_1 (XI1552_bsn cm190_2 XI1552_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1552_MN53 (VSS XI1552_bsn cm191_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1552_MN29 (XI1552_bn1 XI1552_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1552_MN30 (XI1552_bcon cm107_0 XI1552_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1552_MN33 (XI1552_bn2 cm190_2 XI1552_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1552_MN31 (VSS XI1552_s1 XI1552_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1552_MN32 (XI1552_bn2 cm107_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1552_MN55 (VSS XI1552_bcon cm191_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1552_MN38 (XI1552_bn4 XI1552_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1552_MN38_1 (VSS XI1552_s1 XI1552_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1552_MN25 (VSS XI1552_asn XI1552_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1552_MN10 (VSS cm104_1 XI1552_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1552_MN6 (XI1552_an3 cm104_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1552_MN9 (XI1552_asn XI1552_acon XI1552_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1552_MN12 (XI1552_an5 cm106_1 XI1552_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1552_MN11 (XI1552_an4 cm105_1 XI1552_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1552_MN11_1 (XI1552_an5 cm105_1 XI1552_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1552_MN12_1 (XI1552_asn cm106_1 XI1552_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1552_MN10_1 (XI1552_an4 cm104_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1552_MN5 (XI1552_acon cm106_1 XI1552_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1552_MN2 (XI1552_an1 cm105_1 XI1552_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1552_MN1 (VSS cm104_1 XI1552_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1552_MN3 (XI1552_an2 cm104_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1552_MN4 (VSS cm105_1 XI1552_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1552_MN27 (cm191_2 XI1552_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1552_MN7 (XI1552_an3 cm105_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1552_MN8 (VSS cm106_1 XI1552_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1551_MN34 (XI1551_bn3 XI1551_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1551_MN35 (VSS cm104_0 XI1551_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1551_MN36 (XI1551_bn3 cm189_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1551_MN37 (XI1551_bsn XI1551_bcon XI1551_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1551_MN40 (XI1551_bn5 cm189_2 XI1551_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1551_MN39 (XI1551_bn4 cm104_0 XI1551_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1551_MN39_1 (XI1551_bn5 cm104_0 XI1551_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1551_MN40_1 (XI1551_bsn cm189_2 XI1551_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1551_MN53 (VSS XI1551_bsn cm190_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1551_MN29 (XI1551_bn1 XI1551_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1551_MN30 (XI1551_bcon cm104_0 XI1551_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1551_MN33 (XI1551_bn2 cm189_2 XI1551_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1551_MN31 (VSS XI1551_s1 XI1551_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1551_MN32 (XI1551_bn2 cm104_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1551_MN55 (VSS XI1551_bcon cm190_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1551_MN38 (XI1551_bn4 XI1551_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1551_MN38_1 (VSS XI1551_s1 XI1551_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1551_MN25 (VSS XI1551_asn XI1551_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1551_MN10 (VSS cm101_1 XI1551_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1551_MN6 (XI1551_an3 cm101_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1551_MN9 (XI1551_asn XI1551_acon XI1551_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1551_MN12 (XI1551_an5 cm103_1 XI1551_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1551_MN11 (XI1551_an4 cm102_1 XI1551_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1551_MN11_1 (XI1551_an5 cm102_1 XI1551_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1551_MN12_1 (XI1551_asn cm103_1 XI1551_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1551_MN10_1 (XI1551_an4 cm101_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1551_MN5 (XI1551_acon cm103_1 XI1551_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1551_MN2 (XI1551_an1 cm102_1 XI1551_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1551_MN1 (VSS cm101_1 XI1551_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1551_MN3 (XI1551_an2 cm101_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1551_MN4 (VSS cm102_1 XI1551_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1551_MN27 (cm190_2 XI1551_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1551_MN7 (XI1551_an3 cm102_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1551_MN8 (VSS cm103_1 XI1551_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1554_MN34 (XI1554_bn3 XI1554_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1554_MN35 (VSS cm110_0 XI1554_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1554_MN36 (XI1554_bn3 cm191_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1554_MN37 (XI1554_bsn XI1554_bcon XI1554_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1554_MN40 (XI1554_bn5 cm191_2 XI1554_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1554_MN39 (XI1554_bn4 cm110_0 XI1554_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1554_MN39_1 (XI1554_bn5 cm110_0 XI1554_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1554_MN40_1 (XI1554_bsn cm191_2 XI1554_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1554_MN53 (VSS XI1554_bsn cm193_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1554_MN29 (XI1554_bn1 XI1554_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1554_MN30 (XI1554_bcon cm110_0 XI1554_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1554_MN33 (XI1554_bn2 cm191_2 XI1554_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1554_MN31 (VSS XI1554_s1 XI1554_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1554_MN32 (XI1554_bn2 cm110_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1554_MN55 (VSS XI1554_bcon cm193_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1554_MN38 (XI1554_bn4 XI1554_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1554_MN38_1 (VSS XI1554_s1 XI1554_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1554_MN25 (VSS XI1554_asn XI1554_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1554_MN10 (VSS cm107_1 XI1554_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1554_MN6 (XI1554_an3 cm107_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1554_MN9 (XI1554_asn XI1554_acon XI1554_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1554_MN12 (XI1554_an5 fa109_1 XI1554_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1554_MN11 (XI1554_an4 cm108_1 XI1554_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1554_MN11_1 (XI1554_an5 cm108_1 XI1554_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1554_MN12_1 (XI1554_asn fa109_1 XI1554_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1554_MN10_1 (XI1554_an4 cm107_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1554_MN5 (XI1554_acon fa109_1 XI1554_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1554_MN2 (XI1554_an1 cm108_1 XI1554_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1554_MN1 (VSS cm107_1 XI1554_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1554_MN3 (XI1554_an2 cm107_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1554_MN4 (VSS cm108_1 XI1554_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1554_MN27 (cm193_2 XI1554_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1554_MN7 (XI1554_an3 cm108_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1554_MN8 (VSS fa109_1 XI1554_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1485_MN34 (XI1485_bn3 XI1485_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1485_MN35 (VSS pp15_20 XI1485_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1485_MN36 (XI1485_bn3 cm122_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1485_MN37 (XI1485_bsn XI1485_bcon XI1485_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1485_MN40 (XI1485_bn5 cm122_2 XI1485_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1485_MN39 (XI1485_bn4 pp15_20 XI1485_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1485_MN39_1 (XI1485_bn5 pp15_20 XI1485_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1485_MN40_1 (XI1485_bsn cm122_2 XI1485_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1485_MN53 (VSS XI1485_bsn cm124_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1485_MN29 (XI1485_bn1 XI1485_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1485_MN30 (XI1485_bcon pp15_20 XI1485_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1485_MN33 (XI1485_bn2 cm122_2 XI1485_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1485_MN31 (VSS XI1485_s1 XI1485_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1485_MN32 (XI1485_bn2 pp15_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1485_MN55 (VSS XI1485_bcon cm124_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1485_MN38 (XI1485_bn4 XI1485_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1485_MN38_1 (VSS XI1485_s1 XI1485_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1485_MN25 (VSS XI1485_asn XI1485_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1485_MN10 (VSS pp12_26 XI1485_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1485_MN6 (XI1485_an3 pp12_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1485_MN9 (XI1485_asn XI1485_acon XI1485_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1485_MN12 (XI1485_an5 pp14_22 XI1485_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1485_MN11 (XI1485_an4 pp13_24 XI1485_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1485_MN11_1 (XI1485_an5 pp13_24 XI1485_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1485_MN12_1 (XI1485_asn pp14_22 XI1485_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1485_MN10_1 (XI1485_an4 pp12_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1485_MN5 (XI1485_acon pp14_22 XI1485_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1485_MN2 (XI1485_an1 pp13_24 XI1485_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1485_MN1 (VSS pp12_26 XI1485_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1485_MN3 (XI1485_an2 pp12_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1485_MN4 (VSS pp13_24 XI1485_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1485_MN27 (cm124_2 XI1485_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1485_MN7 (XI1485_an3 pp13_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1485_MN8 (VSS pp14_22 XI1485_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1453_MN34 (XI1453_bn3 XI1453_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1453_MN35 (VSS pp5_28 XI1453_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1453_MN36 (XI1453_bn3 cm89_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1453_MN37 (XI1453_bsn XI1453_bcon XI1453_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1453_MN40 (XI1453_bn5 cm89_2 XI1453_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1453_MN39 (XI1453_bn4 pp5_28 XI1453_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1453_MN39_1 (XI1453_bn5 pp5_28 XI1453_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1453_MN40_1 (XI1453_bsn cm89_2 XI1453_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1453_MN53 (VSS XI1453_bsn cm92_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1453_MN29 (XI1453_bn1 XI1453_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1453_MN30 (XI1453_bcon pp5_28 XI1453_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1453_MN33 (XI1453_bn2 cm89_2 XI1453_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1453_MN31 (VSS XI1453_s1 XI1453_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1453_MN32 (XI1453_bn2 pp5_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1453_MN55 (VSS XI1453_bcon cm92_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1453_MN38 (XI1453_bn4 XI1453_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1453_MN38_1 (VSS XI1453_s1 XI1453_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1453_MN25 (VSS XI1453_asn XI1453_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1453_MN10 (VSS VDD XI1453_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1453_MN6 (XI1453_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1453_MN9 (XI1453_asn XI1453_acon XI1453_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1453_MN12 (XI1453_an5 pp4_30 XI1453_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1453_MN11 (XI1453_an4 pp3_32 XI1453_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1453_MN11_1 (XI1453_an5 pp3_32 XI1453_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1453_MN12_1 (XI1453_asn pp4_30 XI1453_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1453_MN10_1 (XI1453_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1453_MN5 (XI1453_acon pp4_30 XI1453_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1453_MN2 (XI1453_an1 pp3_32 XI1453_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1453_MN1 (VSS VDD XI1453_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1453_MN3 (XI1453_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1453_MN4 (VSS pp3_32 XI1453_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1453_MN27 (cm92_2 XI1453_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1453_MN7 (XI1453_an3 pp3_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1453_MN8 (VSS pp4_30 XI1453_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1594_MN34 (XI1594_bn3 XI1594_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1594_MN35 (VSS fa186_0 XI1594_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1594_MN36 (XI1594_bn3 cm232_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1594_MN37 (XI1594_bsn XI1594_bcon XI1594_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1594_MN40 (XI1594_bn5 cm232_2 XI1594_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1594_MN39 (XI1594_bn4 fa186_0 XI1594_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1594_MN39_1 (XI1594_bn5 fa186_0 XI1594_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1594_MN40_1 (XI1594_bsn cm232_2 XI1594_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1594_MN53 (VSS XI1594_bsn cm233_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1594_MN29 (XI1594_bn1 XI1594_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1594_MN30 (XI1594_bcon fa186_0 XI1594_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1594_MN33 (XI1594_bn2 cm232_2 XI1594_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1594_MN31 (VSS XI1594_s1 XI1594_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1594_MN32 (XI1594_bn2 fa186_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1594_MN55 (VSS XI1594_bcon cm233_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1594_MN38 (XI1594_bn4 XI1594_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1594_MN38_1 (VSS XI1594_s1 XI1594_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1594_MN25 (VSS XI1594_asn XI1594_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1594_MN10 (VSS cm183_1 XI1594_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1594_MN6 (XI1594_an3 cm183_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1594_MN9 (XI1594_asn XI1594_acon XI1594_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1594_MN12 (XI1594_an5 cm185_0 XI1594_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1594_MN11 (XI1594_an4 cm184_1 XI1594_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1594_MN11_1 (XI1594_an5 cm184_1 XI1594_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1594_MN12_1 (XI1594_asn cm185_0 XI1594_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1594_MN10_1 (XI1594_an4 cm183_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1594_MN5 (XI1594_acon cm185_0 XI1594_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1594_MN2 (XI1594_an1 cm184_1 XI1594_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1594_MN1 (VSS cm183_1 XI1594_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1594_MN3 (XI1594_an2 cm183_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1594_MN4 (VSS cm184_1 XI1594_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1594_MN27 (cm233_2 XI1594_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1594_MN7 (XI1594_an3 cm184_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1594_MN8 (VSS cm185_0 XI1594_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1548_MN34 (XI1548_bn3 XI1548_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1548_MN35 (VSS cm98_0 XI1548_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1548_MN36 (XI1548_bn3 cm185_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1548_MN37 (XI1548_bsn XI1548_bcon XI1548_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1548_MN40 (XI1548_bn5 cm185_2 XI1548_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1548_MN39 (XI1548_bn4 cm98_0 XI1548_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1548_MN39_1 (XI1548_bn5 cm98_0 XI1548_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1548_MN40_1 (XI1548_bsn cm185_2 XI1548_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1548_MN53 (VSS XI1548_bsn cm187_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1548_MN29 (XI1548_bn1 XI1548_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1548_MN30 (XI1548_bcon cm98_0 XI1548_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1548_MN33 (XI1548_bn2 cm185_2 XI1548_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1548_MN31 (VSS XI1548_s1 XI1548_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1548_MN32 (XI1548_bn2 cm98_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1548_MN55 (VSS XI1548_bcon cm187_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1548_MN38 (XI1548_bn4 XI1548_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1548_MN38_1 (VSS XI1548_s1 XI1548_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1548_MN25 (VSS XI1548_asn XI1548_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1548_MN10 (VSS cm95_1 XI1548_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1548_MN6 (XI1548_an3 cm95_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1548_MN9 (XI1548_asn XI1548_acon XI1548_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1548_MN12 (XI1548_an5 cm97_1 XI1548_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1548_MN11 (XI1548_an4 cm96_1 XI1548_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1548_MN11_1 (XI1548_an5 cm96_1 XI1548_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1548_MN12_1 (XI1548_asn cm97_1 XI1548_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1548_MN10_1 (XI1548_an4 cm95_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1548_MN5 (XI1548_acon cm97_1 XI1548_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1548_MN2 (XI1548_an1 cm96_1 XI1548_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1548_MN1 (VSS cm95_1 XI1548_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1548_MN3 (XI1548_an2 cm95_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1548_MN4 (VSS cm96_1 XI1548_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1548_MN27 (cm187_2 XI1548_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1548_MN7 (XI1548_an3 cm96_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1548_MN8 (VSS cm97_1 XI1548_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1545_MN34 (XI1545_bn3 XI1545_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1545_MN35 (VSS pp15_8 XI1545_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1545_MN36 (XI1545_bn3 cm182_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1545_MN37 (XI1545_bsn XI1545_bcon XI1545_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1545_MN40 (XI1545_bn5 cm182_2 XI1545_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1545_MN39 (XI1545_bn4 pp15_8 XI1545_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1545_MN39_1 (XI1545_bn5 pp15_8 XI1545_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1545_MN40_1 (XI1545_bsn cm182_2 XI1545_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1545_MN53 (VSS XI1545_bsn cm184_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1545_MN29 (XI1545_bn1 XI1545_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1545_MN30 (XI1545_bcon pp15_8 XI1545_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1545_MN33 (XI1545_bn2 cm182_2 XI1545_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1545_MN31 (VSS XI1545_s1 XI1545_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1545_MN32 (XI1545_bn2 pp15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1545_MN55 (VSS XI1545_bcon cm184_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1545_MN38 (XI1545_bn4 XI1545_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1545_MN38_1 (VSS XI1545_s1 XI1545_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1545_MN25 (VSS XI1545_asn XI1545_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1545_MN10 (VSS cm93_0 XI1545_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1545_MN6 (XI1545_an3 cm93_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1545_MN9 (XI1545_asn XI1545_acon XI1545_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1545_MN12 (XI1545_an5 pp14_10 XI1545_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1545_MN11 (XI1545_an4 cm94_0 XI1545_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1545_MN11_1 (XI1545_an5 cm94_0 XI1545_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1545_MN12_1 (XI1545_asn pp14_10 XI1545_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1545_MN10_1 (XI1545_an4 cm93_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1545_MN5 (XI1545_acon pp14_10 XI1545_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1545_MN2 (XI1545_an1 cm94_0 XI1545_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1545_MN1 (VSS cm93_0 XI1545_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1545_MN3 (XI1545_an2 cm93_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1545_MN4 (VSS cm94_0 XI1545_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1545_MN27 (cm184_2 XI1545_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1545_MN7 (XI1545_an3 cm94_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1545_MN8 (VSS pp14_10 XI1545_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1596_MN34 (XI1596_bn3 XI1596_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1596_MN35 (VSS cm102_0 XI1596_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1596_MN36 (XI1596_bn3 cm234_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1596_MN37 (XI1596_bsn XI1596_bcon XI1596_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1596_MN40 (XI1596_bn5 cm234_2 XI1596_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1596_MN39 (XI1596_bn4 cm102_0 XI1596_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1596_MN39_1 (XI1596_bn5 cm102_0 XI1596_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1596_MN40_1 (XI1596_bsn cm234_2 XI1596_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1596_MN53 (VSS XI1596_bsn cm235_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1596_MN29 (XI1596_bn1 XI1596_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1596_MN30 (XI1596_bcon cm102_0 XI1596_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1596_MN33 (XI1596_bn2 cm234_2 XI1596_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1596_MN31 (VSS XI1596_s1 XI1596_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1596_MN32 (XI1596_bn2 cm102_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1596_MN55 (VSS XI1596_bcon cm235_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1596_MN38 (XI1596_bn4 XI1596_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1596_MN38_1 (VSS XI1596_s1 XI1596_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1596_MN25 (VSS XI1596_asn XI1596_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1596_MN10 (VSS cm187_1 XI1596_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1596_MN6 (XI1596_an3 cm187_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1596_MN9 (XI1596_asn XI1596_acon XI1596_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1596_MN12 (XI1596_an5 cm189_0 XI1596_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1596_MN11 (XI1596_an4 fa188_1 XI1596_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1596_MN11_1 (XI1596_an5 fa188_1 XI1596_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1596_MN12_1 (XI1596_asn cm189_0 XI1596_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1596_MN10_1 (XI1596_an4 cm187_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1596_MN5 (XI1596_acon cm189_0 XI1596_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1596_MN2 (XI1596_an1 fa188_1 XI1596_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1596_MN1 (VSS cm187_1 XI1596_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1596_MN3 (XI1596_an2 cm187_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1596_MN4 (VSS fa188_1 XI1596_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1596_MN27 (cm235_2 XI1596_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1596_MN7 (XI1596_an3 fa188_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1596_MN8 (VSS cm189_0 XI1596_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1597_MN34 (XI1597_bn3 XI1597_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1597_MN35 (VSS cm106_0 XI1597_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1597_MN36 (XI1597_bn3 cm235_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1597_MN37 (XI1597_bsn XI1597_bcon XI1597_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1597_MN40 (XI1597_bn5 cm235_2 XI1597_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1597_MN39 (XI1597_bn4 cm106_0 XI1597_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1597_MN39_1 (XI1597_bn5 cm106_0 XI1597_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1597_MN40_1 (XI1597_bsn cm235_2 XI1597_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1597_MN53 (VSS XI1597_bsn cm236_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1597_MN29 (XI1597_bn1 XI1597_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1597_MN30 (XI1597_bcon cm106_0 XI1597_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1597_MN33 (XI1597_bn2 cm235_2 XI1597_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1597_MN31 (VSS XI1597_s1 XI1597_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1597_MN32 (XI1597_bn2 cm106_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1597_MN55 (VSS XI1597_bcon cm236_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1597_MN38 (XI1597_bn4 XI1597_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1597_MN38_1 (VSS XI1597_s1 XI1597_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1597_MN25 (VSS XI1597_asn XI1597_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1597_MN10 (VSS cm189_1 XI1597_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1597_MN6 (XI1597_an3 cm189_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1597_MN9 (XI1597_asn XI1597_acon XI1597_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1597_MN12 (XI1597_an5 cm105_0 XI1597_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1597_MN11 (XI1597_an4 cm190_0 XI1597_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1597_MN11_1 (XI1597_an5 cm190_0 XI1597_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1597_MN12_1 (XI1597_asn cm105_0 XI1597_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1597_MN10_1 (XI1597_an4 cm189_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1597_MN5 (XI1597_acon cm105_0 XI1597_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1597_MN2 (XI1597_an1 cm190_0 XI1597_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1597_MN1 (VSS cm189_1 XI1597_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1597_MN3 (XI1597_an2 cm189_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1597_MN4 (VSS cm190_0 XI1597_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1597_MN27 (cm236_2 XI1597_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1597_MN7 (XI1597_an3 cm190_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1597_MN8 (VSS cm105_0 XI1597_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1563_MN34 (XI1563_bn3 XI1563_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1563_MN35 (VSS fa128_0 XI1563_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1563_MN36 (XI1563_bn3 cm201_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1563_MN37 (XI1563_bsn XI1563_bcon XI1563_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1563_MN40 (XI1563_bn5 cm201_2 XI1563_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1563_MN39 (XI1563_bn4 fa128_0 XI1563_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1563_MN39_1 (XI1563_bn5 fa128_0 XI1563_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1563_MN40_1 (XI1563_bsn cm201_2 XI1563_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1563_MN53 (VSS XI1563_bsn cm202_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1563_MN29 (XI1563_bn1 XI1563_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1563_MN30 (XI1563_bcon fa128_0 XI1563_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1563_MN33 (XI1563_bn2 cm201_2 XI1563_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1563_MN31 (VSS XI1563_s1 XI1563_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1563_MN32 (XI1563_bn2 fa128_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1563_MN55 (VSS XI1563_bcon cm202_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1563_MN38 (XI1563_bn4 XI1563_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1563_MN38_1 (VSS XI1563_s1 XI1563_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1563_MN25 (VSS XI1563_asn XI1563_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1563_MN10 (VSS cm125_1 XI1563_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1563_MN6 (XI1563_an3 cm125_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1563_MN9 (XI1563_asn XI1563_acon XI1563_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1563_MN12 (XI1563_an5 cm127_0 XI1563_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1563_MN11 (XI1563_an4 fa126_1 XI1563_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1563_MN11_1 (XI1563_an5 fa126_1 XI1563_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1563_MN12_1 (XI1563_asn cm127_0 XI1563_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1563_MN10_1 (XI1563_an4 cm125_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1563_MN5 (XI1563_acon cm127_0 XI1563_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1563_MN2 (XI1563_an1 fa126_1 XI1563_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1563_MN1 (VSS cm125_1 XI1563_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1563_MN3 (XI1563_an2 cm125_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1563_MN4 (VSS fa126_1 XI1563_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1563_MN27 (cm202_2 XI1563_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1563_MN7 (XI1563_an3 fa126_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1563_MN8 (VSS cm127_0 XI1563_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1450_MN34 (XI1450_bn3 XI1450_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1450_MN35 (VSS pp5_27 XI1450_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1450_MN36 (XI1450_bn3 cm85_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1450_MN37 (XI1450_bsn XI1450_bcon XI1450_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1450_MN40 (XI1450_bn5 cm85_2 XI1450_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1450_MN39 (XI1450_bn4 pp5_27 XI1450_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1450_MN39_1 (XI1450_bn5 pp5_27 XI1450_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1450_MN40_1 (XI1450_bsn cm85_2 XI1450_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1450_MN53 (VSS XI1450_bsn cm89_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1450_MN29 (XI1450_bn1 XI1450_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1450_MN30 (XI1450_bcon pp5_27 XI1450_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1450_MN33 (XI1450_bn2 cm85_2 XI1450_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1450_MN31 (VSS XI1450_s1 XI1450_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1450_MN32 (XI1450_bn2 pp5_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1450_MN55 (VSS XI1450_bcon cm89_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1450_MN38 (XI1450_bn4 XI1450_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1450_MN38_1 (VSS XI1450_s1 XI1450_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1450_MN25 (VSS XI1450_asn XI1450_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1450_MN10 (VSS sn2 XI1450_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1450_MN6 (XI1450_an3 sn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1450_MN9 (XI1450_asn XI1450_acon XI1450_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1450_MN12 (XI1450_an5 pp4_29 XI1450_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1450_MN11 (XI1450_an4 pp3_31 XI1450_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1450_MN11_1 (XI1450_an5 pp3_31 XI1450_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1450_MN12_1 (XI1450_asn pp4_29 XI1450_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1450_MN10_1 (XI1450_an4 sn2 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1450_MN5 (XI1450_acon pp4_29 XI1450_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1450_MN2 (XI1450_an1 pp3_31 XI1450_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1450_MN1 (VSS sn2 XI1450_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1450_MN3 (XI1450_an2 sn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1450_MN4 (VSS pp3_31 XI1450_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1450_MN27 (cm89_2 XI1450_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1450_MN7 (XI1450_an3 pp3_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1450_MN8 (VSS pp4_29 XI1450_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1593_MN34 (XI1593_bn3 XI1593_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1593_MN35 (VSS cm184_0 XI1593_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1593_MN36 (XI1593_bn3 cm231_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1593_MN37 (XI1593_bsn XI1593_bcon XI1593_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1593_MN40 (XI1593_bn5 cm231_2 XI1593_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1593_MN39 (XI1593_bn4 cm184_0 XI1593_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1593_MN39_1 (XI1593_bn5 cm184_0 XI1593_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1593_MN40_1 (XI1593_bsn cm231_2 XI1593_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1593_MN53 (VSS XI1593_bsn cm232_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1593_MN29 (XI1593_bn1 XI1593_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1593_MN30 (XI1593_bcon cm184_0 XI1593_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1593_MN33 (XI1593_bn2 cm231_2 XI1593_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1593_MN31 (VSS XI1593_s1 XI1593_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1593_MN32 (XI1593_bn2 cm184_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1593_MN55 (VSS XI1593_bcon cm232_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1593_MN38 (XI1593_bn4 XI1593_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1593_MN38_1 (VSS XI1593_s1 XI1593_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1593_MN25 (VSS XI1593_asn XI1593_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1593_MN10 (VSS cm181_1 XI1593_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1593_MN6 (XI1593_an3 cm181_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1593_MN9 (XI1593_asn XI1593_acon XI1593_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1593_MN12 (XI1593_an5 cm183_0 XI1593_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1593_MN11 (XI1593_an4 cm182_1 XI1593_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1593_MN11_1 (XI1593_an5 cm182_1 XI1593_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1593_MN12_1 (XI1593_asn cm183_0 XI1593_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1593_MN10_1 (XI1593_an4 cm181_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1593_MN5 (XI1593_acon cm183_0 XI1593_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1593_MN2 (XI1593_an1 cm182_1 XI1593_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1593_MN1 (VSS cm181_1 XI1593_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1593_MN3 (XI1593_an2 cm181_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1593_MN4 (VSS cm182_1 XI1593_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1593_MN27 (cm232_2 XI1593_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1593_MN7 (XI1593_an3 cm182_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1593_MN8 (VSS cm183_0 XI1593_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1543_MN34 (XI1543_bn3 XI1543_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1543_MN35 (VSS pp14_9 XI1543_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1543_MN36 (XI1543_bn3 cm180_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1543_MN37 (XI1543_bsn XI1543_bcon XI1543_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1543_MN40 (XI1543_bn5 cm180_2 XI1543_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1543_MN39 (XI1543_bn4 pp14_9 XI1543_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1543_MN39_1 (XI1543_bn5 pp14_9 XI1543_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1543_MN40_1 (XI1543_bsn cm180_2 XI1543_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1543_MN53 (VSS XI1543_bsn cm182_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1543_MN29 (XI1543_bn1 XI1543_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1543_MN30 (XI1543_bcon pp14_9 XI1543_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1543_MN33 (XI1543_bn2 cm180_2 XI1543_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1543_MN31 (VSS XI1543_s1 XI1543_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1543_MN32 (XI1543_bn2 pp14_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1543_MN55 (VSS XI1543_bcon cm182_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1543_MN38 (XI1543_bn4 XI1543_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1543_MN38_1 (VSS XI1543_s1 XI1543_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1543_MN25 (VSS XI1543_asn XI1543_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1543_MN10 (VSS cm89_0 XI1543_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1543_MN6 (XI1543_an3 cm89_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1543_MN9 (XI1543_asn XI1543_acon XI1543_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1543_MN12 (XI1543_an5 cm91_0 XI1543_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1543_MN11 (XI1543_an4 cm90_0 XI1543_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1543_MN11_1 (XI1543_an5 cm90_0 XI1543_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1543_MN12_1 (XI1543_asn cm91_0 XI1543_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1543_MN10_1 (XI1543_an4 cm89_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1543_MN5 (XI1543_acon cm91_0 XI1543_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1543_MN2 (XI1543_an1 cm90_0 XI1543_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1543_MN1 (VSS cm89_0 XI1543_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1543_MN3 (XI1543_an2 cm89_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1543_MN4 (VSS cm90_0 XI1543_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1543_MN27 (cm182_2 XI1543_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1543_MN7 (XI1543_an3 cm90_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1543_MN8 (VSS cm91_0 XI1543_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1452_MN34 (XI1452_bn3 XI1452_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1452_MN35 (VSS pp13_11 XI1452_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1452_MN36 (XI1452_bn3 cm87_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1452_MN37 (XI1452_bsn XI1452_bcon XI1452_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1452_MN40 (XI1452_bn5 cm87_2 XI1452_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1452_MN39 (XI1452_bn4 pp13_11 XI1452_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1452_MN39_1 (XI1452_bn5 pp13_11 XI1452_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1452_MN40_1 (XI1452_bsn cm87_2 XI1452_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1452_MN53 (VSS XI1452_bsn cm91_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1452_MN29 (XI1452_bn1 XI1452_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1452_MN30 (XI1452_bcon pp13_11 XI1452_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1452_MN33 (XI1452_bn2 cm87_2 XI1452_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1452_MN31 (VSS XI1452_s1 XI1452_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1452_MN32 (XI1452_bn2 pp13_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1452_MN55 (VSS XI1452_bcon cm91_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1452_MN38 (XI1452_bn4 XI1452_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1452_MN38_1 (VSS XI1452_s1 XI1452_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1452_MN25 (VSS XI1452_asn XI1452_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1452_MN10 (VSS pp10_17 XI1452_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1452_MN6 (XI1452_an3 pp10_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1452_MN9 (XI1452_asn XI1452_acon XI1452_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1452_MN12 (XI1452_an5 pp12_13 XI1452_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1452_MN11 (XI1452_an4 pp11_15 XI1452_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1452_MN11_1 (XI1452_an5 pp11_15 XI1452_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1452_MN12_1 (XI1452_asn pp12_13 XI1452_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1452_MN10_1 (XI1452_an4 pp10_17 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1452_MN5 (XI1452_acon pp12_13 XI1452_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1452_MN2 (XI1452_an1 pp11_15 XI1452_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1452_MN1 (VSS pp10_17 XI1452_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1452_MN3 (XI1452_an2 pp10_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1452_MN4 (VSS pp11_15 XI1452_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1452_MN27 (cm91_2 XI1452_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1452_MN7 (XI1452_an3 pp11_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1452_MN8 (VSS pp12_13 XI1452_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1455_MN34 (XI1455_bn3 XI1455_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1455_MN35 (VSS pp13_12 XI1455_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1455_MN36 (XI1455_bn3 cm91_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1455_MN37 (XI1455_bsn XI1455_bcon XI1455_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1455_MN40 (XI1455_bn5 cm91_2 XI1455_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1455_MN39 (XI1455_bn4 pp13_12 XI1455_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1455_MN39_1 (XI1455_bn5 pp13_12 XI1455_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1455_MN40_1 (XI1455_bsn cm91_2 XI1455_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1455_MN53 (VSS XI1455_bsn cm94_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1455_MN29 (XI1455_bn1 XI1455_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1455_MN30 (XI1455_bcon pp13_12 XI1455_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1455_MN33 (XI1455_bn2 cm91_2 XI1455_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1455_MN31 (VSS XI1455_s1 XI1455_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1455_MN32 (XI1455_bn2 pp13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1455_MN55 (VSS XI1455_bcon cm94_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1455_MN38 (XI1455_bn4 XI1455_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1455_MN38_1 (VSS XI1455_s1 XI1455_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1455_MN25 (VSS XI1455_asn XI1455_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1455_MN10 (VSS pp10_18 XI1455_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1455_MN6 (XI1455_an3 pp10_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1455_MN9 (XI1455_asn XI1455_acon XI1455_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1455_MN12 (XI1455_an5 pp12_14 XI1455_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1455_MN11 (XI1455_an4 pp11_16 XI1455_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1455_MN11_1 (XI1455_an5 pp11_16 XI1455_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1455_MN12_1 (XI1455_asn pp12_14 XI1455_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1455_MN10_1 (XI1455_an4 pp10_18 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1455_MN5 (XI1455_acon pp12_14 XI1455_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1455_MN2 (XI1455_an1 pp11_16 XI1455_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1455_MN1 (VSS pp10_18 XI1455_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1455_MN3 (XI1455_an2 pp10_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1455_MN4 (VSS pp11_16 XI1455_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1455_MN27 (cm94_2 XI1455_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1455_MN7 (XI1455_an3 pp11_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1455_MN8 (VSS pp12_14 XI1455_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1461_MN34 (XI1461_bn3 XI1461_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1461_MN35 (VSS pp14_12 XI1461_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1461_MN36 (XI1461_bn3 cm97_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1461_MN37 (XI1461_bsn XI1461_bcon XI1461_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1461_MN40 (XI1461_bn5 cm97_2 XI1461_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1461_MN39 (XI1461_bn4 pp14_12 XI1461_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1461_MN39_1 (XI1461_bn5 pp14_12 XI1461_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1461_MN40_1 (XI1461_bsn cm97_2 XI1461_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1461_MN53 (VSS XI1461_bsn cm100_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1461_MN29 (XI1461_bn1 XI1461_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1461_MN30 (XI1461_bcon pp14_12 XI1461_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1461_MN33 (XI1461_bn2 cm97_2 XI1461_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1461_MN31 (VSS XI1461_s1 XI1461_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1461_MN32 (XI1461_bn2 pp14_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1461_MN55 (VSS XI1461_bcon cm100_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1461_MN38 (XI1461_bn4 XI1461_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1461_MN38_1 (VSS XI1461_s1 XI1461_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1461_MN25 (VSS XI1461_asn XI1461_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1461_MN10 (VSS pp11_18 XI1461_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1461_MN6 (XI1461_an3 pp11_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1461_MN9 (XI1461_asn XI1461_acon XI1461_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1461_MN12 (XI1461_an5 pp13_14 XI1461_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1461_MN11 (XI1461_an4 pp12_16 XI1461_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1461_MN11_1 (XI1461_an5 pp12_16 XI1461_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1461_MN12_1 (XI1461_asn pp13_14 XI1461_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1461_MN10_1 (XI1461_an4 pp11_18 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1461_MN5 (XI1461_acon pp13_14 XI1461_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1461_MN2 (XI1461_an1 pp12_16 XI1461_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1461_MN1 (VSS pp11_18 XI1461_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1461_MN3 (XI1461_an2 pp11_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1461_MN4 (VSS pp12_16 XI1461_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1461_MN27 (cm100_2 XI1461_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1461_MN7 (XI1461_an3 pp12_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1461_MN8 (VSS pp13_14 XI1461_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1464_MN34 (XI1464_bn3 XI1464_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1464_MN35 (VSS pp15_11 XI1464_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1464_MN36 (XI1464_bn3 cm100_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1464_MN37 (XI1464_bsn XI1464_bcon XI1464_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1464_MN40 (XI1464_bn5 cm100_2 XI1464_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1464_MN39 (XI1464_bn4 pp15_11 XI1464_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1464_MN39_1 (XI1464_bn5 pp15_11 XI1464_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1464_MN40_1 (XI1464_bsn cm100_2 XI1464_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1464_MN53 (VSS XI1464_bsn cm103_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1464_MN29 (XI1464_bn1 XI1464_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1464_MN30 (XI1464_bcon pp15_11 XI1464_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1464_MN33 (XI1464_bn2 cm100_2 XI1464_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1464_MN31 (VSS XI1464_s1 XI1464_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1464_MN32 (XI1464_bn2 pp15_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1464_MN55 (VSS XI1464_bcon cm103_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1464_MN38 (XI1464_bn4 XI1464_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1464_MN38_1 (VSS XI1464_s1 XI1464_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1464_MN25 (VSS XI1464_asn XI1464_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1464_MN10 (VSS pp12_17 XI1464_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1464_MN6 (XI1464_an3 pp12_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1464_MN9 (XI1464_asn XI1464_acon XI1464_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1464_MN12 (XI1464_an5 pp14_13 XI1464_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1464_MN11 (XI1464_an4 pp13_15 XI1464_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1464_MN11_1 (XI1464_an5 pp13_15 XI1464_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1464_MN12_1 (XI1464_asn pp14_13 XI1464_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1464_MN10_1 (XI1464_an4 pp12_17 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1464_MN5 (XI1464_acon pp14_13 XI1464_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1464_MN2 (XI1464_an1 pp13_15 XI1464_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1464_MN1 (VSS pp12_17 XI1464_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1464_MN3 (XI1464_an2 pp12_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1464_MN4 (VSS pp13_15 XI1464_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1464_MN27 (cm103_2 XI1464_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1464_MN7 (XI1464_an3 pp13_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1464_MN8 (VSS pp14_13 XI1464_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1446_MN34 (XI1446_bn3 XI1446_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1446_MN35 (VSS pp4_28 XI1446_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1446_MN36 (XI1446_bn3 cm81_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1446_MN37 (XI1446_bsn XI1446_bcon XI1446_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1446_MN40 (XI1446_bn5 cm81_2 XI1446_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1446_MN39 (XI1446_bn4 pp4_28 XI1446_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1446_MN39_1 (XI1446_bn5 pp4_28 XI1446_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1446_MN40_1 (XI1446_bsn cm81_2 XI1446_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1446_MN53 (VSS XI1446_bsn cm85_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1446_MN29 (XI1446_bn1 XI1446_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1446_MN30 (XI1446_bcon pp4_28 XI1446_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1446_MN33 (XI1446_bn2 cm81_2 XI1446_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1446_MN31 (VSS XI1446_s1 XI1446_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1446_MN32 (XI1446_bn2 pp4_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1446_MN55 (VSS XI1446_bcon cm85_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1446_MN38 (XI1446_bn4 XI1446_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1446_MN38_1 (VSS XI1446_s1 XI1446_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1446_MN25 (VSS XI1446_asn XI1446_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1446_MN10 (VSS VDD XI1446_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1446_MN6 (XI1446_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1446_MN9 (XI1446_asn XI1446_acon XI1446_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1446_MN12 (XI1446_an5 pp3_30 XI1446_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1446_MN11 (XI1446_an4 pp2_32 XI1446_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1446_MN11_1 (XI1446_an5 pp2_32 XI1446_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1446_MN12_1 (XI1446_asn pp3_30 XI1446_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1446_MN10_1 (XI1446_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1446_MN5 (XI1446_acon pp3_30 XI1446_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1446_MN2 (XI1446_an1 pp2_32 XI1446_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1446_MN1 (VSS VDD XI1446_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1446_MN3 (XI1446_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1446_MN4 (VSS pp2_32 XI1446_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1446_MN27 (cm85_2 XI1446_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1446_MN7 (XI1446_an3 pp2_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1446_MN8 (VSS pp3_30 XI1446_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1542_MN34 (XI1542_bn3 XI1542_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1542_MN35 (VSS fa88_1 XI1542_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1542_MN36 (XI1542_bn3 cm179_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1542_MN37 (XI1542_bsn XI1542_bcon XI1542_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1542_MN40 (XI1542_bn5 cm179_2 XI1542_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1542_MN39 (XI1542_bn4 fa88_1 XI1542_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1542_MN39_1 (XI1542_bn5 fa88_1 XI1542_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1542_MN40_1 (XI1542_bsn cm179_2 XI1542_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1542_MN53 (VSS XI1542_bsn cm181_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1542_MN29 (XI1542_bn1 XI1542_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1542_MN30 (XI1542_bcon fa88_1 XI1542_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1542_MN33 (XI1542_bn2 cm179_2 XI1542_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1542_MN31 (VSS XI1542_s1 XI1542_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1542_MN32 (XI1542_bn2 fa88_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1542_MN55 (VSS XI1542_bcon cm181_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1542_MN38 (XI1542_bn4 XI1542_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1542_MN38_1 (VSS XI1542_s1 XI1542_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1542_MN25 (VSS XI1542_asn XI1542_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1542_MN10 (VSS cm85_1 XI1542_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1542_MN6 (XI1542_an3 cm85_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1542_MN9 (XI1542_asn XI1542_acon XI1542_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1542_MN12 (XI1542_an5 cm87_1 XI1542_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1542_MN11 (XI1542_an4 cm86_1 XI1542_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1542_MN11_1 (XI1542_an5 cm86_1 XI1542_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1542_MN12_1 (XI1542_asn cm87_1 XI1542_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1542_MN10_1 (XI1542_an4 cm85_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1542_MN5 (XI1542_acon cm87_1 XI1542_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1542_MN2 (XI1542_an1 cm86_1 XI1542_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1542_MN1 (VSS cm85_1 XI1542_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1542_MN3 (XI1542_an2 cm85_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1542_MN4 (VSS cm86_1 XI1542_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1542_MN27 (cm181_2 XI1542_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1542_MN7 (XI1542_an3 cm86_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1542_MN8 (VSS cm87_1 XI1542_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1592_MN34 (XI1592_bn3 XI1592_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1592_MN35 (VSS cm182_0 XI1592_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1592_MN36 (XI1592_bn3 cm230_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1592_MN37 (XI1592_bsn XI1592_bcon XI1592_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1592_MN40 (XI1592_bn5 cm230_2 XI1592_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1592_MN39 (XI1592_bn4 cm182_0 XI1592_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1592_MN39_1 (XI1592_bn5 cm182_0 XI1592_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1592_MN40_1 (XI1592_bsn cm230_2 XI1592_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1592_MN53 (VSS XI1592_bsn cm231_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1592_MN29 (XI1592_bn1 XI1592_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1592_MN30 (XI1592_bcon cm182_0 XI1592_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1592_MN33 (XI1592_bn2 cm230_2 XI1592_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1592_MN31 (VSS XI1592_s1 XI1592_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1592_MN32 (XI1592_bn2 cm182_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1592_MN55 (VSS XI1592_bcon cm231_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1592_MN38 (XI1592_bn4 XI1592_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1592_MN38_1 (VSS XI1592_s1 XI1592_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1592_MN25 (VSS XI1592_asn XI1592_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1592_MN10 (VSS cm179_1 XI1592_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1592_MN6 (XI1592_an3 cm179_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1592_MN9 (XI1592_asn XI1592_acon XI1592_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1592_MN12 (XI1592_an5 cm181_0 XI1592_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1592_MN11 (XI1592_an4 cm180_1 XI1592_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1592_MN11_1 (XI1592_an5 cm180_1 XI1592_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1592_MN12_1 (XI1592_asn cm181_0 XI1592_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1592_MN10_1 (XI1592_an4 cm179_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1592_MN5 (XI1592_acon cm181_0 XI1592_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1592_MN2 (XI1592_an1 cm180_1 XI1592_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1592_MN1 (VSS cm179_1 XI1592_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1592_MN3 (XI1592_an2 cm179_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1592_MN4 (VSS cm180_1 XI1592_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1592_MN27 (cm231_2 XI1592_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1592_MN7 (XI1592_an3 cm180_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1592_MN8 (VSS cm181_0 XI1592_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1458_MN34 (XI1458_bn3 XI1458_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1458_MN35 (VSS pp14_11 XI1458_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1458_MN36 (XI1458_bn3 cm94_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1458_MN37 (XI1458_bsn XI1458_bcon XI1458_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1458_MN40 (XI1458_bn5 cm94_2 XI1458_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1458_MN39 (XI1458_bn4 pp14_11 XI1458_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1458_MN39_1 (XI1458_bn5 pp14_11 XI1458_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1458_MN40_1 (XI1458_bsn cm94_2 XI1458_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1458_MN53 (VSS XI1458_bsn cm97_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1458_MN29 (XI1458_bn1 XI1458_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1458_MN30 (XI1458_bcon pp14_11 XI1458_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1458_MN33 (XI1458_bn2 cm94_2 XI1458_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1458_MN31 (VSS XI1458_s1 XI1458_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1458_MN32 (XI1458_bn2 pp14_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1458_MN55 (VSS XI1458_bcon cm97_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1458_MN38 (XI1458_bn4 XI1458_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1458_MN38_1 (VSS XI1458_s1 XI1458_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1458_MN25 (VSS XI1458_asn XI1458_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1458_MN10 (VSS pp11_17 XI1458_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1458_MN6 (XI1458_an3 pp11_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1458_MN9 (XI1458_asn XI1458_acon XI1458_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1458_MN12 (XI1458_an5 pp13_13 XI1458_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1458_MN11 (XI1458_an4 pp12_15 XI1458_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1458_MN11_1 (XI1458_an5 pp12_15 XI1458_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1458_MN12_1 (XI1458_asn pp13_13 XI1458_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1458_MN10_1 (XI1458_an4 pp11_17 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1458_MN5 (XI1458_acon pp13_13 XI1458_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1458_MN2 (XI1458_an1 pp12_15 XI1458_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1458_MN1 (VSS pp11_17 XI1458_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1458_MN3 (XI1458_an2 pp11_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1458_MN4 (VSS pp12_15 XI1458_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1458_MN27 (cm97_2 XI1458_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1458_MN7 (XI1458_an3 pp12_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1458_MN8 (VSS pp13_13 XI1458_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1467_MN34 (XI1467_bn3 XI1467_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1467_MN35 (VSS pp15_12 XI1467_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1467_MN36 (XI1467_bn3 cm103_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1467_MN37 (XI1467_bsn XI1467_bcon XI1467_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1467_MN40 (XI1467_bn5 cm103_2 XI1467_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1467_MN39 (XI1467_bn4 pp15_12 XI1467_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1467_MN39_1 (XI1467_bn5 pp15_12 XI1467_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1467_MN40_1 (XI1467_bsn cm103_2 XI1467_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1467_MN53 (VSS XI1467_bsn cm106_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1467_MN29 (XI1467_bn1 XI1467_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1467_MN30 (XI1467_bcon pp15_12 XI1467_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1467_MN33 (XI1467_bn2 cm103_2 XI1467_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1467_MN31 (VSS XI1467_s1 XI1467_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1467_MN32 (XI1467_bn2 pp15_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1467_MN55 (VSS XI1467_bcon cm106_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1467_MN38 (XI1467_bn4 XI1467_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1467_MN38_1 (VSS XI1467_s1 XI1467_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1467_MN25 (VSS XI1467_asn XI1467_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1467_MN10 (VSS pp12_18 XI1467_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1467_MN6 (XI1467_an3 pp12_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1467_MN9 (XI1467_asn XI1467_acon XI1467_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1467_MN12 (XI1467_an5 pp14_14 XI1467_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1467_MN11 (XI1467_an4 pp13_16 XI1467_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1467_MN11_1 (XI1467_an5 pp13_16 XI1467_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1467_MN12_1 (XI1467_asn pp14_14 XI1467_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1467_MN10_1 (XI1467_an4 pp12_18 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1467_MN5 (XI1467_acon pp14_14 XI1467_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1467_MN2 (XI1467_an1 pp13_16 XI1467_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1467_MN1 (VSS pp12_18 XI1467_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1467_MN3 (XI1467_an2 pp12_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1467_MN4 (VSS pp13_16 XI1467_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1467_MN27 (cm106_2 XI1467_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1467_MN7 (XI1467_an3 pp13_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1467_MN8 (VSS pp14_14 XI1467_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1488_MN34 (XI1488_bn3 XI1488_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1488_MN35 (VSS pp12_28 XI1488_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1488_MN36 (XI1488_bn3 cm125_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1488_MN37 (XI1488_bsn XI1488_bcon XI1488_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1488_MN40 (XI1488_bn5 cm125_2 XI1488_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1488_MN39 (XI1488_bn4 pp12_28 XI1488_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1488_MN39_1 (XI1488_bn5 pp12_28 XI1488_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1488_MN40_1 (XI1488_bsn cm125_2 XI1488_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1488_MN53 (VSS XI1488_bsn cm127_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1488_MN29 (XI1488_bn1 XI1488_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1488_MN30 (XI1488_bcon pp12_28 XI1488_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1488_MN33 (XI1488_bn2 cm125_2 XI1488_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1488_MN31 (VSS XI1488_s1 XI1488_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1488_MN32 (XI1488_bn2 pp12_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1488_MN55 (VSS XI1488_bcon cm127_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1488_MN38 (XI1488_bn4 XI1488_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67999u
    I_MXI1488_MN38_1 (VSS XI1488_s1 XI1488_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67999u ps=1.21999u
    I_MXI1488_MN25 (VSS XI1488_asn XI1488_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1488_MN10 (VSS VDD XI1488_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1488_MN6 (XI1488_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1488_MN9 (XI1488_asn XI1488_acon XI1488_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1488_MN12 (XI1488_an5 pp11_30 XI1488_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1488_MN11 (XI1488_an4 pp10_32 XI1488_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75999u ps=0.67999u
    I_MXI1488_MN11_1 (XI1488_an5 pp10_32 XI1488_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67999u ps=1.75999u
    I_MXI1488_MN12_1 (XI1488_asn pp11_30 XI1488_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1488_MN10_1 (XI1488_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1488_MN5 (XI1488_acon pp11_30 XI1488_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1488_MN2 (XI1488_an1 pp10_32 XI1488_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1488_MN1 (VSS VDD XI1488_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1488_MN3 (XI1488_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1488_MN4 (VSS pp10_32 XI1488_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1488_MN27 (cm127_2 XI1488_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1488_MN7 (XI1488_an3 pp10_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1488_MN8 (VSS pp11_30 XI1488_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1564_MN34 (XI1564_bn3 XI1564_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1564_MN35 (VSS pp14_25 XI1564_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1564_MN36 (XI1564_bn3 cm202_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1564_MN37 (XI1564_bsn XI1564_bcon XI1564_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1564_MN40 (XI1564_bn5 cm202_2 XI1564_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67999u ps=0.67999u
    I_MXI1564_MN39 (XI1564_bn4 pp14_25 XI1564_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1564_MN39_1 (XI1564_bn5 pp14_25 XI1564_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1564_MN40_1 (XI1564_bsn cm202_2 XI1564_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15999u ps=0.67999u
    I_MXI1564_MN53 (VSS XI1564_bsn cm203_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1564_MN29 (XI1564_bn1 XI1564_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67999u ps=0.67999u
    I_MXI1564_MN30 (XI1564_bcon pp14_25 XI1564_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1564_MN33 (XI1564_bn2 cm202_2 XI1564_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1564_MN31 (VSS XI1564_s1 XI1564_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1564_MN32 (XI1564_bn2 pp14_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1564_MN55 (VSS XI1564_bcon cm203_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67999u ps=1.15999u
    I_MXI1564_MN38 (XI1564_bn4 XI1564_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21999u ps=0.67998u
    I_MXI1564_MN38_1 (VSS XI1564_s1 XI1564_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21999u
    I_MXI1564_MN25 (VSS XI1564_asn XI1564_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1564_MN10 (VSS cm127_1 XI1564_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1564_MN6 (XI1564_an3 cm127_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1564_MN9 (XI1564_asn XI1564_acon XI1564_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1564_MN12 (XI1564_an5 cm129_0 XI1564_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1564_MN11 (XI1564_an4 fa128_1 XI1564_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1564_MN11_1 (XI1564_an5 fa128_1 XI1564_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1564_MN12_1 (XI1564_asn cm129_0 XI1564_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1564_MN10_1 (XI1564_an4 cm127_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1564_MN5 (XI1564_acon cm129_0 XI1564_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1564_MN2 (XI1564_an1 fa128_1 XI1564_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1564_MN1 (VSS cm127_1 XI1564_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1564_MN3 (XI1564_an2 cm127_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1564_MN4 (VSS fa128_1 XI1564_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1564_MN27 (cm203_2 XI1564_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1564_MN7 (XI1564_an3 fa128_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1564_MN8 (VSS cm129_0 XI1564_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1443_MN34 (XI1443_bn3 XI1443_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1443_MN35 (VSS pp7_21 XI1443_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1443_MN36 (XI1443_bn3 cm78_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1443_MN37 (XI1443_bsn XI1443_bcon XI1443_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1443_MN40 (XI1443_bn5 cm78_2 XI1443_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1443_MN39 (XI1443_bn4 pp7_21 XI1443_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1443_MN39_1 (XI1443_bn5 pp7_21 XI1443_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1443_MN40_1 (XI1443_bsn cm78_2 XI1443_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1443_MN53 (VSS XI1443_bsn cm82_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1443_MN29 (XI1443_bn1 XI1443_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1443_MN30 (XI1443_bcon pp7_21 XI1443_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1443_MN33 (XI1443_bn2 cm78_2 XI1443_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1443_MN31 (VSS XI1443_s1 XI1443_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1443_MN32 (XI1443_bn2 pp7_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1443_MN55 (VSS XI1443_bcon cm82_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1443_MN38 (XI1443_bn4 XI1443_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1443_MN38_1 (VSS XI1443_s1 XI1443_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1443_MN25 (VSS XI1443_asn XI1443_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1443_MN10 (VSS pp4_27 XI1443_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1443_MN6 (XI1443_an3 pp4_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1443_MN9 (XI1443_asn XI1443_acon XI1443_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1443_MN12 (XI1443_an5 pp6_23 XI1443_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1443_MN11 (XI1443_an4 pp5_25 XI1443_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1443_MN11_1 (XI1443_an5 pp5_25 XI1443_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1443_MN12_1 (XI1443_asn pp6_23 XI1443_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1443_MN10_1 (XI1443_an4 pp4_27 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1443_MN5 (XI1443_acon pp6_23 XI1443_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1443_MN2 (XI1443_an1 pp5_25 XI1443_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1443_MN1 (VSS pp4_27 XI1443_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1443_MN3 (XI1443_an2 pp4_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1443_MN4 (VSS pp5_25 XI1443_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1443_MN27 (cm82_2 XI1443_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1443_MN7 (XI1443_an3 pp5_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1443_MN8 (VSS pp6_23 XI1443_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1442_MN34 (XI1442_bn3 XI1442_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1442_MN35 (VSS pp3_29 XI1442_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1442_MN36 (XI1442_bn3 cm77_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1442_MN37 (XI1442_bsn XI1442_bcon XI1442_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1442_MN40 (XI1442_bn5 cm77_2 XI1442_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1442_MN39 (XI1442_bn4 pp3_29 XI1442_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1442_MN39_1 (XI1442_bn5 pp3_29 XI1442_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1442_MN40_1 (XI1442_bsn cm77_2 XI1442_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1442_MN53 (VSS XI1442_bsn cm81_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1442_MN29 (XI1442_bn1 XI1442_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1442_MN30 (XI1442_bcon pp3_29 XI1442_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1442_MN33 (XI1442_bn2 cm77_2 XI1442_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1442_MN31 (VSS XI1442_s1 XI1442_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1442_MN32 (XI1442_bn2 pp3_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1442_MN55 (VSS XI1442_bcon cm81_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1442_MN38 (XI1442_bn4 XI1442_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1442_MN38_1 (VSS XI1442_s1 XI1442_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1442_MN25 (VSS XI1442_asn XI1442_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1442_MN10 (VSS sn0 XI1442_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1442_MN6 (XI1442_an3 sn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1442_MN9 (XI1442_asn XI1442_acon XI1442_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1442_MN12 (XI1442_an5 pp2_31 XI1442_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1442_MN11 (XI1442_an4 sn1 XI1442_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1442_MN11_1 (XI1442_an5 sn1 XI1442_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1442_MN12_1 (XI1442_asn pp2_31 XI1442_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1442_MN10_1 (XI1442_an4 sn0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1442_MN5 (XI1442_acon pp2_31 XI1442_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1442_MN2 (XI1442_an1 sn1 XI1442_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1442_MN1 (VSS sn0 XI1442_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1442_MN3 (XI1442_an2 sn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1442_MN4 (VSS sn1 XI1442_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1442_MN27 (cm81_2 XI1442_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1442_MN7 (XI1442_an3 sn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1442_MN8 (VSS pp2_31 XI1442_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1541_MN34 (XI1541_bn3 XI1541_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1541_MN35 (VSS fa88_0 XI1541_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1541_MN36 (XI1541_bn3 cm178_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1541_MN37 (XI1541_bsn XI1541_bcon XI1541_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1541_MN40 (XI1541_bn5 cm178_2 XI1541_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1541_MN39 (XI1541_bn4 fa88_0 XI1541_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1541_MN39_1 (XI1541_bn5 fa88_0 XI1541_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1541_MN40_1 (XI1541_bsn cm178_2 XI1541_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1541_MN53 (VSS XI1541_bsn cm180_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1541_MN29 (XI1541_bn1 XI1541_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1541_MN30 (XI1541_bcon fa88_0 XI1541_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1541_MN33 (XI1541_bn2 cm178_2 XI1541_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1541_MN31 (VSS XI1541_s1 XI1541_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1541_MN32 (XI1541_bn2 fa88_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1541_MN55 (VSS XI1541_bcon cm180_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1541_MN38 (XI1541_bn4 XI1541_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1541_MN38_1 (VSS XI1541_s1 XI1541_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1541_MN25 (VSS XI1541_asn XI1541_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1541_MN10 (VSS cm85_0 XI1541_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1541_MN6 (XI1541_an3 cm85_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1541_MN9 (XI1541_asn XI1541_acon XI1541_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1541_MN12 (XI1541_an5 cm87_0 XI1541_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1541_MN11 (XI1541_an4 cm86_0 XI1541_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1541_MN11_1 (XI1541_an5 cm86_0 XI1541_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1541_MN12_1 (XI1541_asn cm87_0 XI1541_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1541_MN10_1 (XI1541_an4 cm85_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1541_MN5 (XI1541_acon cm87_0 XI1541_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1541_MN2 (XI1541_an1 cm86_0 XI1541_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1541_MN1 (VSS cm85_0 XI1541_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1541_MN3 (XI1541_an2 cm85_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1541_MN4 (VSS cm86_0 XI1541_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1541_MN27 (cm180_2 XI1541_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1541_MN7 (XI1541_an3 cm86_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1541_MN8 (VSS cm87_0 XI1541_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1540_MN34 (XI1540_bn3 XI1540_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1540_MN35 (VSS cm84_1 XI1540_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1540_MN36 (XI1540_bn3 cm177_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1540_MN37 (XI1540_bsn XI1540_bcon XI1540_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1540_MN40 (XI1540_bn5 cm177_2 XI1540_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1540_MN39 (XI1540_bn4 cm84_1 XI1540_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1540_MN39_1 (XI1540_bn5 cm84_1 XI1540_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1540_MN40_1 (XI1540_bsn cm177_2 XI1540_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1540_MN53 (VSS XI1540_bsn cm179_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1540_MN29 (XI1540_bn1 XI1540_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1540_MN30 (XI1540_bcon cm84_1 XI1540_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1540_MN33 (XI1540_bn2 cm177_2 XI1540_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1540_MN31 (VSS XI1540_s1 XI1540_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1540_MN32 (XI1540_bn2 cm84_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1540_MN55 (VSS XI1540_bcon cm179_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1540_MN38 (XI1540_bn4 XI1540_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1540_MN38_1 (VSS XI1540_s1 XI1540_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1540_MN25 (VSS XI1540_asn XI1540_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1540_MN10 (VSS cm81_1 XI1540_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1540_MN6 (XI1540_an3 cm81_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1540_MN9 (XI1540_asn XI1540_acon XI1540_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1540_MN12 (XI1540_an5 cm83_1 XI1540_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1540_MN11 (XI1540_an4 cm82_1 XI1540_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1540_MN11_1 (XI1540_an5 cm82_1 XI1540_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1540_MN12_1 (XI1540_asn cm83_1 XI1540_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1540_MN10_1 (XI1540_an4 cm81_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1540_MN5 (XI1540_acon cm83_1 XI1540_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1540_MN2 (XI1540_an1 cm82_1 XI1540_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1540_MN1 (VSS cm81_1 XI1540_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1540_MN3 (XI1540_an2 cm81_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1540_MN4 (VSS cm82_1 XI1540_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1540_MN27 (cm179_2 XI1540_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1540_MN7 (XI1540_an3 cm82_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1540_MN8 (VSS cm83_1 XI1540_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1444_MN34 (XI1444_bn3 XI1444_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1444_MN35 (VSS pp11_13 XI1444_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1444_MN36 (XI1444_bn3 cm79_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1444_MN37 (XI1444_bsn XI1444_bcon XI1444_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1444_MN40 (XI1444_bn5 cm79_2 XI1444_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1444_MN39 (XI1444_bn4 pp11_13 XI1444_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1444_MN39_1 (XI1444_bn5 pp11_13 XI1444_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1444_MN40_1 (XI1444_bsn cm79_2 XI1444_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1444_MN53 (VSS XI1444_bsn cm83_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1444_MN29 (XI1444_bn1 XI1444_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1444_MN30 (XI1444_bcon pp11_13 XI1444_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1444_MN33 (XI1444_bn2 cm79_2 XI1444_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1444_MN31 (VSS XI1444_s1 XI1444_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1444_MN32 (XI1444_bn2 pp11_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1444_MN55 (VSS XI1444_bcon cm83_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1444_MN38 (XI1444_bn4 XI1444_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1444_MN38_1 (VSS XI1444_s1 XI1444_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1444_MN25 (VSS XI1444_asn XI1444_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1444_MN10 (VSS pp8_19 XI1444_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1444_MN6 (XI1444_an3 pp8_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1444_MN9 (XI1444_asn XI1444_acon XI1444_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1444_MN12 (XI1444_an5 pp10_15 XI1444_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1444_MN11 (XI1444_an4 pp9_17 XI1444_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1444_MN11_1 (XI1444_an5 pp9_17 XI1444_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1444_MN12_1 (XI1444_asn pp10_15 XI1444_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1444_MN10_1 (XI1444_an4 pp8_19 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1444_MN5 (XI1444_acon pp10_15 XI1444_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1444_MN2 (XI1444_an1 pp9_17 XI1444_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1444_MN1 (VSS pp8_19 XI1444_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1444_MN3 (XI1444_an2 pp8_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1444_MN4 (VSS pp9_17 XI1444_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1444_MN27 (cm83_2 XI1444_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1444_MN7 (XI1444_an3 pp9_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1444_MN8 (VSS pp10_15 XI1444_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1448_MN34 (XI1448_bn3 XI1448_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1448_MN35 (VSS pp12_12 XI1448_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1448_MN36 (XI1448_bn3 cm83_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1448_MN37 (XI1448_bsn XI1448_bcon XI1448_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1448_MN40 (XI1448_bn5 cm83_2 XI1448_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1448_MN39 (XI1448_bn4 pp12_12 XI1448_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1448_MN39_1 (XI1448_bn5 pp12_12 XI1448_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1448_MN40_1 (XI1448_bsn cm83_2 XI1448_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1448_MN53 (VSS XI1448_bsn cm87_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1448_MN29 (XI1448_bn1 XI1448_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1448_MN30 (XI1448_bcon pp12_12 XI1448_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1448_MN33 (XI1448_bn2 cm83_2 XI1448_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1448_MN31 (VSS XI1448_s1 XI1448_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1448_MN32 (XI1448_bn2 pp12_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1448_MN55 (VSS XI1448_bcon cm87_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1448_MN38 (XI1448_bn4 XI1448_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1448_MN38_1 (VSS XI1448_s1 XI1448_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1448_MN25 (VSS XI1448_asn XI1448_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1448_MN10 (VSS pp9_18 XI1448_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1448_MN6 (XI1448_an3 pp9_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1448_MN9 (XI1448_asn XI1448_acon XI1448_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1448_MN12 (XI1448_an5 pp11_14 XI1448_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1448_MN11 (XI1448_an4 pp10_16 XI1448_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1448_MN11_1 (XI1448_an5 pp10_16 XI1448_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1448_MN12_1 (XI1448_asn pp11_14 XI1448_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1448_MN10_1 (XI1448_an4 pp9_18 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1448_MN5 (XI1448_acon pp11_14 XI1448_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1448_MN2 (XI1448_an1 pp10_16 XI1448_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1448_MN1 (VSS pp9_18 XI1448_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1448_MN3 (XI1448_an2 pp9_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1448_MN4 (VSS pp10_16 XI1448_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1448_MN27 (cm87_2 XI1448_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1448_MN7 (XI1448_an3 pp10_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1448_MN8 (VSS pp11_14 XI1448_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1599_MN34 (XI1599_bn3 XI1599_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1599_MN35 (VSS cm111_0 XI1599_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1599_MN36 (XI1599_bn3 fa112_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1599_MN37 (XI1599_bsn XI1599_bcon XI1599_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1599_MN40 (XI1599_bn5 fa112_0 XI1599_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1599_MN39 (XI1599_bn4 cm111_0 XI1599_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1599_MN39_1 (XI1599_bn5 cm111_0 XI1599_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1599_MN40_1 (XI1599_bsn fa112_0 XI1599_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1599_MN53 (VSS XI1599_bsn cm238_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1599_MN29 (XI1599_bn1 XI1599_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1599_MN30 (XI1599_bcon cm111_0 XI1599_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1599_MN33 (XI1599_bn2 fa112_0 XI1599_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1599_MN31 (VSS XI1599_s1 XI1599_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
