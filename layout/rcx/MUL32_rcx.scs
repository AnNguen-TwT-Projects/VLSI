    I_MXI1599_MN32 (XI1599_bn2 cm111_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1599_MN55 (VSS XI1599_bcon cm238_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1599_MN38 (XI1599_bn4 XI1599_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1599_MN38_1 (VSS XI1599_s1 XI1599_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1599_MN25 (VSS XI1599_asn XI1599_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1599_MN10 (VSS cm191_1 XI1599_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1599_MN6 (XI1599_an3 cm191_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1599_MN9 (XI1599_asn XI1599_acon XI1599_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1599_MN12 (XI1599_an5 cm193_0 XI1599_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1599_MN11 (XI1599_an4 fa192_1 XI1599_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1599_MN11_1 (XI1599_an5 fa192_1 XI1599_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1599_MN12_1 (XI1599_asn cm193_0 XI1599_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1599_MN10_1 (XI1599_an4 cm191_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1599_MN5 (XI1599_acon cm193_0 XI1599_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1599_MN2 (XI1599_an1 fa192_1 XI1599_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1599_MN1 (VSS cm191_1 XI1599_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1599_MN3 (XI1599_an2 cm191_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1599_MN4 (VSS fa192_1 XI1599_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1599_MN27 (cm238_2 XI1599_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1599_MN7 (XI1599_an3 fa192_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1599_MN8 (VSS cm193_0 XI1599_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1490_MN34 (XI1490_bn3 XI1490_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1490_MN35 (VSS pp13_27 XI1490_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1490_MN36 (XI1490_bn3 cm127_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1490_MN37 (XI1490_bsn XI1490_bcon XI1490_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1490_MN40 (XI1490_bn5 cm127_2 XI1490_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1490_MN39 (XI1490_bn4 pp13_27 XI1490_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1490_MN39_1 (XI1490_bn5 pp13_27 XI1490_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1490_MN40_1 (XI1490_bsn cm127_2 XI1490_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1490_MN53 (VSS XI1490_bsn cm129_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1490_MN29 (XI1490_bn1 XI1490_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1490_MN30 (XI1490_bcon pp13_27 XI1490_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1490_MN33 (XI1490_bn2 cm127_2 XI1490_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1490_MN31 (VSS XI1490_s1 XI1490_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1490_MN32 (XI1490_bn2 pp13_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1490_MN55 (VSS XI1490_bcon cm129_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1490_MN38 (XI1490_bn4 XI1490_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1490_MN38_1 (VSS XI1490_s1 XI1490_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1490_MN25 (VSS XI1490_asn XI1490_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1490_MN10 (VSS sn10 XI1490_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1490_MN6 (XI1490_an3 sn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1490_MN9 (XI1490_asn XI1490_acon XI1490_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1490_MN12 (XI1490_an5 pp12_29 XI1490_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1490_MN11 (XI1490_an4 pp11_31 XI1490_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1490_MN11_1 (XI1490_an5 pp11_31 XI1490_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1490_MN12_1 (XI1490_asn pp12_29 XI1490_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1490_MN10_1 (XI1490_an4 sn10 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1490_MN5 (XI1490_acon pp12_29 XI1490_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1490_MN2 (XI1490_an1 pp11_31 XI1490_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1490_MN1 (VSS sn10 XI1490_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1490_MN3 (XI1490_an2 sn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1490_MN4 (VSS pp11_31 XI1490_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1490_MN27 (cm129_2 XI1490_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1490_MN7 (XI1490_an3 pp11_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1490_MN8 (VSS pp12_29 XI1490_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1439_MN34 (XI1439_bn3 XI1439_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1439_MN35 (VSS pp7_20 XI1439_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1439_MN36 (XI1439_bn3 cm74_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1439_MN37 (XI1439_bsn XI1439_bcon XI1439_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1439_MN40 (XI1439_bn5 cm74_2 XI1439_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1439_MN39 (XI1439_bn4 pp7_20 XI1439_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1439_MN39_1 (XI1439_bn5 pp7_20 XI1439_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1439_MN40_1 (XI1439_bsn cm74_2 XI1439_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1439_MN53 (VSS XI1439_bsn cm78_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1439_MN29 (XI1439_bn1 XI1439_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1439_MN30 (XI1439_bcon pp7_20 XI1439_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1439_MN33 (XI1439_bn2 cm74_2 XI1439_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1439_MN31 (VSS XI1439_s1 XI1439_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1439_MN32 (XI1439_bn2 pp7_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1439_MN55 (VSS XI1439_bcon cm78_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1439_MN38 (XI1439_bn4 XI1439_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1439_MN38_1 (VSS XI1439_s1 XI1439_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1439_MN25 (VSS XI1439_asn XI1439_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1439_MN10 (VSS pp4_26 XI1439_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1439_MN6 (XI1439_an3 pp4_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1439_MN9 (XI1439_asn XI1439_acon XI1439_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1439_MN12 (XI1439_an5 pp6_22 XI1439_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1439_MN11 (XI1439_an4 pp5_24 XI1439_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1439_MN11_1 (XI1439_an5 pp5_24 XI1439_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1439_MN12_1 (XI1439_asn pp6_22 XI1439_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1439_MN10_1 (XI1439_an4 pp4_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1439_MN5 (XI1439_acon pp6_22 XI1439_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1439_MN2 (XI1439_an1 pp5_24 XI1439_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1439_MN1 (VSS pp4_26 XI1439_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1439_MN3 (XI1439_an2 pp4_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1439_MN4 (VSS pp5_24 XI1439_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1439_MN27 (cm78_2 XI1439_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1439_MN7 (XI1439_an3 pp5_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1439_MN8 (VSS pp6_22 XI1439_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1539_MN34 (XI1539_bn3 XI1539_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1539_MN35 (VSS cm84_0 XI1539_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1539_MN36 (XI1539_bn3 cm176_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1539_MN37 (XI1539_bsn XI1539_bcon XI1539_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1539_MN40 (XI1539_bn5 cm176_2 XI1539_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1539_MN39 (XI1539_bn4 cm84_0 XI1539_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1539_MN39_1 (XI1539_bn5 cm84_0 XI1539_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1539_MN40_1 (XI1539_bsn cm176_2 XI1539_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1539_MN53 (VSS XI1539_bsn cm178_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1539_MN29 (XI1539_bn1 XI1539_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1539_MN30 (XI1539_bcon cm84_0 XI1539_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1539_MN33 (XI1539_bn2 cm176_2 XI1539_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1539_MN31 (VSS XI1539_s1 XI1539_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1539_MN32 (XI1539_bn2 cm84_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1539_MN55 (VSS XI1539_bcon cm178_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1539_MN38 (XI1539_bn4 XI1539_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1539_MN38_1 (VSS XI1539_s1 XI1539_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1539_MN25 (VSS XI1539_asn XI1539_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1539_MN10 (VSS cm81_0 XI1539_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1539_MN6 (XI1539_an3 cm81_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1539_MN9 (XI1539_asn XI1539_acon XI1539_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1539_MN12 (XI1539_an5 cm83_0 XI1539_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1539_MN11 (XI1539_an4 cm82_0 XI1539_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1539_MN11_1 (XI1539_an5 cm82_0 XI1539_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1539_MN12_1 (XI1539_asn cm83_0 XI1539_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1539_MN10_1 (XI1539_an4 cm81_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1539_MN5 (XI1539_acon cm83_0 XI1539_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1539_MN2 (XI1539_an1 cm82_0 XI1539_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1539_MN1 (VSS cm81_0 XI1539_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1539_MN3 (XI1539_an2 cm81_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1539_MN4 (VSS cm82_0 XI1539_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1539_MN27 (cm178_2 XI1539_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1539_MN7 (XI1539_an3 cm82_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1539_MN8 (VSS cm83_0 XI1539_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1591_MN34 (XI1591_bn3 XI1591_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1591_MN35 (VSS cm180_0 XI1591_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1591_MN36 (XI1591_bn3 cm229_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1591_MN37 (XI1591_bsn XI1591_bcon XI1591_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1591_MN40 (XI1591_bn5 cm229_2 XI1591_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1591_MN39 (XI1591_bn4 cm180_0 XI1591_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1591_MN39_1 (XI1591_bn5 cm180_0 XI1591_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1591_MN40_1 (XI1591_bsn cm229_2 XI1591_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1591_MN53 (VSS XI1591_bsn cm230_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1591_MN29 (XI1591_bn1 XI1591_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1591_MN30 (XI1591_bcon cm180_0 XI1591_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1591_MN33 (XI1591_bn2 cm229_2 XI1591_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1591_MN31 (VSS XI1591_s1 XI1591_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1591_MN32 (XI1591_bn2 cm180_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1591_MN55 (VSS XI1591_bcon cm230_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1591_MN38 (XI1591_bn4 XI1591_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1591_MN38_1 (VSS XI1591_s1 XI1591_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1591_MN25 (VSS XI1591_asn XI1591_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1591_MN10 (VSS cm177_1 XI1591_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1591_MN6 (XI1591_an3 cm177_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1591_MN9 (XI1591_asn XI1591_acon XI1591_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1591_MN12 (XI1591_an5 cm179_0 XI1591_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1591_MN11 (XI1591_an4 cm178_1 XI1591_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1591_MN11_1 (XI1591_an5 cm178_1 XI1591_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1591_MN12_1 (XI1591_asn cm179_0 XI1591_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1591_MN10_1 (XI1591_an4 cm177_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1591_MN5 (XI1591_acon cm179_0 XI1591_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1591_MN2 (XI1591_an1 cm178_1 XI1591_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1591_MN1 (VSS cm177_1 XI1591_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1591_MN3 (XI1591_an2 cm177_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1591_MN4 (VSS cm178_1 XI1591_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1591_MN27 (cm230_2 XI1591_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1591_MN7 (XI1591_an3 cm178_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1591_MN8 (VSS cm179_0 XI1591_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1565_MN34 (XI1565_bn3 XI1565_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1565_MN35 (VSS pp15_24 XI1565_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1565_MN36 (XI1565_bn3 cm203_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1565_MN37 (XI1565_bsn XI1565_bcon XI1565_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1565_MN40 (XI1565_bn5 cm203_2 XI1565_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1565_MN39 (XI1565_bn4 pp15_24 XI1565_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1565_MN39_1 (XI1565_bn5 pp15_24 XI1565_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1565_MN40_1 (XI1565_bsn cm203_2 XI1565_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1565_MN53 (VSS XI1565_bsn cm204_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1565_MN29 (XI1565_bn1 XI1565_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1565_MN30 (XI1565_bcon pp15_24 XI1565_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1565_MN33 (XI1565_bn2 cm203_2 XI1565_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1565_MN31 (VSS XI1565_s1 XI1565_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1565_MN32 (XI1565_bn2 pp15_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1565_MN55 (VSS XI1565_bcon cm204_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1565_MN38 (XI1565_bn4 XI1565_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1565_MN38_1 (VSS XI1565_s1 XI1565_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1565_MN25 (VSS XI1565_asn XI1565_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1565_MN10 (VSS cm129_1 XI1565_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1565_MN6 (XI1565_an3 cm129_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1565_MN9 (XI1565_asn XI1565_acon XI1565_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1565_MN12 (XI1565_an5 pp14_26 XI1565_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1565_MN11 (XI1565_an4 cm130_0 XI1565_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1565_MN11_1 (XI1565_an5 cm130_0 XI1565_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1565_MN12_1 (XI1565_asn pp14_26 XI1565_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1565_MN10_1 (XI1565_an4 cm129_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1565_MN5 (XI1565_acon pp14_26 XI1565_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1565_MN2 (XI1565_an1 cm130_0 XI1565_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1565_MN1 (VSS cm129_1 XI1565_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1565_MN3 (XI1565_an2 cm129_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1565_MN4 (VSS cm130_0 XI1565_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1565_MN27 (cm204_2 XI1565_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1565_MN7 (XI1565_an3 cm130_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1565_MN8 (VSS pp14_26 XI1565_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1435_MN34 (XI1435_bn3 XI1435_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1435_MN35 (VSS pp7_19 XI1435_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1435_MN36 (XI1435_bn3 cm70_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1435_MN37 (XI1435_bsn XI1435_bcon XI1435_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1435_MN40 (XI1435_bn5 cm70_2 XI1435_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1435_MN39 (XI1435_bn4 pp7_19 XI1435_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1435_MN39_1 (XI1435_bn5 pp7_19 XI1435_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1435_MN40_1 (XI1435_bsn cm70_2 XI1435_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1435_MN53 (VSS XI1435_bsn cm74_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1435_MN29 (XI1435_bn1 XI1435_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1435_MN30 (XI1435_bcon pp7_19 XI1435_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1435_MN33 (XI1435_bn2 cm70_2 XI1435_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1435_MN31 (VSS XI1435_s1 XI1435_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1435_MN32 (XI1435_bn2 pp7_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1435_MN55 (VSS XI1435_bcon cm74_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1435_MN38 (XI1435_bn4 XI1435_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1435_MN38_1 (VSS XI1435_s1 XI1435_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1435_MN25 (VSS XI1435_asn XI1435_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1435_MN10 (VSS pp4_25 XI1435_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1435_MN6 (XI1435_an3 pp4_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1435_MN9 (XI1435_asn XI1435_acon XI1435_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1435_MN12 (XI1435_an5 pp6_21 XI1435_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1435_MN11 (XI1435_an4 pp5_23 XI1435_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1435_MN11_1 (XI1435_an5 pp5_23 XI1435_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1435_MN12_1 (XI1435_asn pp6_21 XI1435_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1435_MN10_1 (XI1435_an4 pp4_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1435_MN5 (XI1435_acon pp6_21 XI1435_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1435_MN2 (XI1435_an1 pp5_23 XI1435_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1435_MN1 (VSS pp4_25 XI1435_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1435_MN3 (XI1435_an2 pp4_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1435_MN4 (VSS pp5_23 XI1435_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1435_MN27 (cm74_2 XI1435_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1435_MN7 (XI1435_an3 pp5_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1435_MN8 (VSS pp6_21 XI1435_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1438_MN34 (XI1438_bn3 XI1438_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1438_MN35 (VSS pp3_28 XI1438_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1438_MN36 (XI1438_bn3 cm73_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1438_MN37 (XI1438_bsn XI1438_bcon XI1438_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1438_MN40 (XI1438_bn5 cm73_2 XI1438_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1438_MN39 (XI1438_bn4 pp3_28 XI1438_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1438_MN39_1 (XI1438_bn5 pp3_28 XI1438_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1438_MN40_1 (XI1438_bsn cm73_2 XI1438_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1438_MN53 (VSS XI1438_bsn cm77_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1438_MN29 (XI1438_bn1 XI1438_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1438_MN30 (XI1438_bcon pp3_28 XI1438_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1438_MN33 (XI1438_bn2 cm73_2 XI1438_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1438_MN31 (VSS XI1438_s1 XI1438_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1438_MN32 (XI1438_bn2 pp3_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1438_MN55 (VSS XI1438_bcon cm77_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1438_MN38 (XI1438_bn4 XI1438_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1438_MN38_1 (VSS XI1438_s1 XI1438_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1438_MN25 (VSS XI1438_asn XI1438_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1438_MN10 (VSS pp0_32 XI1438_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1438_MN6 (XI1438_an3 pp0_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1438_MN9 (XI1438_asn XI1438_acon XI1438_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1438_MN12 (XI1438_an5 pp2_30 XI1438_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1438_MN11 (XI1438_an4 pp1_32 XI1438_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1438_MN11_1 (XI1438_an5 pp1_32 XI1438_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1438_MN12_1 (XI1438_asn pp2_30 XI1438_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1438_MN10_1 (XI1438_an4 pp0_32 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1438_MN5 (XI1438_acon pp2_30 XI1438_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1438_MN2 (XI1438_an1 pp1_32 XI1438_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1438_MN1 (VSS pp0_32 XI1438_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1438_MN3 (XI1438_an2 pp0_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1438_MN4 (VSS pp1_32 XI1438_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1438_MN27 (cm77_2 XI1438_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1438_MN7 (XI1438_an3 pp1_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1438_MN8 (VSS pp2_30 XI1438_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1538_MN34 (XI1538_bn3 XI1538_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1538_MN35 (VSS cm80_1 XI1538_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1538_MN36 (XI1538_bn3 cm175_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1538_MN37 (XI1538_bsn XI1538_bcon XI1538_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1538_MN40 (XI1538_bn5 cm175_2 XI1538_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1538_MN39 (XI1538_bn4 cm80_1 XI1538_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1538_MN39_1 (XI1538_bn5 cm80_1 XI1538_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1538_MN40_1 (XI1538_bsn cm175_2 XI1538_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1538_MN53 (VSS XI1538_bsn cm177_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1538_MN29 (XI1538_bn1 XI1538_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1538_MN30 (XI1538_bcon cm80_1 XI1538_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1538_MN33 (XI1538_bn2 cm175_2 XI1538_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1538_MN31 (VSS XI1538_s1 XI1538_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1538_MN32 (XI1538_bn2 cm80_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1538_MN55 (VSS XI1538_bcon cm177_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1538_MN38 (XI1538_bn4 XI1538_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1538_MN38_1 (VSS XI1538_s1 XI1538_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1538_MN25 (VSS XI1538_asn XI1538_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1538_MN10 (VSS cm77_1 XI1538_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1538_MN6 (XI1538_an3 cm77_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1538_MN9 (XI1538_asn XI1538_acon XI1538_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1538_MN12 (XI1538_an5 cm79_1 XI1538_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1538_MN11 (XI1538_an4 cm78_1 XI1538_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1538_MN11_1 (XI1538_an5 cm78_1 XI1538_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1538_MN12_1 (XI1538_asn cm79_1 XI1538_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1538_MN10_1 (XI1538_an4 cm77_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1538_MN5 (XI1538_acon cm79_1 XI1538_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1538_MN2 (XI1538_an1 cm78_1 XI1538_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1538_MN1 (VSS cm77_1 XI1538_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1538_MN3 (XI1538_an2 cm77_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1538_MN4 (VSS cm78_1 XI1538_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1538_MN27 (cm177_2 XI1538_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1538_MN7 (XI1538_an3 cm78_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1538_MN8 (VSS cm79_1 XI1538_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1537_MN34 (XI1537_bn3 XI1537_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1537_MN35 (VSS cm80_0 XI1537_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1537_MN36 (XI1537_bn3 cm174_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1537_MN37 (XI1537_bsn XI1537_bcon XI1537_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1537_MN40 (XI1537_bn5 cm174_2 XI1537_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1537_MN39 (XI1537_bn4 cm80_0 XI1537_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1537_MN39_1 (XI1537_bn5 cm80_0 XI1537_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1537_MN40_1 (XI1537_bsn cm174_2 XI1537_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1537_MN53 (VSS XI1537_bsn cm176_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1537_MN29 (XI1537_bn1 XI1537_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1537_MN30 (XI1537_bcon cm80_0 XI1537_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1537_MN33 (XI1537_bn2 cm174_2 XI1537_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1537_MN31 (VSS XI1537_s1 XI1537_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1537_MN32 (XI1537_bn2 cm80_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1537_MN55 (VSS XI1537_bcon cm176_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1537_MN38 (XI1537_bn4 XI1537_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1537_MN38_1 (VSS XI1537_s1 XI1537_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1537_MN25 (VSS XI1537_asn XI1537_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1537_MN10 (VSS cm77_0 XI1537_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1537_MN6 (XI1537_an3 cm77_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1537_MN9 (XI1537_asn XI1537_acon XI1537_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1537_MN12 (XI1537_an5 cm79_0 XI1537_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1537_MN11 (XI1537_an4 cm78_0 XI1537_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1537_MN11_1 (XI1537_an5 cm78_0 XI1537_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1537_MN12_1 (XI1537_asn cm79_0 XI1537_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1537_MN10_1 (XI1537_an4 cm77_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1537_MN5 (XI1537_acon cm79_0 XI1537_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1537_MN2 (XI1537_an1 cm78_0 XI1537_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1537_MN1 (VSS cm77_0 XI1537_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1537_MN3 (XI1537_an2 cm77_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1537_MN4 (VSS cm78_0 XI1537_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1537_MN27 (cm176_2 XI1537_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1537_MN7 (XI1537_an3 cm78_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1537_MN8 (VSS cm79_0 XI1537_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1440_MN34 (XI1440_bn3 XI1440_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1440_MN35 (VSS pp11_12 XI1440_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1440_MN36 (XI1440_bn3 cm75_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1440_MN37 (XI1440_bsn XI1440_bcon XI1440_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1440_MN40 (XI1440_bn5 cm75_2 XI1440_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1440_MN39 (XI1440_bn4 pp11_12 XI1440_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1440_MN39_1 (XI1440_bn5 pp11_12 XI1440_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1440_MN40_1 (XI1440_bsn cm75_2 XI1440_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1440_MN53 (VSS XI1440_bsn cm79_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1440_MN29 (XI1440_bn1 XI1440_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1440_MN30 (XI1440_bcon pp11_12 XI1440_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1440_MN33 (XI1440_bn2 cm75_2 XI1440_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1440_MN31 (VSS XI1440_s1 XI1440_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1440_MN32 (XI1440_bn2 pp11_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1440_MN55 (VSS XI1440_bcon cm79_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1440_MN38 (XI1440_bn4 XI1440_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1440_MN38_1 (VSS XI1440_s1 XI1440_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1440_MN25 (VSS XI1440_asn XI1440_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1440_MN10 (VSS pp8_18 XI1440_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1440_MN6 (XI1440_an3 pp8_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1440_MN9 (XI1440_asn XI1440_acon XI1440_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1440_MN12 (XI1440_an5 pp10_14 XI1440_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1440_MN11 (XI1440_an4 pp9_16 XI1440_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1440_MN11_1 (XI1440_an5 pp9_16 XI1440_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1440_MN12_1 (XI1440_asn pp10_14 XI1440_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1440_MN10_1 (XI1440_an4 pp8_18 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1440_MN5 (XI1440_acon pp10_14 XI1440_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1440_MN2 (XI1440_an1 pp9_16 XI1440_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1440_MN1 (VSS pp8_18 XI1440_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1440_MN3 (XI1440_an2 pp8_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1440_MN4 (VSS pp9_16 XI1440_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1440_MN27 (cm79_2 XI1440_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1440_MN7 (XI1440_an3 pp9_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1440_MN8 (VSS pp10_14 XI1440_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1601_MN34 (XI1601_bn3 XI1601_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1601_MN35 (VSS pp14_18 XI1601_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1601_MN36 (XI1601_bn3 pp15_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1601_MN37 (XI1601_bsn XI1601_bcon XI1601_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1601_MN40 (XI1601_bn5 pp15_16 XI1601_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1601_MN39 (XI1601_bn4 pp14_18 XI1601_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1601_MN39_1 (XI1601_bn5 pp14_18 XI1601_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1601_MN40_1 (XI1601_bsn pp15_16 XI1601_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1601_MN53 (VSS XI1601_bsn cm240_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1601_MN29 (XI1601_bn1 XI1601_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1601_MN30 (XI1601_bcon pp14_18 XI1601_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1601_MN33 (XI1601_bn2 pp15_16 XI1601_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1601_MN31 (VSS XI1601_s1 XI1601_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1601_MN32 (XI1601_bn2 pp14_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1601_MN55 (VSS XI1601_bcon cm240_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1601_MN38 (XI1601_bn4 XI1601_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1601_MN38_1 (VSS XI1601_s1 XI1601_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1601_MN25 (VSS XI1601_asn XI1601_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1601_MN10 (VSS cm194_1 XI1601_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1601_MN6 (XI1601_an3 cm194_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1601_MN9 (XI1601_asn XI1601_acon XI1601_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1601_MN12 (XI1601_an5 cm196_0 XI1601_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1601_MN11 (XI1601_an4 fa195_1 XI1601_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1601_MN11_1 (XI1601_an5 fa195_1 XI1601_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1601_MN12_1 (XI1601_asn cm196_0 XI1601_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1601_MN10_1 (XI1601_an4 cm194_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1601_MN5 (XI1601_acon cm196_0 XI1601_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1601_MN2 (XI1601_an1 fa195_1 XI1601_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1601_MN1 (VSS cm194_1 XI1601_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1601_MN3 (XI1601_an2 cm194_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1601_MN4 (VSS fa195_1 XI1601_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1601_MN27 (cm240_2 XI1601_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1601_MN7 (XI1601_an3 fa195_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1601_MN8 (VSS cm196_0 XI1601_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1491_MN34 (XI1491_bn3 XI1491_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1491_MN35 (VSS pp13_28 XI1491_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1491_MN36 (XI1491_bn3 cm129_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1491_MN37 (XI1491_bsn XI1491_bcon XI1491_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1491_MN40 (XI1491_bn5 cm129_2 XI1491_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1491_MN39 (XI1491_bn4 pp13_28 XI1491_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1491_MN39_1 (XI1491_bn5 pp13_28 XI1491_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1491_MN40_1 (XI1491_bsn cm129_2 XI1491_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1491_MN53 (VSS XI1491_bsn cm130_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1491_MN29 (XI1491_bn1 XI1491_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1491_MN30 (XI1491_bcon pp13_28 XI1491_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1491_MN33 (XI1491_bn2 cm129_2 XI1491_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1491_MN31 (VSS XI1491_s1 XI1491_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1491_MN32 (XI1491_bn2 pp13_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1491_MN55 (VSS XI1491_bcon cm130_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1491_MN38 (XI1491_bn4 XI1491_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1491_MN38_1 (VSS XI1491_s1 XI1491_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1491_MN25 (VSS XI1491_asn XI1491_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1491_MN10 (VSS VDD XI1491_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1491_MN6 (XI1491_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1491_MN9 (XI1491_asn XI1491_acon XI1491_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1491_MN12 (XI1491_an5 pp12_30 XI1491_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1491_MN11 (XI1491_an4 pp11_32 XI1491_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1491_MN11_1 (XI1491_an5 pp11_32 XI1491_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1491_MN12_1 (XI1491_asn pp12_30 XI1491_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1491_MN10_1 (XI1491_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1491_MN5 (XI1491_acon pp12_30 XI1491_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1491_MN2 (XI1491_an1 pp11_32 XI1491_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1491_MN1 (VSS VDD XI1491_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1491_MN3 (XI1491_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1491_MN4 (VSS pp11_32 XI1491_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1491_MN27 (cm130_2 XI1491_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1491_MN7 (XI1491_an3 pp11_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1491_MN8 (VSS pp12_30 XI1491_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1434_MN34 (XI1434_bn3 XI1434_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1434_MN35 (VSS pp3_27 XI1434_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1434_MN36 (XI1434_bn3 cm69_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1434_MN37 (XI1434_bsn XI1434_bcon XI1434_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1434_MN40 (XI1434_bn5 cm69_2 XI1434_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1434_MN39 (XI1434_bn4 pp3_27 XI1434_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1434_MN39_1 (XI1434_bn5 pp3_27 XI1434_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1434_MN40_1 (XI1434_bsn cm69_2 XI1434_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1434_MN53 (VSS XI1434_bsn cm73_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1434_MN29 (XI1434_bn1 XI1434_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1434_MN30 (XI1434_bcon pp3_27 XI1434_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1434_MN33 (XI1434_bn2 cm69_2 XI1434_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1434_MN31 (VSS XI1434_s1 XI1434_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1434_MN32 (XI1434_bn2 pp3_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1434_MN55 (VSS XI1434_bcon cm73_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1434_MN38 (XI1434_bn4 XI1434_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1434_MN38_1 (VSS XI1434_s1 XI1434_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1434_MN25 (VSS XI1434_asn XI1434_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1434_MN10 (VSS pp0_32 XI1434_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1434_MN6 (XI1434_an3 pp0_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1434_MN9 (XI1434_asn XI1434_acon XI1434_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1434_MN12 (XI1434_an5 pp2_29 XI1434_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1434_MN11 (XI1434_an4 pp1_31 XI1434_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1434_MN11_1 (XI1434_an5 pp1_31 XI1434_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1434_MN12_1 (XI1434_asn pp2_29 XI1434_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1434_MN10_1 (XI1434_an4 pp0_32 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1434_MN5 (XI1434_acon pp2_29 XI1434_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1434_MN2 (XI1434_an1 pp1_31 XI1434_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1434_MN1 (VSS pp0_32 XI1434_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1434_MN3 (XI1434_an2 pp0_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1434_MN4 (VSS pp1_31 XI1434_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1434_MN27 (cm73_2 XI1434_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1434_MN7 (XI1434_an3 pp1_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1434_MN8 (VSS pp2_29 XI1434_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1536_MN34 (XI1536_bn3 XI1536_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1536_MN35 (VSS cm76_1 XI1536_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1536_MN36 (XI1536_bn3 cm173_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1536_MN37 (XI1536_bsn XI1536_bcon XI1536_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1536_MN40 (XI1536_bn5 cm173_2 XI1536_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1536_MN39 (XI1536_bn4 cm76_1 XI1536_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1536_MN39_1 (XI1536_bn5 cm76_1 XI1536_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1536_MN40_1 (XI1536_bsn cm173_2 XI1536_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1536_MN53 (VSS XI1536_bsn cm175_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1536_MN29 (XI1536_bn1 XI1536_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1536_MN30 (XI1536_bcon cm76_1 XI1536_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1536_MN33 (XI1536_bn2 cm173_2 XI1536_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1536_MN31 (VSS XI1536_s1 XI1536_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1536_MN32 (XI1536_bn2 cm76_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1536_MN55 (VSS XI1536_bcon cm175_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1536_MN38 (XI1536_bn4 XI1536_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1536_MN38_1 (VSS XI1536_s1 XI1536_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1536_MN25 (VSS XI1536_asn XI1536_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1536_MN10 (VSS cm73_1 XI1536_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1536_MN6 (XI1536_an3 cm73_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1536_MN9 (XI1536_asn XI1536_acon XI1536_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1536_MN12 (XI1536_an5 cm75_1 XI1536_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1536_MN11 (XI1536_an4 cm74_1 XI1536_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1536_MN11_1 (XI1536_an5 cm74_1 XI1536_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1536_MN12_1 (XI1536_asn cm75_1 XI1536_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1536_MN10_1 (XI1536_an4 cm73_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1536_MN5 (XI1536_acon cm75_1 XI1536_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1536_MN2 (XI1536_an1 cm74_1 XI1536_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1536_MN1 (VSS cm73_1 XI1536_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1536_MN3 (XI1536_an2 cm73_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1536_MN4 (VSS cm74_1 XI1536_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1536_MN27 (cm175_2 XI1536_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1536_MN7 (XI1536_an3 cm74_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1536_MN8 (VSS cm75_1 XI1536_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1590_MN34 (XI1590_bn3 XI1590_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1590_MN35 (VSS cm178_0 XI1590_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1590_MN36 (XI1590_bn3 cm228_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1590_MN37 (XI1590_bsn XI1590_bcon XI1590_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1590_MN40 (XI1590_bn5 cm228_2 XI1590_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1590_MN39 (XI1590_bn4 cm178_0 XI1590_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1590_MN39_1 (XI1590_bn5 cm178_0 XI1590_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1590_MN40_1 (XI1590_bsn cm228_2 XI1590_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1590_MN53 (VSS XI1590_bsn cm229_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1590_MN29 (XI1590_bn1 XI1590_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1590_MN30 (XI1590_bcon cm178_0 XI1590_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1590_MN33 (XI1590_bn2 cm228_2 XI1590_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1590_MN31 (VSS XI1590_s1 XI1590_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1590_MN32 (XI1590_bn2 cm178_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1590_MN55 (VSS XI1590_bcon cm229_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1590_MN38 (XI1590_bn4 XI1590_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1590_MN38_1 (VSS XI1590_s1 XI1590_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1590_MN25 (VSS XI1590_asn XI1590_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1590_MN10 (VSS cm175_1 XI1590_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1590_MN6 (XI1590_an3 cm175_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1590_MN9 (XI1590_asn XI1590_acon XI1590_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1590_MN12 (XI1590_an5 cm177_0 XI1590_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1590_MN11 (XI1590_an4 cm176_1 XI1590_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1590_MN11_1 (XI1590_an5 cm176_1 XI1590_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1590_MN12_1 (XI1590_asn cm177_0 XI1590_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1590_MN10_1 (XI1590_an4 cm175_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1590_MN5 (XI1590_acon cm177_0 XI1590_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1590_MN2 (XI1590_an1 cm176_1 XI1590_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1590_MN1 (VSS cm175_1 XI1590_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1590_MN3 (XI1590_an2 cm175_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1590_MN4 (VSS cm176_1 XI1590_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1590_MN27 (cm229_2 XI1590_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1590_MN7 (XI1590_an3 cm176_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1590_MN8 (VSS cm177_0 XI1590_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1436_MN34 (XI1436_bn3 XI1436_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1436_MN35 (VSS pp11_11 XI1436_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1436_MN36 (XI1436_bn3 cm71_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1436_MN37 (XI1436_bsn XI1436_bcon XI1436_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1436_MN40 (XI1436_bn5 cm71_2 XI1436_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1436_MN39 (XI1436_bn4 pp11_11 XI1436_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1436_MN39_1 (XI1436_bn5 pp11_11 XI1436_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1436_MN40_1 (XI1436_bsn cm71_2 XI1436_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1436_MN53 (VSS XI1436_bsn cm75_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1436_MN29 (XI1436_bn1 XI1436_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1436_MN30 (XI1436_bcon pp11_11 XI1436_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1436_MN33 (XI1436_bn2 cm71_2 XI1436_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1436_MN31 (VSS XI1436_s1 XI1436_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1436_MN32 (XI1436_bn2 pp11_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1436_MN55 (VSS XI1436_bcon cm75_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1436_MN38 (XI1436_bn4 XI1436_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1436_MN38_1 (VSS XI1436_s1 XI1436_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1436_MN25 (VSS XI1436_asn XI1436_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1436_MN10 (VSS pp8_17 XI1436_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1436_MN6 (XI1436_an3 pp8_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1436_MN9 (XI1436_asn XI1436_acon XI1436_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1436_MN12 (XI1436_an5 pp10_13 XI1436_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1436_MN11 (XI1436_an4 pp9_15 XI1436_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1436_MN11_1 (XI1436_an5 pp9_15 XI1436_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1436_MN12_1 (XI1436_asn pp10_13 XI1436_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1436_MN10_1 (XI1436_an4 pp8_17 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1436_MN5 (XI1436_acon pp10_13 XI1436_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1436_MN2 (XI1436_an1 pp9_15 XI1436_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1436_MN1 (VSS pp8_17 XI1436_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1436_MN3 (XI1436_an2 pp8_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1436_MN4 (VSS pp9_15 XI1436_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1436_MN27 (cm75_2 XI1436_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1436_MN7 (XI1436_an3 pp9_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1436_MN8 (VSS pp10_13 XI1436_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1431_MN34 (XI1431_bn3 XI1431_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1431_MN35 (VSS pp7_18 XI1431_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1431_MN36 (XI1431_bn3 cm66_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1431_MN37 (XI1431_bsn XI1431_bcon XI1431_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1431_MN40 (XI1431_bn5 cm66_2 XI1431_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1431_MN39 (XI1431_bn4 pp7_18 XI1431_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1431_MN39_1 (XI1431_bn5 pp7_18 XI1431_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1431_MN40_1 (XI1431_bsn cm66_2 XI1431_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1431_MN53 (VSS XI1431_bsn cm70_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1431_MN29 (XI1431_bn1 XI1431_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1431_MN30 (XI1431_bcon pp7_18 XI1431_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1431_MN33 (XI1431_bn2 cm66_2 XI1431_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1431_MN31 (VSS XI1431_s1 XI1431_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1431_MN32 (XI1431_bn2 pp7_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1431_MN55 (VSS XI1431_bcon cm70_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1431_MN38 (XI1431_bn4 XI1431_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1431_MN38_1 (VSS XI1431_s1 XI1431_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1431_MN25 (VSS XI1431_asn XI1431_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1431_MN10 (VSS pp4_24 XI1431_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1431_MN6 (XI1431_an3 pp4_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1431_MN9 (XI1431_asn XI1431_acon XI1431_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1431_MN12 (XI1431_an5 pp6_20 XI1431_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1431_MN11 (XI1431_an4 pp5_22 XI1431_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1431_MN11_1 (XI1431_an5 pp5_22 XI1431_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1431_MN12_1 (XI1431_asn pp6_20 XI1431_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1431_MN10_1 (XI1431_an4 pp4_24 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1431_MN5 (XI1431_acon pp6_20 XI1431_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1431_MN2 (XI1431_an1 pp5_22 XI1431_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1431_MN1 (VSS pp4_24 XI1431_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1431_MN3 (XI1431_an2 pp4_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1431_MN4 (VSS pp5_22 XI1431_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1431_MN27 (cm70_2 XI1431_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1431_MN7 (XI1431_an3 pp5_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1431_MN8 (VSS pp6_20 XI1431_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1535_MN34 (XI1535_bn3 XI1535_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1535_MN35 (VSS cm76_0 XI1535_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1535_MN36 (XI1535_bn3 cm172_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1535_MN37 (XI1535_bsn XI1535_bcon XI1535_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1535_MN40 (XI1535_bn5 cm172_2 XI1535_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1535_MN39 (XI1535_bn4 cm76_0 XI1535_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1535_MN39_1 (XI1535_bn5 cm76_0 XI1535_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1535_MN40_1 (XI1535_bsn cm172_2 XI1535_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1535_MN53 (VSS XI1535_bsn cm174_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1535_MN29 (XI1535_bn1 XI1535_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1535_MN30 (XI1535_bcon cm76_0 XI1535_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1535_MN33 (XI1535_bn2 cm172_2 XI1535_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1535_MN31 (VSS XI1535_s1 XI1535_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1535_MN32 (XI1535_bn2 cm76_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1535_MN55 (VSS XI1535_bcon cm174_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1535_MN38 (XI1535_bn4 XI1535_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1535_MN38_1 (VSS XI1535_s1 XI1535_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1535_MN25 (VSS XI1535_asn XI1535_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1535_MN10 (VSS cm73_0 XI1535_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1535_MN6 (XI1535_an3 cm73_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1535_MN9 (XI1535_asn XI1535_acon XI1535_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1535_MN12 (XI1535_an5 cm75_0 XI1535_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1535_MN11 (XI1535_an4 cm74_0 XI1535_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1535_MN11_1 (XI1535_an5 cm74_0 XI1535_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1535_MN12_1 (XI1535_asn cm75_0 XI1535_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1535_MN10_1 (XI1535_an4 cm73_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1535_MN5 (XI1535_acon cm75_0 XI1535_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1535_MN2 (XI1535_an1 cm74_0 XI1535_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1535_MN1 (VSS cm73_0 XI1535_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1535_MN3 (XI1535_an2 cm73_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1535_MN4 (VSS cm74_0 XI1535_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1535_MN27 (cm174_2 XI1535_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1535_MN7 (XI1535_an3 cm74_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1535_MN8 (VSS cm75_0 XI1535_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1589_MN34 (XI1589_bn3 XI1589_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1589_MN35 (VSS cm176_0 XI1589_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1589_MN36 (XI1589_bn3 cm227_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1589_MN37 (XI1589_bsn XI1589_bcon XI1589_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1589_MN40 (XI1589_bn5 cm227_2 XI1589_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1589_MN39 (XI1589_bn4 cm176_0 XI1589_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1589_MN39_1 (XI1589_bn5 cm176_0 XI1589_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1589_MN40_1 (XI1589_bsn cm227_2 XI1589_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1589_MN53 (VSS XI1589_bsn cm228_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1589_MN29 (XI1589_bn1 XI1589_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1589_MN30 (XI1589_bcon cm176_0 XI1589_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1589_MN33 (XI1589_bn2 cm227_2 XI1589_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1589_MN31 (VSS XI1589_s1 XI1589_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1589_MN32 (XI1589_bn2 cm176_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1589_MN55 (VSS XI1589_bcon cm228_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1589_MN38 (XI1589_bn4 XI1589_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1589_MN38_1 (VSS XI1589_s1 XI1589_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1589_MN25 (VSS XI1589_asn XI1589_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1589_MN10 (VSS cm173_1 XI1589_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1589_MN6 (XI1589_an3 cm173_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1589_MN9 (XI1589_asn XI1589_acon XI1589_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1589_MN12 (XI1589_an5 cm175_0 XI1589_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1589_MN11 (XI1589_an4 cm174_1 XI1589_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1589_MN11_1 (XI1589_an5 cm174_1 XI1589_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1589_MN12_1 (XI1589_asn cm175_0 XI1589_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1589_MN10_1 (XI1589_an4 cm173_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1589_MN5 (XI1589_acon cm175_0 XI1589_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1589_MN2 (XI1589_an1 cm174_1 XI1589_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1589_MN1 (VSS cm173_1 XI1589_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1589_MN3 (XI1589_an2 cm173_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1589_MN4 (VSS cm174_1 XI1589_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1589_MN27 (cm228_2 XI1589_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1589_MN7 (XI1589_an3 cm174_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1589_MN8 (VSS cm175_0 XI1589_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1445_MN34 (XI1445_bn3 XI1445_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1445_MN35 (VSS pp15_5 XI1445_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1445_MN36 (XI1445_bn3 cm80_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1445_MN37 (XI1445_bsn XI1445_bcon XI1445_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1445_MN40 (XI1445_bn5 cm80_2 XI1445_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1445_MN39 (XI1445_bn4 pp15_5 XI1445_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1445_MN39_1 (XI1445_bn5 pp15_5 XI1445_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1445_MN40_1 (XI1445_bsn cm80_2 XI1445_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1445_MN53 (VSS XI1445_bsn cm84_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1445_MN29 (XI1445_bn1 XI1445_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1445_MN30 (XI1445_bcon pp15_5 XI1445_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1445_MN33 (XI1445_bn2 cm80_2 XI1445_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1445_MN31 (VSS XI1445_s1 XI1445_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1445_MN32 (XI1445_bn2 pp15_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1445_MN55 (VSS XI1445_bcon cm84_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1445_MN38 (XI1445_bn4 XI1445_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1445_MN38_1 (VSS XI1445_s1 XI1445_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1445_MN25 (VSS XI1445_asn XI1445_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1445_MN10 (VSS pp12_11 XI1445_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1445_MN6 (XI1445_an3 pp12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1445_MN9 (XI1445_asn XI1445_acon XI1445_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1445_MN12 (XI1445_an5 pp14_7 XI1445_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1445_MN11 (XI1445_an4 pp13_9 XI1445_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1445_MN11_1 (XI1445_an5 pp13_9 XI1445_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1445_MN12_1 (XI1445_asn pp14_7 XI1445_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1445_MN10_1 (XI1445_an4 pp12_11 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1445_MN5 (XI1445_acon pp14_7 XI1445_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1445_MN2 (XI1445_an1 pp13_9 XI1445_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1445_MN1 (VSS pp12_11 XI1445_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1445_MN3 (XI1445_an2 pp12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1445_MN4 (VSS pp13_9 XI1445_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1445_MN27 (cm84_2 XI1445_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1445_MN7 (XI1445_an3 pp13_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1445_MN8 (VSS pp14_7 XI1445_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1441_MN34 (XI1441_bn3 XI1441_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1441_MN35 (VSS pp15_4 XI1441_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1441_MN36 (XI1441_bn3 cm76_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1441_MN37 (XI1441_bsn XI1441_bcon XI1441_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1441_MN40 (XI1441_bn5 cm76_2 XI1441_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1441_MN39 (XI1441_bn4 pp15_4 XI1441_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1441_MN39_1 (XI1441_bn5 pp15_4 XI1441_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1441_MN40_1 (XI1441_bsn cm76_2 XI1441_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1441_MN53 (VSS XI1441_bsn cm80_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1441_MN29 (XI1441_bn1 XI1441_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1441_MN30 (XI1441_bcon pp15_4 XI1441_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1441_MN33 (XI1441_bn2 cm76_2 XI1441_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1441_MN31 (VSS XI1441_s1 XI1441_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1441_MN32 (XI1441_bn2 pp15_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1441_MN55 (VSS XI1441_bcon cm80_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1441_MN38 (XI1441_bn4 XI1441_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1441_MN38_1 (VSS XI1441_s1 XI1441_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1441_MN25 (VSS XI1441_asn XI1441_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1441_MN10 (VSS pp12_10 XI1441_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1441_MN6 (XI1441_an3 pp12_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1441_MN9 (XI1441_asn XI1441_acon XI1441_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1441_MN12 (XI1441_an5 pp14_6 XI1441_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1441_MN11 (XI1441_an4 pp13_8 XI1441_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1441_MN11_1 (XI1441_an5 pp13_8 XI1441_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1441_MN12_1 (XI1441_asn pp14_6 XI1441_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1441_MN10_1 (XI1441_an4 pp12_10 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1441_MN5 (XI1441_acon pp14_6 XI1441_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1441_MN2 (XI1441_an1 pp13_8 XI1441_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1441_MN1 (VSS pp12_10 XI1441_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1441_MN3 (XI1441_an2 pp12_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1441_MN4 (VSS pp13_8 XI1441_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1441_MN27 (cm80_2 XI1441_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1441_MN7 (XI1441_an3 pp13_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1441_MN8 (VSS pp14_6 XI1441_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1492_MN34 (XI1492_bn3 XI1492_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1492_MN35 (VSS pp14_27 XI1492_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1492_MN36 (XI1492_bn3 cm130_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1492_MN37 (XI1492_bsn XI1492_bcon XI1492_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1492_MN40 (XI1492_bn5 cm130_2 XI1492_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1492_MN39 (XI1492_bn4 pp14_27 XI1492_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1492_MN39_1 (XI1492_bn5 pp14_27 XI1492_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1492_MN40_1 (XI1492_bsn cm130_2 XI1492_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1492_MN53 (VSS XI1492_bsn cm131_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1492_MN29 (XI1492_bn1 XI1492_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1492_MN30 (XI1492_bcon pp14_27 XI1492_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1492_MN33 (XI1492_bn2 cm130_2 XI1492_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1492_MN31 (VSS XI1492_s1 XI1492_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1492_MN32 (XI1492_bn2 pp14_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1492_MN55 (VSS XI1492_bcon cm131_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1492_MN38 (XI1492_bn4 XI1492_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1492_MN38_1 (VSS XI1492_s1 XI1492_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1492_MN25 (VSS XI1492_asn XI1492_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1492_MN10 (VSS sn11 XI1492_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1492_MN6 (XI1492_an3 sn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1492_MN9 (XI1492_asn XI1492_acon XI1492_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1492_MN12 (XI1492_an5 pp13_29 XI1492_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1492_MN11 (XI1492_an4 pp12_31 XI1492_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1492_MN11_1 (XI1492_an5 pp12_31 XI1492_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1492_MN12_1 (XI1492_asn pp13_29 XI1492_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1492_MN10_1 (XI1492_an4 sn11 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1492_MN5 (XI1492_acon pp13_29 XI1492_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1492_MN2 (XI1492_an1 pp12_31 XI1492_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1492_MN1 (VSS sn11 XI1492_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1492_MN3 (XI1492_an2 sn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1492_MN4 (VSS pp12_31 XI1492_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1492_MN27 (cm131_2 XI1492_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1492_MN7 (XI1492_an3 pp12_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1492_MN8 (VSS pp13_29 XI1492_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1430_MN34 (XI1430_bn3 XI1430_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1430_MN35 (VSS pp3_26 XI1430_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1430_MN36 (XI1430_bn3 cm65_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1430_MN37 (XI1430_bsn XI1430_bcon XI1430_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1430_MN40 (XI1430_bn5 cm65_2 XI1430_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1430_MN39 (XI1430_bn4 pp3_26 XI1430_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1430_MN39_1 (XI1430_bn5 pp3_26 XI1430_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1430_MN40_1 (XI1430_bsn cm65_2 XI1430_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1430_MN53 (VSS XI1430_bsn cm69_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1430_MN29 (XI1430_bn1 XI1430_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1430_MN30 (XI1430_bcon pp3_26 XI1430_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1430_MN33 (XI1430_bn2 cm65_2 XI1430_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1430_MN31 (VSS XI1430_s1 XI1430_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1430_MN32 (XI1430_bn2 pp3_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1430_MN55 (VSS XI1430_bcon cm69_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1430_MN38 (XI1430_bn4 XI1430_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1430_MN38_1 (VSS XI1430_s1 XI1430_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1430_MN25 (VSS XI1430_asn XI1430_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1430_MN10 (VSS pp0_32 XI1430_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1430_MN6 (XI1430_an3 pp0_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1430_MN9 (XI1430_asn XI1430_acon XI1430_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1430_MN12 (XI1430_an5 pp2_28 XI1430_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1430_MN11 (XI1430_an4 pp1_30 XI1430_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1430_MN11_1 (XI1430_an5 pp1_30 XI1430_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1430_MN12_1 (XI1430_asn pp2_28 XI1430_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1430_MN10_1 (XI1430_an4 pp0_32 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1430_MN5 (XI1430_acon pp2_28 XI1430_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1430_MN2 (XI1430_an1 pp1_30 XI1430_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1430_MN1 (VSS pp0_32 XI1430_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1430_MN3 (XI1430_an2 pp0_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1430_MN4 (VSS pp1_30 XI1430_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1430_MN27 (cm69_2 XI1430_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1430_MN7 (XI1430_an3 pp1_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1430_MN8 (VSS pp2_28 XI1430_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1533_MN34 (XI1533_bn3 XI1533_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1533_MN35 (VSS cm72_0 XI1533_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1533_MN36 (XI1533_bn3 cm170_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1533_MN37 (XI1533_bsn XI1533_bcon XI1533_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1533_MN40 (XI1533_bn5 cm170_2 XI1533_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1533_MN39 (XI1533_bn4 cm72_0 XI1533_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1533_MN39_1 (XI1533_bn5 cm72_0 XI1533_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1533_MN40_1 (XI1533_bsn cm170_2 XI1533_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1533_MN53 (VSS XI1533_bsn cm172_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1533_MN29 (XI1533_bn1 XI1533_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1533_MN30 (XI1533_bcon cm72_0 XI1533_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1533_MN33 (XI1533_bn2 cm170_2 XI1533_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1533_MN31 (VSS XI1533_s1 XI1533_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1533_MN32 (XI1533_bn2 cm72_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1533_MN55 (VSS XI1533_bcon cm172_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1533_MN38 (XI1533_bn4 XI1533_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1533_MN38_1 (VSS XI1533_s1 XI1533_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1533_MN25 (VSS XI1533_asn XI1533_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1533_MN10 (VSS cm69_0 XI1533_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1533_MN6 (XI1533_an3 cm69_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1533_MN9 (XI1533_asn XI1533_acon XI1533_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1533_MN12 (XI1533_an5 cm71_0 XI1533_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1533_MN11 (XI1533_an4 cm70_0 XI1533_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1533_MN11_1 (XI1533_an5 cm70_0 XI1533_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1533_MN12_1 (XI1533_asn cm71_0 XI1533_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1533_MN10_1 (XI1533_an4 cm69_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1533_MN5 (XI1533_acon cm71_0 XI1533_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1533_MN2 (XI1533_an1 cm70_0 XI1533_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1533_MN1 (VSS cm69_0 XI1533_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1533_MN3 (XI1533_an2 cm69_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1533_MN4 (VSS cm70_0 XI1533_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1533_MN27 (cm172_2 XI1533_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1533_MN7 (XI1533_an3 cm70_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1533_MN8 (VSS cm71_0 XI1533_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1534_MN34 (XI1534_bn3 XI1534_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1534_MN35 (VSS cm72_1 XI1534_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1534_MN36 (XI1534_bn3 cm171_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1534_MN37 (XI1534_bsn XI1534_bcon XI1534_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1534_MN40 (XI1534_bn5 cm171_2 XI1534_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1534_MN39 (XI1534_bn4 cm72_1 XI1534_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1534_MN39_1 (XI1534_bn5 cm72_1 XI1534_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1534_MN40_1 (XI1534_bsn cm171_2 XI1534_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1534_MN53 (VSS XI1534_bsn cm173_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1534_MN29 (XI1534_bn1 XI1534_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1534_MN30 (XI1534_bcon cm72_1 XI1534_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1534_MN33 (XI1534_bn2 cm171_2 XI1534_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1534_MN31 (VSS XI1534_s1 XI1534_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1534_MN32 (XI1534_bn2 cm72_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1534_MN55 (VSS XI1534_bcon cm173_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1534_MN38 (XI1534_bn4 XI1534_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1534_MN38_1 (VSS XI1534_s1 XI1534_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1534_MN25 (VSS XI1534_asn XI1534_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1534_MN10 (VSS cm69_1 XI1534_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1534_MN6 (XI1534_an3 cm69_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1534_MN9 (XI1534_asn XI1534_acon XI1534_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1534_MN12 (XI1534_an5 cm71_1 XI1534_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1534_MN11 (XI1534_an4 cm70_1 XI1534_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1534_MN11_1 (XI1534_an5 cm70_1 XI1534_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1534_MN12_1 (XI1534_asn cm71_1 XI1534_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1534_MN10_1 (XI1534_an4 cm69_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1534_MN5 (XI1534_acon cm71_1 XI1534_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1534_MN2 (XI1534_an1 cm70_1 XI1534_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1534_MN1 (VSS cm69_1 XI1534_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1534_MN3 (XI1534_an2 cm69_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1534_MN4 (VSS cm70_1 XI1534_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1534_MN27 (cm173_2 XI1534_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1534_MN7 (XI1534_an3 cm70_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1534_MN8 (VSS cm71_1 XI1534_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1432_MN34 (XI1432_bn3 XI1432_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1432_MN35 (VSS pp11_10 XI1432_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1432_MN36 (XI1432_bn3 cm67_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1432_MN37 (XI1432_bsn XI1432_bcon XI1432_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1432_MN40 (XI1432_bn5 cm67_2 XI1432_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1432_MN39 (XI1432_bn4 pp11_10 XI1432_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1432_MN39_1 (XI1432_bn5 pp11_10 XI1432_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1432_MN40_1 (XI1432_bsn cm67_2 XI1432_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1432_MN53 (VSS XI1432_bsn cm71_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1432_MN29 (XI1432_bn1 XI1432_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1432_MN30 (XI1432_bcon pp11_10 XI1432_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1432_MN33 (XI1432_bn2 cm67_2 XI1432_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1432_MN31 (VSS XI1432_s1 XI1432_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1432_MN32 (XI1432_bn2 pp11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1432_MN55 (VSS XI1432_bcon cm71_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1432_MN38 (XI1432_bn4 XI1432_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1432_MN38_1 (VSS XI1432_s1 XI1432_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1432_MN25 (VSS XI1432_asn XI1432_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1432_MN10 (VSS pp8_16 XI1432_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1432_MN6 (XI1432_an3 pp8_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1432_MN9 (XI1432_asn XI1432_acon XI1432_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1432_MN12 (XI1432_an5 pp10_12 XI1432_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1432_MN11 (XI1432_an4 pp9_14 XI1432_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1432_MN11_1 (XI1432_an5 pp9_14 XI1432_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1432_MN12_1 (XI1432_asn pp10_12 XI1432_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1432_MN10_1 (XI1432_an4 pp8_16 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1432_MN5 (XI1432_acon pp10_12 XI1432_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1432_MN2 (XI1432_an1 pp9_14 XI1432_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1432_MN1 (VSS pp8_16 XI1432_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1432_MN3 (XI1432_an2 pp8_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1432_MN4 (VSS pp9_14 XI1432_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1432_MN27 (cm71_2 XI1432_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1432_MN7 (XI1432_an3 pp9_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1432_MN8 (VSS pp10_12 XI1432_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1437_MN34 (XI1437_bn3 XI1437_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1437_MN35 (VSS pp15_3 XI1437_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1437_MN36 (XI1437_bn3 cm72_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1437_MN37 (XI1437_bsn XI1437_bcon XI1437_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1437_MN40 (XI1437_bn5 cm72_2 XI1437_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1437_MN39 (XI1437_bn4 pp15_3 XI1437_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1437_MN39_1 (XI1437_bn5 pp15_3 XI1437_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1437_MN40_1 (XI1437_bsn cm72_2 XI1437_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1437_MN53 (VSS XI1437_bsn cm76_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1437_MN29 (XI1437_bn1 XI1437_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1437_MN30 (XI1437_bcon pp15_3 XI1437_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1437_MN33 (XI1437_bn2 cm72_2 XI1437_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1437_MN31 (VSS XI1437_s1 XI1437_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1437_MN32 (XI1437_bn2 pp15_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1437_MN55 (VSS XI1437_bcon cm76_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1437_MN38 (XI1437_bn4 XI1437_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1437_MN38_1 (VSS XI1437_s1 XI1437_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1437_MN25 (VSS XI1437_asn XI1437_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1437_MN10 (VSS pp12_9 XI1437_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1437_MN6 (XI1437_an3 pp12_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1437_MN9 (XI1437_asn XI1437_acon XI1437_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1437_MN12 (XI1437_an5 pp14_5 XI1437_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1437_MN11 (XI1437_an4 pp13_7 XI1437_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1437_MN11_1 (XI1437_an5 pp13_7 XI1437_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1437_MN12_1 (XI1437_asn pp14_5 XI1437_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1437_MN10_1 (XI1437_an4 pp12_9 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1437_MN5 (XI1437_acon pp14_5 XI1437_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1437_MN2 (XI1437_an1 pp13_7 XI1437_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1437_MN1 (VSS pp12_9 XI1437_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1437_MN3 (XI1437_an2 pp12_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1437_MN4 (VSS pp13_7 XI1437_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1437_MN27 (cm76_2 XI1437_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1437_MN7 (XI1437_an3 pp13_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1437_MN8 (VSS pp14_5 XI1437_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1494_MN34 (XI1494_bn3 XI1494_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1494_MN35 (VSS pp15_27 XI1494_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1494_MN36 (XI1494_bn3 cm132_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1494_MN37 (XI1494_bsn XI1494_bcon XI1494_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1494_MN40 (XI1494_bn5 cm132_2 XI1494_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1494_MN39 (XI1494_bn4 pp15_27 XI1494_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1494_MN39_1 (XI1494_bn5 pp15_27 XI1494_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1494_MN40_1 (XI1494_bsn cm132_2 XI1494_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1494_MN53 (VSS XI1494_bsn cm133_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1494_MN29 (XI1494_bn1 XI1494_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1494_MN30 (XI1494_bcon pp15_27 XI1494_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1494_MN33 (XI1494_bn2 cm132_2 XI1494_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1494_MN31 (VSS XI1494_s1 XI1494_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1494_MN32 (XI1494_bn2 pp15_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1494_MN55 (VSS XI1494_bcon cm133_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1494_MN38 (XI1494_bn4 XI1494_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1494_MN38_1 (VSS XI1494_s1 XI1494_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1494_MN25 (VSS XI1494_asn XI1494_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1494_MN10 (VSS sn12 XI1494_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1494_MN6 (XI1494_an3 sn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1494_MN9 (XI1494_asn XI1494_acon XI1494_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1494_MN12 (XI1494_an5 pp14_29 XI1494_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1494_MN11 (XI1494_an4 pp13_31 XI1494_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1494_MN11_1 (XI1494_an5 pp13_31 XI1494_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1494_MN12_1 (XI1494_asn pp14_29 XI1494_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1494_MN10_1 (XI1494_an4 sn12 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1494_MN5 (XI1494_acon pp14_29 XI1494_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1494_MN2 (XI1494_an1 pp13_31 XI1494_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1494_MN1 (VSS sn12 XI1494_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1494_MN3 (XI1494_an2 sn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1494_MN4 (VSS pp13_31 XI1494_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1494_MN27 (cm133_2 XI1494_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1494_MN7 (XI1494_an3 pp13_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1494_MN8 (VSS pp14_29 XI1494_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1493_MN34 (XI1493_bn3 XI1493_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1493_MN35 (VSS pp14_28 XI1493_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1493_MN36 (XI1493_bn3 cm131_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1493_MN37 (XI1493_bsn XI1493_bcon XI1493_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1493_MN40 (XI1493_bn5 cm131_2 XI1493_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1493_MN39 (XI1493_bn4 pp14_28 XI1493_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1493_MN39_1 (XI1493_bn5 pp14_28 XI1493_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1493_MN40_1 (XI1493_bsn cm131_2 XI1493_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1493_MN53 (VSS XI1493_bsn cm132_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1493_MN29 (XI1493_bn1 XI1493_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1493_MN30 (XI1493_bcon pp14_28 XI1493_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1493_MN33 (XI1493_bn2 cm131_2 XI1493_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1493_MN31 (VSS XI1493_s1 XI1493_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1493_MN32 (XI1493_bn2 pp14_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1493_MN55 (VSS XI1493_bcon cm132_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1493_MN38 (XI1493_bn4 XI1493_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1493_MN38_1 (VSS XI1493_s1 XI1493_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1493_MN25 (VSS XI1493_asn XI1493_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1493_MN10 (VSS VDD XI1493_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1493_MN6 (XI1493_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1493_MN9 (XI1493_asn XI1493_acon XI1493_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1493_MN12 (XI1493_an5 pp13_30 XI1493_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1493_MN11 (XI1493_an4 pp12_32 XI1493_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1493_MN11_1 (XI1493_an5 pp12_32 XI1493_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1493_MN12_1 (XI1493_asn pp13_30 XI1493_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1493_MN10_1 (XI1493_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1493_MN5 (XI1493_acon pp13_30 XI1493_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1493_MN2 (XI1493_an1 pp12_32 XI1493_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1493_MN1 (VSS VDD XI1493_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1493_MN3 (XI1493_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1493_MN4 (VSS pp12_32 XI1493_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1493_MN27 (cm132_2 XI1493_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1493_MN7 (XI1493_an3 pp12_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1493_MN8 (VSS pp13_30 XI1493_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1427_MN34 (XI1427_bn3 XI1427_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1427_MN35 (VSS pp7_17 XI1427_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1427_MN36 (XI1427_bn3 cm62_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1427_MN37 (XI1427_bsn XI1427_bcon XI1427_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1427_MN40 (XI1427_bn5 cm62_2 XI1427_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1427_MN39 (XI1427_bn4 pp7_17 XI1427_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1427_MN39_1 (XI1427_bn5 pp7_17 XI1427_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1427_MN40_1 (XI1427_bsn cm62_2 XI1427_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1427_MN53 (VSS XI1427_bsn cm66_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1427_MN29 (XI1427_bn1 XI1427_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1427_MN30 (XI1427_bcon pp7_17 XI1427_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1427_MN33 (XI1427_bn2 cm62_2 XI1427_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1427_MN31 (VSS XI1427_s1 XI1427_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1427_MN32 (XI1427_bn2 pp7_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1427_MN55 (VSS XI1427_bcon cm66_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1427_MN38 (XI1427_bn4 XI1427_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1427_MN38_1 (VSS XI1427_s1 XI1427_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1427_MN25 (VSS XI1427_asn XI1427_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1427_MN10 (VSS pp4_23 XI1427_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1427_MN6 (XI1427_an3 pp4_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1427_MN9 (XI1427_asn XI1427_acon XI1427_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1427_MN12 (XI1427_an5 pp6_19 XI1427_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1427_MN11 (XI1427_an4 pp5_21 XI1427_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1427_MN11_1 (XI1427_an5 pp5_21 XI1427_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1427_MN12_1 (XI1427_asn pp6_19 XI1427_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1427_MN10_1 (XI1427_an4 pp4_23 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1427_MN5 (XI1427_acon pp6_19 XI1427_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1427_MN2 (XI1427_an1 pp5_21 XI1427_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1427_MN1 (VSS pp4_23 XI1427_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1427_MN3 (XI1427_an2 pp4_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1427_MN4 (VSS pp5_21 XI1427_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1427_MN27 (cm66_2 XI1427_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1427_MN7 (XI1427_an3 pp5_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1427_MN8 (VSS pp6_19 XI1427_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1532_MN34 (XI1532_bn3 XI1532_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1532_MN35 (VSS cm68_1 XI1532_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1532_MN36 (XI1532_bn3 cm169_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1532_MN37 (XI1532_bsn XI1532_bcon XI1532_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1532_MN40 (XI1532_bn5 cm169_2 XI1532_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1532_MN39 (XI1532_bn4 cm68_1 XI1532_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1532_MN39_1 (XI1532_bn5 cm68_1 XI1532_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1532_MN40_1 (XI1532_bsn cm169_2 XI1532_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1532_MN53 (VSS XI1532_bsn cm171_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1532_MN29 (XI1532_bn1 XI1532_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1532_MN30 (XI1532_bcon cm68_1 XI1532_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1532_MN33 (XI1532_bn2 cm169_2 XI1532_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1532_MN31 (VSS XI1532_s1 XI1532_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1532_MN32 (XI1532_bn2 cm68_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1532_MN55 (VSS XI1532_bcon cm171_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1532_MN38 (XI1532_bn4 XI1532_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1532_MN38_1 (VSS XI1532_s1 XI1532_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1532_MN25 (VSS XI1532_asn XI1532_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1532_MN10 (VSS cm65_1 XI1532_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1532_MN6 (XI1532_an3 cm65_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1532_MN9 (XI1532_asn XI1532_acon XI1532_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1532_MN12 (XI1532_an5 cm67_1 XI1532_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1532_MN11 (XI1532_an4 cm66_1 XI1532_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1532_MN11_1 (XI1532_an5 cm66_1 XI1532_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1532_MN12_1 (XI1532_asn cm67_1 XI1532_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1532_MN10_1 (XI1532_an4 cm65_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1532_MN5 (XI1532_acon cm67_1 XI1532_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1532_MN2 (XI1532_an1 cm66_1 XI1532_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1532_MN1 (VSS cm65_1 XI1532_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1532_MN3 (XI1532_an2 cm65_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1532_MN4 (VSS cm66_1 XI1532_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1532_MN27 (cm171_2 XI1532_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1532_MN7 (XI1532_an3 cm66_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1532_MN8 (VSS cm67_1 XI1532_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1588_MN34 (XI1588_bn3 XI1588_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1588_MN35 (VSS cm174_0 XI1588_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1588_MN36 (XI1588_bn3 cm226_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1588_MN37 (XI1588_bsn XI1588_bcon XI1588_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1588_MN40 (XI1588_bn5 cm226_2 XI1588_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1588_MN39 (XI1588_bn4 cm174_0 XI1588_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1588_MN39_1 (XI1588_bn5 cm174_0 XI1588_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1588_MN40_1 (XI1588_bsn cm226_2 XI1588_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1588_MN53 (VSS XI1588_bsn cm227_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1588_MN29 (XI1588_bn1 XI1588_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1588_MN30 (XI1588_bcon cm174_0 XI1588_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1588_MN33 (XI1588_bn2 cm226_2 XI1588_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1588_MN31 (VSS XI1588_s1 XI1588_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1588_MN32 (XI1588_bn2 cm174_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1588_MN55 (VSS XI1588_bcon cm227_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1588_MN38 (XI1588_bn4 XI1588_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1588_MN38_1 (VSS XI1588_s1 XI1588_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1588_MN25 (VSS XI1588_asn XI1588_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1588_MN10 (VSS cm171_1 XI1588_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1588_MN6 (XI1588_an3 cm171_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1588_MN9 (XI1588_asn XI1588_acon XI1588_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1588_MN12 (XI1588_an5 cm173_0 XI1588_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1588_MN11 (XI1588_an4 cm172_1 XI1588_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1588_MN11_1 (XI1588_an5 cm172_1 XI1588_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1588_MN12_1 (XI1588_asn cm173_0 XI1588_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1588_MN10_1 (XI1588_an4 cm171_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1588_MN5 (XI1588_acon cm173_0 XI1588_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1588_MN2 (XI1588_an1 cm172_1 XI1588_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1588_MN1 (VSS cm171_1 XI1588_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1588_MN3 (XI1588_an2 cm171_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1588_MN4 (VSS cm172_1 XI1588_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1588_MN27 (cm227_2 XI1588_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1588_MN7 (XI1588_an3 cm172_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1588_MN8 (VSS cm173_0 XI1588_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1433_MN34 (XI1433_bn3 XI1433_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1433_MN35 (VSS pp15_2 XI1433_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1433_MN36 (XI1433_bn3 cm68_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1433_MN37 (XI1433_bsn XI1433_bcon XI1433_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1433_MN40 (XI1433_bn5 cm68_2 XI1433_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1433_MN39 (XI1433_bn4 pp15_2 XI1433_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1433_MN39_1 (XI1433_bn5 pp15_2 XI1433_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1433_MN40_1 (XI1433_bsn cm68_2 XI1433_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1433_MN53 (VSS XI1433_bsn cm72_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1433_MN29 (XI1433_bn1 XI1433_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1433_MN30 (XI1433_bcon pp15_2 XI1433_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1433_MN33 (XI1433_bn2 cm68_2 XI1433_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1433_MN31 (VSS XI1433_s1 XI1433_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1433_MN32 (XI1433_bn2 pp15_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1433_MN55 (VSS XI1433_bcon cm72_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1433_MN38 (XI1433_bn4 XI1433_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1433_MN38_1 (VSS XI1433_s1 XI1433_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1433_MN25 (VSS XI1433_asn XI1433_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1433_MN10 (VSS pp12_8 XI1433_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1433_MN6 (XI1433_an3 pp12_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1433_MN9 (XI1433_asn XI1433_acon XI1433_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1433_MN12 (XI1433_an5 pp14_4 XI1433_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1433_MN11 (XI1433_an4 pp13_6 XI1433_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1433_MN11_1 (XI1433_an5 pp13_6 XI1433_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1433_MN12_1 (XI1433_asn pp14_4 XI1433_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1433_MN10_1 (XI1433_an4 pp12_8 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1433_MN5 (XI1433_acon pp14_4 XI1433_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1433_MN2 (XI1433_an1 pp13_6 XI1433_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1433_MN1 (VSS pp12_8 XI1433_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1433_MN3 (XI1433_an2 pp12_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1433_MN4 (VSS pp13_6 XI1433_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1433_MN27 (cm72_2 XI1433_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1433_MN7 (XI1433_an3 pp13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1433_MN8 (VSS pp14_4 XI1433_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1426_MN34 (XI1426_bn3 XI1426_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1426_MN35 (VSS pp3_25 XI1426_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1426_MN36 (XI1426_bn3 cm61_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1426_MN37 (XI1426_bsn XI1426_bcon XI1426_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1426_MN40 (XI1426_bn5 cm61_2 XI1426_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1426_MN39 (XI1426_bn4 pp3_25 XI1426_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1426_MN39_1 (XI1426_bn5 pp3_25 XI1426_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1426_MN40_1 (XI1426_bsn cm61_2 XI1426_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1426_MN53 (VSS XI1426_bsn cm65_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1426_MN29 (XI1426_bn1 XI1426_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1426_MN30 (XI1426_bcon pp3_25 XI1426_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1426_MN33 (XI1426_bn2 cm61_2 XI1426_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1426_MN31 (VSS XI1426_s1 XI1426_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1426_MN32 (XI1426_bn2 pp3_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1426_MN55 (VSS XI1426_bcon cm65_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1426_MN38 (XI1426_bn4 XI1426_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1426_MN38_1 (VSS XI1426_s1 XI1426_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1426_MN25 (VSS XI1426_asn XI1426_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1426_MN10 (VSS pp0_31 XI1426_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1426_MN6 (XI1426_an3 pp0_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1426_MN9 (XI1426_asn XI1426_acon XI1426_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1426_MN12 (XI1426_an5 pp2_27 XI1426_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1426_MN11 (XI1426_an4 pp1_29 XI1426_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1426_MN11_1 (XI1426_an5 pp1_29 XI1426_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1426_MN12_1 (XI1426_asn pp2_27 XI1426_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1426_MN10_1 (XI1426_an4 pp0_31 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1426_MN5 (XI1426_acon pp2_27 XI1426_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1426_MN2 (XI1426_an1 pp1_29 XI1426_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1426_MN1 (VSS pp0_31 XI1426_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1426_MN3 (XI1426_an2 pp0_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1426_MN4 (VSS pp1_29 XI1426_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1426_MN27 (cm65_2 XI1426_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1426_MN7 (XI1426_an3 pp1_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1426_MN8 (VSS pp2_27 XI1426_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1531_MN34 (XI1531_bn3 XI1531_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1531_MN35 (VSS cm68_0 XI1531_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1531_MN36 (XI1531_bn3 cm168_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1531_MN37 (XI1531_bsn XI1531_bcon XI1531_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1531_MN40 (XI1531_bn5 cm168_2 XI1531_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1531_MN39 (XI1531_bn4 cm68_0 XI1531_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1531_MN39_1 (XI1531_bn5 cm68_0 XI1531_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1531_MN40_1 (XI1531_bsn cm168_2 XI1531_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1531_MN53 (VSS XI1531_bsn cm170_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1531_MN29 (XI1531_bn1 XI1531_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1531_MN30 (XI1531_bcon cm68_0 XI1531_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1531_MN33 (XI1531_bn2 cm168_2 XI1531_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1531_MN31 (VSS XI1531_s1 XI1531_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1531_MN32 (XI1531_bn2 cm68_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1531_MN55 (VSS XI1531_bcon cm170_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1531_MN38 (XI1531_bn4 XI1531_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1531_MN38_1 (VSS XI1531_s1 XI1531_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1531_MN25 (VSS XI1531_asn XI1531_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1531_MN10 (VSS cm65_0 XI1531_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1531_MN6 (XI1531_an3 cm65_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1531_MN9 (XI1531_asn XI1531_acon XI1531_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1531_MN12 (XI1531_an5 cm67_0 XI1531_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1531_MN11 (XI1531_an4 cm66_0 XI1531_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1531_MN11_1 (XI1531_an5 cm66_0 XI1531_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1531_MN12_1 (XI1531_asn cm67_0 XI1531_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1531_MN10_1 (XI1531_an4 cm65_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1531_MN5 (XI1531_acon cm67_0 XI1531_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1531_MN2 (XI1531_an1 cm66_0 XI1531_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1531_MN1 (VSS cm65_0 XI1531_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1531_MN3 (XI1531_an2 cm65_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1531_MN4 (VSS cm66_0 XI1531_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1531_MN27 (cm170_2 XI1531_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1531_MN7 (XI1531_an3 cm66_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1531_MN8 (VSS cm67_0 XI1531_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1587_MN34 (XI1587_bn3 XI1587_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1587_MN35 (VSS cm172_0 XI1587_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1587_MN36 (XI1587_bn3 cm225_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1587_MN37 (XI1587_bsn XI1587_bcon XI1587_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1587_MN40 (XI1587_bn5 cm225_2 XI1587_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1587_MN39 (XI1587_bn4 cm172_0 XI1587_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1587_MN39_1 (XI1587_bn5 cm172_0 XI1587_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1587_MN40_1 (XI1587_bsn cm225_2 XI1587_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1587_MN53 (VSS XI1587_bsn cm226_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1587_MN29 (XI1587_bn1 XI1587_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1587_MN30 (XI1587_bcon cm172_0 XI1587_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1587_MN33 (XI1587_bn2 cm225_2 XI1587_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1587_MN31 (VSS XI1587_s1 XI1587_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1587_MN32 (XI1587_bn2 cm172_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1587_MN55 (VSS XI1587_bcon cm226_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1587_MN38 (XI1587_bn4 XI1587_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1587_MN38_1 (VSS XI1587_s1 XI1587_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1587_MN25 (VSS XI1587_asn XI1587_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1587_MN10 (VSS cm169_1 XI1587_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1587_MN6 (XI1587_an3 cm169_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1587_MN9 (XI1587_asn XI1587_acon XI1587_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1587_MN12 (XI1587_an5 cm171_0 XI1587_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1587_MN11 (XI1587_an4 cm170_1 XI1587_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1587_MN11_1 (XI1587_an5 cm170_1 XI1587_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1587_MN12_1 (XI1587_asn cm171_0 XI1587_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1587_MN10_1 (XI1587_an4 cm169_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1587_MN5 (XI1587_acon cm171_0 XI1587_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1587_MN2 (XI1587_an1 cm170_1 XI1587_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1587_MN1 (VSS cm169_1 XI1587_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1587_MN3 (XI1587_an2 cm169_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1587_MN4 (VSS cm170_1 XI1587_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1587_MN27 (cm226_2 XI1587_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1587_MN7 (XI1587_an3 cm170_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1587_MN8 (VSS cm171_0 XI1587_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1428_MN34 (XI1428_bn3 XI1428_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1428_MN35 (VSS pp11_9 XI1428_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1428_MN36 (XI1428_bn3 cm63_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1428_MN37 (XI1428_bsn XI1428_bcon XI1428_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1428_MN40 (XI1428_bn5 cm63_2 XI1428_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1428_MN39 (XI1428_bn4 pp11_9 XI1428_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1428_MN39_1 (XI1428_bn5 pp11_9 XI1428_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1428_MN40_1 (XI1428_bsn cm63_2 XI1428_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1428_MN53 (VSS XI1428_bsn cm67_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1428_MN29 (XI1428_bn1 XI1428_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1428_MN30 (XI1428_bcon pp11_9 XI1428_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1428_MN33 (XI1428_bn2 cm63_2 XI1428_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1428_MN31 (VSS XI1428_s1 XI1428_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1428_MN32 (XI1428_bn2 pp11_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1428_MN55 (VSS XI1428_bcon cm67_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1428_MN38 (XI1428_bn4 XI1428_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1428_MN38_1 (VSS XI1428_s1 XI1428_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1428_MN25 (VSS XI1428_asn XI1428_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1428_MN10 (VSS pp8_15 XI1428_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1428_MN6 (XI1428_an3 pp8_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1428_MN9 (XI1428_asn XI1428_acon XI1428_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1428_MN12 (XI1428_an5 pp10_11 XI1428_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1428_MN11 (XI1428_an4 pp9_13 XI1428_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1428_MN11_1 (XI1428_an5 pp9_13 XI1428_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1428_MN12_1 (XI1428_asn pp10_11 XI1428_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1428_MN10_1 (XI1428_an4 pp8_15 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1428_MN5 (XI1428_acon pp10_11 XI1428_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1428_MN2 (XI1428_an1 pp9_13 XI1428_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1428_MN1 (VSS pp8_15 XI1428_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1428_MN3 (XI1428_an2 pp8_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1428_MN4 (VSS pp9_13 XI1428_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1428_MN27 (cm67_2 XI1428_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1428_MN7 (XI1428_an3 pp9_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1428_MN8 (VSS pp10_11 XI1428_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1429_MN34 (XI1429_bn3 XI1429_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1429_MN35 (VSS pp15_1 XI1429_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1429_MN36 (XI1429_bn3 cm64_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1429_MN37 (XI1429_bsn XI1429_bcon XI1429_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1429_MN40 (XI1429_bn5 cm64_2 XI1429_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1429_MN39 (XI1429_bn4 pp15_1 XI1429_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1429_MN39_1 (XI1429_bn5 pp15_1 XI1429_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1429_MN40_1 (XI1429_bsn cm64_2 XI1429_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1429_MN53 (VSS XI1429_bsn cm68_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1429_MN29 (XI1429_bn1 XI1429_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1429_MN30 (XI1429_bcon pp15_1 XI1429_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1429_MN33 (XI1429_bn2 cm64_2 XI1429_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1429_MN31 (VSS XI1429_s1 XI1429_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1429_MN32 (XI1429_bn2 pp15_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1429_MN55 (VSS XI1429_bcon cm68_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1429_MN38 (XI1429_bn4 XI1429_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1429_MN38_1 (VSS XI1429_s1 XI1429_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1429_MN25 (VSS XI1429_asn XI1429_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1429_MN10 (VSS pp12_7 XI1429_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1429_MN6 (XI1429_an3 pp12_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1429_MN9 (XI1429_asn XI1429_acon XI1429_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1429_MN12 (XI1429_an5 pp14_3 XI1429_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1429_MN11 (XI1429_an4 pp13_5 XI1429_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1429_MN11_1 (XI1429_an5 pp13_5 XI1429_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1429_MN12_1 (XI1429_asn pp14_3 XI1429_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1429_MN10_1 (XI1429_an4 pp12_7 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1429_MN5 (XI1429_acon pp14_3 XI1429_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1429_MN2 (XI1429_an1 pp13_5 XI1429_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1429_MN1 (VSS pp12_7 XI1429_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1429_MN3 (XI1429_an2 pp12_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1429_MN4 (VSS pp13_5 XI1429_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1429_MN27 (cm68_2 XI1429_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1429_MN7 (XI1429_an3 pp13_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1429_MN8 (VSS pp14_3 XI1429_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1495_MN34 (XI1495_bn3 XI1495_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1495_MN35 (VSS pp15_28 XI1495_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1495_MN36 (XI1495_bn3 cm133_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1495_MN37 (XI1495_bsn XI1495_bcon XI1495_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1495_MN40 (XI1495_bn5 cm133_2 XI1495_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1495_MN39 (XI1495_bn4 pp15_28 XI1495_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1495_MN39_1 (XI1495_bn5 pp15_28 XI1495_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1495_MN40_1 (XI1495_bsn cm133_2 XI1495_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1495_MN53 (VSS XI1495_bsn cm134_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1495_MN29 (XI1495_bn1 XI1495_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1495_MN30 (XI1495_bcon pp15_28 XI1495_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1495_MN33 (XI1495_bn2 cm133_2 XI1495_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1495_MN31 (VSS XI1495_s1 XI1495_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1495_MN32 (XI1495_bn2 pp15_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1495_MN55 (VSS XI1495_bcon cm134_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1495_MN38 (XI1495_bn4 XI1495_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1495_MN38_1 (VSS XI1495_s1 XI1495_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1495_MN25 (VSS XI1495_asn XI1495_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1495_MN10 (VSS VDD XI1495_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1495_MN6 (XI1495_an3 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1495_MN9 (XI1495_asn XI1495_acon XI1495_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1495_MN12 (XI1495_an5 pp14_30 XI1495_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1495_MN11 (XI1495_an4 pp13_32 XI1495_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1495_MN11_1 (XI1495_an5 pp13_32 XI1495_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1495_MN12_1 (XI1495_asn pp14_30 XI1495_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1495_MN10_1 (XI1495_an4 VDD VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1495_MN5 (XI1495_acon pp14_30 XI1495_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1495_MN2 (XI1495_an1 pp13_32 XI1495_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1495_MN1 (VSS VDD XI1495_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1495_MN3 (XI1495_an2 VDD VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1495_MN4 (VSS pp13_32 XI1495_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1495_MN27 (cm134_2 XI1495_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1495_MN7 (XI1495_an3 pp13_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1495_MN8 (VSS pp14_30 XI1495_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1423_MN34 (XI1423_bn3 XI1423_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1423_MN35 (VSS pp7_16 XI1423_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1423_MN36 (XI1423_bn3 cm58_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1423_MN37 (XI1423_bsn XI1423_bcon XI1423_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1423_MN40 (XI1423_bn5 cm58_2 XI1423_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1423_MN39 (XI1423_bn4 pp7_16 XI1423_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1423_MN39_1 (XI1423_bn5 pp7_16 XI1423_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1423_MN40_1 (XI1423_bsn cm58_2 XI1423_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1423_MN53 (VSS XI1423_bsn cm62_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1423_MN29 (XI1423_bn1 XI1423_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1423_MN30 (XI1423_bcon pp7_16 XI1423_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1423_MN33 (XI1423_bn2 cm58_2 XI1423_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1423_MN31 (VSS XI1423_s1 XI1423_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1423_MN32 (XI1423_bn2 pp7_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1423_MN55 (VSS XI1423_bcon cm62_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1423_MN38 (XI1423_bn4 XI1423_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1423_MN38_1 (VSS XI1423_s1 XI1423_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1423_MN25 (VSS XI1423_asn XI1423_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1423_MN10 (VSS pp4_22 XI1423_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1423_MN6 (XI1423_an3 pp4_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1423_MN9 (XI1423_asn XI1423_acon XI1423_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1423_MN12 (XI1423_an5 pp6_18 XI1423_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1423_MN11 (XI1423_an4 pp5_20 XI1423_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1423_MN11_1 (XI1423_an5 pp5_20 XI1423_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1423_MN12_1 (XI1423_asn pp6_18 XI1423_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1423_MN10_1 (XI1423_an4 pp4_22 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1423_MN5 (XI1423_acon pp6_18 XI1423_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1423_MN2 (XI1423_an1 pp5_20 XI1423_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1423_MN1 (VSS pp4_22 XI1423_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1423_MN3 (XI1423_an2 pp4_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1423_MN4 (VSS pp5_20 XI1423_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1423_MN27 (cm62_2 XI1423_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1423_MN7 (XI1423_an3 pp5_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1423_MN8 (VSS pp6_18 XI1423_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1422_MN34 (XI1422_bn3 XI1422_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1422_MN35 (VSS pp3_24 XI1422_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1422_MN36 (XI1422_bn3 cm57_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1422_MN37 (XI1422_bsn XI1422_bcon XI1422_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1422_MN40 (XI1422_bn5 cm57_2 XI1422_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1422_MN39 (XI1422_bn4 pp3_24 XI1422_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1422_MN39_1 (XI1422_bn5 pp3_24 XI1422_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1422_MN40_1 (XI1422_bsn cm57_2 XI1422_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1422_MN53 (VSS XI1422_bsn cm61_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1422_MN29 (XI1422_bn1 XI1422_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1422_MN30 (XI1422_bcon pp3_24 XI1422_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1422_MN33 (XI1422_bn2 cm57_2 XI1422_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1422_MN31 (VSS XI1422_s1 XI1422_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1422_MN32 (XI1422_bn2 pp3_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1422_MN55 (VSS XI1422_bcon cm61_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1422_MN38 (XI1422_bn4 XI1422_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1422_MN38_1 (VSS XI1422_s1 XI1422_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1422_MN25 (VSS XI1422_asn XI1422_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1422_MN10 (VSS pp0_30 XI1422_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1422_MN6 (XI1422_an3 pp0_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1422_MN9 (XI1422_asn XI1422_acon XI1422_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1422_MN12 (XI1422_an5 pp2_26 XI1422_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1422_MN11 (XI1422_an4 pp1_28 XI1422_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1422_MN11_1 (XI1422_an5 pp1_28 XI1422_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1422_MN12_1 (XI1422_asn pp2_26 XI1422_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1422_MN10_1 (XI1422_an4 pp0_30 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1422_MN5 (XI1422_acon pp2_26 XI1422_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1422_MN2 (XI1422_an1 pp1_28 XI1422_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1422_MN1 (VSS pp0_30 XI1422_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1422_MN3 (XI1422_an2 pp0_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1422_MN4 (VSS pp1_28 XI1422_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1422_MN27 (cm61_2 XI1422_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1422_MN7 (XI1422_an3 pp1_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1422_MN8 (VSS pp2_26 XI1422_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1530_MN34 (XI1530_bn3 XI1530_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1530_MN35 (VSS cm64_1 XI1530_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1530_MN36 (XI1530_bn3 cm167_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1530_MN37 (XI1530_bsn XI1530_bcon XI1530_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1530_MN40 (XI1530_bn5 cm167_2 XI1530_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1530_MN39 (XI1530_bn4 cm64_1 XI1530_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1530_MN39_1 (XI1530_bn5 cm64_1 XI1530_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1530_MN40_1 (XI1530_bsn cm167_2 XI1530_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1530_MN53 (VSS XI1530_bsn cm169_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1530_MN29 (XI1530_bn1 XI1530_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1530_MN30 (XI1530_bcon cm64_1 XI1530_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1530_MN33 (XI1530_bn2 cm167_2 XI1530_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1530_MN31 (VSS XI1530_s1 XI1530_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1530_MN32 (XI1530_bn2 cm64_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1530_MN55 (VSS XI1530_bcon cm169_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1530_MN38 (XI1530_bn4 XI1530_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1530_MN38_1 (VSS XI1530_s1 XI1530_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1530_MN25 (VSS XI1530_asn XI1530_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1530_MN10 (VSS cm61_1 XI1530_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1530_MN6 (XI1530_an3 cm61_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1530_MN9 (XI1530_asn XI1530_acon XI1530_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1530_MN12 (XI1530_an5 cm63_1 XI1530_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1530_MN11 (XI1530_an4 cm62_1 XI1530_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1530_MN11_1 (XI1530_an5 cm62_1 XI1530_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1530_MN12_1 (XI1530_asn cm63_1 XI1530_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1530_MN10_1 (XI1530_an4 cm61_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1530_MN5 (XI1530_acon cm63_1 XI1530_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1530_MN2 (XI1530_an1 cm62_1 XI1530_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1530_MN1 (VSS cm61_1 XI1530_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1530_MN3 (XI1530_an2 cm61_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1530_MN4 (VSS cm62_1 XI1530_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1530_MN27 (cm169_2 XI1530_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1530_MN7 (XI1530_an3 cm62_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1530_MN8 (VSS cm63_1 XI1530_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1586_MN34 (XI1586_bn3 XI1586_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1586_MN35 (VSS cm170_0 XI1586_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1586_MN36 (XI1586_bn3 cm224_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1586_MN37 (XI1586_bsn XI1586_bcon XI1586_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1586_MN40 (XI1586_bn5 cm224_2 XI1586_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1586_MN39 (XI1586_bn4 cm170_0 XI1586_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1586_MN39_1 (XI1586_bn5 cm170_0 XI1586_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1586_MN40_1 (XI1586_bsn cm224_2 XI1586_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1586_MN53 (VSS XI1586_bsn cm225_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1586_MN29 (XI1586_bn1 XI1586_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1586_MN30 (XI1586_bcon cm170_0 XI1586_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1586_MN33 (XI1586_bn2 cm224_2 XI1586_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1586_MN31 (VSS XI1586_s1 XI1586_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1586_MN32 (XI1586_bn2 cm170_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1586_MN55 (VSS XI1586_bcon cm225_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1586_MN38 (XI1586_bn4 XI1586_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1586_MN38_1 (VSS XI1586_s1 XI1586_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1586_MN25 (VSS XI1586_asn XI1586_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1586_MN10 (VSS cm167_1 XI1586_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1586_MN6 (XI1586_an3 cm167_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1586_MN9 (XI1586_asn XI1586_acon XI1586_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1586_MN12 (XI1586_an5 cm169_0 XI1586_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1586_MN11 (XI1586_an4 cm168_1 XI1586_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1586_MN11_1 (XI1586_an5 cm168_1 XI1586_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1586_MN12_1 (XI1586_asn cm169_0 XI1586_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1586_MN10_1 (XI1586_an4 cm167_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1586_MN5 (XI1586_acon cm169_0 XI1586_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1586_MN2 (XI1586_an1 cm168_1 XI1586_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1586_MN1 (VSS cm167_1 XI1586_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1586_MN3 (XI1586_an2 cm167_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1586_MN4 (VSS cm168_1 XI1586_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1586_MN27 (cm225_2 XI1586_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1586_MN7 (XI1586_an3 cm168_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1586_MN8 (VSS cm169_0 XI1586_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1424_MN34 (XI1424_bn3 XI1424_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1424_MN35 (VSS pp11_8 XI1424_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1424_MN36 (XI1424_bn3 cm59_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1424_MN37 (XI1424_bsn XI1424_bcon XI1424_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1424_MN40 (XI1424_bn5 cm59_2 XI1424_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1424_MN39 (XI1424_bn4 pp11_8 XI1424_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1424_MN39_1 (XI1424_bn5 pp11_8 XI1424_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1424_MN40_1 (XI1424_bsn cm59_2 XI1424_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1424_MN53 (VSS XI1424_bsn cm63_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1424_MN29 (XI1424_bn1 XI1424_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1424_MN30 (XI1424_bcon pp11_8 XI1424_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1424_MN33 (XI1424_bn2 cm59_2 XI1424_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1424_MN31 (VSS XI1424_s1 XI1424_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1424_MN32 (XI1424_bn2 pp11_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1424_MN55 (VSS XI1424_bcon cm63_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1424_MN38 (XI1424_bn4 XI1424_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1424_MN38_1 (VSS XI1424_s1 XI1424_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1424_MN25 (VSS XI1424_asn XI1424_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1424_MN10 (VSS pp8_14 XI1424_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1424_MN6 (XI1424_an3 pp8_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1424_MN9 (XI1424_asn XI1424_acon XI1424_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1424_MN12 (XI1424_an5 pp10_10 XI1424_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1424_MN11 (XI1424_an4 pp9_12 XI1424_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1424_MN11_1 (XI1424_an5 pp9_12 XI1424_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1424_MN12_1 (XI1424_asn pp10_10 XI1424_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1424_MN10_1 (XI1424_an4 pp8_14 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1424_MN5 (XI1424_acon pp10_10 XI1424_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1424_MN2 (XI1424_an1 pp9_12 XI1424_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1424_MN1 (VSS pp8_14 XI1424_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1424_MN3 (XI1424_an2 pp8_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1424_MN4 (VSS pp9_12 XI1424_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1424_MN27 (cm63_2 XI1424_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1424_MN7 (XI1424_an3 pp9_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1424_MN8 (VSS pp10_10 XI1424_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1425_MN34 (XI1425_bn3 XI1425_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1425_MN35 (VSS pp15_0 XI1425_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1425_MN36 (XI1425_bn3 B_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1425_MN37 (XI1425_bsn XI1425_bcon XI1425_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1425_MN40 (XI1425_bn5 B_31_b3_5 XI1425_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1425_MN39 (XI1425_bn4 pp15_0 XI1425_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1425_MN39_1 (XI1425_bn5 pp15_0 XI1425_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1425_MN40_1 (XI1425_bsn B_31_b3_5 XI1425_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1425_MN53 (VSS XI1425_bsn cm64_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1425_MN29 (XI1425_bn1 XI1425_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1425_MN30 (XI1425_bcon pp15_0 XI1425_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1425_MN33 (XI1425_bn2 B_31_b3_5 XI1425_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1425_MN31 (VSS XI1425_s1 XI1425_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1425_MN32 (XI1425_bn2 pp15_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1425_MN55 (VSS XI1425_bcon cm64_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1425_MN38 (XI1425_bn4 XI1425_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1425_MN38_1 (VSS XI1425_s1 XI1425_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1425_MN25 (VSS XI1425_asn XI1425_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1425_MN10 (VSS pp12_6 XI1425_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1425_MN6 (XI1425_an3 pp12_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1425_MN9 (XI1425_asn XI1425_acon XI1425_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1425_MN12 (XI1425_an5 pp14_2 XI1425_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1425_MN11 (XI1425_an4 pp13_4 XI1425_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1425_MN11_1 (XI1425_an5 pp13_4 XI1425_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1425_MN12_1 (XI1425_asn pp14_2 XI1425_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1425_MN10_1 (XI1425_an4 pp12_6 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1425_MN5 (XI1425_acon pp14_2 XI1425_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1425_MN2 (XI1425_an1 pp13_4 XI1425_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1425_MN1 (VSS pp12_6 XI1425_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1425_MN3 (XI1425_an2 pp12_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1425_MN4 (VSS pp13_4 XI1425_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1425_MN27 (cm64_2 XI1425_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1425_MN7 (XI1425_an3 pp13_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1425_MN8 (VSS pp14_2 XI1425_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1418_MN34 (XI1418_bn3 XI1418_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1418_MN35 (VSS pp3_23 XI1418_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1418_MN36 (XI1418_bn3 cm53_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1418_MN37 (XI1418_bsn XI1418_bcon XI1418_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1418_MN40 (XI1418_bn5 cm53_2 XI1418_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1418_MN39 (XI1418_bn4 pp3_23 XI1418_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1418_MN39_1 (XI1418_bn5 pp3_23 XI1418_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1418_MN40_1 (XI1418_bsn cm53_2 XI1418_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1418_MN53 (VSS XI1418_bsn cm57_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1418_MN29 (XI1418_bn1 XI1418_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1418_MN30 (XI1418_bcon pp3_23 XI1418_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1418_MN33 (XI1418_bn2 cm53_2 XI1418_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1418_MN31 (VSS XI1418_s1 XI1418_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1418_MN32 (XI1418_bn2 pp3_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1418_MN55 (VSS XI1418_bcon cm57_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1418_MN38 (XI1418_bn4 XI1418_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1418_MN38_1 (VSS XI1418_s1 XI1418_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1418_MN25 (VSS XI1418_asn XI1418_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1418_MN10 (VSS pp0_29 XI1418_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1418_MN6 (XI1418_an3 pp0_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1418_MN9 (XI1418_asn XI1418_acon XI1418_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1418_MN12 (XI1418_an5 pp2_25 XI1418_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1418_MN11 (XI1418_an4 pp1_27 XI1418_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1418_MN11_1 (XI1418_an5 pp1_27 XI1418_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1418_MN12_1 (XI1418_asn pp2_25 XI1418_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1418_MN10_1 (XI1418_an4 pp0_29 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1418_MN5 (XI1418_acon pp2_25 XI1418_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1418_MN2 (XI1418_an1 pp1_27 XI1418_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1418_MN1 (VSS pp0_29 XI1418_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1418_MN3 (XI1418_an2 pp0_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1418_MN4 (VSS pp1_27 XI1418_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1418_MN27 (cm57_2 XI1418_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1418_MN7 (XI1418_an3 pp1_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1418_MN8 (VSS pp2_25 XI1418_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1528_MN34 (XI1528_bn3 XI1528_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1528_MN35 (VSS fa60_1 XI1528_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1528_MN36 (XI1528_bn3 cm165_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1528_MN37 (XI1528_bsn XI1528_bcon XI1528_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1528_MN40 (XI1528_bn5 cm165_2 XI1528_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1528_MN39 (XI1528_bn4 fa60_1 XI1528_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1528_MN39_1 (XI1528_bn5 fa60_1 XI1528_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1528_MN40_1 (XI1528_bsn cm165_2 XI1528_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1528_MN53 (VSS XI1528_bsn cm167_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1528_MN29 (XI1528_bn1 XI1528_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1528_MN30 (XI1528_bcon fa60_1 XI1528_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1528_MN33 (XI1528_bn2 cm165_2 XI1528_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1528_MN31 (VSS XI1528_s1 XI1528_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1528_MN32 (XI1528_bn2 fa60_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1528_MN55 (VSS XI1528_bcon cm167_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1528_MN38 (XI1528_bn4 XI1528_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1528_MN38_1 (VSS XI1528_s1 XI1528_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1528_MN25 (VSS XI1528_asn XI1528_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1528_MN10 (VSS cm57_1 XI1528_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1528_MN6 (XI1528_an3 cm57_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1528_MN9 (XI1528_asn XI1528_acon XI1528_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1528_MN12 (XI1528_an5 cm59_1 XI1528_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1528_MN11 (XI1528_an4 cm58_1 XI1528_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1528_MN11_1 (XI1528_an5 cm58_1 XI1528_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1528_MN12_1 (XI1528_asn cm59_1 XI1528_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1528_MN10_1 (XI1528_an4 cm57_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1528_MN5 (XI1528_acon cm59_1 XI1528_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1528_MN2 (XI1528_an1 cm58_1 XI1528_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1528_MN1 (VSS cm57_1 XI1528_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1528_MN3 (XI1528_an2 cm57_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1528_MN4 (VSS cm58_1 XI1528_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1528_MN27 (cm167_2 XI1528_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1528_MN7 (XI1528_an3 cm58_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1528_MN8 (VSS cm59_1 XI1528_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1529_MN34 (XI1529_bn3 XI1529_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1529_MN35 (VSS cm64_0 XI1529_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1529_MN36 (XI1529_bn3 cm166_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1529_MN37 (XI1529_bsn XI1529_bcon XI1529_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1529_MN40 (XI1529_bn5 cm166_2 XI1529_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1529_MN39 (XI1529_bn4 cm64_0 XI1529_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1529_MN39_1 (XI1529_bn5 cm64_0 XI1529_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1529_MN40_1 (XI1529_bsn cm166_2 XI1529_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1529_MN53 (VSS XI1529_bsn cm168_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1529_MN29 (XI1529_bn1 XI1529_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1529_MN30 (XI1529_bcon cm64_0 XI1529_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1529_MN33 (XI1529_bn2 cm166_2 XI1529_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1529_MN31 (VSS XI1529_s1 XI1529_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1529_MN32 (XI1529_bn2 cm64_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1529_MN55 (VSS XI1529_bcon cm168_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1529_MN38 (XI1529_bn4 XI1529_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1529_MN38_1 (VSS XI1529_s1 XI1529_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1529_MN25 (VSS XI1529_asn XI1529_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1529_MN10 (VSS cm61_0 XI1529_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1529_MN6 (XI1529_an3 cm61_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1529_MN9 (XI1529_asn XI1529_acon XI1529_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1529_MN12 (XI1529_an5 cm63_0 XI1529_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1529_MN11 (XI1529_an4 cm62_0 XI1529_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1529_MN11_1 (XI1529_an5 cm62_0 XI1529_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1529_MN12_1 (XI1529_asn cm63_0 XI1529_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1529_MN10_1 (XI1529_an4 cm61_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1529_MN5 (XI1529_acon cm63_0 XI1529_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1529_MN2 (XI1529_an1 cm62_0 XI1529_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1529_MN1 (VSS cm61_0 XI1529_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1529_MN3 (XI1529_an2 cm61_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1529_MN4 (VSS cm62_0 XI1529_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1529_MN27 (cm168_2 XI1529_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1529_MN7 (XI1529_an3 cm62_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1529_MN8 (VSS cm63_0 XI1529_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1420_MN34 (XI1420_bn3 XI1420_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1420_MN35 (VSS pp11_7 XI1420_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1420_MN36 (XI1420_bn3 cm55_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1420_MN37 (XI1420_bsn XI1420_bcon XI1420_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1420_MN40 (XI1420_bn5 cm55_2 XI1420_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1420_MN39 (XI1420_bn4 pp11_7 XI1420_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1420_MN39_1 (XI1420_bn5 pp11_7 XI1420_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1420_MN40_1 (XI1420_bsn cm55_2 XI1420_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1420_MN53 (VSS XI1420_bsn cm59_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1420_MN29 (XI1420_bn1 XI1420_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1420_MN30 (XI1420_bcon pp11_7 XI1420_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1420_MN33 (XI1420_bn2 cm55_2 XI1420_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1420_MN31 (VSS XI1420_s1 XI1420_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1420_MN32 (XI1420_bn2 pp11_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1420_MN55 (VSS XI1420_bcon cm59_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1420_MN38 (XI1420_bn4 XI1420_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1420_MN38_1 (VSS XI1420_s1 XI1420_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1420_MN25 (VSS XI1420_asn XI1420_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1420_MN10 (VSS pp8_13 XI1420_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1420_MN6 (XI1420_an3 pp8_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1420_MN9 (XI1420_asn XI1420_acon XI1420_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1420_MN12 (XI1420_an5 pp10_9 XI1420_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1420_MN11 (XI1420_an4 pp9_11 XI1420_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1420_MN11_1 (XI1420_an5 pp9_11 XI1420_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1420_MN12_1 (XI1420_asn pp10_9 XI1420_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1420_MN10_1 (XI1420_an4 pp8_13 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1420_MN5 (XI1420_acon pp10_9 XI1420_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1420_MN2 (XI1420_an1 pp9_11 XI1420_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1420_MN1 (VSS pp8_13 XI1420_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1420_MN3 (XI1420_an2 pp8_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1420_MN4 (VSS pp9_11 XI1420_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1420_MN27 (cm59_2 XI1420_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1420_MN7 (XI1420_an3 pp9_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1420_MN8 (VSS pp10_9 XI1420_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1419_MN34 (XI1419_bn3 XI1419_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1419_MN35 (VSS pp7_15 XI1419_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1419_MN36 (XI1419_bn3 cm54_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1419_MN37 (XI1419_bsn XI1419_bcon XI1419_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1419_MN40 (XI1419_bn5 cm54_2 XI1419_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1419_MN39 (XI1419_bn4 pp7_15 XI1419_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1419_MN39_1 (XI1419_bn5 pp7_15 XI1419_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1419_MN40_1 (XI1419_bsn cm54_2 XI1419_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1419_MN53 (VSS XI1419_bsn cm58_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1419_MN29 (XI1419_bn1 XI1419_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1419_MN30 (XI1419_bcon pp7_15 XI1419_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1419_MN33 (XI1419_bn2 cm54_2 XI1419_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1419_MN31 (VSS XI1419_s1 XI1419_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1419_MN32 (XI1419_bn2 pp7_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1419_MN55 (VSS XI1419_bcon cm58_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1419_MN38 (XI1419_bn4 XI1419_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1419_MN38_1 (VSS XI1419_s1 XI1419_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1419_MN25 (VSS XI1419_asn XI1419_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1419_MN10 (VSS pp4_21 XI1419_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1419_MN6 (XI1419_an3 pp4_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1419_MN9 (XI1419_asn XI1419_acon XI1419_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1419_MN12 (XI1419_an5 pp6_17 XI1419_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1419_MN11 (XI1419_an4 pp5_19 XI1419_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1419_MN11_1 (XI1419_an5 pp5_19 XI1419_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1419_MN12_1 (XI1419_asn pp6_17 XI1419_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1419_MN10_1 (XI1419_an4 pp4_21 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1419_MN5 (XI1419_acon pp6_17 XI1419_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1419_MN2 (XI1419_an1 pp5_19 XI1419_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1419_MN1 (VSS pp4_21 XI1419_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1419_MN3 (XI1419_an2 pp4_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1419_MN4 (VSS pp5_19 XI1419_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1419_MN27 (cm58_2 XI1419_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1419_MN7 (XI1419_an3 pp5_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1419_MN8 (VSS pp6_17 XI1419_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1585_MN34 (XI1585_bn3 XI1585_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1585_MN35 (VSS cm168_0 XI1585_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1585_MN36 (XI1585_bn3 cm223_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1585_MN37 (XI1585_bsn XI1585_bcon XI1585_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1585_MN40 (XI1585_bn5 cm223_2 XI1585_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1585_MN39 (XI1585_bn4 cm168_0 XI1585_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1585_MN39_1 (XI1585_bn5 cm168_0 XI1585_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1585_MN40_1 (XI1585_bsn cm223_2 XI1585_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1585_MN53 (VSS XI1585_bsn cm224_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1585_MN29 (XI1585_bn1 XI1585_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1585_MN30 (XI1585_bcon cm168_0 XI1585_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1585_MN33 (XI1585_bn2 cm223_2 XI1585_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1585_MN31 (VSS XI1585_s1 XI1585_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1585_MN32 (XI1585_bn2 cm168_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1585_MN55 (VSS XI1585_bcon cm224_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1585_MN38 (XI1585_bn4 XI1585_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1585_MN38_1 (VSS XI1585_s1 XI1585_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1585_MN25 (VSS XI1585_asn XI1585_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1585_MN10 (VSS cm165_1 XI1585_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1585_MN6 (XI1585_an3 cm165_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1585_MN9 (XI1585_asn XI1585_acon XI1585_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1585_MN12 (XI1585_an5 cm167_0 XI1585_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1585_MN11 (XI1585_an4 cm166_1 XI1585_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1585_MN11_1 (XI1585_an5 cm166_1 XI1585_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1585_MN12_1 (XI1585_asn cm167_0 XI1585_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1585_MN10_1 (XI1585_an4 cm165_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1585_MN5 (XI1585_acon cm167_0 XI1585_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1585_MN2 (XI1585_an1 cm166_1 XI1585_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1585_MN1 (VSS cm165_1 XI1585_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1585_MN3 (XI1585_an2 cm165_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1585_MN4 (VSS cm166_1 XI1585_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1585_MN27 (cm224_2 XI1585_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1585_MN7 (XI1585_an3 cm166_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1585_MN8 (VSS cm167_0 XI1585_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1527_MN34 (XI1527_bn3 XI1527_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1527_MN35 (VSS fa60_0 XI1527_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1527_MN36 (XI1527_bn3 cm164_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1527_MN37 (XI1527_bsn XI1527_bcon XI1527_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1527_MN40 (XI1527_bn5 cm164_2 XI1527_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1527_MN39 (XI1527_bn4 fa60_0 XI1527_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1527_MN39_1 (XI1527_bn5 fa60_0 XI1527_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1527_MN40_1 (XI1527_bsn cm164_2 XI1527_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1527_MN53 (VSS XI1527_bsn cm166_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1527_MN29 (XI1527_bn1 XI1527_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1527_MN30 (XI1527_bcon fa60_0 XI1527_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1527_MN33 (XI1527_bn2 cm164_2 XI1527_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1527_MN31 (VSS XI1527_s1 XI1527_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1527_MN32 (XI1527_bn2 fa60_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1527_MN55 (VSS XI1527_bcon cm166_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1527_MN38 (XI1527_bn4 XI1527_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1527_MN38_1 (VSS XI1527_s1 XI1527_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1527_MN25 (VSS XI1527_asn XI1527_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1527_MN10 (VSS cm57_0 XI1527_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1527_MN6 (XI1527_an3 cm57_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1527_MN9 (XI1527_asn XI1527_acon XI1527_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1527_MN12 (XI1527_an5 cm59_0 XI1527_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1527_MN11 (XI1527_an4 cm58_0 XI1527_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1527_MN11_1 (XI1527_an5 cm58_0 XI1527_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1527_MN12_1 (XI1527_asn cm59_0 XI1527_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1527_MN10_1 (XI1527_an4 cm57_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1527_MN5 (XI1527_acon cm59_0 XI1527_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1527_MN2 (XI1527_an1 cm58_0 XI1527_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1527_MN1 (VSS cm57_0 XI1527_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1527_MN3 (XI1527_an2 cm57_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1527_MN4 (VSS cm58_0 XI1527_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1527_MN27 (cm166_2 XI1527_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1527_MN7 (XI1527_an3 cm58_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1527_MN8 (VSS cm59_0 XI1527_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1415_MN34 (XI1415_bn3 XI1415_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1415_MN35 (VSS pp7_14 XI1415_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1415_MN36 (XI1415_bn3 cm51_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1415_MN37 (XI1415_bsn XI1415_bcon XI1415_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1415_MN40 (XI1415_bn5 cm51_2 XI1415_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1415_MN39 (XI1415_bn4 pp7_14 XI1415_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1415_MN39_1 (XI1415_bn5 pp7_14 XI1415_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1415_MN40_1 (XI1415_bsn cm51_2 XI1415_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1415_MN53 (VSS XI1415_bsn cm54_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1415_MN29 (XI1415_bn1 XI1415_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1415_MN30 (XI1415_bcon pp7_14 XI1415_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1415_MN33 (XI1415_bn2 cm51_2 XI1415_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1415_MN31 (VSS XI1415_s1 XI1415_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1415_MN32 (XI1415_bn2 pp7_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1415_MN55 (VSS XI1415_bcon cm54_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1415_MN38 (XI1415_bn4 XI1415_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1415_MN38_1 (VSS XI1415_s1 XI1415_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1415_MN25 (VSS XI1415_asn XI1415_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1415_MN10 (VSS pp4_20 XI1415_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1415_MN6 (XI1415_an3 pp4_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1415_MN9 (XI1415_asn XI1415_acon XI1415_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1415_MN12 (XI1415_an5 pp6_16 XI1415_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1415_MN11 (XI1415_an4 pp5_18 XI1415_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1415_MN11_1 (XI1415_an5 pp5_18 XI1415_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1415_MN12_1 (XI1415_asn pp6_16 XI1415_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1415_MN10_1 (XI1415_an4 pp4_20 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1415_MN5 (XI1415_acon pp6_16 XI1415_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1415_MN2 (XI1415_an1 pp5_18 XI1415_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1415_MN1 (VSS pp4_20 XI1415_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1415_MN3 (XI1415_an2 pp4_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1415_MN4 (VSS pp5_18 XI1415_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1415_MN27 (cm54_2 XI1415_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1415_MN7 (XI1415_an3 pp5_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1415_MN8 (VSS pp6_16 XI1415_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1414_MN34 (XI1414_bn3 XI1414_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1414_MN35 (VSS pp3_22 XI1414_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1414_MN36 (XI1414_bn3 cm50_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1414_MN37 (XI1414_bsn XI1414_bcon XI1414_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1414_MN40 (XI1414_bn5 cm50_2 XI1414_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1414_MN39 (XI1414_bn4 pp3_22 XI1414_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1414_MN39_1 (XI1414_bn5 pp3_22 XI1414_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1414_MN40_1 (XI1414_bsn cm50_2 XI1414_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1414_MN53 (VSS XI1414_bsn cm53_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1414_MN29 (XI1414_bn1 XI1414_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1414_MN30 (XI1414_bcon pp3_22 XI1414_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1414_MN33 (XI1414_bn2 cm50_2 XI1414_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1414_MN31 (VSS XI1414_s1 XI1414_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1414_MN32 (XI1414_bn2 pp3_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1414_MN55 (VSS XI1414_bcon cm53_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1414_MN38 (XI1414_bn4 XI1414_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1414_MN38_1 (VSS XI1414_s1 XI1414_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1414_MN25 (VSS XI1414_asn XI1414_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1414_MN10 (VSS pp0_28 XI1414_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1414_MN6 (XI1414_an3 pp0_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1414_MN9 (XI1414_asn XI1414_acon XI1414_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1414_MN12 (XI1414_an5 pp2_24 XI1414_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1414_MN11 (XI1414_an4 pp1_26 XI1414_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1414_MN11_1 (XI1414_an5 pp1_26 XI1414_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1414_MN12_1 (XI1414_asn pp2_24 XI1414_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1414_MN10_1 (XI1414_an4 pp0_28 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1414_MN5 (XI1414_acon pp2_24 XI1414_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1414_MN2 (XI1414_an1 pp1_26 XI1414_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1414_MN1 (VSS pp0_28 XI1414_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1414_MN3 (XI1414_an2 pp0_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1414_MN4 (VSS pp1_26 XI1414_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1414_MN27 (cm53_2 XI1414_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1414_MN7 (XI1414_an3 pp1_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1414_MN8 (VSS pp2_24 XI1414_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1526_MN34 (XI1526_bn3 XI1526_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1526_MN35 (VSS fa56_1 XI1526_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1526_MN36 (XI1526_bn3 cm163_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1526_MN37 (XI1526_bsn XI1526_bcon XI1526_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1526_MN40 (XI1526_bn5 cm163_2 XI1526_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1526_MN39 (XI1526_bn4 fa56_1 XI1526_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1526_MN39_1 (XI1526_bn5 fa56_1 XI1526_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1526_MN40_1 (XI1526_bsn cm163_2 XI1526_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1526_MN53 (VSS XI1526_bsn cm165_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1526_MN29 (XI1526_bn1 XI1526_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1526_MN30 (XI1526_bcon fa56_1 XI1526_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1526_MN33 (XI1526_bn2 cm163_2 XI1526_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1526_MN31 (VSS XI1526_s1 XI1526_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1526_MN32 (XI1526_bn2 fa56_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1526_MN55 (VSS XI1526_bcon cm165_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1526_MN38 (XI1526_bn4 XI1526_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1526_MN38_1 (VSS XI1526_s1 XI1526_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1526_MN25 (VSS XI1526_asn XI1526_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1526_MN10 (VSS cm53_1 XI1526_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1526_MN6 (XI1526_an3 cm53_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1526_MN9 (XI1526_asn XI1526_acon XI1526_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1526_MN12 (XI1526_an5 cm55_1 XI1526_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1526_MN11 (XI1526_an4 cm54_1 XI1526_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1526_MN11_1 (XI1526_an5 cm54_1 XI1526_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1526_MN12_1 (XI1526_asn cm55_1 XI1526_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1526_MN10_1 (XI1526_an4 cm53_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1526_MN5 (XI1526_acon cm55_1 XI1526_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1526_MN2 (XI1526_an1 cm54_1 XI1526_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1526_MN1 (VSS cm53_1 XI1526_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1526_MN3 (XI1526_an2 cm53_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1526_MN4 (VSS cm54_1 XI1526_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1526_MN27 (cm165_2 XI1526_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1526_MN7 (XI1526_an3 cm54_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1526_MN8 (VSS cm55_1 XI1526_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1525_MN34 (XI1525_bn3 XI1525_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1525_MN35 (VSS B_29_b3_5 XI1525_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1525_MN36 (XI1525_bn3 cm162_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1525_MN37 (XI1525_bsn XI1525_bcon XI1525_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1525_MN40 (XI1525_bn5 cm162_2 XI1525_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1525_MN39 (XI1525_bn4 B_29_b3_5 XI1525_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1525_MN39_1 (XI1525_bn5 B_29_b3_5 XI1525_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1525_MN40_1 (XI1525_bsn cm162_2 XI1525_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1525_MN53 (VSS XI1525_bsn cm164_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1525_MN29 (XI1525_bn1 XI1525_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1525_MN30 (XI1525_bcon B_29_b3_5 XI1525_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1525_MN33 (XI1525_bn2 cm162_2 XI1525_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1525_MN31 (VSS XI1525_s1 XI1525_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1525_MN32 (XI1525_bn2 B_29_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1525_MN55 (VSS XI1525_bcon cm164_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1525_MN38 (XI1525_bn4 XI1525_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1525_MN38_1 (VSS XI1525_s1 XI1525_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1525_MN25 (VSS XI1525_asn XI1525_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1525_MN10 (VSS cm54_0 XI1525_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1525_MN6 (XI1525_an3 cm54_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1525_MN9 (XI1525_asn XI1525_acon XI1525_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1525_MN12 (XI1525_an5 fa56_0 XI1525_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1525_MN11 (XI1525_an4 cm55_0 XI1525_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1525_MN11_1 (XI1525_an5 cm55_0 XI1525_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1525_MN12_1 (XI1525_asn fa56_0 XI1525_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1525_MN10_1 (XI1525_an4 cm54_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1525_MN5 (XI1525_acon fa56_0 XI1525_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1525_MN2 (XI1525_an1 cm55_0 XI1525_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1525_MN1 (VSS cm54_0 XI1525_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1525_MN3 (XI1525_an2 cm54_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1525_MN4 (VSS cm55_0 XI1525_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1525_MN27 (cm164_2 XI1525_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1525_MN7 (XI1525_an3 cm55_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1525_MN8 (VSS fa56_0 XI1525_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1416_MN34 (XI1416_bn3 XI1416_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1416_MN35 (VSS pp11_6 XI1416_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1416_MN36 (XI1416_bn3 cm52_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1416_MN37 (XI1416_bsn XI1416_bcon XI1416_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1416_MN40 (XI1416_bn5 cm52_2 XI1416_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1416_MN39 (XI1416_bn4 pp11_6 XI1416_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1416_MN39_1 (XI1416_bn5 pp11_6 XI1416_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1416_MN40_1 (XI1416_bsn cm52_2 XI1416_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1416_MN53 (VSS XI1416_bsn cm55_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1416_MN29 (XI1416_bn1 XI1416_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1416_MN30 (XI1416_bcon pp11_6 XI1416_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1416_MN33 (XI1416_bn2 cm52_2 XI1416_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1416_MN31 (VSS XI1416_s1 XI1416_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1416_MN32 (XI1416_bn2 pp11_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1416_MN55 (VSS XI1416_bcon cm55_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1416_MN38 (XI1416_bn4 XI1416_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1416_MN38_1 (VSS XI1416_s1 XI1416_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1416_MN25 (VSS XI1416_asn XI1416_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1416_MN10 (VSS pp8_12 XI1416_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1416_MN6 (XI1416_an3 pp8_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1416_MN9 (XI1416_asn XI1416_acon XI1416_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1416_MN12 (XI1416_an5 pp10_8 XI1416_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1416_MN11 (XI1416_an4 pp9_10 XI1416_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1416_MN11_1 (XI1416_an5 pp9_10 XI1416_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1416_MN12_1 (XI1416_asn pp10_8 XI1416_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1416_MN10_1 (XI1416_an4 pp8_12 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1416_MN5 (XI1416_acon pp10_8 XI1416_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1416_MN2 (XI1416_an1 pp9_10 XI1416_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1416_MN1 (VSS pp8_12 XI1416_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1416_MN3 (XI1416_an2 pp8_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1416_MN4 (VSS pp9_10 XI1416_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1416_MN27 (cm55_2 XI1416_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1416_MN7 (XI1416_an3 pp9_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1416_MN8 (VSS pp10_8 XI1416_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1412_MN34 (XI1412_bn3 XI1412_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1412_MN35 (VSS pp7_13 XI1412_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1412_MN36 (XI1412_bn3 cm47_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1412_MN37 (XI1412_bsn XI1412_bcon XI1412_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1412_MN40 (XI1412_bn5 cm47_2 XI1412_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1412_MN39 (XI1412_bn4 pp7_13 XI1412_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1412_MN39_1 (XI1412_bn5 pp7_13 XI1412_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1412_MN40_1 (XI1412_bsn cm47_2 XI1412_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1412_MN53 (VSS XI1412_bsn cm51_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1412_MN29 (XI1412_bn1 XI1412_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1412_MN30 (XI1412_bcon pp7_13 XI1412_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1412_MN33 (XI1412_bn2 cm47_2 XI1412_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1412_MN31 (VSS XI1412_s1 XI1412_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1412_MN32 (XI1412_bn2 pp7_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1412_MN55 (VSS XI1412_bcon cm51_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1412_MN38 (XI1412_bn4 XI1412_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1412_MN38_1 (VSS XI1412_s1 XI1412_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1412_MN25 (VSS XI1412_asn XI1412_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1412_MN10 (VSS pp4_19 XI1412_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1412_MN6 (XI1412_an3 pp4_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1412_MN9 (XI1412_asn XI1412_acon XI1412_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1412_MN12 (XI1412_an5 pp6_15 XI1412_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1412_MN11 (XI1412_an4 pp5_17 XI1412_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1412_MN11_1 (XI1412_an5 pp5_17 XI1412_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1412_MN12_1 (XI1412_asn pp6_15 XI1412_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1412_MN10_1 (XI1412_an4 pp4_19 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1412_MN5 (XI1412_acon pp6_15 XI1412_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1412_MN2 (XI1412_an1 pp5_17 XI1412_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1412_MN1 (VSS pp4_19 XI1412_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1412_MN3 (XI1412_an2 pp4_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1412_MN4 (VSS pp5_17 XI1412_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1412_MN27 (cm51_2 XI1412_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1412_MN7 (XI1412_an3 pp5_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1412_MN8 (VSS pp6_15 XI1412_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1411_MN34 (XI1411_bn3 XI1411_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1411_MN35 (VSS pp3_21 XI1411_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1411_MN36 (XI1411_bn3 cm46_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1411_MN37 (XI1411_bsn XI1411_bcon XI1411_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1411_MN40 (XI1411_bn5 cm46_2 XI1411_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1411_MN39 (XI1411_bn4 pp3_21 XI1411_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1411_MN39_1 (XI1411_bn5 pp3_21 XI1411_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1411_MN40_1 (XI1411_bsn cm46_2 XI1411_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1411_MN53 (VSS XI1411_bsn cm50_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1411_MN29 (XI1411_bn1 XI1411_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1411_MN30 (XI1411_bcon pp3_21 XI1411_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1411_MN33 (XI1411_bn2 cm46_2 XI1411_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1411_MN31 (VSS XI1411_s1 XI1411_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1411_MN32 (XI1411_bn2 pp3_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1411_MN55 (VSS XI1411_bcon cm50_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1411_MN38 (XI1411_bn4 XI1411_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1411_MN38_1 (VSS XI1411_s1 XI1411_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1411_MN25 (VSS XI1411_asn XI1411_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1411_MN10 (VSS pp0_27 XI1411_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1411_MN6 (XI1411_an3 pp0_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1411_MN9 (XI1411_asn XI1411_acon XI1411_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1411_MN12 (XI1411_an5 pp2_23 XI1411_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1411_MN11 (XI1411_an4 pp1_25 XI1411_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1411_MN11_1 (XI1411_an5 pp1_25 XI1411_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1411_MN12_1 (XI1411_asn pp2_23 XI1411_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1411_MN10_1 (XI1411_an4 pp0_27 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1411_MN5 (XI1411_acon pp2_23 XI1411_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1411_MN2 (XI1411_an1 pp1_25 XI1411_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1411_MN1 (VSS pp0_27 XI1411_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1411_MN3 (XI1411_an2 pp0_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1411_MN4 (VSS pp1_25 XI1411_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1411_MN27 (cm50_2 XI1411_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1411_MN7 (XI1411_an3 pp1_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1411_MN8 (VSS pp2_23 XI1411_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1584_MN34 (XI1584_bn3 XI1584_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1584_MN35 (VSS cm166_0 XI1584_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1584_MN36 (XI1584_bn3 cm222_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1584_MN37 (XI1584_bsn XI1584_bcon XI1584_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1584_MN40 (XI1584_bn5 cm222_2 XI1584_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1584_MN39 (XI1584_bn4 cm166_0 XI1584_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1584_MN39_1 (XI1584_bn5 cm166_0 XI1584_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1584_MN40_1 (XI1584_bsn cm222_2 XI1584_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1584_MN53 (VSS XI1584_bsn cm223_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1584_MN29 (XI1584_bn1 XI1584_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1584_MN30 (XI1584_bcon cm166_0 XI1584_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1584_MN33 (XI1584_bn2 cm222_2 XI1584_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1584_MN31 (VSS XI1584_s1 XI1584_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1584_MN32 (XI1584_bn2 cm166_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1584_MN55 (VSS XI1584_bcon cm223_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1584_MN38 (XI1584_bn4 XI1584_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1584_MN38_1 (VSS XI1584_s1 XI1584_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1584_MN25 (VSS XI1584_asn XI1584_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1584_MN10 (VSS cm163_1 XI1584_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1584_MN6 (XI1584_an3 cm163_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1584_MN9 (XI1584_asn XI1584_acon XI1584_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1584_MN12 (XI1584_an5 cm165_0 XI1584_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1584_MN11 (XI1584_an4 cm164_1 XI1584_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1584_MN11_1 (XI1584_an5 cm164_1 XI1584_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1584_MN12_1 (XI1584_asn cm165_0 XI1584_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1584_MN10_1 (XI1584_an4 cm163_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1584_MN5 (XI1584_acon cm165_0 XI1584_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1584_MN2 (XI1584_an1 cm164_1 XI1584_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1584_MN1 (VSS cm163_1 XI1584_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1584_MN3 (XI1584_an2 cm163_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1584_MN4 (VSS cm164_1 XI1584_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1584_MN27 (cm223_2 XI1584_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1584_MN7 (XI1584_an3 cm164_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1584_MN8 (VSS cm165_0 XI1584_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1524_MN34 (XI1524_bn3 XI1524_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1524_MN35 (VSS cm53_0 XI1524_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1524_MN36 (XI1524_bn3 cm161_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1524_MN37 (XI1524_bsn XI1524_bcon XI1524_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1524_MN40 (XI1524_bn5 cm161_2 XI1524_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1524_MN39 (XI1524_bn4 cm53_0 XI1524_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1524_MN39_1 (XI1524_bn5 cm53_0 XI1524_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1524_MN40_1 (XI1524_bsn cm161_2 XI1524_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1524_MN53 (VSS XI1524_bsn cm163_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1524_MN29 (XI1524_bn1 XI1524_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1524_MN30 (XI1524_bcon cm53_0 XI1524_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1524_MN33 (XI1524_bn2 cm161_2 XI1524_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1524_MN31 (VSS XI1524_s1 XI1524_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1524_MN32 (XI1524_bn2 cm53_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1524_MN55 (VSS XI1524_bcon cm163_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1524_MN38 (XI1524_bn4 XI1524_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1524_MN38_1 (VSS XI1524_s1 XI1524_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1524_MN25 (VSS XI1524_asn XI1524_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1524_MN10 (VSS cm50_1 XI1524_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1524_MN6 (XI1524_an3 cm50_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1524_MN9 (XI1524_asn XI1524_acon XI1524_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1524_MN12 (XI1524_an5 cm52_1 XI1524_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1524_MN11 (XI1524_an4 cm51_1 XI1524_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1524_MN11_1 (XI1524_an5 cm51_1 XI1524_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1524_MN12_1 (XI1524_asn cm52_1 XI1524_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1524_MN10_1 (XI1524_an4 cm50_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1524_MN5 (XI1524_acon cm52_1 XI1524_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1524_MN2 (XI1524_an1 cm51_1 XI1524_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1524_MN1 (VSS cm50_1 XI1524_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1524_MN3 (XI1524_an2 cm50_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1524_MN4 (VSS cm51_1 XI1524_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1524_MN27 (cm163_2 XI1524_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1524_MN7 (XI1524_an3 cm51_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1524_MN8 (VSS cm52_1 XI1524_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1413_MN34 (XI1413_bn3 XI1413_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1413_MN35 (VSS pp11_5 XI1413_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1413_MN36 (XI1413_bn3 cm48_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1413_MN37 (XI1413_bsn XI1413_bcon XI1413_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1413_MN40 (XI1413_bn5 cm48_2 XI1413_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1413_MN39 (XI1413_bn4 pp11_5 XI1413_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1413_MN39_1 (XI1413_bn5 pp11_5 XI1413_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1413_MN40_1 (XI1413_bsn cm48_2 XI1413_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1413_MN53 (VSS XI1413_bsn cm52_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1413_MN29 (XI1413_bn1 XI1413_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1413_MN30 (XI1413_bcon pp11_5 XI1413_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1413_MN33 (XI1413_bn2 cm48_2 XI1413_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1413_MN31 (VSS XI1413_s1 XI1413_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1413_MN32 (XI1413_bn2 pp11_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1413_MN55 (VSS XI1413_bcon cm52_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1413_MN38 (XI1413_bn4 XI1413_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1413_MN38_1 (VSS XI1413_s1 XI1413_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1413_MN25 (VSS XI1413_asn XI1413_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1413_MN10 (VSS pp8_11 XI1413_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1413_MN6 (XI1413_an3 pp8_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1413_MN9 (XI1413_asn XI1413_acon XI1413_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1413_MN12 (XI1413_an5 pp10_7 XI1413_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1413_MN11 (XI1413_an4 pp9_9 XI1413_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1413_MN11_1 (XI1413_an5 pp9_9 XI1413_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1413_MN12_1 (XI1413_asn pp10_7 XI1413_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1413_MN10_1 (XI1413_an4 pp8_11 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1413_MN5 (XI1413_acon pp10_7 XI1413_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1413_MN2 (XI1413_an1 pp9_9 XI1413_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1413_MN1 (VSS pp8_11 XI1413_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1413_MN3 (XI1413_an2 pp8_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1413_MN4 (VSS pp9_9 XI1413_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1413_MN27 (cm52_2 XI1413_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1413_MN7 (XI1413_an3 pp9_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1413_MN8 (VSS pp10_7 XI1413_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1407_MN34 (XI1407_bn3 XI1407_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1407_MN35 (VSS pp3_20 XI1407_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1407_MN36 (XI1407_bn3 cm43_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1407_MN37 (XI1407_bsn XI1407_bcon XI1407_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1407_MN40 (XI1407_bn5 cm43_2 XI1407_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1407_MN39 (XI1407_bn4 pp3_20 XI1407_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1407_MN39_1 (XI1407_bn5 pp3_20 XI1407_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1407_MN40_1 (XI1407_bsn cm43_2 XI1407_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1407_MN53 (VSS XI1407_bsn cm46_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1407_MN29 (XI1407_bn1 XI1407_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1407_MN30 (XI1407_bcon pp3_20 XI1407_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1407_MN33 (XI1407_bn2 cm43_2 XI1407_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1407_MN31 (VSS XI1407_s1 XI1407_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1407_MN32 (XI1407_bn2 pp3_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1407_MN55 (VSS XI1407_bcon cm46_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1407_MN38 (XI1407_bn4 XI1407_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1407_MN38_1 (VSS XI1407_s1 XI1407_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1407_MN25 (VSS XI1407_asn XI1407_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1407_MN10 (VSS pp0_26 XI1407_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1407_MN6 (XI1407_an3 pp0_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1407_MN9 (XI1407_asn XI1407_acon XI1407_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1407_MN12 (XI1407_an5 pp2_22 XI1407_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1407_MN11 (XI1407_an4 pp1_24 XI1407_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1407_MN11_1 (XI1407_an5 pp1_24 XI1407_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1407_MN12_1 (XI1407_asn pp2_22 XI1407_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1407_MN10_1 (XI1407_an4 pp0_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1407_MN5 (XI1407_acon pp2_22 XI1407_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1407_MN2 (XI1407_an1 pp1_24 XI1407_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1407_MN1 (VSS pp0_26 XI1407_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1407_MN3 (XI1407_an2 pp0_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1407_MN4 (VSS pp1_24 XI1407_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1407_MN27 (cm46_2 XI1407_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1407_MN7 (XI1407_an3 pp1_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1407_MN8 (VSS pp2_22 XI1407_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1523_MN34 (XI1523_bn3 XI1523_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1523_MN35 (VSS pp12_3 XI1523_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1523_MN36 (XI1523_bn3 pp13_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1523_MN37 (XI1523_bsn XI1523_bcon XI1523_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1523_MN40 (XI1523_bn5 pp13_1 XI1523_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1523_MN39 (XI1523_bn4 pp12_3 XI1523_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1523_MN39_1 (XI1523_bn5 pp12_3 XI1523_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1523_MN40_1 (XI1523_bsn pp13_1 XI1523_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1523_MN53 (VSS XI1523_bsn cm162_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1523_MN29 (XI1523_bn1 XI1523_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1523_MN30 (XI1523_bcon pp12_3 XI1523_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1523_MN33 (XI1523_bn2 pp13_1 XI1523_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1523_MN31 (VSS XI1523_s1 XI1523_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1523_MN32 (XI1523_bn2 pp12_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1523_MN55 (VSS XI1523_bcon cm162_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1523_MN38 (XI1523_bn4 XI1523_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1523_MN38_1 (VSS XI1523_s1 XI1523_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1523_MN25 (VSS XI1523_asn XI1523_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1523_MN10 (VSS cm50_0 XI1523_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1523_MN6 (XI1523_an3 cm50_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1523_MN9 (XI1523_asn XI1523_acon XI1523_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1523_MN12 (XI1523_an5 cm52_0 XI1523_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1523_MN11 (XI1523_an4 cm51_0 XI1523_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1523_MN11_1 (XI1523_an5 cm51_0 XI1523_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1523_MN12_1 (XI1523_asn cm52_0 XI1523_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1523_MN10_1 (XI1523_an4 cm50_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1523_MN5 (XI1523_acon cm52_0 XI1523_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1523_MN2 (XI1523_an1 cm51_0 XI1523_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1523_MN1 (VSS cm50_0 XI1523_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1523_MN3 (XI1523_an2 cm50_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1523_MN4 (VSS cm51_0 XI1523_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1523_MN27 (cm162_2 XI1523_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1523_MN7 (XI1523_an3 cm51_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1523_MN8 (VSS cm52_0 XI1523_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1583_MN34 (XI1583_bn3 XI1583_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1583_MN35 (VSS cm164_0 XI1583_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1583_MN36 (XI1583_bn3 cm221_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1583_MN37 (XI1583_bsn XI1583_bcon XI1583_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1583_MN40 (XI1583_bn5 cm221_2 XI1583_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1583_MN39 (XI1583_bn4 cm164_0 XI1583_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1583_MN39_1 (XI1583_bn5 cm164_0 XI1583_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1583_MN40_1 (XI1583_bsn cm221_2 XI1583_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1583_MN53 (VSS XI1583_bsn cm222_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1583_MN29 (XI1583_bn1 XI1583_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1583_MN30 (XI1583_bcon cm164_0 XI1583_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1583_MN33 (XI1583_bn2 cm221_2 XI1583_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1583_MN31 (VSS XI1583_s1 XI1583_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1583_MN32 (XI1583_bn2 cm164_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1583_MN55 (VSS XI1583_bcon cm222_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1583_MN38 (XI1583_bn4 XI1583_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1583_MN38_1 (VSS XI1583_s1 XI1583_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1583_MN25 (VSS XI1583_asn XI1583_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1583_MN10 (VSS cm161_1 XI1583_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1583_MN6 (XI1583_an3 cm161_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1583_MN9 (XI1583_asn XI1583_acon XI1583_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1583_MN12 (XI1583_an5 cm163_0 XI1583_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1583_MN11 (XI1583_an4 cm162_1 XI1583_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1583_MN11_1 (XI1583_an5 cm162_1 XI1583_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1583_MN12_1 (XI1583_asn cm163_0 XI1583_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1583_MN10_1 (XI1583_an4 cm161_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1583_MN5 (XI1583_acon cm163_0 XI1583_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1583_MN2 (XI1583_an1 cm162_1 XI1583_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1583_MN1 (VSS cm161_1 XI1583_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1583_MN3 (XI1583_an2 cm161_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1583_MN4 (VSS cm162_1 XI1583_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1583_MN27 (cm222_2 XI1583_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1583_MN7 (XI1583_an3 cm162_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1583_MN8 (VSS cm163_0 XI1583_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1409_MN34 (XI1409_bn3 XI1409_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1409_MN35 (VSS pp11_4 XI1409_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1409_MN36 (XI1409_bn3 cm45_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1409_MN37 (XI1409_bsn XI1409_bcon XI1409_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1409_MN40 (XI1409_bn5 cm45_2 XI1409_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1409_MN39 (XI1409_bn4 pp11_4 XI1409_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1409_MN39_1 (XI1409_bn5 pp11_4 XI1409_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1409_MN40_1 (XI1409_bsn cm45_2 XI1409_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1409_MN53 (VSS XI1409_bsn cm48_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1409_MN29 (XI1409_bn1 XI1409_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1409_MN30 (XI1409_bcon pp11_4 XI1409_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1409_MN33 (XI1409_bn2 cm45_2 XI1409_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1409_MN31 (VSS XI1409_s1 XI1409_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1409_MN32 (XI1409_bn2 pp11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1409_MN55 (VSS XI1409_bcon cm48_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1409_MN38 (XI1409_bn4 XI1409_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1409_MN38_1 (VSS XI1409_s1 XI1409_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1409_MN25 (VSS XI1409_asn XI1409_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1409_MN10 (VSS pp8_10 XI1409_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1409_MN6 (XI1409_an3 pp8_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1409_MN9 (XI1409_asn XI1409_acon XI1409_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1409_MN12 (XI1409_an5 pp10_6 XI1409_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1409_MN11 (XI1409_an4 pp9_8 XI1409_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1409_MN11_1 (XI1409_an5 pp9_8 XI1409_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1409_MN12_1 (XI1409_asn pp10_6 XI1409_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1409_MN10_1 (XI1409_an4 pp8_10 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1409_MN5 (XI1409_acon pp10_6 XI1409_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1409_MN2 (XI1409_an1 pp9_8 XI1409_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1409_MN1 (VSS pp8_10 XI1409_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1409_MN3 (XI1409_an2 pp8_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1409_MN4 (VSS pp9_8 XI1409_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1409_MN27 (cm48_2 XI1409_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1409_MN7 (XI1409_an3 pp9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1409_MN8 (VSS pp10_6 XI1409_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1408_MN34 (XI1408_bn3 XI1408_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1408_MN35 (VSS pp7_12 XI1408_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1408_MN36 (XI1408_bn3 cm44_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1408_MN37 (XI1408_bsn XI1408_bcon XI1408_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1408_MN40 (XI1408_bn5 cm44_2 XI1408_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1408_MN39 (XI1408_bn4 pp7_12 XI1408_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1408_MN39_1 (XI1408_bn5 pp7_12 XI1408_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1408_MN40_1 (XI1408_bsn cm44_2 XI1408_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1408_MN53 (VSS XI1408_bsn cm47_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1408_MN29 (XI1408_bn1 XI1408_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1408_MN30 (XI1408_bcon pp7_12 XI1408_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1408_MN33 (XI1408_bn2 cm44_2 XI1408_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1408_MN31 (VSS XI1408_s1 XI1408_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1408_MN32 (XI1408_bn2 pp7_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1408_MN55 (VSS XI1408_bcon cm47_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1408_MN38 (XI1408_bn4 XI1408_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1408_MN38_1 (VSS XI1408_s1 XI1408_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1408_MN25 (VSS XI1408_asn XI1408_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1408_MN10 (VSS pp4_18 XI1408_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1408_MN6 (XI1408_an3 pp4_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1408_MN9 (XI1408_asn XI1408_acon XI1408_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1408_MN12 (XI1408_an5 pp6_14 XI1408_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1408_MN11 (XI1408_an4 pp5_16 XI1408_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1408_MN11_1 (XI1408_an5 pp5_16 XI1408_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1408_MN12_1 (XI1408_asn pp6_14 XI1408_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1408_MN10_1 (XI1408_an4 pp4_18 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1408_MN5 (XI1408_acon pp6_14 XI1408_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1408_MN2 (XI1408_an1 pp5_16 XI1408_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1408_MN1 (VSS pp4_18 XI1408_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1408_MN3 (XI1408_an2 pp4_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1408_MN4 (VSS pp5_16 XI1408_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1408_MN27 (cm47_2 XI1408_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1408_MN7 (XI1408_an3 pp5_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1408_MN8 (VSS pp6_14 XI1408_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1405_MN34 (XI1405_bn3 XI1405_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1405_MN35 (VSS pp7_11 XI1405_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1405_MN36 (XI1405_bn3 cm41_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1405_MN37 (XI1405_bsn XI1405_bcon XI1405_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1405_MN40 (XI1405_bn5 cm41_2 XI1405_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1405_MN39 (XI1405_bn4 pp7_11 XI1405_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1405_MN39_1 (XI1405_bn5 pp7_11 XI1405_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1405_MN40_1 (XI1405_bsn cm41_2 XI1405_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1405_MN53 (VSS XI1405_bsn cm44_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1405_MN29 (XI1405_bn1 XI1405_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1405_MN30 (XI1405_bcon pp7_11 XI1405_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1405_MN33 (XI1405_bn2 cm41_2 XI1405_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1405_MN31 (VSS XI1405_s1 XI1405_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1405_MN32 (XI1405_bn2 pp7_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1405_MN55 (VSS XI1405_bcon cm44_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1405_MN38 (XI1405_bn4 XI1405_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1405_MN38_1 (VSS XI1405_s1 XI1405_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1405_MN25 (VSS XI1405_asn XI1405_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1405_MN10 (VSS pp4_17 XI1405_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1405_MN6 (XI1405_an3 pp4_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1405_MN9 (XI1405_asn XI1405_acon XI1405_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1405_MN12 (XI1405_an5 pp6_13 XI1405_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1405_MN11 (XI1405_an4 pp5_15 XI1405_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1405_MN11_1 (XI1405_an5 pp5_15 XI1405_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1405_MN12_1 (XI1405_asn pp6_13 XI1405_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1405_MN10_1 (XI1405_an4 pp4_17 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1405_MN5 (XI1405_acon pp6_13 XI1405_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1405_MN2 (XI1405_an1 pp5_15 XI1405_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1405_MN1 (VSS pp4_17 XI1405_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1405_MN3 (XI1405_an2 pp4_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1405_MN4 (VSS pp5_15 XI1405_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1405_MN27 (cm44_2 XI1405_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1405_MN7 (XI1405_an3 pp5_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1405_MN8 (VSS pp6_13 XI1405_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1520_MN34 (XI1520_bn3 XI1520_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1520_MN35 (VSS cm46_0 XI1520_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1520_MN36 (XI1520_bn3 cm157_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1520_MN37 (XI1520_bsn XI1520_bcon XI1520_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1520_MN40 (XI1520_bn5 cm157_2 XI1520_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1520_MN39 (XI1520_bn4 cm46_0 XI1520_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1520_MN39_1 (XI1520_bn5 cm46_0 XI1520_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1520_MN40_1 (XI1520_bsn cm157_2 XI1520_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1520_MN53 (VSS XI1520_bsn cm159_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1520_MN29 (XI1520_bn1 XI1520_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1520_MN30 (XI1520_bcon cm46_0 XI1520_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1520_MN33 (XI1520_bn2 cm157_2 XI1520_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1520_MN31 (VSS XI1520_s1 XI1520_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1520_MN32 (XI1520_bn2 cm46_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1520_MN55 (VSS XI1520_bcon cm159_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1520_MN38 (XI1520_bn4 XI1520_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1520_MN38_1 (VSS XI1520_s1 XI1520_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1520_MN25 (VSS XI1520_asn XI1520_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1520_MN10 (VSS cm43_1 XI1520_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1520_MN6 (XI1520_an3 cm43_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1520_MN9 (XI1520_asn XI1520_acon XI1520_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1520_MN12 (XI1520_an5 cm45_1 XI1520_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1520_MN11 (XI1520_an4 cm44_1 XI1520_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1520_MN11_1 (XI1520_an5 cm44_1 XI1520_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1520_MN12_1 (XI1520_asn cm45_1 XI1520_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1520_MN10_1 (XI1520_an4 cm43_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1520_MN5 (XI1520_acon cm45_1 XI1520_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1520_MN2 (XI1520_an1 cm44_1 XI1520_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1520_MN1 (VSS cm43_1 XI1520_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1520_MN3 (XI1520_an2 cm43_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1520_MN4 (VSS cm44_1 XI1520_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1520_MN27 (cm159_2 XI1520_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1520_MN7 (XI1520_an3 cm44_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1520_MN8 (VSS cm45_1 XI1520_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1522_MN34 (XI1522_bn3 XI1522_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1522_MN35 (VSS fa49_1 XI1522_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1522_MN36 (XI1522_bn3 cm159_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1522_MN37 (XI1522_bsn XI1522_bcon XI1522_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1522_MN40 (XI1522_bn5 cm159_2 XI1522_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1522_MN39 (XI1522_bn4 fa49_1 XI1522_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1522_MN39_1 (XI1522_bn5 fa49_1 XI1522_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1522_MN40_1 (XI1522_bsn cm159_2 XI1522_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1522_MN53 (VSS XI1522_bsn cm161_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1522_MN29 (XI1522_bn1 XI1522_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1522_MN30 (XI1522_bcon fa49_1 XI1522_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1522_MN33 (XI1522_bn2 cm159_2 XI1522_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1522_MN31 (VSS XI1522_s1 XI1522_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1522_MN32 (XI1522_bn2 fa49_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1522_MN55 (VSS XI1522_bcon cm161_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1522_MN38 (XI1522_bn4 XI1522_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1522_MN38_1 (VSS XI1522_s1 XI1522_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1522_MN25 (VSS XI1522_asn XI1522_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1522_MN10 (VSS cm46_1 XI1522_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1522_MN6 (XI1522_an3 cm46_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1522_MN9 (XI1522_asn XI1522_acon XI1522_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1522_MN12 (XI1522_an5 cm48_1 XI1522_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1522_MN11 (XI1522_an4 cm47_1 XI1522_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1522_MN11_1 (XI1522_an5 cm47_1 XI1522_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1522_MN12_1 (XI1522_asn cm48_1 XI1522_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1522_MN10_1 (XI1522_an4 cm46_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1522_MN5 (XI1522_acon cm48_1 XI1522_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1522_MN2 (XI1522_an1 cm47_1 XI1522_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1522_MN1 (VSS cm46_1 XI1522_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1522_MN3 (XI1522_an2 cm46_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1522_MN4 (VSS cm47_1 XI1522_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1522_MN27 (cm161_2 XI1522_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1522_MN7 (XI1522_an3 cm47_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1522_MN8 (VSS cm48_1 XI1522_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1404_MN34 (XI1404_bn3 XI1404_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1404_MN35 (VSS pp3_19 XI1404_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1404_MN36 (XI1404_bn3 cm40_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1404_MN37 (XI1404_bsn XI1404_bcon XI1404_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1404_MN40 (XI1404_bn5 cm40_2 XI1404_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1404_MN39 (XI1404_bn4 pp3_19 XI1404_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1404_MN39_1 (XI1404_bn5 pp3_19 XI1404_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1404_MN40_1 (XI1404_bsn cm40_2 XI1404_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1404_MN53 (VSS XI1404_bsn cm43_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1404_MN29 (XI1404_bn1 XI1404_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1404_MN30 (XI1404_bcon pp3_19 XI1404_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1404_MN33 (XI1404_bn2 cm40_2 XI1404_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1404_MN31 (VSS XI1404_s1 XI1404_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1404_MN32 (XI1404_bn2 pp3_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1404_MN55 (VSS XI1404_bcon cm43_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1404_MN38 (XI1404_bn4 XI1404_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1404_MN38_1 (VSS XI1404_s1 XI1404_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1404_MN25 (VSS XI1404_asn XI1404_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1404_MN10 (VSS pp0_25 XI1404_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1404_MN6 (XI1404_an3 pp0_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1404_MN9 (XI1404_asn XI1404_acon XI1404_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1404_MN12 (XI1404_an5 pp2_21 XI1404_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1404_MN11 (XI1404_an4 pp1_23 XI1404_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1404_MN11_1 (XI1404_an5 pp1_23 XI1404_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1404_MN12_1 (XI1404_asn pp2_21 XI1404_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1404_MN10_1 (XI1404_an4 pp0_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1404_MN5 (XI1404_acon pp2_21 XI1404_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1404_MN2 (XI1404_an1 pp1_23 XI1404_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1404_MN1 (VSS pp0_25 XI1404_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1404_MN3 (XI1404_an2 pp0_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1404_MN4 (VSS pp1_23 XI1404_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1404_MN27 (cm43_2 XI1404_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1404_MN7 (XI1404_an3 pp1_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1404_MN8 (VSS pp2_21 XI1404_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1582_MN34 (XI1582_bn3 XI1582_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1582_MN35 (VSS cm162_0 XI1582_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1582_MN36 (XI1582_bn3 cm220_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1582_MN37 (XI1582_bsn XI1582_bcon XI1582_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1582_MN40 (XI1582_bn5 cm220_2 XI1582_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1582_MN39 (XI1582_bn4 cm162_0 XI1582_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1582_MN39_1 (XI1582_bn5 cm162_0 XI1582_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1582_MN40_1 (XI1582_bsn cm220_2 XI1582_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1582_MN53 (VSS XI1582_bsn cm221_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1582_MN29 (XI1582_bn1 XI1582_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1582_MN30 (XI1582_bcon cm162_0 XI1582_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1582_MN33 (XI1582_bn2 cm220_2 XI1582_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1582_MN31 (VSS XI1582_s1 XI1582_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1582_MN32 (XI1582_bn2 cm162_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1582_MN55 (VSS XI1582_bcon cm221_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1582_MN38 (XI1582_bn4 XI1582_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1582_MN38_1 (VSS XI1582_s1 XI1582_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1582_MN25 (VSS XI1582_asn XI1582_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1582_MN10 (VSS cm159_1 XI1582_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1582_MN6 (XI1582_an3 cm159_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1582_MN9 (XI1582_asn XI1582_acon XI1582_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1582_MN12 (XI1582_an5 cm161_0 XI1582_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1582_MN11 (XI1582_an4 fa160_1 XI1582_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1582_MN11_1 (XI1582_an5 fa160_1 XI1582_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1582_MN12_1 (XI1582_asn cm161_0 XI1582_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1582_MN10_1 (XI1582_an4 cm159_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1582_MN5 (XI1582_acon cm161_0 XI1582_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1582_MN2 (XI1582_an1 fa160_1 XI1582_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1582_MN1 (VSS cm159_1 XI1582_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1582_MN3 (XI1582_an2 cm159_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1582_MN4 (VSS fa160_1 XI1582_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1582_MN27 (cm221_2 XI1582_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1582_MN7 (XI1582_an3 fa160_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1582_MN8 (VSS cm161_0 XI1582_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1406_MN34 (XI1406_bn3 XI1406_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1406_MN35 (VSS pp11_3 XI1406_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1406_MN36 (XI1406_bn3 cm42_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1406_MN37 (XI1406_bsn XI1406_bcon XI1406_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1406_MN40 (XI1406_bn5 cm42_2 XI1406_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1406_MN39 (XI1406_bn4 pp11_3 XI1406_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1406_MN39_1 (XI1406_bn5 pp11_3 XI1406_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1406_MN40_1 (XI1406_bsn cm42_2 XI1406_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1406_MN53 (VSS XI1406_bsn cm45_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1406_MN29 (XI1406_bn1 XI1406_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1406_MN30 (XI1406_bcon pp11_3 XI1406_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1406_MN33 (XI1406_bn2 cm42_2 XI1406_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1406_MN31 (VSS XI1406_s1 XI1406_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1406_MN32 (XI1406_bn2 pp11_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1406_MN55 (VSS XI1406_bcon cm45_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1406_MN38 (XI1406_bn4 XI1406_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1406_MN38_1 (VSS XI1406_s1 XI1406_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1406_MN25 (VSS XI1406_asn XI1406_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1406_MN10 (VSS pp8_9 XI1406_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1406_MN6 (XI1406_an3 pp8_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1406_MN9 (XI1406_asn XI1406_acon XI1406_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1406_MN12 (XI1406_an5 pp10_5 XI1406_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1406_MN11 (XI1406_an4 pp9_7 XI1406_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1406_MN11_1 (XI1406_an5 pp9_7 XI1406_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1406_MN12_1 (XI1406_asn pp10_5 XI1406_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1406_MN10_1 (XI1406_an4 pp8_9 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1406_MN5 (XI1406_acon pp10_5 XI1406_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1406_MN2 (XI1406_an1 pp9_7 XI1406_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1406_MN1 (VSS pp8_9 XI1406_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1406_MN3 (XI1406_an2 pp8_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1406_MN4 (VSS pp9_7 XI1406_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1406_MN27 (cm45_2 XI1406_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1406_MN7 (XI1406_an3 pp9_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1406_MN8 (VSS pp10_5 XI1406_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1402_MN34 (XI1402_bn3 XI1402_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1402_MN35 (VSS pp7_10 XI1402_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1402_MN36 (XI1402_bn3 cm38_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1402_MN37 (XI1402_bsn XI1402_bcon XI1402_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1402_MN40 (XI1402_bn5 cm38_2 XI1402_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1402_MN39 (XI1402_bn4 pp7_10 XI1402_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1402_MN39_1 (XI1402_bn5 pp7_10 XI1402_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1402_MN40_1 (XI1402_bsn cm38_2 XI1402_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1402_MN53 (VSS XI1402_bsn cm41_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1402_MN29 (XI1402_bn1 XI1402_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1402_MN30 (XI1402_bcon pp7_10 XI1402_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1402_MN33 (XI1402_bn2 cm38_2 XI1402_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1402_MN31 (VSS XI1402_s1 XI1402_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1402_MN32 (XI1402_bn2 pp7_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1402_MN55 (VSS XI1402_bcon cm41_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1402_MN38 (XI1402_bn4 XI1402_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1402_MN38_1 (VSS XI1402_s1 XI1402_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1402_MN25 (VSS XI1402_asn XI1402_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1402_MN10 (VSS pp4_16 XI1402_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1402_MN6 (XI1402_an3 pp4_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1402_MN9 (XI1402_asn XI1402_acon XI1402_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1402_MN12 (XI1402_an5 pp6_12 XI1402_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1402_MN11 (XI1402_an4 pp5_14 XI1402_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1402_MN11_1 (XI1402_an5 pp5_14 XI1402_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1402_MN12_1 (XI1402_asn pp6_12 XI1402_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1402_MN10_1 (XI1402_an4 pp4_16 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1402_MN5 (XI1402_acon pp6_12 XI1402_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1402_MN2 (XI1402_an1 pp5_14 XI1402_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1402_MN1 (VSS pp4_16 XI1402_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1402_MN3 (XI1402_an2 pp4_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1402_MN4 (VSS pp5_14 XI1402_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1402_MN27 (cm41_2 XI1402_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1402_MN7 (XI1402_an3 pp5_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1402_MN8 (VSS pp6_12 XI1402_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1398_MN34 (XI1398_bn3 XI1398_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1398_MN35 (VSS pp3_17 XI1398_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1398_MN36 (XI1398_bn3 cm34_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1398_MN37 (XI1398_bsn XI1398_bcon XI1398_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1398_MN40 (XI1398_bn5 cm34_2 XI1398_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1398_MN39 (XI1398_bn4 pp3_17 XI1398_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1398_MN39_1 (XI1398_bn5 pp3_17 XI1398_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1398_MN40_1 (XI1398_bsn cm34_2 XI1398_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1398_MN53 (VSS XI1398_bsn cm37_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1398_MN29 (XI1398_bn1 XI1398_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1398_MN30 (XI1398_bcon pp3_17 XI1398_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1398_MN33 (XI1398_bn2 cm34_2 XI1398_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1398_MN31 (VSS XI1398_s1 XI1398_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1398_MN32 (XI1398_bn2 pp3_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1398_MN55 (VSS XI1398_bcon cm37_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1398_MN38 (XI1398_bn4 XI1398_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1398_MN38_1 (VSS XI1398_s1 XI1398_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1398_MN25 (VSS XI1398_asn XI1398_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1398_MN10 (VSS pp0_23 XI1398_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1398_MN6 (XI1398_an3 pp0_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1398_MN9 (XI1398_asn XI1398_acon XI1398_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1398_MN12 (XI1398_an5 pp2_19 XI1398_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1398_MN11 (XI1398_an4 pp1_21 XI1398_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1398_MN11_1 (XI1398_an5 pp1_21 XI1398_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1398_MN12_1 (XI1398_asn pp2_19 XI1398_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1398_MN10_1 (XI1398_an4 pp0_23 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1398_MN5 (XI1398_acon pp2_19 XI1398_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1398_MN2 (XI1398_an1 pp1_21 XI1398_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1398_MN1 (VSS pp0_23 XI1398_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1398_MN3 (XI1398_an2 pp0_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1398_MN4 (VSS pp1_21 XI1398_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1398_MN27 (cm37_2 XI1398_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1398_MN7 (XI1398_an3 pp1_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1398_MN8 (VSS pp2_19 XI1398_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1401_MN34 (XI1401_bn3 XI1401_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1401_MN35 (VSS pp3_18 XI1401_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1401_MN36 (XI1401_bn3 cm37_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1401_MN37 (XI1401_bsn XI1401_bcon XI1401_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1401_MN40 (XI1401_bn5 cm37_2 XI1401_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1401_MN39 (XI1401_bn4 pp3_18 XI1401_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1401_MN39_1 (XI1401_bn5 pp3_18 XI1401_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1401_MN40_1 (XI1401_bsn cm37_2 XI1401_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1401_MN53 (VSS XI1401_bsn cm40_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1401_MN29 (XI1401_bn1 XI1401_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1401_MN30 (XI1401_bcon pp3_18 XI1401_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1401_MN33 (XI1401_bn2 cm37_2 XI1401_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1401_MN31 (VSS XI1401_s1 XI1401_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1401_MN32 (XI1401_bn2 pp3_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1401_MN55 (VSS XI1401_bcon cm40_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1401_MN38 (XI1401_bn4 XI1401_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21998u ps=0.67998u
    I_MXI1401_MN38_1 (VSS XI1401_s1 XI1401_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67998u ps=1.21998u
    I_MXI1401_MN25 (VSS XI1401_asn XI1401_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1401_MN10 (VSS pp0_24 XI1401_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1401_MN6 (XI1401_an3 pp0_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1401_MN9 (XI1401_asn XI1401_acon XI1401_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1401_MN12 (XI1401_an5 pp2_20 XI1401_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1401_MN11 (XI1401_an4 pp1_22 XI1401_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75998u ps=0.67998u
    I_MXI1401_MN11_1 (XI1401_an5 pp1_22 XI1401_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67998u ps=1.75998u
    I_MXI1401_MN12_1 (XI1401_asn pp2_20 XI1401_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1401_MN10_1 (XI1401_an4 pp0_24 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1401_MN5 (XI1401_acon pp2_20 XI1401_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1401_MN2 (XI1401_an1 pp1_22 XI1401_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1401_MN1 (VSS pp0_24 XI1401_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1401_MN3 (XI1401_an2 pp0_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1401_MN4 (VSS pp1_22 XI1401_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1401_MN27 (cm40_2 XI1401_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1401_MN7 (XI1401_an3 pp1_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67998u ps=1.15998u
    I_MXI1401_MN8 (VSS pp2_20 XI1401_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1518_MN34 (XI1518_bn3 XI1518_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1518_MN35 (VSS cm43_0 XI1518_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1518_MN36 (XI1518_bn3 cm155_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1518_MN37 (XI1518_bsn XI1518_bcon XI1518_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1518_MN40 (XI1518_bn5 cm155_2 XI1518_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67998u ps=0.67998u
    I_MXI1518_MN39 (XI1518_bn4 cm43_0 XI1518_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1518_MN39_1 (XI1518_bn5 cm43_0 XI1518_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1518_MN40_1 (XI1518_bsn cm155_2 XI1518_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15998u ps=0.67998u
    I_MXI1518_MN53 (VSS XI1518_bsn cm157_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15998u ps=1.15998u
    I_MXI1518_MN29 (XI1518_bn1 XI1518_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67998u ps=0.67998u
    I_MXI1518_MN30 (XI1518_bcon cm43_0 XI1518_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1518_MN33 (XI1518_bn2 cm155_2 XI1518_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1518_MN31 (VSS XI1518_s1 XI1518_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67998u ps=0.67998u
    I_MXI1518_MN32 (XI1518_bn2 cm43_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15998u ps=0.67998u
    I_MXI1518_MN55 (VSS XI1518_bcon cm157_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67998u ps=1.15998u
    I_MXI1518_MN38 (XI1518_bn4 XI1518_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1518_MN38_1 (VSS XI1518_s1 XI1518_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1518_MN25 (VSS XI1518_asn XI1518_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1518_MN10 (VSS cm40_1 XI1518_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1518_MN6 (XI1518_an3 cm40_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1518_MN9 (XI1518_asn XI1518_acon XI1518_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1518_MN12 (XI1518_an5 cm42_1 XI1518_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1518_MN11 (XI1518_an4 cm41_1 XI1518_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1518_MN11_1 (XI1518_an5 cm41_1 XI1518_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1518_MN12_1 (XI1518_asn cm42_1 XI1518_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1518_MN10_1 (XI1518_an4 cm40_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1518_MN5 (XI1518_acon cm42_1 XI1518_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1518_MN2 (XI1518_an1 cm41_1 XI1518_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1518_MN1 (VSS cm40_1 XI1518_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1518_MN3 (XI1518_an2 cm40_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1518_MN4 (VSS cm41_1 XI1518_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1518_MN27 (cm157_2 XI1518_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1518_MN7 (XI1518_an3 cm41_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1518_MN8 (VSS cm42_1 XI1518_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1581_MN34 (XI1581_bn3 XI1581_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1581_MN35 (VSS fa160_0 XI1581_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1581_MN36 (XI1581_bn3 cm219_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1581_MN37 (XI1581_bsn XI1581_bcon XI1581_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1581_MN40 (XI1581_bn5 cm219_2 XI1581_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1581_MN39 (XI1581_bn4 fa160_0 XI1581_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1581_MN39_1 (XI1581_bn5 fa160_0 XI1581_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1581_MN40_1 (XI1581_bsn cm219_2 XI1581_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1581_MN53 (VSS XI1581_bsn cm220_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1581_MN29 (XI1581_bn1 XI1581_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1581_MN30 (XI1581_bcon fa160_0 XI1581_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1581_MN33 (XI1581_bn2 cm219_2 XI1581_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1581_MN31 (VSS XI1581_s1 XI1581_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1581_MN32 (XI1581_bn2 fa160_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1581_MN55 (VSS XI1581_bcon cm220_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1581_MN38 (XI1581_bn4 XI1581_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1581_MN38_1 (VSS XI1581_s1 XI1581_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1581_MN25 (VSS XI1581_asn XI1581_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1581_MN10 (VSS cm157_1 XI1581_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1581_MN6 (XI1581_an3 cm157_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1581_MN9 (XI1581_asn XI1581_acon XI1581_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1581_MN12 (XI1581_an5 cm159_0 XI1581_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1581_MN11 (XI1581_an4 fa158_1 XI1581_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1581_MN11_1 (XI1581_an5 fa158_1 XI1581_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1581_MN12_1 (XI1581_asn cm159_0 XI1581_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1581_MN10_1 (XI1581_an4 cm157_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1581_MN5 (XI1581_acon cm159_0 XI1581_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1581_MN2 (XI1581_an1 fa158_1 XI1581_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1581_MN1 (VSS cm157_1 XI1581_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1581_MN3 (XI1581_an2 cm157_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1581_MN4 (VSS fa158_1 XI1581_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1581_MN27 (cm220_2 XI1581_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1581_MN7 (XI1581_an3 fa158_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1581_MN8 (VSS cm159_0 XI1581_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1403_MN34 (XI1403_bn3 XI1403_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1403_MN35 (VSS pp11_2 XI1403_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1403_MN36 (XI1403_bn3 cm39_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1403_MN37 (XI1403_bsn XI1403_bcon XI1403_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1403_MN40 (XI1403_bn5 cm39_2 XI1403_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1403_MN39 (XI1403_bn4 pp11_2 XI1403_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1403_MN39_1 (XI1403_bn5 pp11_2 XI1403_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1403_MN40_1 (XI1403_bsn cm39_2 XI1403_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1403_MN53 (VSS XI1403_bsn cm42_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1403_MN29 (XI1403_bn1 XI1403_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1403_MN30 (XI1403_bcon pp11_2 XI1403_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1403_MN33 (XI1403_bn2 cm39_2 XI1403_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1403_MN31 (VSS XI1403_s1 XI1403_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1403_MN32 (XI1403_bn2 pp11_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1403_MN55 (VSS XI1403_bcon cm42_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1403_MN38 (XI1403_bn4 XI1403_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1403_MN38_1 (VSS XI1403_s1 XI1403_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1403_MN25 (VSS XI1403_asn XI1403_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1403_MN10 (VSS pp8_8 XI1403_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1403_MN6 (XI1403_an3 pp8_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1403_MN9 (XI1403_asn XI1403_acon XI1403_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1403_MN12 (XI1403_an5 pp10_4 XI1403_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1403_MN11 (XI1403_an4 pp9_6 XI1403_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1403_MN11_1 (XI1403_an5 pp9_6 XI1403_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1403_MN12_1 (XI1403_asn pp10_4 XI1403_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1403_MN10_1 (XI1403_an4 pp8_8 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1403_MN5 (XI1403_acon pp10_4 XI1403_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1403_MN2 (XI1403_an1 pp9_6 XI1403_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1403_MN1 (VSS pp8_8 XI1403_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1403_MN3 (XI1403_an2 pp8_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1403_MN4 (VSS pp9_6 XI1403_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1403_MN27 (cm42_2 XI1403_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1403_MN7 (XI1403_an3 pp9_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1403_MN8 (VSS pp10_4 XI1403_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1399_MN34 (XI1399_bn3 XI1399_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1399_MN35 (VSS pp7_9 XI1399_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1399_MN36 (XI1399_bn3 cm35_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1399_MN37 (XI1399_bsn XI1399_bcon XI1399_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1399_MN40 (XI1399_bn5 cm35_2 XI1399_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1399_MN39 (XI1399_bn4 pp7_9 XI1399_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1399_MN39_1 (XI1399_bn5 pp7_9 XI1399_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1399_MN40_1 (XI1399_bsn cm35_2 XI1399_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1399_MN53 (VSS XI1399_bsn cm38_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1399_MN29 (XI1399_bn1 XI1399_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1399_MN30 (XI1399_bcon pp7_9 XI1399_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1399_MN33 (XI1399_bn2 cm35_2 XI1399_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1399_MN31 (VSS XI1399_s1 XI1399_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1399_MN32 (XI1399_bn2 pp7_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1399_MN55 (VSS XI1399_bcon cm38_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1399_MN38 (XI1399_bn4 XI1399_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1399_MN38_1 (VSS XI1399_s1 XI1399_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1399_MN25 (VSS XI1399_asn XI1399_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1399_MN10 (VSS pp4_15 XI1399_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1399_MN6 (XI1399_an3 pp4_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1399_MN9 (XI1399_asn XI1399_acon XI1399_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1399_MN12 (XI1399_an5 pp6_11 XI1399_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1399_MN11 (XI1399_an4 pp5_13 XI1399_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1399_MN11_1 (XI1399_an5 pp5_13 XI1399_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1399_MN12_1 (XI1399_asn pp6_11 XI1399_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1399_MN10_1 (XI1399_an4 pp4_15 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1399_MN5 (XI1399_acon pp6_11 XI1399_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1399_MN2 (XI1399_an1 pp5_13 XI1399_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1399_MN1 (VSS pp4_15 XI1399_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1399_MN3 (XI1399_an2 pp4_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1399_MN4 (VSS pp5_13 XI1399_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1399_MN27 (cm38_2 XI1399_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1399_MN7 (XI1399_an3 pp5_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1399_MN8 (VSS pp6_11 XI1399_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1516_MN34 (XI1516_bn3 XI1516_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1516_MN35 (VSS cm40_0 XI1516_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1516_MN36 (XI1516_bn3 cm154_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1516_MN37 (XI1516_bsn XI1516_bcon XI1516_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1516_MN40 (XI1516_bn5 cm154_2 XI1516_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1516_MN39 (XI1516_bn4 cm40_0 XI1516_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1516_MN39_1 (XI1516_bn5 cm40_0 XI1516_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1516_MN40_1 (XI1516_bsn cm154_2 XI1516_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1516_MN53 (VSS XI1516_bsn cm155_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1516_MN29 (XI1516_bn1 XI1516_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1516_MN30 (XI1516_bcon cm40_0 XI1516_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1516_MN33 (XI1516_bn2 cm154_2 XI1516_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1516_MN31 (VSS XI1516_s1 XI1516_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1516_MN32 (XI1516_bn2 cm40_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1516_MN55 (VSS XI1516_bcon cm155_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1516_MN38 (XI1516_bn4 XI1516_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1516_MN38_1 (VSS XI1516_s1 XI1516_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1516_MN25 (VSS XI1516_asn XI1516_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1516_MN10 (VSS cm37_1 XI1516_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1516_MN6 (XI1516_an3 cm37_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1516_MN9 (XI1516_asn XI1516_acon XI1516_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1516_MN12 (XI1516_an5 cm39_1 XI1516_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1516_MN11 (XI1516_an4 cm38_1 XI1516_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1516_MN11_1 (XI1516_an5 cm38_1 XI1516_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1516_MN12_1 (XI1516_asn cm39_1 XI1516_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1516_MN10_1 (XI1516_an4 cm37_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1516_MN5 (XI1516_acon cm39_1 XI1516_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1516_MN2 (XI1516_an1 cm38_1 XI1516_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1516_MN1 (VSS cm37_1 XI1516_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1516_MN3 (XI1516_an2 cm37_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1516_MN4 (VSS cm38_1 XI1516_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1516_MN27 (cm155_2 XI1516_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1516_MN7 (XI1516_an3 cm38_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1516_MN8 (VSS cm39_1 XI1516_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1580_MN34 (XI1580_bn3 XI1580_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1580_MN35 (VSS fa158_0 XI1580_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1580_MN36 (XI1580_bn3 cm218_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1580_MN37 (XI1580_bsn XI1580_bcon XI1580_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1580_MN40 (XI1580_bn5 cm218_2 XI1580_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1580_MN39 (XI1580_bn4 fa158_0 XI1580_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1580_MN39_1 (XI1580_bn5 fa158_0 XI1580_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1580_MN40_1 (XI1580_bsn cm218_2 XI1580_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1580_MN53 (VSS XI1580_bsn cm219_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1580_MN29 (XI1580_bn1 XI1580_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1580_MN30 (XI1580_bcon fa158_0 XI1580_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1580_MN33 (XI1580_bn2 cm218_2 XI1580_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1580_MN31 (VSS XI1580_s1 XI1580_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1580_MN32 (XI1580_bn2 fa158_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1580_MN55 (VSS XI1580_bcon cm219_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1580_MN38 (XI1580_bn4 XI1580_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1580_MN38_1 (VSS XI1580_s1 XI1580_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1580_MN25 (VSS XI1580_asn XI1580_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1580_MN10 (VSS cm155_1 XI1580_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1580_MN6 (XI1580_an3 cm155_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1580_MN9 (XI1580_asn XI1580_acon XI1580_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1580_MN12 (XI1580_an5 cm157_0 XI1580_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1580_MN11 (XI1580_an4 fa156_1 XI1580_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1580_MN11_1 (XI1580_an5 fa156_1 XI1580_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1580_MN12_1 (XI1580_asn cm157_0 XI1580_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1580_MN10_1 (XI1580_an4 cm155_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1580_MN5 (XI1580_acon cm157_0 XI1580_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1580_MN2 (XI1580_an1 fa156_1 XI1580_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1580_MN1 (VSS cm155_1 XI1580_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1580_MN3 (XI1580_an2 cm155_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1580_MN4 (VSS fa156_1 XI1580_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1580_MN27 (cm219_2 XI1580_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1580_MN7 (XI1580_an3 fa156_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1580_MN8 (VSS cm157_0 XI1580_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1400_MN34 (XI1400_bn3 XI1400_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1400_MN35 (VSS pp11_1 XI1400_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1400_MN36 (XI1400_bn3 cm36_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1400_MN37 (XI1400_bsn XI1400_bcon XI1400_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1400_MN40 (XI1400_bn5 cm36_2 XI1400_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1400_MN39 (XI1400_bn4 pp11_1 XI1400_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1400_MN39_1 (XI1400_bn5 pp11_1 XI1400_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1400_MN40_1 (XI1400_bsn cm36_2 XI1400_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1400_MN53 (VSS XI1400_bsn cm39_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1400_MN29 (XI1400_bn1 XI1400_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1400_MN30 (XI1400_bcon pp11_1 XI1400_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1400_MN33 (XI1400_bn2 cm36_2 XI1400_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1400_MN31 (VSS XI1400_s1 XI1400_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1400_MN32 (XI1400_bn2 pp11_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1400_MN55 (VSS XI1400_bcon cm39_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1400_MN38 (XI1400_bn4 XI1400_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1400_MN38_1 (VSS XI1400_s1 XI1400_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1400_MN25 (VSS XI1400_asn XI1400_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1400_MN10 (VSS pp8_7 XI1400_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1400_MN6 (XI1400_an3 pp8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1400_MN9 (XI1400_asn XI1400_acon XI1400_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1400_MN12 (XI1400_an5 pp10_3 XI1400_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1400_MN11 (XI1400_an4 pp9_5 XI1400_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1400_MN11_1 (XI1400_an5 pp9_5 XI1400_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1400_MN12_1 (XI1400_asn pp10_3 XI1400_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1400_MN10_1 (XI1400_an4 pp8_7 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1400_MN5 (XI1400_acon pp10_3 XI1400_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1400_MN2 (XI1400_an1 pp9_5 XI1400_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1400_MN1 (VSS pp8_7 XI1400_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1400_MN3 (XI1400_an2 pp8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1400_MN4 (VSS pp9_5 XI1400_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1400_MN27 (cm39_2 XI1400_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1400_MN7 (XI1400_an3 pp9_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1400_MN8 (VSS pp10_3 XI1400_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1397_MN34 (XI1397_bn3 XI1397_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1397_MN35 (VSS pp11_0 XI1397_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1397_MN36 (XI1397_bn3 B_23_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1397_MN37 (XI1397_bsn XI1397_bcon XI1397_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1397_MN40 (XI1397_bn5 B_23_b3_5 XI1397_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1397_MN39 (XI1397_bn4 pp11_0 XI1397_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1397_MN39_1 (XI1397_bn5 pp11_0 XI1397_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1397_MN40_1 (XI1397_bsn B_23_b3_5 XI1397_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1397_MN53 (VSS XI1397_bsn cm36_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1397_MN29 (XI1397_bn1 XI1397_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1397_MN30 (XI1397_bcon pp11_0 XI1397_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1397_MN33 (XI1397_bn2 B_23_b3_5 XI1397_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1397_MN31 (VSS XI1397_s1 XI1397_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1397_MN32 (XI1397_bn2 pp11_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1397_MN55 (VSS XI1397_bcon cm36_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1397_MN38 (XI1397_bn4 XI1397_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1397_MN38_1 (VSS XI1397_s1 XI1397_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1397_MN25 (VSS XI1397_asn XI1397_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1397_MN10 (VSS pp8_6 XI1397_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1397_MN6 (XI1397_an3 pp8_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1397_MN9 (XI1397_asn XI1397_acon XI1397_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1397_MN12 (XI1397_an5 pp10_2 XI1397_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1397_MN11 (XI1397_an4 pp9_4 XI1397_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1397_MN11_1 (XI1397_an5 pp9_4 XI1397_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1397_MN12_1 (XI1397_asn pp10_2 XI1397_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1397_MN10_1 (XI1397_an4 pp8_6 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1397_MN5 (XI1397_acon pp10_2 XI1397_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1397_MN2 (XI1397_an1 pp9_4 XI1397_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1397_MN1 (VSS pp8_6 XI1397_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1397_MN3 (XI1397_an2 pp8_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1397_MN4 (VSS pp9_4 XI1397_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1397_MN27 (cm36_2 XI1397_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1397_MN7 (XI1397_an3 pp9_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1397_MN8 (VSS pp10_2 XI1397_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1395_MN34 (XI1395_bn3 XI1395_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1395_MN35 (VSS pp3_16 XI1395_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1395_MN36 (XI1395_bn3 cm31_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1395_MN37 (XI1395_bsn XI1395_bcon XI1395_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1395_MN40 (XI1395_bn5 cm31_2 XI1395_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1395_MN39 (XI1395_bn4 pp3_16 XI1395_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1395_MN39_1 (XI1395_bn5 pp3_16 XI1395_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1395_MN40_1 (XI1395_bsn cm31_2 XI1395_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1395_MN53 (VSS XI1395_bsn cm34_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1395_MN29 (XI1395_bn1 XI1395_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1395_MN30 (XI1395_bcon pp3_16 XI1395_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1395_MN33 (XI1395_bn2 cm31_2 XI1395_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1395_MN31 (VSS XI1395_s1 XI1395_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1395_MN32 (XI1395_bn2 pp3_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1395_MN55 (VSS XI1395_bcon cm34_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1395_MN38 (XI1395_bn4 XI1395_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1395_MN38_1 (VSS XI1395_s1 XI1395_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1395_MN25 (VSS XI1395_asn XI1395_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1395_MN10 (VSS pp0_22 XI1395_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1395_MN6 (XI1395_an3 pp0_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1395_MN9 (XI1395_asn XI1395_acon XI1395_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1395_MN12 (XI1395_an5 pp2_18 XI1395_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1395_MN11 (XI1395_an4 pp1_20 XI1395_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1395_MN11_1 (XI1395_an5 pp1_20 XI1395_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1395_MN12_1 (XI1395_asn pp2_18 XI1395_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1395_MN10_1 (XI1395_an4 pp0_22 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1395_MN5 (XI1395_acon pp2_18 XI1395_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1395_MN2 (XI1395_an1 pp1_20 XI1395_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1395_MN1 (VSS pp0_22 XI1395_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1395_MN3 (XI1395_an2 pp0_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1395_MN4 (VSS pp1_20 XI1395_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1395_MN27 (cm34_2 XI1395_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1395_MN7 (XI1395_an3 pp1_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1395_MN8 (VSS pp2_18 XI1395_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1515_MN34 (XI1515_bn3 XI1515_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1515_MN35 (VSS cm37_0 XI1515_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1515_MN36 (XI1515_bn3 cm153_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1515_MN37 (XI1515_bsn XI1515_bcon XI1515_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1515_MN40 (XI1515_bn5 cm153_2 XI1515_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1515_MN39 (XI1515_bn4 cm37_0 XI1515_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1515_MN39_1 (XI1515_bn5 cm37_0 XI1515_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1515_MN40_1 (XI1515_bsn cm153_2 XI1515_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1515_MN53 (VSS XI1515_bsn cm154_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1515_MN29 (XI1515_bn1 XI1515_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1515_MN30 (XI1515_bcon cm37_0 XI1515_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1515_MN33 (XI1515_bn2 cm153_2 XI1515_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1515_MN31 (VSS XI1515_s1 XI1515_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1515_MN32 (XI1515_bn2 cm37_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1515_MN55 (VSS XI1515_bcon cm154_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1515_MN38 (XI1515_bn4 XI1515_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1515_MN38_1 (VSS XI1515_s1 XI1515_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1515_MN25 (VSS XI1515_asn XI1515_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1515_MN10 (VSS cm34_1 XI1515_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1515_MN6 (XI1515_an3 cm34_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1515_MN9 (XI1515_asn XI1515_acon XI1515_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1515_MN12 (XI1515_an5 cm36_1 XI1515_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1515_MN11 (XI1515_an4 cm35_1 XI1515_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1515_MN11_1 (XI1515_an5 cm35_1 XI1515_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1515_MN12_1 (XI1515_asn cm36_1 XI1515_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1515_MN10_1 (XI1515_an4 cm34_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1515_MN5 (XI1515_acon cm36_1 XI1515_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1515_MN2 (XI1515_an1 cm35_1 XI1515_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1515_MN1 (VSS cm34_1 XI1515_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1515_MN3 (XI1515_an2 cm34_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1515_MN4 (VSS cm35_1 XI1515_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1515_MN27 (cm154_2 XI1515_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1515_MN7 (XI1515_an3 cm35_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1515_MN8 (VSS cm36_1 XI1515_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1579_MN34 (XI1579_bn3 XI1579_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1579_MN35 (VSS B_25_b3_5 XI1579_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1579_MN36 (XI1579_bn3 cm217_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1579_MN37 (XI1579_bsn XI1579_bcon XI1579_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1579_MN40 (XI1579_bn5 cm217_2 XI1579_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1579_MN39 (XI1579_bn4 B_25_b3_5 XI1579_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1579_MN39_1 (XI1579_bn5 B_25_b3_5 XI1579_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1579_MN40_1 (XI1579_bsn cm217_2 XI1579_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1579_MN53 (VSS XI1579_bsn cm218_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1579_MN29 (XI1579_bn1 XI1579_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1579_MN30 (XI1579_bcon B_25_b3_5 XI1579_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1579_MN33 (XI1579_bn2 cm217_2 XI1579_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1579_MN31 (VSS XI1579_s1 XI1579_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1579_MN32 (XI1579_bn2 B_25_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1579_MN55 (VSS XI1579_bcon cm218_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1579_MN38 (XI1579_bn4 XI1579_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1579_MN38_1 (VSS XI1579_s1 XI1579_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1579_MN25 (VSS XI1579_asn XI1579_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1579_MN10 (VSS cm154_1 XI1579_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1579_MN6 (XI1579_an3 cm154_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1579_MN9 (XI1579_asn XI1579_acon XI1579_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1579_MN12 (XI1579_an5 fa156_0 XI1579_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1579_MN11 (XI1579_an4 cm155_0 XI1579_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1579_MN11_1 (XI1579_an5 cm155_0 XI1579_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1579_MN12_1 (XI1579_asn fa156_0 XI1579_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1579_MN10_1 (XI1579_an4 cm154_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1579_MN5 (XI1579_acon fa156_0 XI1579_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1579_MN2 (XI1579_an1 cm155_0 XI1579_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1579_MN1 (VSS cm154_1 XI1579_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1579_MN3 (XI1579_an2 cm154_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1579_MN4 (VSS cm155_0 XI1579_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1579_MN27 (cm218_2 XI1579_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1579_MN7 (XI1579_an3 cm155_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1579_MN8 (VSS fa156_0 XI1579_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1396_MN34 (XI1396_bn3 XI1396_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1396_MN35 (VSS pp7_8 XI1396_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1396_MN36 (XI1396_bn3 cm32_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1396_MN37 (XI1396_bsn XI1396_bcon XI1396_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1396_MN40 (XI1396_bn5 cm32_2 XI1396_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1396_MN39 (XI1396_bn4 pp7_8 XI1396_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1396_MN39_1 (XI1396_bn5 pp7_8 XI1396_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1396_MN40_1 (XI1396_bsn cm32_2 XI1396_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1396_MN53 (VSS XI1396_bsn cm35_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1396_MN29 (XI1396_bn1 XI1396_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1396_MN30 (XI1396_bcon pp7_8 XI1396_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1396_MN33 (XI1396_bn2 cm32_2 XI1396_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1396_MN31 (VSS XI1396_s1 XI1396_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1396_MN32 (XI1396_bn2 pp7_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1396_MN55 (VSS XI1396_bcon cm35_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1396_MN38 (XI1396_bn4 XI1396_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1396_MN38_1 (VSS XI1396_s1 XI1396_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1396_MN25 (VSS XI1396_asn XI1396_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1396_MN10 (VSS pp4_14 XI1396_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1396_MN6 (XI1396_an3 pp4_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1396_MN9 (XI1396_asn XI1396_acon XI1396_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1396_MN12 (XI1396_an5 pp6_10 XI1396_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1396_MN11 (XI1396_an4 pp5_12 XI1396_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1396_MN11_1 (XI1396_an5 pp5_12 XI1396_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1396_MN12_1 (XI1396_asn pp6_10 XI1396_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1396_MN10_1 (XI1396_an4 pp4_14 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1396_MN5 (XI1396_acon pp6_10 XI1396_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1396_MN2 (XI1396_an1 pp5_12 XI1396_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1396_MN1 (VSS pp4_14 XI1396_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1396_MN3 (XI1396_an2 pp4_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1396_MN4 (VSS pp5_12 XI1396_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1396_MN27 (cm35_2 XI1396_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1396_MN7 (XI1396_an3 pp5_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1396_MN8 (VSS pp6_10 XI1396_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1392_MN34 (XI1392_bn3 XI1392_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1392_MN35 (VSS pp3_15 XI1392_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1392_MN36 (XI1392_bn3 cm28_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1392_MN37 (XI1392_bsn XI1392_bcon XI1392_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1392_MN40 (XI1392_bn5 cm28_2 XI1392_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1392_MN39 (XI1392_bn4 pp3_15 XI1392_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1392_MN39_1 (XI1392_bn5 pp3_15 XI1392_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1392_MN40_1 (XI1392_bsn cm28_2 XI1392_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1392_MN53 (VSS XI1392_bsn cm31_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1392_MN29 (XI1392_bn1 XI1392_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1392_MN30 (XI1392_bcon pp3_15 XI1392_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1392_MN33 (XI1392_bn2 cm28_2 XI1392_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1392_MN31 (VSS XI1392_s1 XI1392_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1392_MN32 (XI1392_bn2 pp3_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1392_MN55 (VSS XI1392_bcon cm31_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1392_MN38 (XI1392_bn4 XI1392_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1392_MN38_1 (VSS XI1392_s1 XI1392_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1392_MN25 (VSS XI1392_asn XI1392_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1392_MN10 (VSS pp0_21 XI1392_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1392_MN6 (XI1392_an3 pp0_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1392_MN9 (XI1392_asn XI1392_acon XI1392_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1392_MN12 (XI1392_an5 pp2_17 XI1392_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1392_MN11 (XI1392_an4 pp1_19 XI1392_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1392_MN11_1 (XI1392_an5 pp1_19 XI1392_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1392_MN12_1 (XI1392_asn pp2_17 XI1392_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1392_MN10_1 (XI1392_an4 pp0_21 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1392_MN5 (XI1392_acon pp2_17 XI1392_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1392_MN2 (XI1392_an1 pp1_19 XI1392_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1392_MN1 (VSS pp0_21 XI1392_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1392_MN3 (XI1392_an2 pp0_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1392_MN4 (VSS pp1_19 XI1392_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1392_MN27 (cm31_2 XI1392_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1392_MN7 (XI1392_an3 pp1_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1392_MN8 (VSS pp2_17 XI1392_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1514_MN34 (XI1514_bn3 XI1514_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1514_MN35 (VSS cm34_0 XI1514_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1514_MN36 (XI1514_bn3 cm152_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1514_MN37 (XI1514_bsn XI1514_bcon XI1514_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1514_MN40 (XI1514_bn5 cm152_2 XI1514_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1514_MN39 (XI1514_bn4 cm34_0 XI1514_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1514_MN39_1 (XI1514_bn5 cm34_0 XI1514_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1514_MN40_1 (XI1514_bsn cm152_2 XI1514_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1514_MN53 (VSS XI1514_bsn cm153_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1514_MN29 (XI1514_bn1 XI1514_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1514_MN30 (XI1514_bcon cm34_0 XI1514_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1514_MN33 (XI1514_bn2 cm152_2 XI1514_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1514_MN31 (VSS XI1514_s1 XI1514_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1514_MN32 (XI1514_bn2 cm34_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1514_MN55 (VSS XI1514_bcon cm153_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1514_MN38 (XI1514_bn4 XI1514_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1514_MN38_1 (VSS XI1514_s1 XI1514_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1514_MN25 (VSS XI1514_asn XI1514_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1514_MN10 (VSS cm31_1 XI1514_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1514_MN6 (XI1514_an3 cm31_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1514_MN9 (XI1514_asn XI1514_acon XI1514_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1514_MN12 (XI1514_an5 fa33_1 XI1514_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1514_MN11 (XI1514_an4 cm32_1 XI1514_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1514_MN11_1 (XI1514_an5 cm32_1 XI1514_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1514_MN12_1 (XI1514_asn fa33_1 XI1514_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1514_MN10_1 (XI1514_an4 cm31_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1514_MN5 (XI1514_acon fa33_1 XI1514_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1514_MN2 (XI1514_an1 cm32_1 XI1514_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1514_MN1 (VSS cm31_1 XI1514_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1514_MN3 (XI1514_an2 cm31_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1514_MN4 (VSS cm32_1 XI1514_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1514_MN27 (cm153_2 XI1514_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1514_MN7 (XI1514_an3 cm32_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1514_MN8 (VSS fa33_1 XI1514_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1578_MN34 (XI1578_bn3 XI1578_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1578_MN35 (VSS cm39_0 XI1578_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1578_MN36 (XI1578_bn3 cm216_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1578_MN37 (XI1578_bsn XI1578_bcon XI1578_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1578_MN40 (XI1578_bn5 cm216_2 XI1578_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1578_MN39 (XI1578_bn4 cm39_0 XI1578_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1578_MN39_1 (XI1578_bn5 cm39_0 XI1578_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1578_MN40_1 (XI1578_bsn cm216_2 XI1578_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1578_MN53 (VSS XI1578_bsn cm217_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1578_MN29 (XI1578_bn1 XI1578_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1578_MN30 (XI1578_bcon cm39_0 XI1578_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1578_MN33 (XI1578_bn2 cm216_2 XI1578_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1578_MN31 (VSS XI1578_s1 XI1578_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1578_MN32 (XI1578_bn2 cm39_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1578_MN55 (VSS XI1578_bcon cm217_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1578_MN38 (XI1578_bn4 XI1578_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1578_MN38_1 (VSS XI1578_s1 XI1578_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1578_MN25 (VSS XI1578_asn XI1578_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1578_MN10 (VSS cm153_1 XI1578_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1578_MN6 (XI1578_an3 cm153_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1578_MN9 (XI1578_asn XI1578_acon XI1578_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1578_MN12 (XI1578_an5 cm38_0 XI1578_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1578_MN11 (XI1578_an4 cm154_0 XI1578_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1578_MN11_1 (XI1578_an5 cm154_0 XI1578_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1578_MN12_1 (XI1578_asn cm38_0 XI1578_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1578_MN10_1 (XI1578_an4 cm153_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1578_MN5 (XI1578_acon cm38_0 XI1578_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1578_MN2 (XI1578_an1 cm154_0 XI1578_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1578_MN1 (VSS cm153_1 XI1578_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1578_MN3 (XI1578_an2 cm153_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1578_MN4 (VSS cm154_0 XI1578_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1578_MN27 (cm217_2 XI1578_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1578_MN7 (XI1578_an3 cm154_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1578_MN8 (VSS cm38_0 XI1578_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1393_MN34 (XI1393_bn3 XI1393_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1393_MN35 (VSS pp7_7 XI1393_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1393_MN36 (XI1393_bn3 cm29_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1393_MN37 (XI1393_bsn XI1393_bcon XI1393_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1393_MN40 (XI1393_bn5 cm29_2 XI1393_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1393_MN39 (XI1393_bn4 pp7_7 XI1393_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1393_MN39_1 (XI1393_bn5 pp7_7 XI1393_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1393_MN40_1 (XI1393_bsn cm29_2 XI1393_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1393_MN53 (VSS XI1393_bsn cm32_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1393_MN29 (XI1393_bn1 XI1393_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1393_MN30 (XI1393_bcon pp7_7 XI1393_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1393_MN33 (XI1393_bn2 cm29_2 XI1393_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1393_MN31 (VSS XI1393_s1 XI1393_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1393_MN32 (XI1393_bn2 pp7_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1393_MN55 (VSS XI1393_bcon cm32_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1393_MN38 (XI1393_bn4 XI1393_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1393_MN38_1 (VSS XI1393_s1 XI1393_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1393_MN25 (VSS XI1393_asn XI1393_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1393_MN10 (VSS pp4_13 XI1393_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1393_MN6 (XI1393_an3 pp4_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1393_MN9 (XI1393_asn XI1393_acon XI1393_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1393_MN12 (XI1393_an5 pp6_9 XI1393_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1393_MN11 (XI1393_an4 pp5_11 XI1393_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1393_MN11_1 (XI1393_an5 pp5_11 XI1393_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1393_MN12_1 (XI1393_asn pp6_9 XI1393_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1393_MN10_1 (XI1393_an4 pp4_13 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1393_MN5 (XI1393_acon pp6_9 XI1393_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1393_MN2 (XI1393_an1 pp5_11 XI1393_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1393_MN1 (VSS pp4_13 XI1393_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1393_MN3 (XI1393_an2 pp4_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1393_MN4 (VSS pp5_11 XI1393_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
