    I_MXI969_MP18 (XI969_xp1 XI969_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI969_MP20 (pp8_26 B_17_b3_4 XI969_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI969_MP19 (XI969_xp1 XI969_xan pp8_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI969_MP17 (VDD XI969_xn XI969_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI969_MP6 (XI969_p1 A_26_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI969_MP8 (XI969_xn A_25_b3_3 XI969_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI969_MP7 (XI969_p1 two8_b3_4 XI969_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI969_MP5 (VDD one8_b3_4 XI969_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI969_MP10 (XI969_xan XI969_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1023_MP12 (VDD B_19_b3_4 XI1023_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1023_MP18 (XI1023_xp1 XI1023_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1023_MP20 (pp9_25 B_19_b3_4 XI1023_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1023_MP19 (XI1023_xp1 XI1023_xan pp9_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1023_MP17 (VDD XI1023_xn XI1023_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1023_MP6 (XI1023_p1 A_25_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1023_MP8 (XI1023_xn A_24_b3_3 XI1023_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1023_MP7 (XI1023_p1 two9_b3_4 XI1023_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1023_MP5 (VDD one9_b3_4 XI1023_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1023_MP10 (XI1023_xan XI1023_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1025_MP12 (VDD B_19_b3_4 XI1025_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1025_MP18 (XI1025_xp1 XI1025_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1025_MP20 (pp9_27 B_19_b3_4 XI1025_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1025_MP19 (XI1025_xp1 XI1025_xan pp9_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1025_MP17 (VDD XI1025_xn XI1025_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1025_MP6 (XI1025_p1 A_27_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1025_MP8 (XI1025_xn A_26_b3_3 XI1025_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1025_MP7 (XI1025_p1 two9_b3_4 XI1025_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1025_MP5 (VDD one9_b3_4 XI1025_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1025_MP10 (XI1025_xan XI1025_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI971_MP12 (VDD B_17_b3_4 XI971_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI971_MP18 (XI971_xp1 XI971_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI971_MP20 (pp8_28 B_17_b3_4 XI971_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI971_MP19 (XI971_xp1 XI971_xan pp8_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI971_MP17 (VDD XI971_xn XI971_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI971_MP6 (XI971_p1 A_28_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI971_MP8 (XI971_xn A_27_b3_3 XI971_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI971_MP7 (XI971_p1 two8_b3_5 XI971_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI971_MP5 (VDD one8_b3_5 XI971_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI971_MP10 (XI971_xan XI971_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1026_MP12 (VDD B_19_b3_4 XI1026_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1026_MP18 (XI1026_xp1 XI1026_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1026_MP20 (pp9_28 B_19_b3_4 XI1026_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1026_MP19 (XI1026_xp1 XI1026_xan pp9_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1026_MP17 (VDD XI1026_xn XI1026_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1026_MP6 (XI1026_p1 A_28_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1026_MP8 (XI1026_xn A_27_b3_3 XI1026_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1026_MP7 (XI1026_p1 two9_b3_5 XI1026_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1026_MP5 (VDD one9_b3_5 XI1026_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1026_MP10 (XI1026_xan XI1026_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI972_MP12 (VDD B_17_b3_5 XI972_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI972_MP18 (XI972_xp1 XI972_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI972_MP20 (pp8_29 B_17_b3_5 XI972_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI972_MP19 (XI972_xp1 XI972_xan pp8_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI972_MP17 (VDD XI972_xn XI972_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI972_MP6 (XI972_p1 A_29_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI972_MP8 (XI972_xn A_28_b3_3 XI972_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI972_MP7 (XI972_p1 two8_b3_5 XI972_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI972_MP5 (VDD one8_b3_5 XI972_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI972_MP10 (XI972_xan XI972_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI974_MP12 (VDD B_17_b3_5 XI974_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI974_MP18 (XI974_xp1 XI974_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI974_MP20 (pp8_31 B_17_b3_5 XI974_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI974_MP19 (XI974_xp1 XI974_xan pp8_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI974_MP17 (VDD XI974_xn XI974_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI974_MP6 (XI974_p1 A_31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI974_MP8 (XI974_xn A_30_b3_3 XI974_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI974_MP7 (XI974_p1 two8_b3_5 XI974_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI974_MP5 (VDD one8_b3_5 XI974_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI974_MP10 (XI974_xan XI974_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1027_MP12 (VDD B_19_b3_5 XI1027_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1027_MP18 (XI1027_xp1 XI1027_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1027_MP20 (pp9_29 B_19_b3_5 XI1027_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1027_MP19 (XI1027_xp1 XI1027_xan pp9_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1027_MP17 (VDD XI1027_xn XI1027_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1027_MP6 (XI1027_p1 A_29_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1027_MP8 (XI1027_xn A_28_b3_3 XI1027_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1027_MP7 (XI1027_p1 two9_b3_5 XI1027_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1027_MP5 (VDD one9_b3_5 XI1027_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1027_MP10 (XI1027_xan XI1027_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1030_MP12 (VDD B_19_b3_5 XI1030_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1030_MP18 (XI1030_xp1 XI1030_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1030_MP20 (pp9_32 B_19_b3_5 XI1030_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1030_MP19 (XI1030_xp1 XI1030_xan pp9_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1030_MP17 (VDD XI1030_xn XI1030_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1030_MP6 (XI1030_p1 A_31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1030_MP8 (XI1030_xn A_31_b3_4 XI1030_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1030_MP7 (XI1030_p1 two9_b3_5 XI1030_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1030_MP5 (VDD one9_b3_5 XI1030_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1030_MP10 (XI1030_xan XI1030_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI914_MP12 (VDD B_15_b3_4 XI914_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI914_MP18 (XI914_xp1 XI914_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI914_MP20 (pp7_26 B_15_b3_4 XI914_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI914_MP19 (XI914_xp1 XI914_xan pp7_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI914_MP17 (VDD XI914_xn XI914_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI914_MP6 (XI914_p1 A_26_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI914_MP8 (XI914_xn A_25_b3_2 XI914_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI914_MP7 (XI914_p1 two7_b3_4 XI914_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI914_MP5 (VDD one7_b3_4 XI914_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI914_MP10 (XI914_xan XI914_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI913_MP12 (VDD B_15_b3_4 XI913_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI913_MP18 (XI913_xp1 XI913_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI913_MP20 (pp7_25 B_15_b3_4 XI913_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI913_MP19 (XI913_xp1 XI913_xan pp7_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI913_MP17 (VDD XI913_xn XI913_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI913_MP6 (XI913_p1 A_25_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI913_MP8 (XI913_xn A_24_b3_2 XI913_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI913_MP7 (XI913_p1 two7_b3_4 XI913_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI913_MP5 (VDD one7_b3_4 XI913_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI913_MP10 (XI913_xan XI913_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI809_MP12 (VDD B_11_b3_5 XI809_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI809_MP18 (XI809_xp1 XI809_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI809_MP20 (pp5_31 B_11_b3_5 XI809_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI809_MP19 (XI809_xp1 XI809_xan pp5_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI809_MP17 (VDD XI809_xn XI809_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI809_MP6 (XI809_p1 A_31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI809_MP8 (XI809_xn A_30_b3_2 XI809_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI809_MP7 (XI809_p1 two5_b3_5 XI809_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI809_MP5 (VDD one5_b3_5 XI809_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI809_MP10 (XI809_xan XI809_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI863_MP12 (VDD B_13_b3_5 XI863_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI863_MP18 (XI863_xp1 XI863_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI863_MP20 (pp6_30 B_13_b3_5 XI863_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI863_MP19 (XI863_xp1 XI863_xan pp6_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI863_MP17 (VDD XI863_xn XI863_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI863_MP6 (XI863_p1 A_30_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI863_MP8 (XI863_xn A_29_b3_2 XI863_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI863_MP7 (XI863_p1 two6_b3_5 XI863_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI863_MP5 (VDD one6_b3_5 XI863_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI863_MP10 (XI863_xan XI863_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1019_MP12 (VDD B_19_b3_3 XI1019_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1019_MP18 (XI1019_xp1 XI1019_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1019_MP20 (pp9_21 B_19_b3_3 XI1019_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1019_MP19 (XI1019_xp1 XI1019_xan pp9_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1019_MP17 (VDD XI1019_xn XI1019_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1019_MP6 (XI1019_p1 A_21_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1019_MP8 (XI1019_xn A_20_b3_3 XI1019_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1019_MP7 (XI1019_p1 two9_b3_3 XI1019_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1019_MP5 (VDD one9_b3_3 XI1019_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1019_MP10 (XI1019_xan XI1019_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1015_MP12 (VDD B_19_b3_3 XI1015_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1015_MP18 (XI1015_xp1 XI1015_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1015_MP20 (pp9_17 B_19_b3_3 XI1015_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1015_MP19 (XI1015_xp1 XI1015_xan pp9_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1015_MP17 (VDD XI1015_xn XI1015_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1015_MP6 (XI1015_p1 A_17_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1015_MP8 (XI1015_xn A_16_b3_3 XI1015_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1015_MP7 (XI1015_p1 two9_b3_3 XI1015_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1015_MP5 (VDD one9_b3_3 XI1015_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1015_MP10 (XI1015_xan XI1015_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI965_MP12 (VDD B_17_b3_3 XI965_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI965_MP18 (XI965_xp1 XI965_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI965_MP20 (pp8_22 B_17_b3_3 XI965_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI965_MP19 (XI965_xp1 XI965_xan pp8_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI965_MP17 (VDD XI965_xn XI965_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI965_MP6 (XI965_p1 A_22_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI965_MP8 (XI965_xn A_21_b3_3 XI965_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI965_MP7 (XI965_p1 two8_b3_4 XI965_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI965_MP5 (VDD one8_b3_4 XI965_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI965_MP10 (XI965_xan XI965_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1020_MP12 (VDD B_19_b3_3 XI1020_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1020_MP18 (XI1020_xp1 XI1020_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1020_MP20 (pp9_22 B_19_b3_3 XI1020_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1020_MP19 (XI1020_xp1 XI1020_xan pp9_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1020_MP17 (VDD XI1020_xn XI1020_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1020_MP6 (XI1020_p1 A_22_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1020_MP8 (XI1020_xn A_21_b3_3 XI1020_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1020_MP7 (XI1020_p1 two9_b3_4 XI1020_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1020_MP5 (VDD one9_b3_4 XI1020_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1020_MP10 (XI1020_xan XI1020_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI967_MP12 (VDD B_17_b3_4 XI967_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI967_MP18 (XI967_xp1 XI967_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI967_MP20 (pp8_24 B_17_b3_4 XI967_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI967_MP19 (XI967_xp1 XI967_xan pp8_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI967_MP17 (VDD XI967_xn XI967_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI967_MP6 (XI967_p1 A_24_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI967_MP8 (XI967_xn A_23_b3_3 XI967_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI967_MP7 (XI967_p1 two8_b3_4 XI967_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI967_MP5 (VDD one8_b3_4 XI967_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI967_MP10 (XI967_xan XI967_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1076_MP12 (VDD B_21_b3_4 XI1076_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1076_MP18 (XI1076_xp1 XI1076_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1076_MP20 (pp10_23 B_21_b3_4 XI1076_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1076_MP19 (XI1076_xp1 XI1076_xan pp10_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1076_MP17 (VDD XI1076_xn XI1076_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1076_MP6 (XI1076_p1 A_23_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1076_MP8 (XI1076_xn A_22_b3_3 XI1076_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1076_MP7 (XI1076_p1 two10_b3_4 XI1076_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1076_MP5 (VDD one10_b3_4 XI1076_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1076_MP10 (XI1076_xan XI1076_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI968_MP12 (VDD B_17_b3_4 XI968_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI968_MP18 (XI968_xp1 XI968_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI968_MP20 (pp8_25 B_17_b3_4 XI968_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI968_MP19 (XI968_xp1 XI968_xan pp8_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI968_MP17 (VDD XI968_xn XI968_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI968_MP6 (XI968_p1 A_25_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI968_MP8 (XI968_xn A_24_b3_3 XI968_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI968_MP7 (XI968_p1 two8_b3_4 XI968_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI968_MP5 (VDD one8_b3_4 XI968_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI968_MP10 (XI968_xan XI968_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1024_MP12 (VDD B_19_b3_4 XI1024_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1024_MP18 (XI1024_xp1 XI1024_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1024_MP20 (pp9_26 B_19_b3_4 XI1024_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1024_MP19 (XI1024_xp1 XI1024_xan pp9_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1024_MP17 (VDD XI1024_xn XI1024_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1024_MP6 (XI1024_p1 A_26_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1024_MP8 (XI1024_xn A_25_b3_3 XI1024_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1024_MP7 (XI1024_p1 two9_b3_4 XI1024_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1024_MP5 (VDD one9_b3_4 XI1024_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1024_MP10 (XI1024_xan XI1024_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1080_MP12 (VDD B_21_b3_4 XI1080_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1080_MP18 (XI1080_xp1 XI1080_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1080_MP20 (pp10_27 B_21_b3_4 XI1080_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1080_MP19 (XI1080_xp1 XI1080_xan pp10_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1080_MP17 (VDD XI1080_xn XI1080_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1080_MP6 (XI1080_p1 A_27_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1080_MP8 (XI1080_xn A_26_b3_3 XI1080_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1080_MP7 (XI1080_p1 two10_b3_4 XI1080_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1080_MP5 (VDD one10_b3_4 XI1080_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1080_MP10 (XI1080_xan XI1080_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1081_MP12 (VDD B_21_b3_4 XI1081_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1081_MP18 (XI1081_xp1 XI1081_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1081_MP20 (pp10_28 B_21_b3_4 XI1081_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1081_MP19 (XI1081_xp1 XI1081_xan pp10_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1081_MP17 (VDD XI1081_xn XI1081_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1081_MP6 (XI1081_p1 A_28_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1081_MP8 (XI1081_xn A_27_b3_3 XI1081_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1081_MP7 (XI1081_p1 two10_b3_5 XI1081_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1081_MP5 (VDD one10_b3_5 XI1081_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1081_MP10 (XI1081_xan XI1081_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1083_MP12 (VDD B_21_b3_5 XI1083_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1083_MP18 (XI1083_xp1 XI1083_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1083_MP20 (pp10_30 B_21_b3_5 XI1083_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1083_MP19 (XI1083_xp1 XI1083_xan pp10_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1083_MP17 (VDD XI1083_xn XI1083_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1083_MP6 (XI1083_p1 A_30_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1083_MP8 (XI1083_xn A_29_b3_3 XI1083_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1083_MP7 (XI1083_p1 two10_b3_5 XI1083_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1083_MP5 (VDD one10_b3_5 XI1083_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1083_MP10 (XI1083_xan XI1083_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI912_MP12 (VDD B_15_b3_4 XI912_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI912_MP18 (XI912_xp1 XI912_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI912_MP20 (pp7_24 B_15_b3_4 XI912_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI912_MP19 (XI912_xp1 XI912_xan pp7_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI912_MP17 (VDD XI912_xn XI912_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI912_MP6 (XI912_p1 A_24_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI912_MP8 (XI912_xn A_23_b3_2 XI912_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI912_MP7 (XI912_p1 two7_b3_4 XI912_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI912_MP5 (VDD one7_b3_4 XI912_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI912_MP10 (XI912_xan XI912_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI911_MP12 (VDD B_15_b3_4 XI911_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI911_MP18 (XI911_xp1 XI911_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI911_MP20 (pp7_23 B_15_b3_4 XI911_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI911_MP19 (XI911_xp1 XI911_xan pp7_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI911_MP17 (VDD XI911_xn XI911_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI911_MP6 (XI911_p1 A_23_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI911_MP8 (XI911_xn A_22_b3_2 XI911_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI911_MP7 (XI911_p1 two7_b3_4 XI911_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI911_MP5 (VDD one7_b3_4 XI911_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI911_MP10 (XI911_xan XI911_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI861_MP12 (VDD B_13_b3_4 XI861_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI861_MP18 (XI861_xp1 XI861_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI861_MP20 (pp6_28 B_13_b3_4 XI861_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI861_MP19 (XI861_xp1 XI861_xan pp6_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI861_MP17 (VDD XI861_xn XI861_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI861_MP6 (XI861_p1 A_28_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI861_MP8 (XI861_xn A_27_b3_2 XI861_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI861_MP7 (XI861_p1 two6_b3_5 XI861_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI861_MP5 (VDD one6_b3_5 XI861_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI861_MP10 (XI861_xan XI861_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI810_MP12 (VDD B_11_b3_5 XI810_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI810_MP18 (XI810_xp1 XI810_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI810_MP20 (pp5_32 B_11_b3_5 XI810_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI810_MP19 (XI810_xp1 XI810_xan pp5_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI810_MP17 (VDD XI810_xn XI810_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI810_MP6 (XI810_p1 A_31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI810_MP8 (XI810_xn A_31_b3_2 XI810_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI810_MP7 (XI810_p1 two5_b3_5 XI810_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI810_MP5 (VDD one5_b3_5 XI810_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI810_MP10 (XI810_xan XI810_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1070_MP12 (VDD B_21_b3_3 XI1070_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1070_MP18 (XI1070_xp1 XI1070_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1070_MP20 (pp10_17 B_21_b3_3 XI1070_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1070_MP19 (XI1070_xp1 XI1070_xan pp10_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1070_MP17 (VDD XI1070_xn XI1070_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1070_MP6 (XI1070_p1 A_17_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1070_MP8 (XI1070_xn A_16_b3_3 XI1070_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1070_MP7 (XI1070_p1 two10_b3_3 XI1070_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1070_MP5 (VDD one10_b3_3 XI1070_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1070_MP10 (XI1070_xan XI1070_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1072_MP12 (VDD B_21_b3_3 XI1072_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1072_MP18 (XI1072_xp1 XI1072_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1072_MP20 (pp10_19 B_21_b3_3 XI1072_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1072_MP19 (XI1072_xp1 XI1072_xan pp10_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1072_MP17 (VDD XI1072_xn XI1072_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1072_MP6 (XI1072_p1 A_19_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1072_MP8 (XI1072_xn A_18_b3_3 XI1072_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1072_MP7 (XI1072_p1 two10_b3_3 XI1072_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1072_MP5 (VDD one10_b3_3 XI1072_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1072_MP10 (XI1072_xan XI1072_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1074_MP12 (VDD B_21_b3_3 XI1074_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1074_MP18 (XI1074_xp1 XI1074_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1074_MP20 (pp10_21 B_21_b3_3 XI1074_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1074_MP19 (XI1074_xp1 XI1074_xan pp10_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1074_MP17 (VDD XI1074_xn XI1074_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1074_MP6 (XI1074_p1 A_21_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1074_MP8 (XI1074_xn A_20_b3_3 XI1074_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1074_MP7 (XI1074_p1 two10_b3_3 XI1074_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1074_MP5 (VDD one10_b3_3 XI1074_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1074_MP10 (XI1074_xan XI1074_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1073_MP12 (VDD B_21_b3_3 XI1073_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1073_MP18 (XI1073_xp1 XI1073_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1073_MP20 (pp10_20 B_21_b3_3 XI1073_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1073_MP19 (XI1073_xp1 XI1073_xan pp10_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1073_MP17 (VDD XI1073_xn XI1073_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1073_MP6 (XI1073_p1 A_20_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1073_MP8 (XI1073_xn A_19_b3_3 XI1073_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1073_MP7 (XI1073_p1 two10_b3_3 XI1073_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1073_MP5 (VDD one10_b3_3 XI1073_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1073_MP10 (XI1073_xan XI1073_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1075_MP12 (VDD B_21_b3_3 XI1075_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1075_MP18 (XI1075_xp1 XI1075_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1075_MP20 (pp10_22 B_21_b3_3 XI1075_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1075_MP19 (XI1075_xp1 XI1075_xan pp10_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1075_MP17 (VDD XI1075_xn XI1075_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1075_MP6 (XI1075_p1 A_22_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1075_MP8 (XI1075_xn A_21_b3_3 XI1075_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1075_MP7 (XI1075_p1 two10_b3_4 XI1075_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1075_MP5 (VDD one10_b3_4 XI1075_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1075_MP10 (XI1075_xan XI1075_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1077_MP12 (VDD B_21_b3_4 XI1077_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1077_MP18 (XI1077_xp1 XI1077_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1077_MP20 (pp10_24 B_21_b3_4 XI1077_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1077_MP19 (XI1077_xp1 XI1077_xan pp10_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1077_MP17 (VDD XI1077_xn XI1077_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1077_MP6 (XI1077_p1 A_24_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1077_MP8 (XI1077_xn A_23_b3_3 XI1077_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1077_MP7 (XI1077_p1 two10_b3_4 XI1077_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1077_MP5 (VDD one10_b3_4 XI1077_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1077_MP10 (XI1077_xan XI1077_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1078_MP12 (VDD B_21_b3_4 XI1078_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1078_MP18 (XI1078_xp1 XI1078_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1078_MP20 (pp10_25 B_21_b3_4 XI1078_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1078_MP19 (XI1078_xp1 XI1078_xan pp10_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1078_MP17 (VDD XI1078_xn XI1078_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1078_MP6 (XI1078_p1 A_25_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1078_MP8 (XI1078_xn A_24_b3_3 XI1078_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1078_MP7 (XI1078_p1 two10_b3_4 XI1078_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1078_MP5 (VDD one10_b3_4 XI1078_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1078_MP10 (XI1078_xan XI1078_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1079_MP12 (VDD B_21_b3_4 XI1079_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1079_MP18 (XI1079_xp1 XI1079_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1079_MP20 (pp10_26 B_21_b3_4 XI1079_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1079_MP19 (XI1079_xp1 XI1079_xan pp10_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1079_MP17 (VDD XI1079_xn XI1079_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1079_MP6 (XI1079_p1 A_26_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1079_MP8 (XI1079_xn A_25_b3_3 XI1079_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1079_MP7 (XI1079_p1 two10_b3_4 XI1079_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1079_MP5 (VDD one10_b3_4 XI1079_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1079_MP10 (XI1079_xan XI1079_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1082_MP12 (VDD B_21_b3_5 XI1082_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1082_MP18 (XI1082_xp1 XI1082_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1082_MP20 (pp10_29 B_21_b3_5 XI1082_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1082_MP19 (XI1082_xp1 XI1082_xan pp10_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1082_MP17 (VDD XI1082_xn XI1082_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1082_MP6 (XI1082_p1 A_29_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1082_MP8 (XI1082_xn A_28_b3_3 XI1082_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1082_MP7 (XI1082_p1 two10_b3_5 XI1082_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1082_MP5 (VDD one10_b3_5 XI1082_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1082_MP10 (XI1082_xan XI1082_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI910_MP12 (VDD B_15_b3_3 XI910_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI910_MP18 (XI910_xp1 XI910_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI910_MP20 (pp7_22 B_15_b3_3 XI910_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI910_MP19 (XI910_xp1 XI910_xan pp7_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI910_MP17 (VDD XI910_xn XI910_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI910_MP6 (XI910_p1 A_22_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI910_MP8 (XI910_xn A_21_b3_2 XI910_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI910_MP7 (XI910_p1 two7_b3_4 XI910_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI910_MP5 (VDD one7_b3_4 XI910_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI910_MP10 (XI910_xan XI910_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI859_MP12 (VDD B_13_b3_4 XI859_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI859_MP18 (XI859_xp1 XI859_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI859_MP20 (pp6_26 B_13_b3_4 XI859_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI859_MP19 (XI859_xp1 XI859_xan pp6_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI859_MP17 (VDD XI859_xn XI859_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI859_MP6 (XI859_p1 A_26_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI859_MP8 (XI859_xn A_25_b3_2 XI859_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI859_MP7 (XI859_p1 two6_b3_4 XI859_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI859_MP5 (VDD one6_b3_4 XI859_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI859_MP10 (XI859_xan XI859_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI754_MP12 (VDD B_9_b3_5 XI754_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI754_MP18 (XI754_xp1 XI754_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI754_MP20 (pp4_31 B_9_b3_5 XI754_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI754_MP19 (XI754_xp1 XI754_xan pp4_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI754_MP17 (VDD XI754_xn XI754_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI754_MP6 (XI754_p1 A_31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI754_MP8 (XI754_xn A_30_b3_1 XI754_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI754_MP7 (XI754_p1 two4_b3_5 XI754_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI754_MP5 (VDD one4_b3_5 XI754_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI754_MP10 (XI754_xan XI754_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI858_MP12 (VDD B_13_b3_4 XI858_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI858_MP18 (XI858_xp1 XI858_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI858_MP20 (pp6_25 B_13_b3_4 XI858_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI858_MP19 (XI858_xp1 XI858_xan pp6_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI858_MP17 (VDD XI858_xn XI858_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI858_MP6 (XI858_p1 A_25_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI858_MP8 (XI858_xn A_24_b3_2 XI858_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI858_MP7 (XI858_p1 two6_b3_4 XI858_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI858_MP5 (VDD one6_b3_4 XI858_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI858_MP10 (XI858_xan XI858_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI808_MP12 (VDD B_11_b3_5 XI808_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI808_MP18 (XI808_xp1 XI808_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI808_MP20 (pp5_30 B_11_b3_5 XI808_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI808_MP19 (XI808_xp1 XI808_xan pp5_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI808_MP17 (VDD XI808_xn XI808_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI808_MP6 (XI808_p1 A_30_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI808_MP8 (XI808_xn A_29_b3_2 XI808_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI808_MP7 (XI808_p1 two5_b3_5 XI808_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI808_MP5 (VDD one5_b3_5 XI808_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI808_MP10 (XI808_xan XI808_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI755_MP12 (VDD B_9_b3_5 XI755_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI755_MP18 (XI755_xp1 XI755_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI755_MP20 (pp4_32 B_9_b3_5 XI755_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI755_MP19 (XI755_xp1 XI755_xan pp4_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI755_MP17 (VDD XI755_xn XI755_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI755_MP6 (XI755_p1 A_31_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI755_MP8 (XI755_xn A_31_b3_2 XI755_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI755_MP7 (XI755_p1 two4_b3_5 XI755_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI755_MP5 (VDD one4_b3_5 XI755_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI755_MP10 (XI755_xan XI755_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI963_MP12 (VDD B_17_b3_3 XI963_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI963_MP18 (XI963_xp1 XI963_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI963_MP20 (pp8_20 B_17_b3_3 XI963_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI963_MP19 (XI963_xp1 XI963_xan pp8_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI963_MP17 (VDD XI963_xn XI963_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI963_MP6 (XI963_p1 A_20_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI963_MP8 (XI963_xn A_19_b3_3 XI963_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI963_MP7 (XI963_p1 two8_b3_3 XI963_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI963_MP5 (VDD one8_b3_3 XI963_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI963_MP10 (XI963_xan XI963_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI964_MP12 (VDD B_17_b3_3 XI964_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI964_MP18 (XI964_xp1 XI964_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI964_MP20 (pp8_21 B_17_b3_3 XI964_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI964_MP19 (XI964_xp1 XI964_xan pp8_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI964_MP17 (VDD XI964_xn XI964_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI964_MP6 (XI964_p1 A_21_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI964_MP8 (XI964_xn A_20_b3_3 XI964_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI964_MP7 (XI964_p1 two8_b3_3 XI964_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI964_MP5 (VDD one8_b3_3 XI964_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI964_MP10 (XI964_xan XI964_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI960_MP12 (VDD B_17_b3_3 XI960_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI960_MP18 (XI960_xp1 XI960_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI960_MP20 (pp8_17 B_17_b3_3 XI960_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI960_MP19 (XI960_xp1 XI960_xan pp8_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI960_MP17 (VDD XI960_xn XI960_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI960_MP6 (XI960_p1 A_17_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI960_MP8 (XI960_xn A_16_b3_3 XI960_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI960_MP7 (XI960_p1 two8_b3_3 XI960_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI960_MP5 (VDD one8_b3_3 XI960_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI960_MP10 (XI960_xan XI960_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1071_MP12 (VDD B_21_b3_3 XI1071_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1071_MP18 (XI1071_xp1 XI1071_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1071_MP20 (pp10_18 B_21_b3_3 XI1071_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1071_MP19 (XI1071_xp1 XI1071_xan pp10_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1071_MP17 (VDD XI1071_xn XI1071_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1071_MP6 (XI1071_p1 A_18_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1071_MP8 (XI1071_xn A_17_b3_3 XI1071_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1071_MP7 (XI1071_p1 two10_b3_3 XI1071_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1071_MP5 (VDD one10_b3_3 XI1071_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1071_MP10 (XI1071_xan XI1071_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1131_MP12 (VDD B_23_b3_4 XI1131_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1131_MP18 (XI1131_xp1 XI1131_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1131_MP20 (pp11_23 B_23_b3_4 XI1131_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1131_MP19 (XI1131_xp1 XI1131_xan pp11_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1131_MP17 (VDD XI1131_xn XI1131_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1131_MP6 (XI1131_p1 A_23_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1131_MP8 (XI1131_xn A_22_b3_4 XI1131_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1131_MP7 (XI1131_p1 two11_b3_4 XI1131_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1131_MP5 (VDD one11_b3_4 XI1131_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1131_MP10 (XI1131_xan XI1131_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1085_MP12 (VDD B_21_b3_5 XI1085_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1085_MP18 (XI1085_xp1 XI1085_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1085_MP20 (pp10_32 B_21_b3_5 XI1085_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1085_MP19 (XI1085_xp1 XI1085_xan pp10_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1085_MP17 (VDD XI1085_xn XI1085_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1085_MP6 (XI1085_p1 A_31_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1085_MP8 (XI1085_xn A_31_b3_5 XI1085_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1085_MP7 (XI1085_p1 two10_b3_5 XI1085_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1085_MP5 (VDD one10_b3_5 XI1085_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1085_MP10 (XI1085_xan XI1085_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1084_MP12 (VDD B_21_b3_5 XI1084_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1084_MP18 (XI1084_xp1 XI1084_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1084_MP20 (pp10_31 B_21_b3_5 XI1084_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1084_MP19 (XI1084_xp1 XI1084_xan pp10_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1084_MP17 (VDD XI1084_xn XI1084_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1084_MP6 (XI1084_p1 A_31_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1084_MP8 (XI1084_xn A_30_b3_3 XI1084_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1084_MP7 (XI1084_p1 two10_b3_5 XI1084_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1084_MP5 (VDD one10_b3_5 XI1084_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1084_MP10 (XI1084_xan XI1084_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1135_MP12 (VDD B_23_b3_4 XI1135_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1135_MP18 (XI1135_xp1 XI1135_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1135_MP20 (pp11_27 B_23_b3_4 XI1135_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1135_MP19 (XI1135_xp1 XI1135_xan pp11_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1135_MP17 (VDD XI1135_xn XI1135_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1135_MP6 (XI1135_p1 A_27_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1135_MP8 (XI1135_xn A_26_b3_4 XI1135_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1135_MP7 (XI1135_p1 two11_b3_4 XI1135_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1135_MP5 (VDD one11_b3_4 XI1135_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1135_MP10 (XI1135_xan XI1135_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1134_MP12 (VDD B_23_b3_4 XI1134_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1134_MP18 (XI1134_xp1 XI1134_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1134_MP20 (pp11_26 B_23_b3_4 XI1134_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1134_MP19 (XI1134_xp1 XI1134_xan pp11_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1134_MP17 (VDD XI1134_xn XI1134_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1134_MP6 (XI1134_p1 A_26_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1134_MP8 (XI1134_xn A_25_b3_4 XI1134_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1134_MP7 (XI1134_p1 two11_b3_4 XI1134_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1134_MP5 (VDD one11_b3_4 XI1134_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1134_MP10 (XI1134_xan XI1134_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1190_MP12 (VDD B_25_b3_4 XI1190_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1190_MP18 (XI1190_xp1 XI1190_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1190_MP20 (pp12_27 B_25_b3_4 XI1190_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1190_MP19 (XI1190_xp1 XI1190_xan pp12_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1190_MP17 (VDD XI1190_xn XI1190_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1190_MP6 (XI1190_p1 A_27_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1190_MP8 (XI1190_xn A_26_b3_4 XI1190_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1190_MP7 (XI1190_p1 two12_b3_4 XI1190_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1190_MP5 (VDD one12_b3_4 XI1190_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1190_MP10 (XI1190_xan XI1190_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI856_MP12 (VDD B_13_b3_4 XI856_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI856_MP18 (XI856_xp1 XI856_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI856_MP20 (pp6_23 B_13_b3_4 XI856_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI856_MP19 (XI856_xp1 XI856_xan pp6_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI856_MP17 (VDD XI856_xn XI856_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI856_MP6 (XI856_p1 A_23_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI856_MP8 (XI856_xn A_22_b3_2 XI856_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI856_MP7 (XI856_p1 two6_b3_4 XI856_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI856_MP5 (VDD one6_b3_4 XI856_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI856_MP10 (XI856_xan XI856_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI857_MP12 (VDD B_13_b3_4 XI857_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI857_MP18 (XI857_xp1 XI857_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI857_MP20 (pp6_24 B_13_b3_4 XI857_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI857_MP19 (XI857_xp1 XI857_xan pp6_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI857_MP17 (VDD XI857_xn XI857_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI857_MP6 (XI857_p1 A_24_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI857_MP8 (XI857_xn A_23_b3_2 XI857_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI857_MP7 (XI857_p1 two6_b3_4 XI857_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI857_MP5 (VDD one6_b3_4 XI857_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI857_MP10 (XI857_xan XI857_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI860_MP12 (VDD B_13_b3_4 XI860_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI860_MP18 (XI860_xp1 XI860_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI860_MP20 (pp6_27 B_13_b3_4 XI860_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI860_MP19 (XI860_xp1 XI860_xan pp6_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI860_MP17 (VDD XI860_xn XI860_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI860_MP6 (XI860_p1 A_27_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI860_MP8 (XI860_xn A_26_b3_2 XI860_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI860_MP7 (XI860_p1 two6_b3_4 XI860_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI860_MP5 (VDD one6_b3_4 XI860_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI860_MP10 (XI860_xan XI860_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI807_MP12 (VDD B_11_b3_5 XI807_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI807_MP18 (XI807_xp1 XI807_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI807_MP20 (pp5_29 B_11_b3_5 XI807_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI807_MP19 (XI807_xp1 XI807_xan pp5_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI807_MP17 (VDD XI807_xn XI807_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI807_MP6 (XI807_p1 A_29_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI807_MP8 (XI807_xn A_28_b3_2 XI807_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI807_MP7 (XI807_p1 two5_b3_5 XI807_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI807_MP5 (VDD one5_b3_5 XI807_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI807_MP10 (XI807_xan XI807_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI962_MP12 (VDD B_17_b3_3 XI962_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI962_MP18 (XI962_xp1 XI962_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI962_MP20 (pp8_19 B_17_b3_3 XI962_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI962_MP19 (XI962_xp1 XI962_xan pp8_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI962_MP17 (VDD XI962_xn XI962_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI962_MP6 (XI962_p1 A_19_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI962_MP8 (XI962_xn A_18_b3_3 XI962_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI962_MP7 (XI962_p1 two8_b3_3 XI962_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI962_MP5 (VDD one8_b3_3 XI962_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI962_MP10 (XI962_xan XI962_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI961_MP12 (VDD B_17_b3_3 XI961_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI961_MP18 (XI961_xp1 XI961_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI961_MP20 (pp8_18 B_17_b3_3 XI961_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI961_MP19 (XI961_xp1 XI961_xan pp8_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI961_MP17 (VDD XI961_xn XI961_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI961_MP6 (XI961_p1 A_18_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI961_MP8 (XI961_xn A_17_b3_3 XI961_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI961_MP7 (XI961_p1 two8_b3_3 XI961_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI961_MP5 (VDD one8_b3_3 XI961_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI961_MP10 (XI961_xan XI961_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1183_MP12 (VDD B_25_b3_3 XI1183_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1183_MP18 (XI1183_xp1 XI1183_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1183_MP20 (pp12_20 B_25_b3_3 XI1183_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1183_MP19 (XI1183_xp1 XI1183_xan pp12_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1183_MP17 (VDD XI1183_xn XI1183_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1183_MP6 (XI1183_p1 A_20_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1183_MP8 (XI1183_xn A_19_b3_4 XI1183_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1183_MP7 (XI1183_p1 two12_b3_3 XI1183_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1183_MP5 (VDD one12_b3_3 XI1183_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1183_MP10 (XI1183_xan XI1183_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1184_MP12 (VDD B_25_b3_3 XI1184_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1184_MP18 (XI1184_xp1 XI1184_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1184_MP20 (pp12_21 B_25_b3_3 XI1184_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1184_MP19 (XI1184_xp1 XI1184_xan pp12_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1184_MP17 (VDD XI1184_xn XI1184_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1184_MP6 (XI1184_p1 A_21_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1184_MP8 (XI1184_xn A_20_b3_4 XI1184_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1184_MP7 (XI1184_p1 two12_b3_3 XI1184_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1184_MP5 (VDD one12_b3_3 XI1184_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1184_MP10 (XI1184_xan XI1184_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1185_MP12 (VDD B_25_b3_3 XI1185_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1185_MP18 (XI1185_xp1 XI1185_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1185_MP20 (pp12_22 B_25_b3_3 XI1185_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1185_MP19 (XI1185_xp1 XI1185_xan pp12_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1185_MP17 (VDD XI1185_xn XI1185_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1185_MP6 (XI1185_p1 A_22_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1185_MP8 (XI1185_xn A_21_b3_4 XI1185_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1185_MP7 (XI1185_p1 two12_b3_4 XI1185_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1185_MP5 (VDD one12_b3_4 XI1185_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1185_MP10 (XI1185_xan XI1185_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1130_MP12 (VDD B_23_b3_3 XI1130_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1130_MP18 (XI1130_xp1 XI1130_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1130_MP20 (pp11_22 B_23_b3_3 XI1130_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1130_MP19 (XI1130_xp1 XI1130_xan pp11_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1130_MP17 (VDD XI1130_xn XI1130_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1130_MP6 (XI1130_p1 A_22_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1130_MP8 (XI1130_xn A_21_b3_4 XI1130_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1130_MP7 (XI1130_p1 two11_b3_4 XI1130_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1130_MP5 (VDD one11_b3_4 XI1130_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1130_MP10 (XI1130_xan XI1130_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1132_MP12 (VDD B_23_b3_4 XI1132_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1132_MP18 (XI1132_xp1 XI1132_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1132_MP20 (pp11_24 B_23_b3_4 XI1132_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1132_MP19 (XI1132_xp1 XI1132_xan pp11_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1132_MP17 (VDD XI1132_xn XI1132_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1132_MP6 (XI1132_p1 A_24_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1132_MP8 (XI1132_xn A_23_b3_4 XI1132_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1132_MP7 (XI1132_p1 two11_b3_4 XI1132_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1132_MP5 (VDD one11_b3_4 XI1132_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1132_MP10 (XI1132_xan XI1132_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1133_MP12 (VDD B_23_b3_4 XI1133_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1133_MP18 (XI1133_xp1 XI1133_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1133_MP20 (pp11_25 B_23_b3_4 XI1133_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1133_MP19 (XI1133_xp1 XI1133_xan pp11_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1133_MP17 (VDD XI1133_xn XI1133_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1133_MP6 (XI1133_p1 A_25_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1133_MP8 (XI1133_xn A_24_b3_4 XI1133_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1133_MP7 (XI1133_p1 two11_b3_4 XI1133_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1133_MP5 (VDD one11_b3_4 XI1133_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1133_MP10 (XI1133_xan XI1133_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1186_MP12 (VDD B_25_b3_4 XI1186_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1186_MP18 (XI1186_xp1 XI1186_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1186_MP20 (pp12_23 B_25_b3_4 XI1186_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1186_MP19 (XI1186_xp1 XI1186_xan pp12_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1186_MP17 (VDD XI1186_xn XI1186_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1186_MP6 (XI1186_p1 A_23_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1186_MP8 (XI1186_xn A_22_b3_4 XI1186_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1186_MP7 (XI1186_p1 two12_b3_4 XI1186_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1186_MP5 (VDD one12_b3_4 XI1186_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1186_MP10 (XI1186_xan XI1186_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1189_MP12 (VDD B_25_b3_4 XI1189_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1189_MP18 (XI1189_xp1 XI1189_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1189_MP20 (pp12_26 B_25_b3_4 XI1189_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1189_MP19 (XI1189_xp1 XI1189_xan pp12_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1189_MP17 (VDD XI1189_xn XI1189_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1189_MP6 (XI1189_p1 A_26_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1189_MP8 (XI1189_xn A_25_b3_4 XI1189_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1189_MP7 (XI1189_p1 two12_b3_4 XI1189_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1189_MP5 (VDD one12_b3_4 XI1189_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1189_MP10 (XI1189_xan XI1189_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1187_MP12 (VDD B_25_b3_4 XI1187_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1187_MP18 (XI1187_xp1 XI1187_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1187_MP20 (pp12_24 B_25_b3_4 XI1187_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1187_MP19 (XI1187_xp1 XI1187_xan pp12_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1187_MP17 (VDD XI1187_xn XI1187_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1187_MP6 (XI1187_p1 A_24_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1187_MP8 (XI1187_xn A_23_b3_4 XI1187_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1187_MP7 (XI1187_p1 two12_b3_4 XI1187_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1187_MP5 (VDD one12_b3_4 XI1187_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1187_MP10 (XI1187_xan XI1187_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1188_MP12 (VDD B_25_b3_4 XI1188_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1188_MP18 (XI1188_xp1 XI1188_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1188_MP20 (pp12_25 B_25_b3_4 XI1188_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1188_MP19 (XI1188_xp1 XI1188_xan pp12_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1188_MP17 (VDD XI1188_xn XI1188_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1188_MP6 (XI1188_p1 A_25_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1188_MP8 (XI1188_xn A_24_b3_4 XI1188_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1188_MP7 (XI1188_p1 two12_b3_4 XI1188_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1188_MP5 (VDD one12_b3_4 XI1188_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1188_MP10 (XI1188_xan XI1188_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI855_MP12 (VDD B_13_b3_3 XI855_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI855_MP18 (XI855_xp1 XI855_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI855_MP20 (pp6_22 B_13_b3_3 XI855_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI855_MP19 (XI855_xp1 XI855_xan pp6_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI855_MP17 (VDD XI855_xn XI855_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI855_MP6 (XI855_p1 A_22_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI855_MP8 (XI855_xn A_21_b3_2 XI855_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI855_MP7 (XI855_p1 two6_b3_4 XI855_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI855_MP5 (VDD one6_b3_4 XI855_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI855_MP10 (XI855_xan XI855_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI806_MP12 (VDD B_11_b3_4 XI806_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI806_MP18 (XI806_xp1 XI806_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI806_MP20 (pp5_28 B_11_b3_4 XI806_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI806_MP19 (XI806_xp1 XI806_xan pp5_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI806_MP17 (VDD XI806_xn XI806_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI806_MP6 (XI806_p1 A_28_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI806_MP8 (XI806_xn A_27_b3_2 XI806_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI806_MP7 (XI806_p1 two5_b3_5 XI806_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI806_MP5 (VDD one5_b3_5 XI806_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI806_MP10 (XI806_xan XI806_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI753_MP12 (VDD B_9_b3_5 XI753_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI753_MP18 (XI753_xp1 XI753_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI753_MP20 (pp4_30 B_9_b3_5 XI753_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI753_MP19 (XI753_xp1 XI753_xan pp4_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI753_MP17 (VDD XI753_xn XI753_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI753_MP6 (XI753_p1 A_30_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI753_MP8 (XI753_xn A_29_b3_1 XI753_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI753_MP7 (XI753_p1 two4_b3_5 XI753_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI753_MP5 (VDD one4_b3_5 XI753_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI753_MP10 (XI753_xan XI753_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1129_MP12 (VDD B_23_b3_3 XI1129_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1129_MP18 (XI1129_xp1 XI1129_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1129_MP20 (pp11_21 B_23_b3_3 XI1129_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1129_MP19 (XI1129_xp1 XI1129_xan pp11_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1129_MP17 (VDD XI1129_xn XI1129_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1129_MP6 (XI1129_p1 A_21_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1129_MP8 (XI1129_xn A_20_b3_4 XI1129_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1129_MP7 (XI1129_p1 two11_b3_3 XI1129_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1129_MP5 (VDD one11_b3_3 XI1129_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1129_MP10 (XI1129_xan XI1129_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1128_MP12 (VDD B_23_b3_3 XI1128_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1128_MP18 (XI1128_xp1 XI1128_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1128_MP20 (pp11_20 B_23_b3_3 XI1128_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1128_MP19 (XI1128_xp1 XI1128_xan pp11_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1128_MP17 (VDD XI1128_xn XI1128_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1128_MP6 (XI1128_p1 A_20_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1128_MP8 (XI1128_xn A_19_b3_4 XI1128_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1128_MP7 (XI1128_p1 two11_b3_3 XI1128_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1128_MP5 (VDD one11_b3_3 XI1128_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1128_MP10 (XI1128_xan XI1128_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1182_MP12 (VDD B_25_b3_3 XI1182_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1182_MP18 (XI1182_xp1 XI1182_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1182_MP20 (pp12_19 B_25_b3_3 XI1182_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1182_MP19 (XI1182_xp1 XI1182_xan pp12_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1182_MP17 (VDD XI1182_xn XI1182_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1182_MP6 (XI1182_p1 A_19_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1182_MP8 (XI1182_xn A_18_b3_4 XI1182_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1182_MP7 (XI1182_p1 two12_b3_3 XI1182_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1182_MP5 (VDD one12_b3_3 XI1182_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1182_MP10 (XI1182_xan XI1182_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1238_MP12 (VDD B_27_b3_3 XI1238_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1238_MP18 (XI1238_xp1 XI1238_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1238_MP20 (pp13_20 B_27_b3_3 XI1238_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1238_MP19 (XI1238_xp1 XI1238_xan pp13_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1238_MP17 (VDD XI1238_xn XI1238_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1238_MP6 (XI1238_p1 A_20_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1238_MP8 (XI1238_xn A_19_b3_5 XI1238_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1238_MP7 (XI1238_p1 two13_b3_3 XI1238_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1238_MP5 (VDD one13_b3_3 XI1238_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1238_MP10 (XI1238_xan XI1238_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1239_MP12 (VDD B_27_b3_3 XI1239_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1239_MP18 (XI1239_xp1 XI1239_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1239_MP20 (pp13_21 B_27_b3_3 XI1239_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1239_MP19 (XI1239_xp1 XI1239_xan pp13_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1239_MP17 (VDD XI1239_xn XI1239_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1239_MP6 (XI1239_p1 A_21_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1239_MP8 (XI1239_xn A_20_b3_5 XI1239_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1239_MP7 (XI1239_p1 two13_b3_3 XI1239_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1239_MP5 (VDD one13_b3_3 XI1239_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1239_MP10 (XI1239_xan XI1239_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1294_MP12 (VDD B_29_b3_3 XI1294_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1294_MP18 (XI1294_xp1 XI1294_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1294_MP20 (pp14_21 B_29_b3_3 XI1294_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1294_MP19 (XI1294_xp1 XI1294_xan pp14_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1294_MP17 (VDD XI1294_xn XI1294_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1294_MP6 (XI1294_p1 A_21_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1294_MP8 (XI1294_xn A_20_b3_5 XI1294_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1294_MP7 (XI1294_p1 two14_b3_3 XI1294_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1294_MP5 (VDD one14_b3_3 XI1294_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1294_MP10 (XI1294_xan XI1294_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1240_MP12 (VDD B_27_b3_3 XI1240_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1240_MP18 (XI1240_xp1 XI1240_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1240_MP20 (pp13_22 B_27_b3_3 XI1240_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1240_MP19 (XI1240_xp1 XI1240_xan pp13_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1240_MP17 (VDD XI1240_xn XI1240_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1240_MP6 (XI1240_p1 A_22_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1240_MP8 (XI1240_xn A_21_b3_5 XI1240_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1240_MP7 (XI1240_p1 two13_b3_4 XI1240_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1240_MP5 (VDD one13_b3_4 XI1240_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1240_MP10 (XI1240_xan XI1240_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1348_MP12 (VDD B_31_b3_3 XI1348_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1348_MP18 (XI1348_xp1 XI1348_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1348_MP20 (pp15_20 B_31_b3_3 XI1348_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1348_MP19 (XI1348_xp1 XI1348_xan pp15_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1348_MP17 (VDD XI1348_xn XI1348_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1348_MP6 (XI1348_p1 A_20_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1348_MP8 (XI1348_xn A_19_b3_5 XI1348_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1348_MP7 (XI1348_p1 two15_b3_3 XI1348_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1348_MP5 (VDD one15_b3_3 XI1348_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1348_MP10 (XI1348_xan XI1348_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1241_MP12 (VDD B_27_b3_4 XI1241_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1241_MP18 (XI1241_xp1 XI1241_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1241_MP20 (pp13_23 B_27_b3_4 XI1241_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1241_MP19 (XI1241_xp1 XI1241_xan pp13_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1241_MP17 (VDD XI1241_xn XI1241_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1241_MP6 (XI1241_p1 A_23_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1241_MP8 (XI1241_xn A_22_b3_5 XI1241_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1241_MP7 (XI1241_p1 two13_b3_4 XI1241_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1241_MP5 (VDD one13_b3_4 XI1241_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1241_MP10 (XI1241_xan XI1241_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1243_MP12 (VDD B_27_b3_4 XI1243_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1243_MP18 (XI1243_xp1 XI1243_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1243_MP20 (pp13_25 B_27_b3_4 XI1243_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1243_MP19 (XI1243_xp1 XI1243_xan pp13_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1243_MP17 (VDD XI1243_xn XI1243_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1243_MP6 (XI1243_p1 A_25_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1243_MP8 (XI1243_xn A_24_b3_5 XI1243_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1243_MP7 (XI1243_p1 two13_b3_4 XI1243_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1243_MP5 (VDD one13_b3_4 XI1243_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1243_MP10 (XI1243_xan XI1243_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1242_MP12 (VDD B_27_b3_4 XI1242_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1242_MP18 (XI1242_xp1 XI1242_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1242_MP20 (pp13_24 B_27_b3_4 XI1242_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1242_MP19 (XI1242_xp1 XI1242_xan pp13_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1242_MP17 (VDD XI1242_xn XI1242_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1242_MP6 (XI1242_p1 A_24_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1242_MP8 (XI1242_xn A_23_b3_5 XI1242_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1242_MP7 (XI1242_p1 two13_b3_4 XI1242_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1242_MP5 (VDD one13_b3_4 XI1242_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1242_MP10 (XI1242_xan XI1242_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI804_MP12 (VDD B_11_b3_4 XI804_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI804_MP18 (XI804_xp1 XI804_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI804_MP20 (pp5_26 B_11_b3_4 XI804_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI804_MP19 (XI804_xp1 XI804_xan pp5_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI804_MP17 (VDD XI804_xn XI804_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI804_MP6 (XI804_p1 A_26_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI804_MP8 (XI804_xn A_25_b3_2 XI804_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI804_MP7 (XI804_p1 two5_b3_4 XI804_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI804_MP5 (VDD one5_b3_4 XI804_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI804_MP10 (XI804_xan XI804_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI805_MP12 (VDD B_11_b3_4 XI805_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI805_MP18 (XI805_xp1 XI805_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI805_MP20 (pp5_27 B_11_b3_4 XI805_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI805_MP19 (XI805_xp1 XI805_xan pp5_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI805_MP17 (VDD XI805_xn XI805_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI805_MP6 (XI805_p1 A_27_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI805_MP8 (XI805_xn A_26_b3_2 XI805_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI805_MP7 (XI805_p1 two5_b3_4 XI805_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI805_MP5 (VDD one5_b3_4 XI805_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI805_MP10 (XI805_xan XI805_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI752_MP12 (VDD B_9_b3_5 XI752_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI752_MP18 (XI752_xp1 XI752_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI752_MP20 (pp4_29 B_9_b3_5 XI752_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI752_MP19 (XI752_xp1 XI752_xan pp4_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI752_MP17 (VDD XI752_xn XI752_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI752_MP6 (XI752_p1 A_29_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI752_MP8 (XI752_xn A_28_b3_1 XI752_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI752_MP7 (XI752_p1 two4_b3_5 XI752_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI752_MP5 (VDD one4_b3_5 XI752_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI752_MP10 (XI752_xan XI752_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1177_MP12 (VDD B_25_b3_2 XI1177_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1177_MP18 (XI1177_xp1 XI1177_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1177_MP20 (pp12_14 B_25_b3_2 XI1177_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1177_MP19 (XI1177_xp1 XI1177_xan pp12_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1177_MP17 (VDD XI1177_xn XI1177_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1177_MP6 (XI1177_p1 A_14_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1177_MP8 (XI1177_xn A_13_b3_4 XI1177_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1177_MP7 (XI1177_p1 two12_b3_2 XI1177_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1177_MP5 (VDD one12_b3_2 XI1177_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1177_MP10 (XI1177_xan XI1177_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1126_MP12 (VDD B_23_b3_3 XI1126_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1126_MP18 (XI1126_xp1 XI1126_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1126_MP20 (pp11_18 B_23_b3_3 XI1126_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1126_MP19 (XI1126_xp1 XI1126_xan pp11_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1126_MP17 (VDD XI1126_xn XI1126_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1126_MP6 (XI1126_p1 A_18_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1126_MP8 (XI1126_xn A_17_b3_4 XI1126_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1126_MP7 (XI1126_p1 two11_b3_3 XI1126_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1126_MP5 (VDD one11_b3_3 XI1126_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1126_MP10 (XI1126_xan XI1126_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1127_MP12 (VDD B_23_b3_3 XI1127_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1127_MP18 (XI1127_xp1 XI1127_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1127_MP20 (pp11_19 B_23_b3_3 XI1127_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1127_MP19 (XI1127_xp1 XI1127_xan pp11_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1127_MP17 (VDD XI1127_xn XI1127_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1127_MP6 (XI1127_p1 A_19_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1127_MP8 (XI1127_xn A_18_b3_4 XI1127_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1127_MP7 (XI1127_p1 two11_b3_3 XI1127_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1127_MP5 (VDD one11_b3_3 XI1127_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1127_MP10 (XI1127_xan XI1127_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1180_MP12 (VDD B_25_b3_3 XI1180_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1180_MP18 (XI1180_xp1 XI1180_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1180_MP20 (pp12_17 B_25_b3_3 XI1180_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1180_MP19 (XI1180_xp1 XI1180_xan pp12_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1180_MP17 (VDD XI1180_xn XI1180_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1180_MP6 (XI1180_p1 A_17_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1180_MP8 (XI1180_xn A_16_b3_4 XI1180_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1180_MP7 (XI1180_p1 two12_b3_3 XI1180_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1180_MP5 (VDD one12_b3_3 XI1180_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1180_MP10 (XI1180_xan XI1180_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1237_MP12 (VDD B_27_b3_3 XI1237_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1237_MP18 (XI1237_xp1 XI1237_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1237_MP20 (pp13_19 B_27_b3_3 XI1237_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1237_MP19 (XI1237_xp1 XI1237_xan pp13_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1237_MP17 (VDD XI1237_xn XI1237_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1237_MP6 (XI1237_p1 A_19_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1237_MP8 (XI1237_xn A_18_b3_5 XI1237_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1237_MP7 (XI1237_p1 two13_b3_3 XI1237_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1237_MP5 (VDD one13_b3_3 XI1237_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1237_MP10 (XI1237_xan XI1237_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1293_MP12 (VDD B_29_b3_3 XI1293_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1293_MP18 (XI1293_xp1 XI1293_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1293_MP20 (pp14_20 B_29_b3_3 XI1293_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1293_MP19 (XI1293_xp1 XI1293_xan pp14_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1293_MP17 (VDD XI1293_xn XI1293_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1293_MP6 (XI1293_p1 A_20_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1293_MP8 (XI1293_xn A_19_b3_5 XI1293_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1293_MP7 (XI1293_p1 two14_b3_3 XI1293_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1293_MP5 (VDD one14_b3_3 XI1293_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1293_MP10 (XI1293_xan XI1293_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1347_MP12 (VDD B_31_b3_3 XI1347_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1347_MP18 (XI1347_xp1 XI1347_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1347_MP20 (pp15_19 B_31_b3_3 XI1347_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1347_MP19 (XI1347_xp1 XI1347_xan pp15_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1347_MP17 (VDD XI1347_xn XI1347_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1347_MP6 (XI1347_p1 A_19_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1347_MP8 (XI1347_xn A_18_b3_5 XI1347_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1347_MP7 (XI1347_p1 two15_b3_3 XI1347_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1347_MP5 (VDD one15_b3_3 XI1347_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1347_MP10 (XI1347_xan XI1347_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1295_MP12 (VDD B_29_b3_3 XI1295_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1295_MP18 (XI1295_xp1 XI1295_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1295_MP20 (pp14_22 B_29_b3_3 XI1295_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1295_MP19 (XI1295_xp1 XI1295_xan pp14_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1295_MP17 (VDD XI1295_xn XI1295_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1295_MP6 (XI1295_p1 A_22_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1295_MP8 (XI1295_xn A_21_b3_5 XI1295_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1295_MP7 (XI1295_p1 two14_b3_4 XI1295_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1295_MP5 (VDD one14_b3_4 XI1295_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1295_MP10 (XI1295_xan XI1295_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1349_MP12 (VDD B_31_b3_3 XI1349_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1349_MP18 (XI1349_xp1 XI1349_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1349_MP20 (pp15_21 B_31_b3_3 XI1349_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1349_MP19 (XI1349_xp1 XI1349_xan pp15_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1349_MP17 (VDD XI1349_xn XI1349_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1349_MP6 (XI1349_p1 A_21_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1349_MP8 (XI1349_xn A_20_b3_5 XI1349_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1349_MP7 (XI1349_p1 two15_b3_3 XI1349_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1349_MP5 (VDD one15_b3_3 XI1349_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1349_MP10 (XI1349_xan XI1349_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1244_MP12 (VDD B_27_b3_4 XI1244_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1244_MP18 (XI1244_xp1 XI1244_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1244_MP20 (pp13_26 B_27_b3_4 XI1244_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1244_MP19 (XI1244_xp1 XI1244_xan pp13_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1244_MP17 (VDD XI1244_xn XI1244_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1244_MP6 (XI1244_p1 A_26_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1244_MP8 (XI1244_xn A_25_b3_5 XI1244_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1244_MP7 (XI1244_p1 two13_b3_4 XI1244_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1244_MP5 (VDD one13_b3_4 XI1244_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1244_MP10 (XI1244_xan XI1244_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1297_MP12 (VDD B_29_b3_4 XI1297_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1297_MP18 (XI1297_xp1 XI1297_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1297_MP20 (pp14_24 B_29_b3_4 XI1297_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1297_MP19 (XI1297_xp1 XI1297_xan pp14_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1297_MP17 (VDD XI1297_xn XI1297_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1297_MP6 (XI1297_p1 A_24_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1297_MP8 (XI1297_xn A_23_b3_5 XI1297_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1297_MP7 (XI1297_p1 two14_b3_4 XI1297_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1297_MP5 (VDD one14_b3_4 XI1297_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1297_MP10 (XI1297_xan XI1297_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1296_MP12 (VDD B_29_b3_4 XI1296_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1296_MP18 (XI1296_xp1 XI1296_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1296_MP20 (pp14_23 B_29_b3_4 XI1296_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1296_MP19 (XI1296_xp1 XI1296_xan pp14_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1296_MP17 (VDD XI1296_xn XI1296_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1296_MP6 (XI1296_p1 A_23_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1296_MP8 (XI1296_xn A_22_b3_5 XI1296_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1296_MP7 (XI1296_p1 two14_b3_4 XI1296_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1296_MP5 (VDD one14_b3_4 XI1296_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1296_MP10 (XI1296_xan XI1296_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI801_MP12 (VDD B_11_b3_4 XI801_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI801_MP18 (XI801_xp1 XI801_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI801_MP20 (pp5_23 B_11_b3_4 XI801_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI801_MP19 (XI801_xp1 XI801_xan pp5_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI801_MP17 (VDD XI801_xn XI801_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI801_MP6 (XI801_p1 A_23_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI801_MP8 (XI801_xn A_22_b3_2 XI801_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI801_MP7 (XI801_p1 two5_b3_4 XI801_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI801_MP5 (VDD one5_b3_4 XI801_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI801_MP10 (XI801_xan XI801_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI802_MP12 (VDD B_11_b3_4 XI802_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI802_MP18 (XI802_xp1 XI802_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI802_MP20 (pp5_24 B_11_b3_4 XI802_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI802_MP19 (XI802_xp1 XI802_xan pp5_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI802_MP17 (VDD XI802_xn XI802_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI802_MP6 (XI802_p1 A_24_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI802_MP8 (XI802_xn A_23_b3_2 XI802_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI802_MP7 (XI802_p1 two5_b3_4 XI802_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI802_MP5 (VDD one5_b3_4 XI802_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI802_MP10 (XI802_xan XI802_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI698_MP12 (VDD B_7_b3_5 XI698_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI698_MP18 (XI698_xp1 XI698_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI698_MP20 (pp3_30 B_7_b3_5 XI698_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI698_MP19 (XI698_xp1 XI698_xan pp3_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI698_MP17 (VDD XI698_xn XI698_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI698_MP6 (XI698_p1 A_30_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI698_MP8 (XI698_xn A_29_b3_1 XI698_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI698_MP7 (XI698_p1 two3_b3_5 XI698_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI698_MP5 (VDD one3_b3_5 XI698_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI698_MP10 (XI698_xan XI698_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1124_MP12 (VDD B_23_b3_2 XI1124_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1124_MP18 (XI1124_xp1 XI1124_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1124_MP20 (pp11_16 B_23_b3_2 XI1124_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1124_MP19 (XI1124_xp1 XI1124_xan pp11_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1124_MP17 (VDD XI1124_xn XI1124_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1124_MP6 (XI1124_p1 A_16_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1124_MP8 (XI1124_xn A_15_b3_4 XI1124_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1124_MP7 (XI1124_p1 two11_b3_2 XI1124_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1124_MP5 (VDD one11_b3_2 XI1124_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1124_MP10 (XI1124_xan XI1124_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1123_MP12 (VDD B_23_b3_2 XI1123_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1123_MP18 (XI1123_xp1 XI1123_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1123_MP20 (pp11_15 B_23_b3_2 XI1123_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1123_MP19 (XI1123_xp1 XI1123_xan pp11_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1123_MP17 (VDD XI1123_xn XI1123_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1123_MP6 (XI1123_p1 A_15_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1123_MP8 (XI1123_xn A_14_b3_4 XI1123_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1123_MP7 (XI1123_p1 two11_b3_2 XI1123_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1123_MP5 (VDD one11_b3_2 XI1123_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1123_MP10 (XI1123_xan XI1123_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1176_MP12 (VDD B_25_b3_2 XI1176_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1176_MP18 (XI1176_xp1 XI1176_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1176_MP20 (pp12_13 B_25_b3_2 XI1176_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1176_MP19 (XI1176_xp1 XI1176_xan pp12_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1176_MP17 (VDD XI1176_xn XI1176_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1176_MP6 (XI1176_p1 A_13_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1176_MP8 (XI1176_xn A_12_b3_4 XI1176_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1176_MP7 (XI1176_p1 two12_b3_2 XI1176_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1176_MP5 (VDD one12_b3_2 XI1176_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1176_MP10 (XI1176_xan XI1176_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1178_MP12 (VDD B_25_b3_2 XI1178_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1178_MP18 (XI1178_xp1 XI1178_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1178_MP20 (pp12_15 B_25_b3_2 XI1178_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1178_MP19 (XI1178_xp1 XI1178_xan pp12_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1178_MP17 (VDD XI1178_xn XI1178_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1178_MP6 (XI1178_p1 A_15_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1178_MP8 (XI1178_xn A_14_b3_4 XI1178_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1178_MP7 (XI1178_p1 two12_b3_2 XI1178_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1178_MP5 (VDD one12_b3_2 XI1178_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1178_MP10 (XI1178_xan XI1178_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1179_MP12 (VDD B_25_b3_2 XI1179_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1179_MP18 (XI1179_xp1 XI1179_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1179_MP20 (pp12_16 B_25_b3_2 XI1179_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1179_MP19 (XI1179_xp1 XI1179_xan pp12_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1179_MP17 (VDD XI1179_xn XI1179_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1179_MP6 (XI1179_p1 A_16_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1179_MP8 (XI1179_xn A_15_b3_4 XI1179_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1179_MP7 (XI1179_p1 two12_b3_2 XI1179_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1179_MP5 (VDD one12_b3_2 XI1179_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1179_MP10 (XI1179_xan XI1179_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1234_MP12 (VDD B_27_b3_2 XI1234_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1234_MP18 (XI1234_xp1 XI1234_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1234_MP20 (pp13_16 B_27_b3_2 XI1234_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1234_MP19 (XI1234_xp1 XI1234_xan pp13_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1234_MP17 (VDD XI1234_xn XI1234_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1234_MP6 (XI1234_p1 A_16_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1234_MP8 (XI1234_xn A_15_b3_5 XI1234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1234_MP7 (XI1234_p1 two13_b3_2 XI1234_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1234_MP5 (VDD one13_b3_2 XI1234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1234_MP10 (XI1234_xan XI1234_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1125_MP12 (VDD B_23_b3_3 XI1125_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1125_MP18 (XI1125_xp1 XI1125_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1125_MP20 (pp11_17 B_23_b3_3 XI1125_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1125_MP19 (XI1125_xp1 XI1125_xan pp11_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1125_MP17 (VDD XI1125_xn XI1125_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1125_MP6 (XI1125_p1 A_17_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1125_MP8 (XI1125_xn A_16_b3_4 XI1125_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1125_MP7 (XI1125_p1 two11_b3_3 XI1125_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1125_MP5 (VDD one11_b3_3 XI1125_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1125_MP10 (XI1125_xan XI1125_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1181_MP12 (VDD B_25_b3_3 XI1181_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1181_MP18 (XI1181_xp1 XI1181_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1181_MP20 (pp12_18 B_25_b3_3 XI1181_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1181_MP19 (XI1181_xp1 XI1181_xan pp12_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1181_MP17 (VDD XI1181_xn XI1181_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1181_MP6 (XI1181_p1 A_18_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1181_MP8 (XI1181_xn A_17_b3_4 XI1181_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1181_MP7 (XI1181_p1 two12_b3_3 XI1181_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1181_MP5 (VDD one12_b3_3 XI1181_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1181_MP10 (XI1181_xan XI1181_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1235_MP12 (VDD B_27_b3_3 XI1235_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1235_MP18 (XI1235_xp1 XI1235_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1235_MP20 (pp13_17 B_27_b3_3 XI1235_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1235_MP19 (XI1235_xp1 XI1235_xan pp13_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1235_MP17 (VDD XI1235_xn XI1235_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1235_MP6 (XI1235_p1 A_17_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1235_MP8 (XI1235_xn A_16_b3_5 XI1235_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1235_MP7 (XI1235_p1 two13_b3_3 XI1235_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1235_MP5 (VDD one13_b3_3 XI1235_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1235_MP10 (XI1235_xan XI1235_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1292_MP12 (VDD B_29_b3_3 XI1292_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1292_MP18 (XI1292_xp1 XI1292_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1292_MP20 (pp14_19 B_29_b3_3 XI1292_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1292_MP19 (XI1292_xp1 XI1292_xan pp14_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1292_MP17 (VDD XI1292_xn XI1292_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1292_MP6 (XI1292_p1 A_19_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1292_MP8 (XI1292_xn A_18_b3_5 XI1292_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1292_MP7 (XI1292_p1 two14_b3_3 XI1292_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1292_MP5 (VDD one14_b3_3 XI1292_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1292_MP10 (XI1292_xan XI1292_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1346_MP12 (VDD B_31_b3_3 XI1346_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1346_MP18 (XI1346_xp1 XI1346_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1346_MP20 (pp15_18 B_31_b3_3 XI1346_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1346_MP19 (XI1346_xp1 XI1346_xan pp15_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1346_MP17 (VDD XI1346_xn XI1346_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1346_MP6 (XI1346_p1 A_18_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1346_MP8 (XI1346_xn A_17_b3_5 XI1346_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1346_MP7 (XI1346_p1 two15_b3_3 XI1346_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1346_MP5 (VDD one15_b3_3 XI1346_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1346_MP10 (XI1346_xan XI1346_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1136_MP12 (VDD B_23_b3_4 XI1136_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1136_MP18 (XI1136_xp1 XI1136_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1136_MP20 (pp11_28 B_23_b3_4 XI1136_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1136_MP19 (XI1136_xp1 XI1136_xan pp11_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1136_MP17 (VDD XI1136_xn XI1136_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1136_MP6 (XI1136_p1 A_28_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1136_MP8 (XI1136_xn A_27_b3_4 XI1136_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1136_MP7 (XI1136_p1 two11_b3_5 XI1136_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1136_MP5 (VDD one11_b3_5 XI1136_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1136_MP10 (XI1136_xan XI1136_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1245_MP12 (VDD B_27_b3_4 XI1245_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1245_MP18 (XI1245_xp1 XI1245_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1245_MP20 (pp13_27 B_27_b3_4 XI1245_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1245_MP19 (XI1245_xp1 XI1245_xan pp13_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1245_MP17 (VDD XI1245_xn XI1245_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1245_MP6 (XI1245_p1 A_27_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1245_MP8 (XI1245_xn A_26_b3_5 XI1245_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1245_MP7 (XI1245_p1 two13_b3_4 XI1245_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1245_MP5 (VDD one13_b3_4 XI1245_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1245_MP10 (XI1245_xan XI1245_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1298_MP12 (VDD B_29_b3_4 XI1298_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1298_MP18 (XI1298_xp1 XI1298_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1298_MP20 (pp14_25 B_29_b3_4 XI1298_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1298_MP19 (XI1298_xp1 XI1298_xan pp14_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1298_MP17 (VDD XI1298_xn XI1298_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1298_MP6 (XI1298_p1 A_25_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1298_MP8 (XI1298_xn A_24_b3_5 XI1298_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1298_MP7 (XI1298_p1 two14_b3_4 XI1298_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1298_MP5 (VDD one14_b3_4 XI1298_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1298_MP10 (XI1298_xan XI1298_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI803_MP12 (VDD B_11_b3_4 XI803_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI803_MP18 (XI803_xp1 XI803_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI803_MP20 (pp5_25 B_11_b3_4 XI803_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI803_MP19 (XI803_xp1 XI803_xan pp5_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI803_MP17 (VDD XI803_xn XI803_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI803_MP6 (XI803_p1 A_25_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI803_MP8 (XI803_xn A_24_b3_2 XI803_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI803_MP7 (XI803_p1 two5_b3_4 XI803_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI803_MP5 (VDD one5_b3_4 XI803_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI803_MP10 (XI803_xan XI803_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI699_MP12 (VDD B_7_b3_5 XI699_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI699_MP18 (XI699_xp1 XI699_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI699_MP20 (pp3_31 B_7_b3_5 XI699_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI699_MP19 (XI699_xp1 XI699_xan pp3_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI699_MP17 (VDD XI699_xn XI699_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI699_MP6 (XI699_p1 A_31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI699_MP8 (XI699_xn A_30_b3_1 XI699_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI699_MP7 (XI699_p1 two3_b3_5 XI699_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI699_MP5 (VDD one3_b3_5 XI699_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI699_MP10 (XI699_xan XI699_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1231_MP12 (VDD B_27_b3_2 XI1231_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1231_MP18 (XI1231_xp1 XI1231_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1231_MP20 (pp13_13 B_27_b3_2 XI1231_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1231_MP19 (XI1231_xp1 XI1231_xan pp13_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1231_MP17 (VDD XI1231_xn XI1231_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1231_MP6 (XI1231_p1 A_13_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1231_MP8 (XI1231_xn A_12_b3_5 XI1231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1231_MP7 (XI1231_p1 two13_b3_2 XI1231_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1231_MP5 (VDD one13_b3_2 XI1231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1231_MP10 (XI1231_xan XI1231_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1175_MP12 (VDD B_25_b3_2 XI1175_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1175_MP18 (XI1175_xp1 XI1175_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1175_MP20 (pp12_12 B_25_b3_2 XI1175_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1175_MP19 (XI1175_xp1 XI1175_xan pp12_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1175_MP17 (VDD XI1175_xn XI1175_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1175_MP6 (XI1175_p1 A_12_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1175_MP8 (XI1175_xn A_11_b3_4 XI1175_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1175_MP7 (XI1175_p1 two12_b3_2 XI1175_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1175_MP5 (VDD one12_b3_2 XI1175_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1175_MP10 (XI1175_xan XI1175_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1232_MP12 (VDD B_27_b3_2 XI1232_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1232_MP18 (XI1232_xp1 XI1232_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1232_MP20 (pp13_14 B_27_b3_2 XI1232_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1232_MP19 (XI1232_xp1 XI1232_xan pp13_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1232_MP17 (VDD XI1232_xn XI1232_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1232_MP6 (XI1232_p1 A_14_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1232_MP8 (XI1232_xn A_13_b3_5 XI1232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1232_MP7 (XI1232_p1 two13_b3_2 XI1232_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1232_MP5 (VDD one13_b3_2 XI1232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1232_MP10 (XI1232_xan XI1232_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1233_MP12 (VDD B_27_b3_2 XI1233_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1233_MP18 (XI1233_xp1 XI1233_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1233_MP20 (pp13_15 B_27_b3_2 XI1233_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1233_MP19 (XI1233_xp1 XI1233_xan pp13_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1233_MP17 (VDD XI1233_xn XI1233_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1233_MP6 (XI1233_p1 A_15_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1233_MP8 (XI1233_xn A_14_b3_5 XI1233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1233_MP7 (XI1233_p1 two13_b3_2 XI1233_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1233_MP5 (VDD one13_b3_2 XI1233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1233_MP10 (XI1233_xan XI1233_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1286_MP12 (VDD B_29_b3_2 XI1286_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1286_MP18 (XI1286_xp1 XI1286_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1286_MP20 (pp14_13 B_29_b3_2 XI1286_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1286_MP19 (XI1286_xp1 XI1286_xan pp14_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1286_MP17 (VDD XI1286_xn XI1286_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1286_MP6 (XI1286_p1 A_13_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1286_MP8 (XI1286_xn A_12_b3_5 XI1286_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1286_MP7 (XI1286_p1 two14_b3_2 XI1286_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1286_MP5 (VDD one14_b3_2 XI1286_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1286_MP10 (XI1286_xan XI1286_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1288_MP12 (VDD B_29_b3_2 XI1288_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1288_MP18 (XI1288_xp1 XI1288_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1288_MP20 (pp14_15 B_29_b3_2 XI1288_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1288_MP19 (XI1288_xp1 XI1288_xan pp14_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1288_MP17 (VDD XI1288_xn XI1288_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1288_MP6 (XI1288_p1 A_15_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1288_MP8 (XI1288_xn A_14_b3_5 XI1288_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1288_MP7 (XI1288_p1 two14_b3_2 XI1288_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1288_MP5 (VDD one14_b3_2 XI1288_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1288_MP10 (XI1288_xan XI1288_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1289_MP12 (VDD B_29_b3_2 XI1289_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1289_MP18 (XI1289_xp1 XI1289_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1289_MP20 (pp14_16 B_29_b3_2 XI1289_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1289_MP19 (XI1289_xp1 XI1289_xan pp14_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1289_MP17 (VDD XI1289_xn XI1289_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1289_MP6 (XI1289_p1 A_16_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1289_MP8 (XI1289_xn A_15_b3_5 XI1289_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1289_MP7 (XI1289_p1 two14_b3_2 XI1289_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1289_MP5 (VDD one14_b3_2 XI1289_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1289_MP10 (XI1289_xan XI1289_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1287_MP12 (VDD B_29_b3_2 XI1287_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1287_MP18 (XI1287_xp1 XI1287_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1287_MP20 (pp14_14 B_29_b3_2 XI1287_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1287_MP19 (XI1287_xp1 XI1287_xan pp14_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1287_MP17 (VDD XI1287_xn XI1287_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1287_MP6 (XI1287_p1 A_14_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1287_MP8 (XI1287_xn A_13_b3_5 XI1287_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1287_MP7 (XI1287_p1 two14_b3_2 XI1287_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1287_MP5 (VDD one14_b3_2 XI1287_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1287_MP10 (XI1287_xan XI1287_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1236_MP12 (VDD B_27_b3_3 XI1236_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1236_MP18 (XI1236_xp1 XI1236_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1236_MP20 (pp13_18 B_27_b3_3 XI1236_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1236_MP19 (XI1236_xp1 XI1236_xan pp13_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1236_MP17 (VDD XI1236_xn XI1236_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1236_MP6 (XI1236_p1 A_18_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1236_MP8 (XI1236_xn A_17_b3_5 XI1236_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1236_MP7 (XI1236_p1 two13_b3_3 XI1236_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1236_MP5 (VDD one13_b3_3 XI1236_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1236_MP10 (XI1236_xan XI1236_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1291_MP12 (VDD B_29_b3_3 XI1291_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1291_MP18 (XI1291_xp1 XI1291_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1291_MP20 (pp14_18 B_29_b3_3 XI1291_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1291_MP19 (XI1291_xp1 XI1291_xan pp14_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1291_MP17 (VDD XI1291_xn XI1291_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1291_MP6 (XI1291_p1 A_18_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1291_MP8 (XI1291_xn A_17_b3_5 XI1291_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1291_MP7 (XI1291_p1 two14_b3_3 XI1291_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1291_MP5 (VDD one14_b3_3 XI1291_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1291_MP10 (XI1291_xan XI1291_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1350_MP12 (VDD B_31_b3_3 XI1350_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1350_MP18 (XI1350_xp1 XI1350_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1350_MP20 (pp15_22 B_31_b3_3 XI1350_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1350_MP19 (XI1350_xp1 XI1350_xan pp15_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1350_MP17 (VDD XI1350_xn XI1350_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1350_MP6 (XI1350_p1 A_22_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1350_MP8 (XI1350_xn A_21_b3_5 XI1350_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1350_MP7 (XI1350_p1 two15_b3_4 XI1350_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1350_MP5 (VDD one15_b3_4 XI1350_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1350_MP10 (XI1350_xan XI1350_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1139_MP12 (VDD B_23_b3_5 XI1139_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1139_MP18 (XI1139_xp1 XI1139_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1139_MP20 (pp11_31 B_23_b3_5 XI1139_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1139_MP19 (XI1139_xp1 XI1139_xan pp11_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1139_MP17 (VDD XI1139_xn XI1139_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1139_MP6 (XI1139_p1 A_31_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1139_MP8 (XI1139_xn A_30_b3_4 XI1139_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1139_MP7 (XI1139_p1 two11_b3_5 XI1139_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1139_MP5 (VDD one11_b3_5 XI1139_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1139_MP10 (XI1139_xan XI1139_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1138_MP12 (VDD B_23_b3_5 XI1138_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1138_MP18 (XI1138_xp1 XI1138_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1138_MP20 (pp11_30 B_23_b3_5 XI1138_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1138_MP19 (XI1138_xp1 XI1138_xan pp11_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1138_MP17 (VDD XI1138_xn XI1138_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1138_MP6 (XI1138_p1 A_30_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1138_MP8 (XI1138_xn A_29_b3_4 XI1138_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1138_MP7 (XI1138_p1 two11_b3_5 XI1138_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1138_MP5 (VDD one11_b3_5 XI1138_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1138_MP10 (XI1138_xan XI1138_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1191_MP12 (VDD B_25_b3_4 XI1191_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1191_MP18 (XI1191_xp1 XI1191_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1191_MP20 (pp12_28 B_25_b3_4 XI1191_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1191_MP19 (XI1191_xp1 XI1191_xan pp12_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1191_MP17 (VDD XI1191_xn XI1191_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1191_MP6 (XI1191_p1 A_28_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1191_MP8 (XI1191_xn A_27_b3_4 XI1191_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1191_MP7 (XI1191_p1 two12_b3_5 XI1191_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1191_MP5 (VDD one12_b3_5 XI1191_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1191_MP10 (XI1191_xan XI1191_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1351_MP12 (VDD B_31_b3_4 XI1351_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1351_MP18 (XI1351_xp1 XI1351_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1351_MP20 (pp15_23 B_31_b3_4 XI1351_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1351_MP19 (XI1351_xp1 XI1351_xan pp15_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1351_MP17 (VDD XI1351_xn XI1351_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1351_MP6 (XI1351_p1 A_23_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1351_MP8 (XI1351_xn A_22_b3_5 XI1351_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1351_MP7 (XI1351_p1 two15_b3_4 XI1351_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1351_MP5 (VDD one15_b3_4 XI1351_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1351_MP10 (XI1351_xan XI1351_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI909_MP12 (VDD B_15_b3_3 XI909_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI909_MP18 (XI909_xp1 XI909_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI909_MP20 (pp7_21 B_15_b3_3 XI909_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI909_MP19 (XI909_xp1 XI909_xan pp7_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI909_MP17 (VDD XI909_xn XI909_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI909_MP6 (XI909_p1 A_21_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI909_MP8 (XI909_xn A_20_b3_2 XI909_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI909_MP7 (XI909_p1 two7_b3_3 XI909_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI909_MP5 (VDD one7_b3_3 XI909_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI909_MP10 (XI909_xan XI909_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI749_MP12 (VDD B_9_b3_4 XI749_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI749_MP18 (XI749_xp1 XI749_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI749_MP20 (pp4_26 B_9_b3_4 XI749_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI749_MP19 (XI749_xp1 XI749_xan pp4_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI749_MP17 (VDD XI749_xn XI749_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI749_MP6 (XI749_p1 A_26_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI749_MP8 (XI749_xn A_25_b3_1 XI749_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI749_MP7 (XI749_p1 two4_b3_4 XI749_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI749_MP5 (VDD one4_b3_4 XI749_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI749_MP10 (XI749_xan XI749_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI751_MP12 (VDD B_9_b3_4 XI751_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI751_MP18 (XI751_xp1 XI751_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI751_MP20 (pp4_28 B_9_b3_4 XI751_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI751_MP19 (XI751_xp1 XI751_xan pp4_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI751_MP17 (VDD XI751_xn XI751_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI751_MP6 (XI751_p1 A_28_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI751_MP8 (XI751_xn A_27_b3_1 XI751_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI751_MP7 (XI751_p1 two4_b3_5 XI751_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI751_MP5 (VDD one4_b3_5 XI751_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI751_MP10 (XI751_xan XI751_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI700_MP12 (VDD B_7_b3_5 XI700_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI700_MP18 (XI700_xp1 XI700_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI700_MP20 (pp3_32 B_7_b3_5 XI700_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI700_MP19 (XI700_xp1 XI700_xan pp3_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI700_MP17 (VDD XI700_xn XI700_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI700_MP6 (XI700_p1 A_31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI700_MP8 (XI700_xn A_31_b3_1 XI700_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI700_MP7 (XI700_p1 two3_b3_5 XI700_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI700_MP5 (VDD one3_b3_5 XI700_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI700_MP10 (XI700_xan XI700_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI697_MP12 (VDD B_7_b3_5 XI697_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI697_MP18 (XI697_xp1 XI697_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI697_MP20 (pp3_29 B_7_b3_5 XI697_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI697_MP19 (XI697_xp1 XI697_xan pp3_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI697_MP17 (VDD XI697_xn XI697_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI697_MP6 (XI697_p1 A_29_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI697_MP8 (XI697_xn A_28_b3_1 XI697_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI697_MP7 (XI697_p1 two3_b3_5 XI697_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI697_MP5 (VDD one3_b3_5 XI697_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI697_MP10 (XI697_xan XI697_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI644_MP12 (VDD B_5_b3_5 XI644_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI644_MP18 (XI644_xp1 XI644_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI644_MP20 (pp2_31 B_5_b3_5 XI644_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI644_MP19 (XI644_xp1 XI644_xan pp2_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI644_MP17 (VDD XI644_xn XI644_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI644_MP6 (XI644_p1 A_31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI644_MP8 (XI644_xn A_30_b3_0 XI644_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI644_MP7 (XI644_p1 two2_b3_5 XI644_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI644_MP5 (VDD one2_b3_5 XI644_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI644_MP10 (XI644_xan XI644_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1121_MP12 (VDD B_23_b3_2 XI1121_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1121_MP18 (XI1121_xp1 XI1121_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1121_MP20 (pp11_13 B_23_b3_2 XI1121_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1121_MP19 (XI1121_xp1 XI1121_xan pp11_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1121_MP17 (VDD XI1121_xn XI1121_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1121_MP6 (XI1121_p1 A_13_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1121_MP8 (XI1121_xn A_12_b3_4 XI1121_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1121_MP7 (XI1121_p1 two11_b3_2 XI1121_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1121_MP5 (VDD one11_b3_2 XI1121_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1121_MP10 (XI1121_xan XI1121_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1069_MP12 (VDD B_21_b3_2 XI1069_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1069_MP18 (XI1069_xp1 XI1069_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1069_MP20 (pp10_16 B_21_b3_2 XI1069_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1069_MP19 (XI1069_xp1 XI1069_xan pp10_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1069_MP17 (VDD XI1069_xn XI1069_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1069_MP6 (XI1069_p1 A_16_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1069_MP8 (XI1069_xn A_15_b3_3 XI1069_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1069_MP7 (XI1069_p1 two10_b3_2 XI1069_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1069_MP5 (VDD one10_b3_2 XI1069_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1069_MP10 (XI1069_xan XI1069_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1229_MP12 (VDD B_27_b3_2 XI1229_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1229_MP18 (XI1229_xp1 XI1229_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1229_MP20 (pp13_11 B_27_b3_2 XI1229_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1229_MP19 (XI1229_xp1 XI1229_xan pp13_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1229_MP17 (VDD XI1229_xn XI1229_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1229_MP6 (XI1229_p1 A_11_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1229_MP8 (XI1229_xn A_10_b3_5 XI1229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1229_MP7 (XI1229_p1 two13_b3_2 XI1229_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1229_MP5 (VDD one13_b3_2 XI1229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1229_MP10 (XI1229_xan XI1229_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1122_MP12 (VDD B_23_b3_2 XI1122_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1122_MP18 (XI1122_xp1 XI1122_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1122_MP20 (pp11_14 B_23_b3_2 XI1122_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1122_MP19 (XI1122_xp1 XI1122_xan pp11_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1122_MP17 (VDD XI1122_xn XI1122_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1122_MP6 (XI1122_p1 A_14_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1122_MP8 (XI1122_xn A_13_b3_4 XI1122_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1122_MP7 (XI1122_p1 two11_b3_2 XI1122_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1122_MP5 (VDD one11_b3_2 XI1122_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1122_MP10 (XI1122_xan XI1122_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1230_MP12 (VDD B_27_b3_2 XI1230_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1230_MP18 (XI1230_xp1 XI1230_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1230_MP20 (pp13_12 B_27_b3_2 XI1230_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1230_MP19 (XI1230_xp1 XI1230_xan pp13_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1230_MP17 (VDD XI1230_xn XI1230_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1230_MP6 (XI1230_p1 A_12_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1230_MP8 (XI1230_xn A_11_b3_5 XI1230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1230_MP7 (XI1230_p1 two13_b3_2 XI1230_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1230_MP5 (VDD one13_b3_2 XI1230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1230_MP10 (XI1230_xan XI1230_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1337_MP12 (VDD B_31_b3_1 XI1337_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1337_MP18 (XI1337_xp1 XI1337_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1337_MP20 (pp15_9 B_31_b3_1 XI1337_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1337_MP19 (XI1337_xp1 XI1337_xan pp15_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1337_MP17 (VDD XI1337_xn XI1337_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1337_MP6 (XI1337_p1 A_9_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1337_MP8 (XI1337_xn A_8_b3_5 XI1337_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1337_MP7 (XI1337_p1 two15_b3_1 XI1337_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1337_MP5 (VDD one15_b3_1 XI1337_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1337_MP10 (XI1337_xan XI1337_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1338_MP12 (VDD B_31_b3_1 XI1338_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1338_MP18 (XI1338_xp1 XI1338_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1338_MP20 (pp15_10 B_31_b3_1 XI1338_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1338_MP19 (XI1338_xp1 XI1338_xan pp15_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1338_MP17 (VDD XI1338_xn XI1338_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1338_MP6 (XI1338_p1 A_10_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1338_MP8 (XI1338_xn A_9_b3_5 XI1338_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1338_MP7 (XI1338_p1 two15_b3_1 XI1338_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1338_MP5 (VDD one15_b3_1 XI1338_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1338_MP10 (XI1338_xan XI1338_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1285_MP12 (VDD B_29_b3_2 XI1285_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1285_MP18 (XI1285_xp1 XI1285_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1285_MP20 (pp14_12 B_29_b3_2 XI1285_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1285_MP19 (XI1285_xp1 XI1285_xan pp14_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1285_MP17 (VDD XI1285_xn XI1285_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1285_MP6 (XI1285_p1 A_12_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1285_MP8 (XI1285_xn A_11_b3_5 XI1285_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1285_MP7 (XI1285_p1 two14_b3_2 XI1285_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1285_MP5 (VDD one14_b3_2 XI1285_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1285_MP10 (XI1285_xan XI1285_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1284_MP12 (VDD B_29_b3_2 XI1284_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1284_MP18 (XI1284_xp1 XI1284_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1284_MP20 (pp14_11 B_29_b3_2 XI1284_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1284_MP19 (XI1284_xp1 XI1284_xan pp14_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1284_MP17 (VDD XI1284_xn XI1284_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1284_MP6 (XI1284_p1 A_11_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1284_MP8 (XI1284_xn A_10_b3_5 XI1284_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1284_MP7 (XI1284_p1 two14_b3_2 XI1284_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1284_MP5 (VDD one14_b3_2 XI1284_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1284_MP10 (XI1284_xan XI1284_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1340_MP12 (VDD B_31_b3_2 XI1340_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1340_MP18 (XI1340_xp1 XI1340_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1340_MP20 (pp15_12 B_31_b3_2 XI1340_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1340_MP19 (XI1340_xp1 XI1340_xan pp15_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1340_MP17 (VDD XI1340_xn XI1340_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1340_MP6 (XI1340_p1 A_12_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1340_MP8 (XI1340_xn A_11_b3_5 XI1340_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1340_MP7 (XI1340_p1 two15_b3_2 XI1340_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1340_MP5 (VDD one15_b3_2 XI1340_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1340_MP10 (XI1340_xan XI1340_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1341_MP12 (VDD B_31_b3_2 XI1341_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1341_MP18 (XI1341_xp1 XI1341_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1341_MP20 (pp15_13 B_31_b3_2 XI1341_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1341_MP19 (XI1341_xp1 XI1341_xan pp15_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1341_MP17 (VDD XI1341_xn XI1341_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1341_MP6 (XI1341_p1 A_13_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1341_MP8 (XI1341_xn A_12_b3_5 XI1341_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1341_MP7 (XI1341_p1 two15_b3_2 XI1341_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1341_MP5 (VDD one15_b3_2 XI1341_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1341_MP10 (XI1341_xan XI1341_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1343_MP12 (VDD B_31_b3_2 XI1343_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1343_MP18 (XI1343_xp1 XI1343_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1343_MP20 (pp15_15 B_31_b3_2 XI1343_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1343_MP19 (XI1343_xp1 XI1343_xan pp15_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1343_MP17 (VDD XI1343_xn XI1343_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1343_MP6 (XI1343_p1 A_15_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1343_MP8 (XI1343_xn A_14_b3_5 XI1343_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1343_MP7 (XI1343_p1 two15_b3_2 XI1343_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1343_MP5 (VDD one15_b3_2 XI1343_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1343_MP10 (XI1343_xan XI1343_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1342_MP12 (VDD B_31_b3_2 XI1342_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1342_MP18 (XI1342_xp1 XI1342_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1342_MP20 (pp15_14 B_31_b3_2 XI1342_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1342_MP19 (XI1342_xp1 XI1342_xan pp15_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1342_MP17 (VDD XI1342_xn XI1342_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1342_MP6 (XI1342_p1 A_14_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1342_MP8 (XI1342_xn A_13_b3_5 XI1342_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1342_MP7 (XI1342_p1 two15_b3_2 XI1342_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1342_MP5 (VDD one15_b3_2 XI1342_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1342_MP10 (XI1342_xan XI1342_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1290_MP12 (VDD B_29_b3_3 XI1290_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1290_MP18 (XI1290_xp1 XI1290_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1290_MP20 (pp14_17 B_29_b3_3 XI1290_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1290_MP19 (XI1290_xp1 XI1290_xan pp14_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1290_MP17 (VDD XI1290_xn XI1290_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1290_MP6 (XI1290_p1 A_17_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1290_MP8 (XI1290_xn A_16_b3_5 XI1290_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1290_MP7 (XI1290_p1 two14_b3_3 XI1290_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1290_MP5 (VDD one14_b3_3 XI1290_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1290_MP10 (XI1290_xan XI1290_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1345_MP12 (VDD B_31_b3_3 XI1345_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1345_MP18 (XI1345_xp1 XI1345_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1345_MP20 (pp15_17 B_31_b3_3 XI1345_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1345_MP19 (XI1345_xp1 XI1345_xan pp15_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1345_MP17 (VDD XI1345_xn XI1345_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1345_MP6 (XI1345_p1 A_17_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1345_MP8 (XI1345_xn A_16_b3_5 XI1345_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1345_MP7 (XI1345_p1 two15_b3_3 XI1345_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1345_MP5 (VDD one15_b3_3 XI1345_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1345_MP10 (XI1345_xan XI1345_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1140_MP12 (VDD B_23_b3_5 XI1140_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1140_MP18 (XI1140_xp1 XI1140_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1140_MP20 (pp11_32 B_23_b3_5 XI1140_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1140_MP19 (XI1140_xp1 XI1140_xan pp11_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1140_MP17 (VDD XI1140_xn XI1140_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1140_MP6 (XI1140_p1 A_31_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1140_MP8 (XI1140_xn A_31_b3_5 XI1140_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1140_MP7 (XI1140_p1 two11_b3_5 XI1140_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1140_MP5 (VDD one11_b3_5 XI1140_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1140_MP10 (XI1140_xan XI1140_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1137_MP12 (VDD B_23_b3_5 XI1137_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1137_MP18 (XI1137_xp1 XI1137_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1137_MP20 (pp11_29 B_23_b3_5 XI1137_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1137_MP19 (XI1137_xp1 XI1137_xan pp11_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1137_MP17 (VDD XI1137_xn XI1137_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1137_MP6 (XI1137_p1 A_29_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1137_MP8 (XI1137_xn A_28_b3_4 XI1137_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1137_MP7 (XI1137_p1 two11_b3_5 XI1137_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1137_MP5 (VDD one11_b3_5 XI1137_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1137_MP10 (XI1137_xan XI1137_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1299_MP12 (VDD B_29_b3_4 XI1299_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1299_MP18 (XI1299_xp1 XI1299_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1299_MP20 (pp14_26 B_29_b3_4 XI1299_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1299_MP19 (XI1299_xp1 XI1299_xan pp14_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1299_MP17 (VDD XI1299_xn XI1299_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1299_MP6 (XI1299_p1 A_26_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1299_MP8 (XI1299_xn A_25_b3_5 XI1299_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1299_MP7 (XI1299_p1 two14_b3_4 XI1299_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1299_MP5 (VDD one14_b3_4 XI1299_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1299_MP10 (XI1299_xan XI1299_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1352_MP12 (VDD B_31_b3_4 XI1352_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1352_MP18 (XI1352_xp1 XI1352_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1352_MP20 (pp15_24 B_31_b3_4 XI1352_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1352_MP19 (XI1352_xp1 XI1352_xan pp15_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1352_MP17 (VDD XI1352_xn XI1352_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1352_MP6 (XI1352_p1 A_24_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1352_MP8 (XI1352_xn A_23_b3_5 XI1352_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1352_MP7 (XI1352_p1 two15_b3_4 XI1352_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1352_MP5 (VDD one15_b3_4 XI1352_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1352_MP10 (XI1352_xan XI1352_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI908_MP12 (VDD B_15_b3_3 XI908_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI908_MP18 (XI908_xp1 XI908_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI908_MP20 (pp7_20 B_15_b3_3 XI908_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI908_MP19 (XI908_xp1 XI908_xan pp7_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI908_MP17 (VDD XI908_xn XI908_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI908_MP6 (XI908_p1 A_20_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI908_MP8 (XI908_xn A_19_b3_2 XI908_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI908_MP7 (XI908_p1 two7_b3_3 XI908_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI908_MP5 (VDD one7_b3_3 XI908_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI908_MP10 (XI908_xan XI908_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI748_MP12 (VDD B_9_b3_4 XI748_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI748_MP18 (XI748_xp1 XI748_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI748_MP20 (pp4_25 B_9_b3_4 XI748_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI748_MP19 (XI748_xp1 XI748_xan pp4_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI748_MP17 (VDD XI748_xn XI748_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI748_MP6 (XI748_p1 A_25_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI748_MP8 (XI748_xn A_24_b3_1 XI748_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI748_MP7 (XI748_p1 two4_b3_4 XI748_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI748_MP5 (VDD one4_b3_4 XI748_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI748_MP10 (XI748_xan XI748_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI750_MP12 (VDD B_9_b3_4 XI750_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI750_MP18 (XI750_xp1 XI750_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI750_MP20 (pp4_27 B_9_b3_4 XI750_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI750_MP19 (XI750_xp1 XI750_xan pp4_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI750_MP17 (VDD XI750_xn XI750_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI750_MP6 (XI750_p1 A_27_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI750_MP8 (XI750_xn A_26_b3_1 XI750_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI750_MP7 (XI750_p1 two4_b3_4 XI750_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI750_MP5 (VDD one4_b3_4 XI750_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI750_MP10 (XI750_xan XI750_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI696_MP12 (VDD B_7_b3_4 XI696_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI696_MP18 (XI696_xp1 XI696_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI696_MP20 (pp3_28 B_7_b3_4 XI696_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI696_MP19 (XI696_xp1 XI696_xan pp3_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI696_MP17 (VDD XI696_xn XI696_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI696_MP6 (XI696_p1 A_28_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI696_MP8 (XI696_xn A_27_b3_1 XI696_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI696_MP7 (XI696_p1 two3_b3_5 XI696_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI696_MP5 (VDD one3_b3_5 XI696_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI696_MP10 (XI696_xan XI696_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI645_MP12 (VDD B_5_b3_5 XI645_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI645_MP18 (XI645_xp1 XI645_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI645_MP20 (pp2_32 B_5_b3_5 XI645_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI645_MP19 (XI645_xp1 XI645_xan pp2_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI645_MP17 (VDD XI645_xn XI645_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI645_MP6 (XI645_p1 A_31_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI645_MP8 (XI645_xn A_31_b3_1 XI645_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI645_MP7 (XI645_p1 two2_b3_5 XI645_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI645_MP5 (VDD one2_b3_5 XI645_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI645_MP10 (XI645_xan XI645_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1120_MP12 (VDD B_23_b3_2 XI1120_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1120_MP18 (XI1120_xp1 XI1120_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1120_MP20 (pp11_12 B_23_b3_2 XI1120_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1120_MP19 (XI1120_xp1 XI1120_xan pp11_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1120_MP17 (VDD XI1120_xn XI1120_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1120_MP6 (XI1120_p1 A_12_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1120_MP8 (XI1120_xn A_11_b3_4 XI1120_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1120_MP7 (XI1120_p1 two11_b3_2 XI1120_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1120_MP5 (VDD one11_b3_2 XI1120_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1120_MP10 (XI1120_xan XI1120_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1068_MP12 (VDD B_21_b3_2 XI1068_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1068_MP18 (XI1068_xp1 XI1068_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1068_MP20 (pp10_15 B_21_b3_2 XI1068_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1068_MP19 (XI1068_xp1 XI1068_xan pp10_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1068_MP17 (VDD XI1068_xn XI1068_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1068_MP6 (XI1068_p1 A_15_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1068_MP8 (XI1068_xn A_14_b3_3 XI1068_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1068_MP7 (XI1068_p1 two10_b3_2 XI1068_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1068_MP5 (VDD one10_b3_2 XI1068_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1068_MP10 (XI1068_xan XI1068_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1283_MP12 (VDD B_29_b3_1 XI1283_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1283_MP18 (XI1283_xp1 XI1283_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1283_MP20 (pp14_10 B_29_b3_1 XI1283_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1283_MP19 (XI1283_xp1 XI1283_xan pp14_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1283_MP17 (VDD XI1283_xn XI1283_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1283_MP6 (XI1283_p1 A_10_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1283_MP8 (XI1283_xn A_9_b3_5 XI1283_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1283_MP7 (XI1283_p1 two14_b3_1 XI1283_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1283_MP5 (VDD one14_b3_1 XI1283_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1283_MP10 (XI1283_xan XI1283_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1281_MP12 (VDD B_29_b3_1 XI1281_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1281_MP18 (XI1281_xp1 XI1281_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1281_MP20 (pp14_8 B_29_b3_1 XI1281_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1281_MP19 (XI1281_xp1 XI1281_xan pp14_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1281_MP17 (VDD XI1281_xn XI1281_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1281_MP6 (XI1281_p1 A_8_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1281_MP8 (XI1281_xn A_7_b3_5 XI1281_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1281_MP7 (XI1281_p1 two14_b3_1 XI1281_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1281_MP5 (VDD one14_b3_1 XI1281_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1281_MP10 (XI1281_xan XI1281_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1336_MP12 (VDD B_31_b3_1 XI1336_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1336_MP18 (XI1336_xp1 XI1336_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1336_MP20 (pp15_8 B_31_b3_1 XI1336_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1336_MP19 (XI1336_xp1 XI1336_xan pp15_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1336_MP17 (VDD XI1336_xn XI1336_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1336_MP6 (XI1336_p1 A_8_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1336_MP8 (XI1336_xn A_7_b3_5 XI1336_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1336_MP7 (XI1336_p1 two15_b3_1 XI1336_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1336_MP5 (VDD one15_b3_1 XI1336_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1336_MP10 (XI1336_xan XI1336_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1334_MP12 (VDD B_31_b3_1 XI1334_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1334_MP18 (XI1334_xp1 XI1334_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1334_MP20 (pp15_6 B_31_b3_1 XI1334_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1334_MP19 (XI1334_xp1 XI1334_xan pp15_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1334_MP17 (VDD XI1334_xn XI1334_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1334_MP6 (XI1334_p1 A_6_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1334_MP8 (XI1334_xn A_5_b3_5 XI1334_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1334_MP7 (XI1334_p1 two15_b3_1 XI1334_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1334_MP5 (VDD one15_b3_1 XI1334_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1334_MP10 (XI1334_xan XI1334_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1335_MP12 (VDD B_31_b3_1 XI1335_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1335_MP18 (XI1335_xp1 XI1335_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1335_MP20 (pp15_7 B_31_b3_1 XI1335_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1335_MP19 (XI1335_xp1 XI1335_xan pp15_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1335_MP17 (VDD XI1335_xn XI1335_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1335_MP6 (XI1335_p1 A_7_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1335_MP8 (XI1335_xn A_6_b3_5 XI1335_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1335_MP7 (XI1335_p1 two15_b3_1 XI1335_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1335_MP5 (VDD one15_b3_1 XI1335_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1335_MP10 (XI1335_xan XI1335_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1339_MP12 (VDD B_31_b3_2 XI1339_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1339_MP18 (XI1339_xp1 XI1339_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1339_MP20 (pp15_11 B_31_b3_2 XI1339_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1339_MP19 (XI1339_xp1 XI1339_xan pp15_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1339_MP17 (VDD XI1339_xn XI1339_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1339_MP6 (XI1339_p1 A_11_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1339_MP8 (XI1339_xn A_10_b3_5 XI1339_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1339_MP7 (XI1339_p1 two15_b3_2 XI1339_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1339_MP5 (VDD one15_b3_2 XI1339_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1339_MP10 (XI1339_xan XI1339_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1344_MP12 (VDD B_31_b3_2 XI1344_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1344_MP18 (XI1344_xp1 XI1344_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1344_MP20 (pp15_16 B_31_b3_2 XI1344_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1344_MP19 (XI1344_xp1 XI1344_xan pp15_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1344_MP17 (VDD XI1344_xn XI1344_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1344_MP6 (XI1344_p1 A_16_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1344_MP8 (XI1344_xn A_15_b3_5 XI1344_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1344_MP7 (XI1344_p1 two15_b3_2 XI1344_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1344_MP5 (VDD one15_b3_2 XI1344_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1344_MP10 (XI1344_xan XI1344_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1193_MP12 (VDD B_25_b3_5 XI1193_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1193_MP18 (XI1193_xp1 XI1193_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1193_MP20 (pp12_30 B_25_b3_5 XI1193_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1193_MP19 (XI1193_xp1 XI1193_xan pp12_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1193_MP17 (VDD XI1193_xn XI1193_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1193_MP6 (XI1193_p1 A_30_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1193_MP8 (XI1193_xn A_29_b3_4 XI1193_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1193_MP7 (XI1193_p1 two12_b3_5 XI1193_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1193_MP5 (VDD one12_b3_5 XI1193_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1193_MP10 (XI1193_xan XI1193_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1192_MP12 (VDD B_25_b3_5 XI1192_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1192_MP18 (XI1192_xp1 XI1192_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1192_MP20 (pp12_29 B_25_b3_5 XI1192_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1192_MP19 (XI1192_xp1 XI1192_xan pp12_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1192_MP17 (VDD XI1192_xn XI1192_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1192_MP6 (XI1192_p1 A_29_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1192_MP8 (XI1192_xn A_28_b3_4 XI1192_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1192_MP7 (XI1192_p1 two12_b3_5 XI1192_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1192_MP5 (VDD one12_b3_5 XI1192_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1192_MP10 (XI1192_xan XI1192_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1300_MP12 (VDD B_29_b3_4 XI1300_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1300_MP18 (XI1300_xp1 XI1300_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1300_MP20 (pp14_27 B_29_b3_4 XI1300_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1300_MP19 (XI1300_xp1 XI1300_xan pp14_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1300_MP17 (VDD XI1300_xn XI1300_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1300_MP6 (XI1300_p1 A_27_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1300_MP8 (XI1300_xn A_26_b3_5 XI1300_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1300_MP7 (XI1300_p1 two14_b3_4 XI1300_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1300_MP5 (VDD one14_b3_4 XI1300_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1300_MP10 (XI1300_xan XI1300_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI907_MP12 (VDD B_15_b3_3 XI907_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI907_MP18 (XI907_xp1 XI907_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI907_MP20 (pp7_19 B_15_b3_3 XI907_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI907_MP19 (XI907_xp1 XI907_xan pp7_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI907_MP17 (VDD XI907_xn XI907_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI907_MP6 (XI907_p1 A_19_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI907_MP8 (XI907_xn A_18_b3_2 XI907_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI907_MP7 (XI907_p1 two7_b3_3 XI907_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI907_MP5 (VDD one7_b3_3 XI907_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI907_MP10 (XI907_xan XI907_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI854_MP12 (VDD B_13_b3_3 XI854_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI854_MP18 (XI854_xp1 XI854_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI854_MP20 (pp6_21 B_13_b3_3 XI854_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI854_MP19 (XI854_xp1 XI854_xan pp6_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI854_MP17 (VDD XI854_xn XI854_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI854_MP6 (XI854_p1 A_21_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI854_MP8 (XI854_xn A_20_b3_2 XI854_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI854_MP7 (XI854_p1 two6_b3_3 XI854_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI854_MP5 (VDD one6_b3_3 XI854_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI854_MP10 (XI854_xan XI854_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI800_MP12 (VDD B_11_b3_3 XI800_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI800_MP18 (XI800_xp1 XI800_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI800_MP20 (pp5_22 B_11_b3_3 XI800_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI800_MP19 (XI800_xp1 XI800_xan pp5_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI800_MP17 (VDD XI800_xn XI800_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI800_MP6 (XI800_p1 A_22_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI800_MP8 (XI800_xn A_21_b3_2 XI800_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI800_MP7 (XI800_p1 two5_b3_4 XI800_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI800_MP5 (VDD one5_b3_4 XI800_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI800_MP10 (XI800_xan XI800_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI694_MP12 (VDD B_7_b3_4 XI694_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI694_MP18 (XI694_xp1 XI694_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI694_MP20 (pp3_26 B_7_b3_4 XI694_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI694_MP19 (XI694_xp1 XI694_xan pp3_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI694_MP17 (VDD XI694_xn XI694_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI694_MP6 (XI694_p1 A_26_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI694_MP8 (XI694_xn A_25_b3_1 XI694_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI694_MP7 (XI694_p1 two3_b3_4 XI694_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI694_MP5 (VDD one3_b3_4 XI694_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI694_MP10 (XI694_xan XI694_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI695_MP12 (VDD B_7_b3_4 XI695_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI695_MP18 (XI695_xp1 XI695_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI695_MP20 (pp3_27 B_7_b3_4 XI695_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI695_MP19 (XI695_xp1 XI695_xan pp3_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI695_MP17 (VDD XI695_xn XI695_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI695_MP6 (XI695_p1 A_27_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI695_MP8 (XI695_xn A_26_b3_1 XI695_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI695_MP7 (XI695_p1 two3_b3_4 XI695_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI695_MP5 (VDD one3_b3_4 XI695_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI695_MP10 (XI695_xan XI695_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI643_MP12 (VDD B_5_b3_5 XI643_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI643_MP18 (XI643_xp1 XI643_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI643_MP20 (pp2_30 B_5_b3_5 XI643_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI643_MP19 (XI643_xp1 XI643_xan pp2_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI643_MP17 (VDD XI643_xn XI643_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI643_MP6 (XI643_p1 A_30_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI643_MP8 (XI643_xn A_29_b3_0 XI643_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI643_MP7 (XI643_p1 two2_b3_5 XI643_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI643_MP5 (VDD one2_b3_5 XI643_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI643_MP10 (XI643_xan XI643_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1119_MP12 (VDD B_23_b3_2 XI1119_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1119_MP18 (XI1119_xp1 XI1119_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1119_MP20 (pp11_11 B_23_b3_2 XI1119_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1119_MP19 (XI1119_xp1 XI1119_xan pp11_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1119_MP17 (VDD XI1119_xn XI1119_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1119_MP6 (XI1119_p1 A_11_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1119_MP8 (XI1119_xn A_10_b3_4 XI1119_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1119_MP7 (XI1119_p1 two11_b3_2 XI1119_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1119_MP5 (VDD one11_b3_2 XI1119_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1119_MP10 (XI1119_xan XI1119_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1067_MP12 (VDD B_21_b3_2 XI1067_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1067_MP18 (XI1067_xp1 XI1067_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1067_MP20 (pp10_14 B_21_b3_2 XI1067_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1067_MP19 (XI1067_xp1 XI1067_xan pp10_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1067_MP17 (VDD XI1067_xn XI1067_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1067_MP6 (XI1067_p1 A_14_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1067_MP8 (XI1067_xn A_13_b3_3 XI1067_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1067_MP7 (XI1067_p1 two10_b3_2 XI1067_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1067_MP5 (VDD one10_b3_2 XI1067_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1067_MP10 (XI1067_xan XI1067_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1282_MP12 (VDD B_29_b3_1 XI1282_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1282_MP18 (XI1282_xp1 XI1282_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1282_MP20 (pp14_9 B_29_b3_1 XI1282_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1282_MP19 (XI1282_xp1 XI1282_xan pp14_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1282_MP17 (VDD XI1282_xn XI1282_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1282_MP6 (XI1282_p1 A_9_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1282_MP8 (XI1282_xn A_8_b3_5 XI1282_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1282_MP7 (XI1282_p1 two14_b3_1 XI1282_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1282_MP5 (VDD one14_b3_1 XI1282_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1282_MP10 (XI1282_xan XI1282_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1174_MP12 (VDD B_25_b3_2 XI1174_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1174_MP18 (XI1174_xp1 XI1174_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1174_MP20 (pp12_11 B_25_b3_2 XI1174_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1174_MP19 (XI1174_xp1 XI1174_xan pp12_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1174_MP17 (VDD XI1174_xn XI1174_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1174_MP6 (XI1174_p1 A_11_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1174_MP8 (XI1174_xn A_10_b3_4 XI1174_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1174_MP7 (XI1174_p1 two12_b3_2 XI1174_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1174_MP5 (VDD one12_b3_2 XI1174_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1174_MP10 (XI1174_xan XI1174_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1280_MP12 (VDD B_29_b3_1 XI1280_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1280_MP18 (XI1280_xp1 XI1280_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1280_MP20 (pp14_7 B_29_b3_1 XI1280_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1280_MP19 (XI1280_xp1 XI1280_xan pp14_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1280_MP17 (VDD XI1280_xn XI1280_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1280_MP6 (XI1280_p1 A_7_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1280_MP8 (XI1280_xn A_6_b3_5 XI1280_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1280_MP7 (XI1280_p1 two14_b3_1 XI1280_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1280_MP5 (VDD one14_b3_1 XI1280_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1280_MP10 (XI1280_xan XI1280_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1279_MP12 (VDD B_29_b3_1 XI1279_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1279_MP18 (XI1279_xp1 XI1279_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1279_MP20 (pp14_6 B_29_b3_1 XI1279_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1279_MP19 (XI1279_xp1 XI1279_xan pp14_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1279_MP17 (VDD XI1279_xn XI1279_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1279_MP6 (XI1279_p1 A_6_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1279_MP8 (XI1279_xn A_5_b3_5 XI1279_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1279_MP7 (XI1279_p1 two14_b3_1 XI1279_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1279_MP5 (VDD one14_b3_1 XI1279_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1279_MP10 (XI1279_xan XI1279_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1247_MP12 (VDD B_27_b3_5 XI1247_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1247_MP18 (XI1247_xp1 XI1247_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1247_MP20 (pp13_29 B_27_b3_5 XI1247_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1247_MP19 (XI1247_xp1 XI1247_xan pp13_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1247_MP17 (VDD XI1247_xn XI1247_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1247_MP6 (XI1247_p1 A_29_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1247_MP8 (XI1247_xn A_28_b3_5 XI1247_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1247_MP7 (XI1247_p1 two13_b3_5 XI1247_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1247_MP5 (VDD one13_b3_5 XI1247_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1247_MP10 (XI1247_xan XI1247_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1246_MP12 (VDD B_27_b3_4 XI1246_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1246_MP18 (XI1246_xp1 XI1246_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1246_MP20 (pp13_28 B_27_b3_4 XI1246_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1246_MP19 (XI1246_xp1 XI1246_xan pp13_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1246_MP17 (VDD XI1246_xn XI1246_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1246_MP6 (XI1246_p1 A_28_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1246_MP8 (XI1246_xn A_27_b3_5 XI1246_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1246_MP7 (XI1246_p1 two13_b3_5 XI1246_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1246_MP5 (VDD one13_b3_5 XI1246_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1246_MP10 (XI1246_xan XI1246_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1355_MP12 (VDD B_31_b3_4 XI1355_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1355_MP18 (XI1355_xp1 XI1355_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1355_MP20 (pp15_27 B_31_b3_4 XI1355_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1355_MP19 (XI1355_xp1 XI1355_xan pp15_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1355_MP17 (VDD XI1355_xn XI1355_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1355_MP6 (XI1355_p1 A_27_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1355_MP8 (XI1355_xn A_26_b3_5 XI1355_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1355_MP7 (XI1355_p1 two15_b3_4 XI1355_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1355_MP5 (VDD one15_b3_4 XI1355_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1355_MP10 (XI1355_xan XI1355_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1353_MP12 (VDD B_31_b3_4 XI1353_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1353_MP18 (XI1353_xp1 XI1353_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1353_MP20 (pp15_25 B_31_b3_4 XI1353_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1353_MP19 (XI1353_xp1 XI1353_xan pp15_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1353_MP17 (VDD XI1353_xn XI1353_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1353_MP6 (XI1353_p1 A_25_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1353_MP8 (XI1353_xn A_24_b3_5 XI1353_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1353_MP7 (XI1353_p1 two15_b3_4 XI1353_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1353_MP5 (VDD one15_b3_4 XI1353_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1353_MP10 (XI1353_xan XI1353_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1354_MP12 (VDD B_31_b3_4 XI1354_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1354_MP18 (XI1354_xp1 XI1354_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1354_MP20 (pp15_26 B_31_b3_4 XI1354_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1354_MP19 (XI1354_xp1 XI1354_xan pp15_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1354_MP17 (VDD XI1354_xn XI1354_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1354_MP6 (XI1354_p1 A_26_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1354_MP8 (XI1354_xn A_25_b3_5 XI1354_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1354_MP7 (XI1354_p1 two15_b3_4 XI1354_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1354_MP5 (VDD one15_b3_4 XI1354_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1354_MP10 (XI1354_xan XI1354_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI853_MP12 (VDD B_13_b3_3 XI853_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI853_MP18 (XI853_xp1 XI853_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI853_MP20 (pp6_20 B_13_b3_3 XI853_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI853_MP19 (XI853_xp1 XI853_xan pp6_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI853_MP17 (VDD XI853_xn XI853_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI853_MP6 (XI853_p1 A_20_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI853_MP8 (XI853_xn A_19_b3_2 XI853_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI853_MP7 (XI853_p1 two6_b3_3 XI853_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI853_MP5 (VDD one6_b3_3 XI853_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI853_MP10 (XI853_xan XI853_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI747_MP12 (VDD B_9_b3_4 XI747_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI747_MP18 (XI747_xp1 XI747_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI747_MP20 (pp4_24 B_9_b3_4 XI747_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI747_MP19 (XI747_xp1 XI747_xan pp4_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI747_MP17 (VDD XI747_xn XI747_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI747_MP6 (XI747_p1 A_24_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI747_MP8 (XI747_xn A_23_b3_1 XI747_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI747_MP7 (XI747_p1 two4_b3_4 XI747_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI747_MP5 (VDD one4_b3_4 XI747_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI747_MP10 (XI747_xan XI747_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI693_MP12 (VDD B_7_b3_4 XI693_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI693_MP18 (XI693_xp1 XI693_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI693_MP20 (pp3_25 B_7_b3_4 XI693_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI693_MP19 (XI693_xp1 XI693_xan pp3_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI693_MP17 (VDD XI693_xn XI693_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI693_MP6 (XI693_p1 A_25_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI693_MP8 (XI693_xn A_24_b3_1 XI693_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI693_MP7 (XI693_p1 two3_b3_4 XI693_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI693_MP5 (VDD one3_b3_4 XI693_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI693_MP10 (XI693_xan XI693_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI590_MP12 (VDD B_3_b3_5 XI590_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI590_MP18 (XI590_xp1 XI590_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI590_MP20 (pp1_32 B_3_b3_5 XI590_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI590_MP19 (XI590_xp1 XI590_xan pp1_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI590_MP17 (VDD XI590_xn XI590_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI590_MP6 (XI590_p1 A_31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI590_MP8 (XI590_xn A_31_b3_0 XI590_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI590_MP7 (XI590_p1 two1_b3_5 XI590_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI590_MP5 (VDD one1_b3_5 XI590_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI590_MP10 (XI590_xan XI590_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI642_MP12 (VDD B_5_b3_5 XI642_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI642_MP18 (XI642_xp1 XI642_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI642_MP20 (pp2_29 B_5_b3_5 XI642_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI642_MP19 (XI642_xp1 XI642_xan pp2_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI642_MP17 (VDD XI642_xn XI642_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI642_MP6 (XI642_p1 A_29_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI642_MP8 (XI642_xn A_28_b3_0 XI642_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI642_MP7 (XI642_p1 two2_b3_5 XI642_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI642_MP5 (VDD one2_b3_5 XI642_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI642_MP10 (XI642_xan XI642_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI589_MP12 (VDD B_3_b3_5 XI589_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI589_MP18 (XI589_xp1 XI589_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI589_MP20 (pp1_31 B_3_b3_5 XI589_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI589_MP19 (XI589_xp1 XI589_xan pp1_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI589_MP17 (VDD XI589_xn XI589_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI589_MP6 (XI589_p1 A_31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI589_MP8 (XI589_xn A_30_b3_0 XI589_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI589_MP7 (XI589_p1 two1_b3_5 XI589_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI589_MP5 (VDD one1_b3_5 XI589_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI589_MP10 (XI589_xan XI589_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1014_MP12 (VDD B_19_b3_2 XI1014_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1014_MP18 (XI1014_xp1 XI1014_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1014_MP20 (pp9_16 B_19_b3_2 XI1014_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1014_MP19 (XI1014_xp1 XI1014_xan pp9_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1014_MP17 (VDD XI1014_xn XI1014_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1014_MP6 (XI1014_p1 A_16_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1014_MP8 (XI1014_xn A_15_b3_3 XI1014_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1014_MP7 (XI1014_p1 two9_b3_2 XI1014_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1014_MP5 (VDD one9_b3_2 XI1014_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1014_MP10 (XI1014_xan XI1014_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1013_MP12 (VDD B_19_b3_2 XI1013_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1013_MP18 (XI1013_xp1 XI1013_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1013_MP20 (pp9_15 B_19_b3_2 XI1013_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1013_MP19 (XI1013_xp1 XI1013_xan pp9_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1013_MP17 (VDD XI1013_xn XI1013_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1013_MP6 (XI1013_p1 A_15_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1013_MP8 (XI1013_xn A_14_b3_3 XI1013_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1013_MP7 (XI1013_p1 two9_b3_2 XI1013_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1013_MP5 (VDD one9_b3_2 XI1013_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1013_MP10 (XI1013_xan XI1013_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1066_MP12 (VDD B_21_b3_2 XI1066_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1066_MP18 (XI1066_xp1 XI1066_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1066_MP20 (pp10_13 B_21_b3_2 XI1066_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1066_MP19 (XI1066_xp1 XI1066_xan pp10_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1066_MP17 (VDD XI1066_xn XI1066_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1066_MP6 (XI1066_p1 A_13_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1066_MP8 (XI1066_xn A_12_b3_3 XI1066_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1066_MP7 (XI1066_p1 two10_b3_2 XI1066_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1066_MP5 (VDD one10_b3_2 XI1066_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1066_MP10 (XI1066_xan XI1066_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1333_MP12 (VDD B_31_b3_1 XI1333_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1333_MP18 (XI1333_xp1 XI1333_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1333_MP20 (pp15_5 B_31_b3_1 XI1333_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1333_MP19 (XI1333_xp1 XI1333_xan pp15_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1333_MP17 (VDD XI1333_xn XI1333_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1333_MP6 (XI1333_p1 A_5_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1333_MP8 (XI1333_xn A_4_b3_5 XI1333_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1333_MP7 (XI1333_p1 two15_b3_0 XI1333_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1333_MP5 (VDD one15_b3_0 XI1333_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1333_MP10 (XI1333_xan XI1333_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1301_MP12 (VDD B_29_b3_4 XI1301_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1301_MP18 (XI1301_xp1 XI1301_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1301_MP20 (pp14_28 B_29_b3_4 XI1301_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1301_MP19 (XI1301_xp1 XI1301_xan pp14_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1301_MP17 (VDD XI1301_xn XI1301_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1301_MP6 (XI1301_p1 A_28_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1301_MP8 (XI1301_xn A_27_b3_5 XI1301_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1301_MP7 (XI1301_p1 two14_b3_5 XI1301_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1301_MP5 (VDD one14_b3_5 XI1301_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1301_MP10 (XI1301_xan XI1301_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1194_MP12 (VDD B_25_b3_5 XI1194_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1194_MP18 (XI1194_xp1 XI1194_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1194_MP20 (pp12_31 B_25_b3_5 XI1194_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1194_MP19 (XI1194_xp1 XI1194_xan pp12_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1194_MP17 (VDD XI1194_xn XI1194_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1194_MP6 (XI1194_p1 A_31_b3_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1194_MP8 (XI1194_xn A_30_b3_4 XI1194_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1194_MP7 (XI1194_p1 two12_b3_5 XI1194_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1194_MP5 (VDD one12_b3_5 XI1194_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1194_MP10 (XI1194_xan XI1194_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1195_MP12 (VDD B_25_b3_5 XI1195_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1195_MP18 (XI1195_xp1 XI1195_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1195_MP20 (pp12_32 B_25_b3_5 XI1195_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1195_MP19 (XI1195_xp1 XI1195_xan pp12_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1195_MP17 (VDD XI1195_xn XI1195_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1195_MP6 (XI1195_p1 A_31_b3_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1195_MP8 (XI1195_xn A_31_b3_6 XI1195_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1195_MP7 (XI1195_p1 two12_b3_5 XI1195_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1195_MP5 (VDD one12_b3_5 XI1195_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1195_MP10 (XI1195_xan XI1195_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI905_MP12 (VDD B_15_b3_3 XI905_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI905_MP18 (XI905_xp1 XI905_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI905_MP20 (pp7_17 B_15_b3_3 XI905_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI905_MP19 (XI905_xp1 XI905_xan pp7_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI905_MP17 (VDD XI905_xn XI905_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI905_MP6 (XI905_p1 A_17_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI905_MP8 (XI905_xn A_16_b3_2 XI905_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI905_MP7 (XI905_p1 two7_b3_3 XI905_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI905_MP5 (VDD one7_b3_3 XI905_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI905_MP10 (XI905_xan XI905_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI906_MP12 (VDD B_15_b3_3 XI906_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI906_MP18 (XI906_xp1 XI906_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI906_MP20 (pp7_18 B_15_b3_3 XI906_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI906_MP19 (XI906_xp1 XI906_xan pp7_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI906_MP17 (VDD XI906_xn XI906_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI906_MP6 (XI906_p1 A_18_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI906_MP8 (XI906_xn A_17_b3_2 XI906_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI906_MP7 (XI906_p1 two7_b3_3 XI906_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI906_MP5 (VDD one7_b3_3 XI906_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI906_MP10 (XI906_xan XI906_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI746_MP12 (VDD B_9_b3_4 XI746_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI746_MP18 (XI746_xp1 XI746_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI746_MP20 (pp4_23 B_9_b3_4 XI746_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI746_MP19 (XI746_xp1 XI746_xan pp4_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI746_MP17 (VDD XI746_xn XI746_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI746_MP6 (XI746_p1 A_23_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI746_MP8 (XI746_xn A_22_b3_1 XI746_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI746_MP7 (XI746_p1 two4_b3_4 XI746_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI746_MP5 (VDD one4_b3_4 XI746_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI746_MP10 (XI746_xan XI746_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI692_MP12 (VDD B_7_b3_4 XI692_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI692_MP18 (XI692_xp1 XI692_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI692_MP20 (pp3_24 B_7_b3_4 XI692_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI692_MP19 (XI692_xp1 XI692_xan pp3_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI692_MP17 (VDD XI692_xn XI692_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI692_MP6 (XI692_p1 A_24_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI692_MP8 (XI692_xn A_23_b3_1 XI692_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI692_MP7 (XI692_p1 two3_b3_4 XI692_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI692_MP5 (VDD one3_b3_4 XI692_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI692_MP10 (XI692_xan XI692_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI691_MP12 (VDD B_7_b3_4 XI691_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI691_MP18 (XI691_xp1 XI691_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI691_MP20 (pp3_23 B_7_b3_4 XI691_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI691_MP19 (XI691_xp1 XI691_xan pp3_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI691_MP17 (VDD XI691_xn XI691_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI691_MP6 (XI691_p1 A_23_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI691_MP8 (XI691_xn A_22_b3_1 XI691_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI691_MP7 (XI691_p1 two3_b3_4 XI691_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI691_MP5 (VDD one3_b3_4 XI691_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI691_MP10 (XI691_xan XI691_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI588_MP12 (VDD B_3_b3_5 XI588_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI588_MP18 (XI588_xp1 XI588_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI588_MP20 (pp1_30 B_3_b3_5 XI588_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI588_MP19 (XI588_xp1 XI588_xan pp1_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI588_MP17 (VDD XI588_xn XI588_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI588_MP6 (XI588_p1 A_30_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI588_MP8 (XI588_xn A_29_b3_0 XI588_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI588_MP7 (XI588_p1 two1_b3_5 XI588_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI588_MP5 (VDD one1_b3_5 XI588_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI588_MP10 (XI588_xan XI588_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI535_MP12 (VDD B_1_b3_5 XI535_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI535_MP18 (XI535_xp1 XI535_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI535_MP20 (pp0_32 B_1_b3_5 XI535_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI535_MP19 (XI535_xp1 XI535_xan pp0_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI535_MP17 (VDD XI535_xn XI535_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI535_MP6 (XI535_p1 A_31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI535_MP8 (XI535_xn A_31_b3_0 XI535_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI535_MP7 (XI535_p1 two0_b3_5 XI535_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI535_MP5 (VDD one0_b3_5 XI535_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI535_MP10 (XI535_xan XI535_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1012_MP12 (VDD B_19_b3_2 XI1012_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1012_MP18 (XI1012_xp1 XI1012_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1012_MP20 (pp9_14 B_19_b3_2 XI1012_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1012_MP19 (XI1012_xp1 XI1012_xan pp9_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1012_MP17 (VDD XI1012_xn XI1012_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1012_MP6 (XI1012_p1 A_14_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1012_MP8 (XI1012_xn A_13_b3_3 XI1012_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1012_MP7 (XI1012_p1 two9_b3_2 XI1012_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1012_MP5 (VDD one9_b3_2 XI1012_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1012_MP10 (XI1012_xan XI1012_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1228_MP12 (VDD B_27_b3_1 XI1228_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1228_MP18 (XI1228_xp1 XI1228_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1228_MP20 (pp13_10 B_27_b3_1 XI1228_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1228_MP19 (XI1228_xp1 XI1228_xan pp13_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1228_MP17 (VDD XI1228_xn XI1228_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1228_MP6 (XI1228_p1 A_10_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1228_MP8 (XI1228_xn A_9_b3_5 XI1228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1228_MP7 (XI1228_p1 two13_b3_1 XI1228_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1228_MP5 (VDD one13_b3_1 XI1228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1228_MP10 (XI1228_xan XI1228_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1227_MP12 (VDD B_27_b3_1 XI1227_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1227_MP18 (XI1227_xp1 XI1227_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1227_MP20 (pp13_9 B_27_b3_1 XI1227_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1227_MP19 (XI1227_xp1 XI1227_xan pp13_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1227_MP17 (VDD XI1227_xn XI1227_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1227_MP6 (XI1227_p1 A_9_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1227_MP8 (XI1227_xn A_8_b3_5 XI1227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1227_MP7 (XI1227_p1 two13_b3_1 XI1227_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1227_MP5 (VDD one13_b3_1 XI1227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1227_MP10 (XI1227_xan XI1227_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1226_MP12 (VDD B_27_b3_1 XI1226_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1226_MP18 (XI1226_xp1 XI1226_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1226_MP20 (pp13_8 B_27_b3_1 XI1226_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1226_MP19 (XI1226_xp1 XI1226_xan pp13_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1226_MP17 (VDD XI1226_xn XI1226_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1226_MP6 (XI1226_p1 A_8_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1226_MP8 (XI1226_xn A_7_b3_5 XI1226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1226_MP7 (XI1226_p1 two13_b3_1 XI1226_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1226_MP5 (VDD one13_b3_1 XI1226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1226_MP10 (XI1226_xan XI1226_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1225_MP12 (VDD B_27_b3_1 XI1225_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1225_MP18 (XI1225_xp1 XI1225_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1225_MP20 (pp13_7 B_27_b3_1 XI1225_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1225_MP19 (XI1225_xp1 XI1225_xan pp13_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1225_MP17 (VDD XI1225_xn XI1225_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1225_MP6 (XI1225_p1 A_7_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1225_MP8 (XI1225_xn A_6_b3_5 XI1225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1225_MP7 (XI1225_p1 two13_b3_1 XI1225_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1225_MP5 (VDD one13_b3_1 XI1225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1225_MP10 (XI1225_xan XI1225_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1278_MP12 (VDD B_29_b3_1 XI1278_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1278_MP18 (XI1278_xp1 XI1278_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1278_MP20 (pp14_5 B_29_b3_1 XI1278_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1278_MP19 (XI1278_xp1 XI1278_xan pp14_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1278_MP17 (VDD XI1278_xn XI1278_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1278_MP6 (XI1278_p1 A_5_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1278_MP8 (XI1278_xn A_4_b3_5 XI1278_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1278_MP7 (XI1278_p1 two14_b3_0 XI1278_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1278_MP5 (VDD one14_b3_0 XI1278_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1278_MP10 (XI1278_xan XI1278_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1332_MP12 (VDD B_31_b3_0 XI1332_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1332_MP18 (XI1332_xp1 XI1332_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1332_MP20 (pp15_4 B_31_b3_0 XI1332_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1332_MP19 (XI1332_xp1 XI1332_xan pp15_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1332_MP17 (VDD XI1332_xn XI1332_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1332_MP6 (XI1332_p1 A_4_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1332_MP8 (XI1332_xn A_3_b3_5 XI1332_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1332_MP7 (XI1332_p1 two15_b3_0 XI1332_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1332_MP5 (VDD one15_b3_0 XI1332_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1332_MP10 (XI1332_xan XI1332_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1356_MP12 (VDD B_31_b3_4 XI1356_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1356_MP18 (XI1356_xp1 XI1356_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1356_MP20 (pp15_28 B_31_b3_4 XI1356_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1356_MP19 (XI1356_xp1 XI1356_xan pp15_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1356_MP17 (VDD XI1356_xn XI1356_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1356_MP6 (XI1356_p1 A_28_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1356_MP8 (XI1356_xn A_27_b3_5 XI1356_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1356_MP7 (XI1356_p1 two15_b3_5 XI1356_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1356_MP5 (VDD one15_b3_5 XI1356_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1356_MP10 (XI1356_xan XI1356_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1248_MP12 (VDD B_27_b3_5 XI1248_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1248_MP18 (XI1248_xp1 XI1248_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1248_MP20 (pp13_30 B_27_b3_5 XI1248_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1248_MP19 (XI1248_xp1 XI1248_xan pp13_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1248_MP17 (VDD XI1248_xn XI1248_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1248_MP6 (XI1248_p1 A_30_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1248_MP8 (XI1248_xn A_29_b3_5 XI1248_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1248_MP7 (XI1248_p1 two13_b3_5 XI1248_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1248_MP5 (VDD one13_b3_5 XI1248_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1248_MP10 (XI1248_xan XI1248_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI852_MP12 (VDD B_13_b3_3 XI852_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI852_MP18 (XI852_xp1 XI852_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI852_MP20 (pp6_19 B_13_b3_3 XI852_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI852_MP19 (XI852_xp1 XI852_xan pp6_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI852_MP17 (VDD XI852_xn XI852_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI852_MP6 (XI852_p1 A_19_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI852_MP8 (XI852_xn A_18_b3_2 XI852_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI852_MP7 (XI852_p1 two6_b3_3 XI852_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI852_MP5 (VDD one6_b3_3 XI852_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI852_MP10 (XI852_xan XI852_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI745_MP12 (VDD B_9_b3_3 XI745_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI745_MP18 (XI745_xp1 XI745_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI745_MP20 (pp4_22 B_9_b3_3 XI745_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI745_MP19 (XI745_xp1 XI745_xan pp4_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI745_MP17 (VDD XI745_xn XI745_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI745_MP6 (XI745_p1 A_22_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI745_MP8 (XI745_xn A_21_b3_1 XI745_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI745_MP7 (XI745_p1 two4_b3_4 XI745_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI745_MP5 (VDD one4_b3_4 XI745_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI745_MP10 (XI745_xan XI745_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI690_MP12 (VDD B_7_b3_3 XI690_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI690_MP18 (XI690_xp1 XI690_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI690_MP20 (pp3_22 B_7_b3_3 XI690_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI690_MP19 (XI690_xp1 XI690_xan pp3_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI690_MP17 (VDD XI690_xn XI690_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI690_MP6 (XI690_p1 A_22_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI690_MP8 (XI690_xn A_21_b3_1 XI690_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI690_MP7 (XI690_p1 two3_b3_4 XI690_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI690_MP5 (VDD one3_b3_4 XI690_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI690_MP10 (XI690_xan XI690_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI587_MP12 (VDD B_3_b3_5 XI587_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI587_MP18 (XI587_xp1 XI587_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI587_MP20 (pp1_29 B_3_b3_5 XI587_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI587_MP19 (XI587_xp1 XI587_xan pp1_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI587_MP17 (VDD XI587_xn XI587_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI587_MP6 (XI587_p1 A_29_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI587_MP8 (XI587_xn A_28_b3_0 XI587_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI587_MP7 (XI587_p1 two1_b3_5 XI587_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI587_MP5 (VDD one1_b3_5 XI587_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI587_MP10 (XI587_xan XI587_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI641_MP12 (VDD B_5_b3_4 XI641_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI641_MP18 (XI641_xp1 XI641_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI641_MP20 (pp2_28 B_5_b3_4 XI641_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI641_MP19 (XI641_xp1 XI641_xan pp2_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI641_MP17 (VDD XI641_xn XI641_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI641_MP6 (XI641_p1 A_28_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI641_MP8 (XI641_xn A_27_b3_0 XI641_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI641_MP7 (XI641_p1 two2_b3_5 XI641_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI641_MP5 (VDD one2_b3_5 XI641_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI641_MP10 (XI641_xan XI641_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI534_MP12 (VDD B_1_b3_5 XI534_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI534_MP18 (XI534_xp1 XI534_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI534_MP20 (pp0_31 B_1_b3_5 XI534_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI534_MP19 (XI534_xp1 XI534_xan pp0_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI534_MP17 (VDD XI534_xn XI534_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI534_MP6 (XI534_p1 A_31_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI534_MP8 (XI534_xn A_30_b3_0 XI534_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI534_MP7 (XI534_p1 two0_b3_5 XI534_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI534_MP5 (VDD one0_b3_5 XI534_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI534_MP10 (XI534_xan XI534_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI958_MP12 (VDD B_17_b3_2 XI958_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI958_MP18 (XI958_xp1 XI958_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI958_MP20 (pp8_15 B_17_b3_2 XI958_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI958_MP19 (XI958_xp1 XI958_xan pp8_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI958_MP17 (VDD XI958_xn XI958_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI958_MP6 (XI958_p1 A_15_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI958_MP8 (XI958_xn A_14_b3_3 XI958_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI958_MP7 (XI958_p1 two8_b3_2 XI958_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI958_MP5 (VDD one8_b3_2 XI958_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI958_MP10 (XI958_xan XI958_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI959_MP12 (VDD B_17_b3_2 XI959_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI959_MP18 (XI959_xp1 XI959_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI959_MP20 (pp8_16 B_17_b3_2 XI959_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI959_MP19 (XI959_xp1 XI959_xan pp8_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI959_MP17 (VDD XI959_xn XI959_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI959_MP6 (XI959_p1 A_16_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI959_MP8 (XI959_xn A_15_b3_3 XI959_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI959_MP7 (XI959_p1 two8_b3_2 XI959_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI959_MP5 (VDD one8_b3_2 XI959_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI959_MP10 (XI959_xan XI959_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1064_MP12 (VDD B_21_b3_2 XI1064_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1064_MP18 (XI1064_xp1 XI1064_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1064_MP20 (pp10_11 B_21_b3_2 XI1064_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1064_MP19 (XI1064_xp1 XI1064_xan pp10_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1064_MP17 (VDD XI1064_xn XI1064_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1064_MP6 (XI1064_p1 A_11_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1064_MP8 (XI1064_xn A_10_b3_3 XI1064_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1064_MP7 (XI1064_p1 two10_b3_2 XI1064_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1064_MP5 (VDD one10_b3_2 XI1064_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1064_MP10 (XI1064_xan XI1064_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1117_MP12 (VDD B_23_b3_1 XI1117_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1117_MP18 (XI1117_xp1 XI1117_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1117_MP20 (pp11_9 B_23_b3_1 XI1117_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1117_MP19 (XI1117_xp1 XI1117_xan pp11_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1117_MP17 (VDD XI1117_xn XI1117_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1117_MP6 (XI1117_p1 A_9_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1117_MP8 (XI1117_xn A_8_b3_4 XI1117_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1117_MP7 (XI1117_p1 two11_b3_1 XI1117_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1117_MP5 (VDD one11_b3_1 XI1117_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1117_MP10 (XI1117_xan XI1117_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1065_MP12 (VDD B_21_b3_2 XI1065_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1065_MP18 (XI1065_xp1 XI1065_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1065_MP20 (pp10_12 B_21_b3_2 XI1065_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1065_MP19 (XI1065_xp1 XI1065_xan pp10_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1065_MP17 (VDD XI1065_xn XI1065_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1065_MP6 (XI1065_p1 A_12_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1065_MP8 (XI1065_xn A_11_b3_3 XI1065_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1065_MP7 (XI1065_p1 two10_b3_2 XI1065_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1065_MP5 (VDD one10_b3_2 XI1065_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1065_MP10 (XI1065_xan XI1065_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1118_MP12 (VDD B_23_b3_1 XI1118_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1118_MP18 (XI1118_xp1 XI1118_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1118_MP20 (pp11_10 B_23_b3_1 XI1118_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1118_MP19 (XI1118_xp1 XI1118_xan pp11_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1118_MP17 (VDD XI1118_xn XI1118_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1118_MP6 (XI1118_p1 A_10_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1118_MP8 (XI1118_xn A_9_b3_4 XI1118_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1118_MP7 (XI1118_p1 two11_b3_1 XI1118_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1118_MP5 (VDD one11_b3_1 XI1118_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1118_MP10 (XI1118_xan XI1118_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1172_MP12 (VDD B_25_b3_1 XI1172_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1172_MP18 (XI1172_xp1 XI1172_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1172_MP20 (pp12_9 B_25_b3_1 XI1172_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1172_MP19 (XI1172_xp1 XI1172_xan pp12_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1172_MP17 (VDD XI1172_xn XI1172_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1172_MP6 (XI1172_p1 A_9_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1172_MP8 (XI1172_xn A_8_b3_4 XI1172_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1172_MP7 (XI1172_p1 two12_b3_1 XI1172_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1172_MP5 (VDD one12_b3_1 XI1172_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1172_MP10 (XI1172_xan XI1172_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1173_MP12 (VDD B_25_b3_1 XI1173_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1173_MP18 (XI1173_xp1 XI1173_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1173_MP20 (pp12_10 B_25_b3_1 XI1173_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1173_MP19 (XI1173_xp1 XI1173_xan pp12_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1173_MP17 (VDD XI1173_xn XI1173_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1173_MP6 (XI1173_p1 A_10_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1173_MP8 (XI1173_xn A_9_b3_4 XI1173_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1173_MP7 (XI1173_p1 two12_b3_1 XI1173_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1173_MP5 (VDD one12_b3_1 XI1173_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1173_MP10 (XI1173_xan XI1173_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1224_MP12 (VDD B_27_b3_1 XI1224_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1224_MP18 (XI1224_xp1 XI1224_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1224_MP20 (pp13_6 B_27_b3_1 XI1224_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1224_MP19 (XI1224_xp1 XI1224_xan pp13_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1224_MP17 (VDD XI1224_xn XI1224_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1224_MP6 (XI1224_p1 A_6_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1224_MP8 (XI1224_xn A_5_b3_5 XI1224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1224_MP7 (XI1224_p1 two13_b3_1 XI1224_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1224_MP5 (VDD one13_b3_1 XI1224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1224_MP10 (XI1224_xan XI1224_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1277_MP12 (VDD B_29_b3_0 XI1277_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1277_MP18 (XI1277_xp1 XI1277_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1277_MP20 (pp14_4 B_29_b3_0 XI1277_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1277_MP19 (XI1277_xp1 XI1277_xan pp14_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1277_MP17 (VDD XI1277_xn XI1277_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1277_MP6 (XI1277_p1 A_4_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1277_MP8 (XI1277_xn A_3_b3_5 XI1277_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1277_MP7 (XI1277_p1 two14_b3_0 XI1277_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1277_MP5 (VDD one14_b3_0 XI1277_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1277_MP10 (XI1277_xan XI1277_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1331_MP12 (VDD B_31_b3_0 XI1331_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1331_MP18 (XI1331_xp1 XI1331_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1331_MP20 (pp15_3 B_31_b3_0 XI1331_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1331_MP19 (XI1331_xp1 XI1331_xan pp15_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1331_MP17 (VDD XI1331_xn XI1331_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1331_MP6 (XI1331_p1 A_3_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1331_MP8 (XI1331_xn A_2_b3_5 XI1331_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1331_MP7 (XI1331_p1 two15_b3_0 XI1331_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1331_MP5 (VDD one15_b3_0 XI1331_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1331_MP10 (XI1331_xan XI1331_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1303_MP12 (VDD B_29_b3_5 XI1303_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1303_MP18 (XI1303_xp1 XI1303_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1303_MP20 (pp14_30 B_29_b3_5 XI1303_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1303_MP19 (XI1303_xp1 XI1303_xan pp14_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1303_MP17 (VDD XI1303_xn XI1303_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1303_MP6 (XI1303_p1 A_30_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1303_MP8 (XI1303_xn A_29_b3_5 XI1303_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1303_MP7 (XI1303_p1 two14_b3_5 XI1303_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1303_MP5 (VDD one14_b3_5 XI1303_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1303_MP10 (XI1303_xan XI1303_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1302_MP12 (VDD B_29_b3_5 XI1302_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1302_MP18 (XI1302_xp1 XI1302_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1302_MP20 (pp14_29 B_29_b3_5 XI1302_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1302_MP19 (XI1302_xp1 XI1302_xan pp14_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1302_MP17 (VDD XI1302_xn XI1302_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1302_MP6 (XI1302_p1 A_29_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1302_MP8 (XI1302_xn A_28_b3_5 XI1302_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1302_MP7 (XI1302_p1 two14_b3_5 XI1302_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1302_MP5 (VDD one14_b3_5 XI1302_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1302_MP10 (XI1302_xan XI1302_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1249_MP12 (VDD B_27_b3_5 XI1249_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1249_MP18 (XI1249_xp1 XI1249_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1249_MP20 (pp13_31 B_27_b3_5 XI1249_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1249_MP19 (XI1249_xp1 XI1249_xan pp13_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1249_MP17 (VDD XI1249_xn XI1249_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1249_MP6 (XI1249_p1 A_31_b3_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1249_MP8 (XI1249_xn A_30_b3_5 XI1249_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1249_MP7 (XI1249_p1 two13_b3_5 XI1249_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1249_MP5 (VDD one13_b3_5 XI1249_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1249_MP10 (XI1249_xan XI1249_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1250_MP12 (VDD B_27_b3_5 XI1250_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1250_MP18 (XI1250_xp1 XI1250_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1250_MP20 (pp13_32 B_27_b3_5 XI1250_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1250_MP19 (XI1250_xp1 XI1250_xan pp13_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1250_MP17 (VDD XI1250_xn XI1250_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1250_MP6 (XI1250_p1 A_31_b3_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1250_MP8 (XI1250_xn A_31_b3_6 XI1250_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1250_MP7 (XI1250_p1 two13_b3_5 XI1250_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1250_MP5 (VDD one13_b3_5 XI1250_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1250_MP10 (XI1250_xan XI1250_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI850_MP12 (VDD B_13_b3_3 XI850_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI850_MP18 (XI850_xp1 XI850_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI850_MP20 (pp6_17 B_13_b3_3 XI850_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI850_MP19 (XI850_xp1 XI850_xan pp6_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI850_MP17 (VDD XI850_xn XI850_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI850_MP6 (XI850_p1 A_17_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI850_MP8 (XI850_xn A_16_b3_2 XI850_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI850_MP7 (XI850_p1 two6_b3_3 XI850_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI850_MP5 (VDD one6_b3_3 XI850_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI850_MP10 (XI850_xan XI850_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI851_MP12 (VDD B_13_b3_3 XI851_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI851_MP18 (XI851_xp1 XI851_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI851_MP20 (pp6_18 B_13_b3_3 XI851_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI851_MP19 (XI851_xp1 XI851_xan pp6_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI851_MP17 (VDD XI851_xn XI851_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI851_MP6 (XI851_p1 A_18_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI851_MP8 (XI851_xn A_17_b3_2 XI851_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI851_MP7 (XI851_p1 two6_b3_3 XI851_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI851_MP5 (VDD one6_b3_3 XI851_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI851_MP10 (XI851_xan XI851_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI799_MP12 (VDD B_11_b3_3 XI799_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI799_MP18 (XI799_xp1 XI799_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI799_MP20 (pp5_21 B_11_b3_3 XI799_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI799_MP19 (XI799_xp1 XI799_xan pp5_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI799_MP17 (VDD XI799_xn XI799_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI799_MP6 (XI799_p1 A_21_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI799_MP8 (XI799_xn A_20_b3_2 XI799_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI799_MP7 (XI799_p1 two5_b3_3 XI799_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI799_MP5 (VDD one5_b3_3 XI799_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI799_MP10 (XI799_xan XI799_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI640_MP12 (VDD B_5_b3_4 XI640_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI640_MP18 (XI640_xp1 XI640_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI640_MP20 (pp2_27 B_5_b3_4 XI640_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI640_MP19 (XI640_xp1 XI640_xan pp2_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI640_MP17 (VDD XI640_xn XI640_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI640_MP6 (XI640_p1 A_27_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI640_MP8 (XI640_xn A_26_b3_0 XI640_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI640_MP7 (XI640_p1 two2_b3_4 XI640_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI640_MP5 (VDD one2_b3_4 XI640_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI640_MP10 (XI640_xan XI640_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI533_MP12 (VDD B_1_b3_5 XI533_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI533_MP18 (XI533_xp1 XI533_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI533_MP20 (pp0_30 B_1_b3_5 XI533_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI533_MP19 (XI533_xp1 XI533_xan pp0_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI533_MP17 (VDD XI533_xn XI533_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI533_MP6 (XI533_p1 A_30_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI533_MP8 (XI533_xn A_29_b3_0 XI533_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI533_MP7 (XI533_p1 two0_b3_5 XI533_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI533_MP5 (VDD one0_b3_5 XI533_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI533_MP10 (XI533_xan XI533_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1011_MP12 (VDD B_19_b3_2 XI1011_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1011_MP18 (XI1011_xp1 XI1011_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1011_MP20 (pp9_13 B_19_b3_2 XI1011_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1011_MP19 (XI1011_xp1 XI1011_xan pp9_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1011_MP17 (VDD XI1011_xn XI1011_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1011_MP6 (XI1011_p1 A_13_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1011_MP8 (XI1011_xn A_12_b3_3 XI1011_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1011_MP7 (XI1011_p1 two9_b3_2 XI1011_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1011_MP5 (VDD one9_b3_2 XI1011_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1011_MP10 (XI1011_xan XI1011_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1009_MP12 (VDD B_19_b3_2 XI1009_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1009_MP18 (XI1009_xp1 XI1009_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1009_MP20 (pp9_11 B_19_b3_2 XI1009_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1009_MP19 (XI1009_xp1 XI1009_xan pp9_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1009_MP17 (VDD XI1009_xn XI1009_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1009_MP6 (XI1009_p1 A_11_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1009_MP8 (XI1009_xn A_10_b3_3 XI1009_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1009_MP7 (XI1009_p1 two9_b3_2 XI1009_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1009_MP5 (VDD one9_b3_2 XI1009_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1009_MP10 (XI1009_xan XI1009_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1171_MP12 (VDD B_25_b3_1 XI1171_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1171_MP18 (XI1171_xp1 XI1171_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1171_MP20 (pp12_8 B_25_b3_1 XI1171_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1171_MP19 (XI1171_xp1 XI1171_xan pp12_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1171_MP17 (VDD XI1171_xn XI1171_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1171_MP6 (XI1171_p1 A_8_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1171_MP8 (XI1171_xn A_7_b3_4 XI1171_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1171_MP7 (XI1171_p1 two12_b3_1 XI1171_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1171_MP5 (VDD one12_b3_1 XI1171_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1171_MP10 (XI1171_xan XI1171_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1330_MP12 (VDD B_31_b3_0 XI1330_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1330_MP18 (XI1330_xp1 XI1330_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1330_MP20 (pp15_2 B_31_b3_0 XI1330_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1330_MP19 (XI1330_xp1 XI1330_xan pp15_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1330_MP17 (VDD XI1330_xn XI1330_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1330_MP6 (XI1330_p1 A_2_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1330_MP8 (XI1330_xn A_1_b3_5 XI1330_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1330_MP7 (XI1330_p1 two15_b3_0 XI1330_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1330_MP5 (VDD one15_b3_0 XI1330_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1330_MP10 (XI1330_xan XI1330_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1329_MP12 (VDD B_31_b3_0 XI1329_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1329_MP18 (XI1329_xp1 XI1329_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1329_MP20 (pp15_1 B_31_b3_0 XI1329_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1329_MP19 (XI1329_xp1 XI1329_xan pp15_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1329_MP17 (VDD XI1329_xn XI1329_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1329_MP6 (XI1329_p1 A_1_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1329_MP8 (XI1329_xn A_0_b3_5 XI1329_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1329_MP7 (XI1329_p1 two15_b3_0 XI1329_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1329_MP5 (VDD one15_b3_0 XI1329_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1329_MP10 (XI1329_xan XI1329_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1305_MP12 (VDD B_29_b3_5 XI1305_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1305_MP18 (XI1305_xp1 XI1305_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1305_MP20 (pp14_32 B_29_b3_5 XI1305_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1305_MP19 (XI1305_xp1 XI1305_xan pp14_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1305_MP17 (VDD XI1305_xn XI1305_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1305_MP6 (XI1305_p1 A_31_b3_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1305_MP8 (XI1305_xn A_31_b3_7 XI1305_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1305_MP7 (XI1305_p1 two14_b3_5 XI1305_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1305_MP5 (VDD one14_b3_5 XI1305_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1305_MP10 (XI1305_xan XI1305_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1304_MP12 (VDD B_29_b3_5 XI1304_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1304_MP18 (XI1304_xp1 XI1304_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1304_MP20 (pp14_31 B_29_b3_5 XI1304_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1304_MP19 (XI1304_xp1 XI1304_xan pp14_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1304_MP17 (VDD XI1304_xn XI1304_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1304_MP6 (XI1304_p1 A_31_b3_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1304_MP8 (XI1304_xn A_30_b3_5 XI1304_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1304_MP7 (XI1304_p1 two14_b3_5 XI1304_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1304_MP5 (VDD one14_b3_5 XI1304_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1304_MP10 (XI1304_xan XI1304_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI796_MP12 (VDD B_11_b3_3 XI796_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI796_MP18 (XI796_xp1 XI796_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI796_MP20 (pp5_18 B_11_b3_3 XI796_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI796_MP19 (XI796_xp1 XI796_xan pp5_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI796_MP17 (VDD XI796_xn XI796_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI796_MP6 (XI796_p1 A_18_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI796_MP8 (XI796_xn A_17_b3_2 XI796_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI796_MP7 (XI796_p1 two5_b3_3 XI796_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI796_MP5 (VDD one5_b3_3 XI796_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI796_MP10 (XI796_xan XI796_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI798_MP12 (VDD B_11_b3_3 XI798_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI798_MP18 (XI798_xp1 XI798_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI798_MP20 (pp5_20 B_11_b3_3 XI798_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI798_MP19 (XI798_xp1 XI798_xan pp5_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI798_MP17 (VDD XI798_xn XI798_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI798_MP6 (XI798_p1 A_20_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI798_MP8 (XI798_xn A_19_b3_2 XI798_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI798_MP7 (XI798_p1 two5_b3_3 XI798_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI798_MP5 (VDD one5_b3_3 XI798_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI798_MP10 (XI798_xan XI798_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI639_MP12 (VDD B_5_b3_4 XI639_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI639_MP18 (XI639_xp1 XI639_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI639_MP20 (pp2_26 B_5_b3_4 XI639_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI639_MP19 (XI639_xp1 XI639_xan pp2_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI639_MP17 (VDD XI639_xn XI639_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI639_MP6 (XI639_p1 A_26_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI639_MP8 (XI639_xn A_25_b3_0 XI639_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI639_MP7 (XI639_p1 two2_b3_4 XI639_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI639_MP5 (VDD one2_b3_4 XI639_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI639_MP10 (XI639_xan XI639_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI532_MP12 (VDD B_1_b3_5 XI532_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI532_MP18 (XI532_xp1 XI532_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI532_MP20 (pp0_29 B_1_b3_5 XI532_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI532_MP19 (XI532_xp1 XI532_xan pp0_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI532_MP17 (VDD XI532_xn XI532_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI532_MP6 (XI532_p1 A_29_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI532_MP8 (XI532_xn A_28_b3_0 XI532_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI532_MP7 (XI532_p1 two0_b3_5 XI532_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI532_MP5 (VDD one0_b3_5 XI532_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI532_MP10 (XI532_xan XI532_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI957_MP12 (VDD B_17_b3_2 XI957_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI957_MP18 (XI957_xp1 XI957_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI957_MP20 (pp8_14 B_17_b3_2 XI957_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI957_MP19 (XI957_xp1 XI957_xan pp8_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI957_MP17 (VDD XI957_xn XI957_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI957_MP6 (XI957_p1 A_14_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI957_MP8 (XI957_xn A_13_b3_3 XI957_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI957_MP7 (XI957_p1 two8_b3_2 XI957_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI957_MP5 (VDD one8_b3_2 XI957_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI957_MP10 (XI957_xan XI957_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1116_MP12 (VDD B_23_b3_1 XI1116_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1116_MP18 (XI1116_xp1 XI1116_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1116_MP20 (pp11_8 B_23_b3_1 XI1116_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1116_MP19 (XI1116_xp1 XI1116_xan pp11_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1116_MP17 (VDD XI1116_xn XI1116_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1116_MP6 (XI1116_p1 A_8_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1116_MP8 (XI1116_xn A_7_b3_4 XI1116_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1116_MP7 (XI1116_p1 two11_b3_1 XI1116_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1116_MP5 (VDD one11_b3_1 XI1116_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1116_MP10 (XI1116_xan XI1116_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1010_MP12 (VDD B_19_b3_2 XI1010_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1010_MP18 (XI1010_xp1 XI1010_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1010_MP20 (pp9_12 B_19_b3_2 XI1010_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1010_MP19 (XI1010_xp1 XI1010_xan pp9_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1010_MP17 (VDD XI1010_xn XI1010_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1010_MP6 (XI1010_p1 A_12_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1010_MP8 (XI1010_xn A_11_b3_3 XI1010_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1010_MP7 (XI1010_p1 two9_b3_2 XI1010_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1010_MP5 (VDD one9_b3_2 XI1010_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1010_MP10 (XI1010_xan XI1010_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1170_MP12 (VDD B_25_b3_1 XI1170_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1170_MP18 (XI1170_xp1 XI1170_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1170_MP20 (pp12_7 B_25_b3_1 XI1170_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1170_MP19 (XI1170_xp1 XI1170_xan pp12_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1170_MP17 (VDD XI1170_xn XI1170_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1170_MP6 (XI1170_p1 A_7_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1170_MP8 (XI1170_xn A_6_b3_4 XI1170_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1170_MP7 (XI1170_p1 two12_b3_1 XI1170_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1170_MP5 (VDD one12_b3_1 XI1170_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1170_MP10 (XI1170_xan XI1170_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1223_MP12 (VDD B_27_b3_1 XI1223_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1223_MP18 (XI1223_xp1 XI1223_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1223_MP20 (pp13_5 B_27_b3_1 XI1223_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1223_MP19 (XI1223_xp1 XI1223_xan pp13_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1223_MP17 (VDD XI1223_xn XI1223_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1223_MP6 (XI1223_p1 A_5_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1223_MP8 (XI1223_xn A_4_b3_5 XI1223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1223_MP7 (XI1223_p1 two13_b3_0 XI1223_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1223_MP5 (VDD one13_b3_0 XI1223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1223_MP10 (XI1223_xan XI1223_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1328_MP12 (VDD B_31_b3_0 XI1328_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1328_MP18 (XI1328_xp1 XI1328_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1328_MP20 (pp15_0 B_31_b3_0 XI1328_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1328_MP19 (XI1328_xp1 XI1328_xan pp15_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1328_MP17 (VDD XI1328_xn XI1328_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1328_MP6 (XI1328_p1 A_0_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1328_MP8 (XI1328_xn VSS XI1328_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1328_MP7 (XI1328_p1 two15_b3_0 XI1328_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1328_MP5 (VDD one15_b3_0 XI1328_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1328_MP10 (XI1328_xan XI1328_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1358_MP12 (VDD B_31_b3_5 XI1358_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1358_MP18 (XI1358_xp1 XI1358_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1358_MP20 (pp15_30 B_31_b3_5 XI1358_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1358_MP19 (XI1358_xp1 XI1358_xan pp15_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1358_MP17 (VDD XI1358_xn XI1358_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1358_MP6 (XI1358_p1 A_30_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1358_MP8 (XI1358_xn A_29_b3_5 XI1358_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1358_MP7 (XI1358_p1 two15_b3_5 XI1358_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1358_MP5 (VDD one15_b3_5 XI1358_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1358_MP10 (XI1358_xan XI1358_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1357_MP12 (VDD B_31_b3_5 XI1357_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1357_MP18 (XI1357_xp1 XI1357_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1357_MP20 (pp15_29 B_31_b3_5 XI1357_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1357_MP19 (XI1357_xp1 XI1357_xan pp15_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1357_MP17 (VDD XI1357_xn XI1357_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1357_MP6 (XI1357_p1 A_29_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1357_MP8 (XI1357_xn A_28_b3_5 XI1357_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1357_MP7 (XI1357_p1 two15_b3_5 XI1357_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1357_MP5 (VDD one15_b3_5 XI1357_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1357_MP10 (XI1357_xan XI1357_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI795_MP12 (VDD B_11_b3_3 XI795_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI795_MP18 (XI795_xp1 XI795_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI795_MP20 (pp5_17 B_11_b3_3 XI795_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI795_MP19 (XI795_xp1 XI795_xan pp5_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI795_MP17 (VDD XI795_xn XI795_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI795_MP6 (XI795_p1 A_17_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI795_MP8 (XI795_xn A_16_b3_2 XI795_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI795_MP7 (XI795_p1 two5_b3_3 XI795_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI795_MP5 (VDD one5_b3_3 XI795_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI795_MP10 (XI795_xan XI795_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI797_MP12 (VDD B_11_b3_3 XI797_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI797_MP18 (XI797_xp1 XI797_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI797_MP20 (pp5_19 B_11_b3_3 XI797_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI797_MP19 (XI797_xp1 XI797_xan pp5_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI797_MP17 (VDD XI797_xn XI797_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI797_MP6 (XI797_p1 A_19_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI797_MP8 (XI797_xn A_18_b3_2 XI797_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI797_MP7 (XI797_p1 two5_b3_3 XI797_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI797_MP5 (VDD one5_b3_3 XI797_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI797_MP10 (XI797_xan XI797_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI586_MP12 (VDD B_3_b3_4 XI586_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI586_MP18 (XI586_xp1 XI586_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI586_MP20 (pp1_28 B_3_b3_4 XI586_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI586_MP19 (XI586_xp1 XI586_xan pp1_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI586_MP17 (VDD XI586_xn XI586_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI586_MP6 (XI586_p1 A_28_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI586_MP8 (XI586_xn A_27_b3_0 XI586_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI586_MP7 (XI586_p1 two1_b3_5 XI586_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI586_MP5 (VDD one1_b3_5 XI586_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI586_MP10 (XI586_xan XI586_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI638_MP12 (VDD B_5_b3_4 XI638_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI638_MP18 (XI638_xp1 XI638_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI638_MP20 (pp2_25 B_5_b3_4 XI638_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI638_MP19 (XI638_xp1 XI638_xan pp2_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI638_MP17 (VDD XI638_xn XI638_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI638_MP6 (XI638_p1 A_25_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI638_MP8 (XI638_xn A_24_b3_0 XI638_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI638_MP7 (XI638_p1 two2_b3_4 XI638_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI638_MP5 (VDD one2_b3_4 XI638_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI638_MP10 (XI638_xan XI638_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI956_MP12 (VDD B_17_b3_2 XI956_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI956_MP18 (XI956_xp1 XI956_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI956_MP20 (pp8_13 B_17_b3_2 XI956_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI956_MP19 (XI956_xp1 XI956_xan pp8_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI956_MP17 (VDD XI956_xn XI956_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI956_MP6 (XI956_p1 A_13_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI956_MP8 (XI956_xn A_12_b3_3 XI956_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI956_MP7 (XI956_p1 two8_b3_2 XI956_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI956_MP5 (VDD one8_b3_2 XI956_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI956_MP10 (XI956_xan XI956_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI955_MP12 (VDD B_17_b3_2 XI955_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI955_MP18 (XI955_xp1 XI955_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI955_MP20 (pp8_12 B_17_b3_2 XI955_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI955_MP19 (XI955_xp1 XI955_xan pp8_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI955_MP17 (VDD XI955_xn XI955_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI955_MP6 (XI955_p1 A_12_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI955_MP8 (XI955_xn A_11_b3_3 XI955_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI955_MP7 (XI955_p1 two8_b3_2 XI955_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI955_MP5 (VDD one8_b3_2 XI955_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI955_MP10 (XI955_xan XI955_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1115_MP12 (VDD B_23_b3_1 XI1115_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1115_MP18 (XI1115_xp1 XI1115_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1115_MP20 (pp11_7 B_23_b3_1 XI1115_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1115_MP19 (XI1115_xp1 XI1115_xan pp11_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1115_MP17 (VDD XI1115_xn XI1115_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1115_MP6 (XI1115_p1 A_7_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1115_MP8 (XI1115_xn A_6_b3_4 XI1115_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1115_MP7 (XI1115_p1 two11_b3_1 XI1115_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1115_MP5 (VDD one11_b3_1 XI1115_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1115_MP10 (XI1115_xan XI1115_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1114_MP12 (VDD B_23_b3_1 XI1114_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1114_MP18 (XI1114_xp1 XI1114_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1114_MP20 (pp11_6 B_23_b3_1 XI1114_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1114_MP19 (XI1114_xp1 XI1114_xan pp11_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1114_MP17 (VDD XI1114_xn XI1114_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1114_MP6 (XI1114_p1 A_6_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1114_MP8 (XI1114_xn A_5_b3_4 XI1114_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1114_MP7 (XI1114_p1 two11_b3_1 XI1114_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1114_MP5 (VDD one11_b3_1 XI1114_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1114_MP10 (XI1114_xan XI1114_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1169_MP12 (VDD B_25_b3_1 XI1169_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1169_MP18 (XI1169_xp1 XI1169_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1169_MP20 (pp12_6 B_25_b3_1 XI1169_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1169_MP19 (XI1169_xp1 XI1169_xan pp12_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1169_MP17 (VDD XI1169_xn XI1169_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1169_MP6 (XI1169_p1 A_6_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1169_MP8 (XI1169_xn A_5_b3_4 XI1169_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1169_MP7 (XI1169_p1 two12_b3_1 XI1169_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1169_MP5 (VDD one12_b3_1 XI1169_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1169_MP10 (XI1169_xan XI1169_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1276_MP12 (VDD B_29_b3_0 XI1276_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1276_MP18 (XI1276_xp1 XI1276_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1276_MP20 (pp14_3 B_29_b3_0 XI1276_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1276_MP19 (XI1276_xp1 XI1276_xan pp14_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1276_MP17 (VDD XI1276_xn XI1276_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1276_MP6 (XI1276_p1 A_3_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1276_MP8 (XI1276_xn A_2_b3_5 XI1276_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1276_MP7 (XI1276_p1 two14_b3_0 XI1276_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1276_MP5 (VDD one14_b3_0 XI1276_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1276_MP10 (XI1276_xan XI1276_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1275_MP12 (VDD B_29_b3_0 XI1275_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1275_MP18 (XI1275_xp1 XI1275_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1275_MP20 (pp14_2 B_29_b3_0 XI1275_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1275_MP19 (XI1275_xp1 XI1275_xan pp14_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1275_MP17 (VDD XI1275_xn XI1275_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1275_MP6 (XI1275_p1 A_2_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1275_MP8 (XI1275_xn A_1_b3_5 XI1275_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1275_MP7 (XI1275_p1 two14_b3_0 XI1275_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1275_MP5 (VDD one14_b3_0 XI1275_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1275_MP10 (XI1275_xan XI1275_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1360_MP12 (VDD B_31_b3_5 XI1360_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1360_MP18 (XI1360_xp1 XI1360_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1360_MP20 (pp15_32 B_31_b3_5 XI1360_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1360_MP19 (XI1360_xp1 XI1360_xan pp15_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1360_MP17 (VDD XI1360_xn XI1360_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1360_MP6 (XI1360_p1 A_31_b3_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1360_MP8 (XI1360_xn A_31_b3_7 XI1360_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1360_MP7 (XI1360_p1 two15_b3_5 XI1360_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1360_MP5 (VDD one15_b3_5 XI1360_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1360_MP10 (XI1360_xan XI1360_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1359_MP12 (VDD B_31_b3_5 XI1359_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1359_MP18 (XI1359_xp1 XI1359_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1359_MP20 (pp15_31 B_31_b3_5 XI1359_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1359_MP19 (XI1359_xp1 XI1359_xan pp15_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1359_MP17 (VDD XI1359_xn XI1359_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1359_MP6 (XI1359_p1 A_31_b3_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1359_MP8 (XI1359_xn A_30_b3_5 XI1359_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1359_MP7 (XI1359_p1 two15_b3_5 XI1359_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1359_MP5 (VDD one15_b3_5 XI1359_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1359_MP10 (XI1359_xan XI1359_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI744_MP12 (VDD B_9_b3_3 XI744_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI744_MP18 (XI744_xp1 XI744_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI744_MP20 (pp4_21 B_9_b3_3 XI744_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI744_MP19 (XI744_xp1 XI744_xan pp4_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI744_MP17 (VDD XI744_xn XI744_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI744_MP6 (XI744_p1 A_21_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI744_MP8 (XI744_xn A_20_b3_1 XI744_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI744_MP7 (XI744_p1 two4_b3_3 XI744_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI744_MP5 (VDD one4_b3_3 XI744_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI744_MP10 (XI744_xan XI744_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI688_MP12 (VDD B_7_b3_3 XI688_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI688_MP18 (XI688_xp1 XI688_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI688_MP20 (pp3_20 B_7_b3_3 XI688_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI688_MP19 (XI688_xp1 XI688_xan pp3_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI688_MP17 (VDD XI688_xn XI688_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI688_MP6 (XI688_p1 A_20_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI688_MP8 (XI688_xn A_19_b3_1 XI688_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI688_MP7 (XI688_p1 two3_b3_3 XI688_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI688_MP5 (VDD one3_b3_3 XI688_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI688_MP10 (XI688_xan XI688_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI689_MP12 (VDD B_7_b3_3 XI689_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI689_MP18 (XI689_xp1 XI689_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI689_MP20 (pp3_21 B_7_b3_3 XI689_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI689_MP19 (XI689_xp1 XI689_xan pp3_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI689_MP17 (VDD XI689_xn XI689_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI689_MP6 (XI689_p1 A_21_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI689_MP8 (XI689_xn A_20_b3_1 XI689_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI689_MP7 (XI689_p1 two3_b3_3 XI689_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI689_MP5 (VDD one3_b3_3 XI689_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI689_MP10 (XI689_xan XI689_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI637_MP12 (VDD B_5_b3_4 XI637_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI637_MP18 (XI637_xp1 XI637_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI637_MP20 (pp2_24 B_5_b3_4 XI637_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI637_MP19 (XI637_xp1 XI637_xan pp2_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI637_MP17 (VDD XI637_xn XI637_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI637_MP6 (XI637_p1 A_24_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI637_MP8 (XI637_xn A_23_b3_0 XI637_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI637_MP7 (XI637_p1 two2_b3_4 XI637_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI637_MP5 (VDD one2_b3_4 XI637_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI637_MP10 (XI637_xan XI637_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI636_MP12 (VDD B_5_b3_4 XI636_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI636_MP18 (XI636_xp1 XI636_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI636_MP20 (pp2_23 B_5_b3_4 XI636_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI636_MP19 (XI636_xp1 XI636_xan pp2_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI636_MP17 (VDD XI636_xn XI636_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI636_MP6 (XI636_p1 A_23_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI636_MP8 (XI636_xn A_22_b3_0 XI636_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI636_MP7 (XI636_p1 two2_b3_4 XI636_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI636_MP5 (VDD one2_b3_4 XI636_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI636_MP10 (XI636_xan XI636_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI531_MP12 (VDD B_1_b3_4 XI531_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI531_MP18 (XI531_xp1 XI531_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI531_MP20 (pp0_28 B_1_b3_4 XI531_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI531_MP19 (XI531_xp1 XI531_xan pp0_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI531_MP17 (VDD XI531_xn XI531_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI531_MP6 (XI531_p1 A_28_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI531_MP8 (XI531_xn A_27_b3_0 XI531_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI531_MP7 (XI531_p1 two0_b3_5 XI531_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI531_MP5 (VDD one0_b3_5 XI531_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI531_MP10 (XI531_xan XI531_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI954_MP12 (VDD B_17_b3_2 XI954_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI954_MP18 (XI954_xp1 XI954_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI954_MP20 (pp8_11 B_17_b3_2 XI954_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI954_MP19 (XI954_xp1 XI954_xan pp8_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI954_MP17 (VDD XI954_xn XI954_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI954_MP6 (XI954_p1 A_11_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI954_MP8 (XI954_xn A_10_b3_3 XI954_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI954_MP7 (XI954_p1 two8_b3_2 XI954_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI954_MP5 (VDD one8_b3_2 XI954_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI954_MP10 (XI954_xan XI954_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1063_MP12 (VDD B_21_b3_1 XI1063_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1063_MP18 (XI1063_xp1 XI1063_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1063_MP20 (pp10_10 B_21_b3_1 XI1063_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1063_MP19 (XI1063_xp1 XI1063_xan pp10_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1063_MP17 (VDD XI1063_xn XI1063_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1063_MP6 (XI1063_p1 A_10_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1063_MP8 (XI1063_xn A_9_b3_3 XI1063_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1063_MP7 (XI1063_p1 two10_b3_1 XI1063_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1063_MP5 (VDD one10_b3_1 XI1063_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1063_MP10 (XI1063_xan XI1063_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1113_MP12 (VDD B_23_b3_1 XI1113_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1113_MP18 (XI1113_xp1 XI1113_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1113_MP20 (pp11_5 B_23_b3_1 XI1113_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1113_MP19 (XI1113_xp1 XI1113_xan pp11_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1113_MP17 (VDD XI1113_xn XI1113_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1113_MP6 (XI1113_p1 A_5_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1113_MP8 (XI1113_xn A_4_b3_4 XI1113_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1113_MP7 (XI1113_p1 two11_b3_0 XI1113_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1113_MP5 (VDD one11_b3_0 XI1113_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1113_MP10 (XI1113_xan XI1113_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1222_MP12 (VDD B_27_b3_0 XI1222_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1222_MP18 (XI1222_xp1 XI1222_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1222_MP20 (pp13_4 B_27_b3_0 XI1222_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1222_MP19 (XI1222_xp1 XI1222_xan pp13_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1222_MP17 (VDD XI1222_xn XI1222_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1222_MP6 (XI1222_p1 A_4_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1222_MP8 (XI1222_xn A_3_b3_5 XI1222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1222_MP7 (XI1222_p1 two13_b3_0 XI1222_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1222_MP5 (VDD one13_b3_0 XI1222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1222_MP10 (XI1222_xan XI1222_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1168_MP12 (VDD B_25_b3_1 XI1168_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1168_MP18 (XI1168_xp1 XI1168_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1168_MP20 (pp12_5 B_25_b3_1 XI1168_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1168_MP19 (XI1168_xp1 XI1168_xan pp12_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1168_MP17 (VDD XI1168_xn XI1168_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1168_MP6 (XI1168_p1 A_5_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1168_MP8 (XI1168_xn A_4_b3_4 XI1168_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1168_MP7 (XI1168_p1 two12_b3_0 XI1168_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1168_MP5 (VDD one12_b3_0 XI1168_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1168_MP10 (XI1168_xan XI1168_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1273_MP12 (VDD B_29_b3_0 XI1273_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1273_MP18 (XI1273_xp1 XI1273_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1273_MP20 (pp14_0 B_29_b3_0 XI1273_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1273_MP19 (XI1273_xp1 XI1273_xan pp14_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1273_MP17 (VDD XI1273_xn XI1273_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1273_MP6 (XI1273_p1 A_0_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1273_MP8 (XI1273_xn VSS XI1273_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1273_MP7 (XI1273_p1 two14_b3_0 XI1273_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1273_MP5 (VDD one14_b3_0 XI1273_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1273_MP10 (XI1273_xan XI1273_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1274_MP12 (VDD B_29_b3_0 XI1274_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1274_MP18 (XI1274_xp1 XI1274_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1274_MP20 (pp14_1 B_29_b3_0 XI1274_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1274_MP19 (XI1274_xp1 XI1274_xan pp14_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1274_MP17 (VDD XI1274_xn XI1274_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1274_MP6 (XI1274_p1 A_1_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1274_MP8 (XI1274_xn A_0_b3_5 XI1274_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1274_MP7 (XI1274_p1 two14_b3_0 XI1274_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1274_MP5 (VDD one14_b3_0 XI1274_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1274_MP10 (XI1274_xan XI1274_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI742_MP12 (VDD B_9_b3_3 XI742_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI742_MP18 (XI742_xp1 XI742_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI742_MP20 (pp4_19 B_9_b3_3 XI742_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI742_MP19 (XI742_xp1 XI742_xan pp4_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI742_MP17 (VDD XI742_xn XI742_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI742_MP6 (XI742_p1 A_19_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI742_MP8 (XI742_xn A_18_b3_1 XI742_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI742_MP7 (XI742_p1 two4_b3_3 XI742_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI742_MP5 (VDD one4_b3_3 XI742_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI742_MP10 (XI742_xan XI742_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI743_MP12 (VDD B_9_b3_3 XI743_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI743_MP18 (XI743_xp1 XI743_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI743_MP20 (pp4_20 B_9_b3_3 XI743_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI743_MP19 (XI743_xp1 XI743_xan pp4_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI743_MP17 (VDD XI743_xn XI743_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI743_MP6 (XI743_p1 A_20_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI743_MP8 (XI743_xn A_19_b3_1 XI743_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI743_MP7 (XI743_p1 two4_b3_3 XI743_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI743_MP5 (VDD one4_b3_3 XI743_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI743_MP10 (XI743_xan XI743_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI687_MP12 (VDD B_7_b3_3 XI687_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI687_MP18 (XI687_xp1 XI687_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI687_MP20 (pp3_19 B_7_b3_3 XI687_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI687_MP19 (XI687_xp1 XI687_xan pp3_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI687_MP17 (VDD XI687_xn XI687_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI687_MP6 (XI687_p1 A_19_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI687_MP8 (XI687_xn A_18_b3_1 XI687_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI687_MP7 (XI687_p1 two3_b3_3 XI687_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI687_MP5 (VDD one3_b3_3 XI687_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI687_MP10 (XI687_xan XI687_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI635_MP12 (VDD B_5_b3_3 XI635_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI635_MP18 (XI635_xp1 XI635_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI635_MP20 (pp2_22 B_5_b3_3 XI635_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI635_MP19 (XI635_xp1 XI635_xan pp2_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI635_MP17 (VDD XI635_xn XI635_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI635_MP6 (XI635_p1 A_22_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI635_MP8 (XI635_xn A_21_b3_0 XI635_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI635_MP7 (XI635_p1 two2_b3_4 XI635_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI635_MP5 (VDD one2_b3_4 XI635_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI635_MP10 (XI635_xan XI635_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI584_MP12 (VDD B_3_b3_4 XI584_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI584_MP18 (XI584_xp1 XI584_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI584_MP20 (pp1_26 B_3_b3_4 XI584_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI584_MP19 (XI584_xp1 XI584_xan pp1_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI584_MP17 (VDD XI584_xn XI584_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI584_MP6 (XI584_p1 A_26_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI584_MP8 (XI584_xn A_25_b3_0 XI584_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI584_MP7 (XI584_p1 two1_b3_4 XI584_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI584_MP5 (VDD one1_b3_4 XI584_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI584_MP10 (XI584_xan XI584_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI585_MP12 (VDD B_3_b3_4 XI585_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI585_MP18 (XI585_xp1 XI585_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI585_MP20 (pp1_27 B_3_b3_4 XI585_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI585_MP19 (XI585_xp1 XI585_xan pp1_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI585_MP17 (VDD XI585_xn XI585_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI585_MP6 (XI585_p1 A_27_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI585_MP8 (XI585_xn A_26_b3_0 XI585_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI585_MP7 (XI585_p1 two1_b3_4 XI585_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI585_MP5 (VDD one1_b3_4 XI585_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI585_MP10 (XI585_xan XI585_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1062_MP12 (VDD B_21_b3_1 XI1062_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1062_MP18 (XI1062_xp1 XI1062_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1062_MP20 (pp10_9 B_21_b3_1 XI1062_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1062_MP19 (XI1062_xp1 XI1062_xan pp10_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1062_MP17 (VDD XI1062_xn XI1062_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1062_MP6 (XI1062_p1 A_9_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1062_MP8 (XI1062_xn A_8_b3_3 XI1062_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1062_MP7 (XI1062_p1 two10_b3_1 XI1062_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1062_MP5 (VDD one10_b3_1 XI1062_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1062_MP10 (XI1062_xan XI1062_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1061_MP12 (VDD B_21_b3_1 XI1061_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1061_MP18 (XI1061_xp1 XI1061_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1061_MP20 (pp10_8 B_21_b3_1 XI1061_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1061_MP19 (XI1061_xp1 XI1061_xan pp10_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1061_MP17 (VDD XI1061_xn XI1061_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1061_MP6 (XI1061_p1 A_8_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1061_MP8 (XI1061_xn A_7_b3_3 XI1061_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1061_MP7 (XI1061_p1 two10_b3_1 XI1061_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1061_MP5 (VDD one10_b3_1 XI1061_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1061_MP10 (XI1061_xan XI1061_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1221_MP12 (VDD B_27_b3_0 XI1221_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1221_MP18 (XI1221_xp1 XI1221_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1221_MP20 (pp13_3 B_27_b3_0 XI1221_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1221_MP19 (XI1221_xp1 XI1221_xan pp13_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1221_MP17 (VDD XI1221_xn XI1221_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1221_MP6 (XI1221_p1 A_3_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1221_MP8 (XI1221_xn A_2_b3_5 XI1221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1221_MP7 (XI1221_p1 two13_b3_0 XI1221_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1221_MP5 (VDD one13_b3_0 XI1221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1221_MP10 (XI1221_xan XI1221_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI904_MP12 (VDD B_15_b3_2 XI904_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI904_MP18 (XI904_xp1 XI904_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI904_MP20 (pp7_16 B_15_b3_2 XI904_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI904_MP19 (XI904_xp1 XI904_xan pp7_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI904_MP17 (VDD XI904_xn XI904_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI904_MP6 (XI904_p1 A_16_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI904_MP8 (XI904_xn A_15_b3_2 XI904_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI904_MP7 (XI904_p1 two7_b3_2 XI904_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI904_MP5 (VDD one7_b3_2 XI904_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI904_MP10 (XI904_xan XI904_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI849_MP12 (VDD B_13_b3_2 XI849_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI849_MP18 (XI849_xp1 XI849_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI849_MP20 (pp6_16 B_13_b3_2 XI849_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI849_MP19 (XI849_xp1 XI849_xan pp6_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI849_MP17 (VDD XI849_xn XI849_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI849_MP6 (XI849_p1 A_16_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI849_MP8 (XI849_xn A_15_b3_2 XI849_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI849_MP7 (XI849_p1 two6_b3_2 XI849_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI849_MP5 (VDD one6_b3_2 XI849_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI849_MP10 (XI849_xan XI849_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI741_MP12 (VDD B_9_b3_3 XI741_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI741_MP18 (XI741_xp1 XI741_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI741_MP20 (pp4_18 B_9_b3_3 XI741_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI741_MP19 (XI741_xp1 XI741_xan pp4_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI741_MP17 (VDD XI741_xn XI741_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI741_MP6 (XI741_p1 A_18_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI741_MP8 (XI741_xn A_17_b3_1 XI741_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI741_MP7 (XI741_p1 two4_b3_3 XI741_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI741_MP5 (VDD one4_b3_3 XI741_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI741_MP10 (XI741_xan XI741_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI685_MP12 (VDD B_7_b3_3 XI685_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI685_MP18 (XI685_xp1 XI685_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI685_MP20 (pp3_17 B_7_b3_3 XI685_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI685_MP19 (XI685_xp1 XI685_xan pp3_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI685_MP17 (VDD XI685_xn XI685_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI685_MP6 (XI685_p1 A_17_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI685_MP8 (XI685_xn A_16_b3_1 XI685_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI685_MP7 (XI685_p1 two3_b3_3 XI685_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI685_MP5 (VDD one3_b3_3 XI685_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI685_MP10 (XI685_xan XI685_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI686_MP12 (VDD B_7_b3_3 XI686_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI686_MP18 (XI686_xp1 XI686_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI686_MP20 (pp3_18 B_7_b3_3 XI686_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI686_MP19 (XI686_xp1 XI686_xan pp3_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI686_MP17 (VDD XI686_xn XI686_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI686_MP6 (XI686_p1 A_18_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI686_MP8 (XI686_xn A_17_b3_1 XI686_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI686_MP7 (XI686_p1 two3_b3_3 XI686_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI686_MP5 (VDD one3_b3_3 XI686_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI686_MP10 (XI686_xan XI686_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI583_MP12 (VDD B_3_b3_4 XI583_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI583_MP18 (XI583_xp1 XI583_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI583_MP20 (pp1_25 B_3_b3_4 XI583_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI583_MP19 (XI583_xp1 XI583_xan pp1_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI583_MP17 (VDD XI583_xn XI583_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI583_MP6 (XI583_p1 A_25_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI583_MP8 (XI583_xn A_24_b3_0 XI583_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI583_MP7 (XI583_p1 two1_b3_4 XI583_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI583_MP5 (VDD one1_b3_4 XI583_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI583_MP10 (XI583_xan XI583_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI530_MP12 (VDD B_1_b3_4 XI530_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI530_MP18 (XI530_xp1 XI530_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI530_MP20 (pp0_27 B_1_b3_4 XI530_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI530_MP19 (XI530_xp1 XI530_xan pp0_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI530_MP17 (VDD XI530_xn XI530_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI530_MP6 (XI530_p1 A_27_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI530_MP8 (XI530_xn A_26_b3_0 XI530_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI530_MP7 (XI530_p1 two0_b3_4 XI530_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI530_MP5 (VDD one0_b3_4 XI530_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI530_MP10 (XI530_xan XI530_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1007_MP12 (VDD B_19_b3_1 XI1007_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1007_MP18 (XI1007_xp1 XI1007_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1007_MP20 (pp9_9 B_19_b3_1 XI1007_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1007_MP19 (XI1007_xp1 XI1007_xan pp9_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1007_MP17 (VDD XI1007_xn XI1007_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1007_MP6 (XI1007_p1 A_9_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1007_MP8 (XI1007_xn A_8_b3_3 XI1007_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1007_MP7 (XI1007_p1 two9_b3_1 XI1007_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1007_MP5 (VDD one9_b3_1 XI1007_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1007_MP10 (XI1007_xan XI1007_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1008_MP12 (VDD B_19_b3_1 XI1008_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1008_MP18 (XI1008_xp1 XI1008_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1008_MP20 (pp9_10 B_19_b3_1 XI1008_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1008_MP19 (XI1008_xp1 XI1008_xan pp9_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1008_MP17 (VDD XI1008_xn XI1008_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1008_MP6 (XI1008_p1 A_10_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1008_MP8 (XI1008_xn A_9_b3_3 XI1008_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1008_MP7 (XI1008_p1 two9_b3_1 XI1008_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1008_MP5 (VDD one9_b3_1 XI1008_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1008_MP10 (XI1008_xan XI1008_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1060_MP12 (VDD B_21_b3_1 XI1060_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1060_MP18 (XI1060_xp1 XI1060_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1060_MP20 (pp10_7 B_21_b3_1 XI1060_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1060_MP19 (XI1060_xp1 XI1060_xan pp10_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1060_MP17 (VDD XI1060_xn XI1060_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1060_MP6 (XI1060_p1 A_7_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1060_MP8 (XI1060_xn A_6_b3_3 XI1060_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1060_MP7 (XI1060_p1 two10_b3_1 XI1060_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1060_MP5 (VDD one10_b3_1 XI1060_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1060_MP10 (XI1060_xan XI1060_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1219_MP12 (VDD B_27_b3_0 XI1219_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1219_MP18 (XI1219_xp1 XI1219_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1219_MP20 (pp13_1 B_27_b3_0 XI1219_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1219_MP19 (XI1219_xp1 XI1219_xan pp13_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1219_MP17 (VDD XI1219_xn XI1219_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1219_MP6 (XI1219_p1 A_1_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1219_MP8 (XI1219_xn A_0_b3_5 XI1219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1219_MP7 (XI1219_p1 two13_b3_0 XI1219_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1219_MP5 (VDD one13_b3_0 XI1219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1219_MP10 (XI1219_xan XI1219_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1112_MP12 (VDD B_23_b3_0 XI1112_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1112_MP18 (XI1112_xp1 XI1112_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1112_MP20 (pp11_4 B_23_b3_0 XI1112_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1112_MP19 (XI1112_xp1 XI1112_xan pp11_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1112_MP17 (VDD XI1112_xn XI1112_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1112_MP6 (XI1112_p1 A_4_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1112_MP8 (XI1112_xn A_3_b3_4 XI1112_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1112_MP7 (XI1112_p1 two11_b3_0 XI1112_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1112_MP5 (VDD one11_b3_0 XI1112_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1112_MP10 (XI1112_xan XI1112_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1167_MP12 (VDD B_25_b3_0 XI1167_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1167_MP18 (XI1167_xp1 XI1167_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1167_MP20 (pp12_4 B_25_b3_0 XI1167_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1167_MP19 (XI1167_xp1 XI1167_xan pp12_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1167_MP17 (VDD XI1167_xn XI1167_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1167_MP6 (XI1167_p1 A_4_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1167_MP8 (XI1167_xn A_3_b3_4 XI1167_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1167_MP7 (XI1167_p1 two12_b3_0 XI1167_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1167_MP5 (VDD one12_b3_0 XI1167_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1167_MP10 (XI1167_xan XI1167_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1220_MP12 (VDD B_27_b3_0 XI1220_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1220_MP18 (XI1220_xp1 XI1220_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1220_MP20 (pp13_2 B_27_b3_0 XI1220_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1220_MP19 (XI1220_xp1 XI1220_xan pp13_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1220_MP17 (VDD XI1220_xn XI1220_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1220_MP6 (XI1220_p1 A_2_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1220_MP8 (XI1220_xn A_1_b3_5 XI1220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1220_MP7 (XI1220_p1 two13_b3_0 XI1220_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1220_MP5 (VDD one13_b3_0 XI1220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1220_MP10 (XI1220_xan XI1220_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI903_MP12 (VDD B_15_b3_2 XI903_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI903_MP18 (XI903_xp1 XI903_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI903_MP20 (pp7_15 B_15_b3_2 XI903_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI903_MP19 (XI903_xp1 XI903_xan pp7_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI903_MP17 (VDD XI903_xn XI903_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI903_MP6 (XI903_p1 A_15_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI903_MP8 (XI903_xn A_14_b3_2 XI903_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI903_MP7 (XI903_p1 two7_b3_2 XI903_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI903_MP5 (VDD one7_b3_2 XI903_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI903_MP10 (XI903_xan XI903_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI902_MP12 (VDD B_15_b3_2 XI902_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI902_MP18 (XI902_xp1 XI902_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI902_MP20 (pp7_14 B_15_b3_2 XI902_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI902_MP19 (XI902_xp1 XI902_xan pp7_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI902_MP17 (VDD XI902_xn XI902_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI902_MP6 (XI902_p1 A_14_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI902_MP8 (XI902_xn A_13_b3_2 XI902_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI902_MP7 (XI902_p1 two7_b3_2 XI902_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI902_MP5 (VDD one7_b3_2 XI902_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI902_MP10 (XI902_xan XI902_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI847_MP12 (VDD B_13_b3_2 XI847_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI847_MP18 (XI847_xp1 XI847_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI847_MP20 (pp6_14 B_13_b3_2 XI847_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI847_MP19 (XI847_xp1 XI847_xan pp6_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI847_MP17 (VDD XI847_xn XI847_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI847_MP6 (XI847_p1 A_14_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
