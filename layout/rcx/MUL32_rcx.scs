    I_MXI1451_MP26 (VDD XI1451_asn XI1451_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1451_MP18 (XI1451_ap3 pp6_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1451_MP21 (XI1451_asn XI1451_acon XI1451_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1451_MP24 (XI1451_ap5 pp8_21 XI1451_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1451_MP23 (XI1451_ap4 pp7_23 XI1451_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1451_MP22 (VDD pp6_25 XI1451_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1451_MP22_1 (XI1451_ap4 pp6_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1451_MP23_1 (XI1451_ap5 pp7_23 XI1451_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1451_MP24_1 (XI1451_asn pp8_21 XI1451_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1451_MP17 (XI1451_acon pp8_21 XI1451_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1451_MP14 (XI1451_ap1 pp7_23 XI1451_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1451_MP13 (VDD pp6_25 XI1451_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1451_MP15 (XI1451_ap2 pp6_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1451_MP16 (VDD pp7_23 XI1451_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1451_MP28 (cm90_2 XI1451_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1451_MP19 (XI1451_ap3 pp7_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1451_MP20 (VDD pp8_21 XI1451_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1454_MP50 (VDD XI1454_s1 XI1454_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1454_MP47 (XI1454_bp3 pp9_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1454_MP49 (XI1454_bsn XI1454_bcon XI1454_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1454_MP52 (XI1454_bp5 cm90_2 XI1454_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1454_MP51 (XI1454_bp4 pp9_20 XI1454_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1454_MP51_1 (XI1454_bp5 pp9_20 XI1454_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1454_MP52_1 (XI1454_bsn cm90_2 XI1454_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1454_MP54 (VDD XI1454_bsn cm93_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1454_MP41 (XI1454_bp1 XI1454_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1454_MP42 (XI1454_bcon pp9_20 XI1454_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1454_MP45 (XI1454_bp2 cm90_2 XI1454_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1454_MP43 (VDD XI1454_s1 XI1454_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1454_MP44 (XI1454_bp2 pp9_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1454_MP56 (VDD XI1454_bcon cm93_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1454_MP46 (XI1454_bp3 XI1454_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1454_MP48 (VDD cm90_2 XI1454_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1454_MP50_1 (XI1454_bp4 XI1454_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1454_MP26 (VDD XI1454_asn XI1454_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1454_MP18 (XI1454_ap3 pp6_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1454_MP21 (XI1454_asn XI1454_acon XI1454_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1454_MP24 (XI1454_ap5 pp8_22 XI1454_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1454_MP23 (XI1454_ap4 pp7_24 XI1454_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1454_MP22 (VDD pp6_26 XI1454_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1454_MP22_1 (XI1454_ap4 pp6_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1454_MP23_1 (XI1454_ap5 pp7_24 XI1454_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1454_MP24_1 (XI1454_asn pp8_22 XI1454_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1454_MP17 (XI1454_acon pp8_22 XI1454_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1454_MP14 (XI1454_ap1 pp7_24 XI1454_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1454_MP13 (VDD pp6_26 XI1454_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1454_MP15 (XI1454_ap2 pp6_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1454_MP16 (VDD pp7_24 XI1454_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1454_MP28 (cm93_2 XI1454_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1454_MP19 (XI1454_ap3 pp7_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1454_MP20 (VDD pp8_22 XI1454_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1472_MP50 (VDD XI1472_s1 XI1472_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1472_MP47 (XI1472_bp3 pp12_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1472_MP49 (XI1472_bsn XI1472_bcon XI1472_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1472_MP52 (XI1472_bp5 cm108_2 XI1472_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1472_MP51 (XI1472_bp4 pp12_20 XI1472_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1472_MP51_1 (XI1472_bp5 pp12_20 XI1472_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1472_MP52_1 (XI1472_bsn cm108_2 XI1472_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1472_MP54 (VDD XI1472_bsn cm111_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1472_MP41 (XI1472_bp1 XI1472_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1472_MP42 (XI1472_bcon pp12_20 XI1472_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1472_MP45 (XI1472_bp2 cm108_2 XI1472_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1472_MP43 (VDD XI1472_s1 XI1472_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1472_MP44 (XI1472_bp2 pp12_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1472_MP56 (VDD XI1472_bcon cm111_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1472_MP46 (XI1472_bp3 XI1472_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1472_MP48 (VDD cm108_2 XI1472_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1472_MP50_1 (XI1472_bp4 XI1472_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1472_MP26 (VDD XI1472_asn XI1472_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1472_MP18 (XI1472_ap3 pp9_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1472_MP21 (XI1472_asn XI1472_acon XI1472_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1472_MP24 (XI1472_ap5 pp11_22 XI1472_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1472_MP23 (XI1472_ap4 pp10_24 XI1472_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1472_MP22 (VDD pp9_26 XI1472_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1472_MP22_1 (XI1472_ap4 pp9_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1472_MP23_1 (XI1472_ap5 pp10_24 XI1472_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1472_MP24_1 (XI1472_asn pp11_22 XI1472_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1472_MP17 (XI1472_acon pp11_22 XI1472_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1472_MP14 (XI1472_ap1 pp10_24 XI1472_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1472_MP13 (VDD pp9_26 XI1472_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1472_MP15 (XI1472_ap2 pp9_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1472_MP16 (VDD pp10_24 XI1472_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1472_MP28 (cm111_2 XI1472_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1472_MP19 (XI1472_ap3 pp10_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1472_MP20 (VDD pp11_22 XI1472_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1557_MP50 (VDD XI1557_s1 XI1557_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1557_MP47 (XI1557_bp3 cm116_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1557_MP49 (XI1557_bsn XI1557_bcon XI1557_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1557_MP52 (XI1557_bp5 cm194_2 XI1557_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1557_MP51 (XI1557_bp4 cm116_0 XI1557_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1557_MP51_1 (XI1557_bp5 cm116_0 XI1557_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1557_MP52_1 (XI1557_bsn cm194_2 XI1557_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1557_MP54 (VDD XI1557_bsn cm196_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1557_MP41 (XI1557_bp1 XI1557_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1557_MP42 (XI1557_bcon cm116_0 XI1557_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1557_MP45 (XI1557_bp2 cm194_2 XI1557_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1557_MP43 (VDD XI1557_s1 XI1557_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1557_MP44 (XI1557_bp2 cm116_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1557_MP56 (VDD XI1557_bcon cm196_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1557_MP46 (XI1557_bp3 XI1557_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1557_MP48 (VDD cm194_2 XI1557_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1557_MP50_1 (XI1557_bp4 XI1557_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1557_MP26 (VDD XI1557_asn XI1557_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1557_MP18 (XI1557_ap3 cm113_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1557_MP21 (XI1557_asn XI1557_acon XI1557_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1557_MP24 (XI1557_ap5 cm115_0 XI1557_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1557_MP23 (XI1557_ap4 cm114_1 XI1557_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1557_MP22 (VDD cm113_1 XI1557_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1557_MP22_1 (XI1557_ap4 cm113_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1557_MP23_1 (XI1557_ap5 cm114_1 XI1557_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1557_MP24_1 (XI1557_asn cm115_0 XI1557_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1557_MP17 (XI1557_acon cm115_0 XI1557_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1557_MP14 (XI1557_ap1 cm114_1 XI1557_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1557_MP13 (VDD cm113_1 XI1557_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1557_MP15 (XI1557_ap2 cm113_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1557_MP16 (VDD cm114_1 XI1557_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1557_MP28 (cm196_2 XI1557_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1557_MP19 (XI1557_ap3 cm114_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1557_MP20 (VDD cm115_0 XI1557_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1479_MP50 (VDD XI1479_s1 XI1479_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1479_MP47 (XI1479_bp3 pp14_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1479_MP49 (XI1479_bsn XI1479_bcon XI1479_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1479_MP52 (XI1479_bp5 cm116_2 XI1479_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1479_MP51 (XI1479_bp4 pp14_19 XI1479_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1479_MP51_1 (XI1479_bp5 pp14_19 XI1479_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1479_MP52_1 (XI1479_bsn cm116_2 XI1479_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1479_MP54 (VDD XI1479_bsn cm118_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1479_MP41 (XI1479_bp1 XI1479_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1479_MP42 (XI1479_bcon pp14_19 XI1479_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1479_MP45 (XI1479_bp2 cm116_2 XI1479_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1479_MP43 (VDD XI1479_s1 XI1479_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1479_MP44 (XI1479_bp2 pp14_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1479_MP56 (VDD XI1479_bcon cm118_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1479_MP46 (XI1479_bp3 XI1479_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1479_MP48 (VDD cm116_2 XI1479_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1479_MP50_1 (XI1479_bp4 XI1479_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1479_MP26 (VDD XI1479_asn XI1479_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1479_MP18 (XI1479_ap3 pp11_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1479_MP21 (XI1479_asn XI1479_acon XI1479_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1479_MP24 (XI1479_ap5 pp13_21 XI1479_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1479_MP23 (XI1479_ap4 pp12_23 XI1479_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1479_MP22 (VDD pp11_25 XI1479_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1479_MP22_1 (XI1479_ap4 pp11_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1479_MP23_1 (XI1479_ap5 pp12_23 XI1479_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1479_MP24_1 (XI1479_asn pp13_21 XI1479_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1479_MP17 (XI1479_acon pp13_21 XI1479_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1479_MP14 (XI1479_ap1 pp12_23 XI1479_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1479_MP13 (VDD pp11_25 XI1479_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1479_MP15 (XI1479_ap2 pp11_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1479_MP16 (VDD pp12_23 XI1479_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1479_MP28 (cm118_2 XI1479_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1479_MP19 (XI1479_ap3 pp12_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1479_MP20 (VDD pp13_21 XI1479_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1561_MP50 (VDD XI1561_s1 XI1561_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1561_MP47 (XI1561_bp3 cm124_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1561_MP49 (XI1561_bsn XI1561_bcon XI1561_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1561_MP52 (XI1561_bp5 cm199_2 XI1561_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1561_MP51 (XI1561_bp4 cm124_0 XI1561_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1561_MP51_1 (XI1561_bp5 cm124_0 XI1561_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1561_MP52_1 (XI1561_bsn cm199_2 XI1561_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1561_MP54 (VDD XI1561_bsn cm200_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1561_MP41 (XI1561_bp1 XI1561_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1561_MP42 (XI1561_bcon cm124_0 XI1561_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1561_MP45 (XI1561_bp2 cm199_2 XI1561_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1561_MP43 (VDD XI1561_s1 XI1561_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1561_MP44 (XI1561_bp2 cm124_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1561_MP56 (VDD XI1561_bcon cm200_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1561_MP46 (XI1561_bp3 XI1561_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1561_MP48 (VDD cm199_2 XI1561_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1561_MP50_1 (XI1561_bp4 XI1561_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1561_MP26 (VDD XI1561_asn XI1561_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1561_MP18 (XI1561_ap3 cm121_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1561_MP21 (XI1561_asn XI1561_acon XI1561_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1561_MP24 (XI1561_ap5 cm123_0 XI1561_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1561_MP23 (XI1561_ap4 cm122_1 XI1561_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1561_MP22 (VDD cm121_1 XI1561_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1561_MP22_1 (XI1561_ap4 cm121_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1561_MP23_1 (XI1561_ap5 cm122_1 XI1561_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1561_MP24_1 (XI1561_asn cm123_0 XI1561_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1561_MP17 (XI1561_acon cm123_0 XI1561_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1561_MP14 (XI1561_ap1 cm122_1 XI1561_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1561_MP13 (VDD cm121_1 XI1561_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1561_MP15 (XI1561_ap2 cm121_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1561_MP16 (VDD cm122_1 XI1561_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1561_MP28 (cm200_2 XI1561_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1561_MP19 (XI1561_ap3 cm122_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1561_MP20 (VDD cm123_0 XI1561_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1481_MP50 (VDD XI1481_s1 XI1481_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1481_MP47 (XI1481_bp3 pp14_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1481_MP49 (XI1481_bsn XI1481_bcon XI1481_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1481_MP52 (XI1481_bp5 cm118_2 XI1481_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1481_MP51 (XI1481_bp4 pp14_20 XI1481_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1481_MP51_1 (XI1481_bp5 pp14_20 XI1481_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1481_MP52_1 (XI1481_bsn cm118_2 XI1481_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1481_MP54 (VDD XI1481_bsn cm120_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1481_MP41 (XI1481_bp1 XI1481_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1481_MP42 (XI1481_bcon pp14_20 XI1481_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1481_MP45 (XI1481_bp2 cm118_2 XI1481_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1481_MP43 (VDD XI1481_s1 XI1481_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1481_MP44 (XI1481_bp2 pp14_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1481_MP56 (VDD XI1481_bcon cm120_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1481_MP46 (XI1481_bp3 XI1481_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1481_MP48 (VDD cm118_2 XI1481_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1481_MP50_1 (XI1481_bp4 XI1481_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1481_MP26 (VDD XI1481_asn XI1481_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1481_MP18 (XI1481_ap3 pp11_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1481_MP21 (XI1481_asn XI1481_acon XI1481_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1481_MP24 (XI1481_ap5 pp13_22 XI1481_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1481_MP23 (XI1481_ap4 pp12_24 XI1481_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1481_MP22 (VDD pp11_26 XI1481_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1481_MP22_1 (XI1481_ap4 pp11_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1481_MP23_1 (XI1481_ap5 pp12_24 XI1481_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1481_MP24_1 (XI1481_asn pp13_22 XI1481_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1481_MP17 (XI1481_acon pp13_22 XI1481_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1481_MP14 (XI1481_ap1 pp12_24 XI1481_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1481_MP13 (VDD pp11_26 XI1481_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1481_MP15 (XI1481_ap2 pp11_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1481_MP16 (VDD pp12_24 XI1481_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1481_MP28 (cm120_2 XI1481_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1481_MP19 (XI1481_ap3 pp12_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1481_MP20 (VDD pp13_22 XI1481_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1483_MP50 (VDD XI1483_s1 XI1483_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1483_MP47 (XI1483_bp3 pp15_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1483_MP49 (XI1483_bsn XI1483_bcon XI1483_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1483_MP52 (XI1483_bp5 cm120_2 XI1483_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1483_MP51 (XI1483_bp4 pp15_19 XI1483_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1483_MP51_1 (XI1483_bp5 pp15_19 XI1483_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1483_MP52_1 (XI1483_bsn cm120_2 XI1483_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1483_MP54 (VDD XI1483_bsn cm122_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1483_MP41 (XI1483_bp1 XI1483_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1483_MP42 (XI1483_bcon pp15_19 XI1483_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1483_MP45 (XI1483_bp2 cm120_2 XI1483_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1483_MP43 (VDD XI1483_s1 XI1483_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1483_MP44 (XI1483_bp2 pp15_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1483_MP56 (VDD XI1483_bcon cm122_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1483_MP46 (XI1483_bp3 XI1483_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1483_MP48 (VDD cm120_2 XI1483_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1483_MP50_1 (XI1483_bp4 XI1483_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1483_MP26 (VDD XI1483_asn XI1483_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1483_MP18 (XI1483_ap3 pp12_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1483_MP21 (XI1483_asn XI1483_acon XI1483_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1483_MP24 (XI1483_ap5 pp14_21 XI1483_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1483_MP23 (XI1483_ap4 pp13_23 XI1483_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1483_MP22 (VDD pp12_25 XI1483_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1483_MP22_1 (XI1483_ap4 pp12_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1483_MP23_1 (XI1483_ap5 pp13_23 XI1483_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1483_MP24_1 (XI1483_asn pp14_21 XI1483_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1483_MP17 (XI1483_acon pp14_21 XI1483_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1483_MP14 (XI1483_ap1 pp13_23 XI1483_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1483_MP13 (VDD pp12_25 XI1483_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1483_MP15 (XI1483_ap2 pp12_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1483_MP16 (VDD pp13_23 XI1483_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1483_MP28 (cm122_2 XI1483_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1483_MP19 (XI1483_ap3 pp13_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1483_MP20 (VDD pp14_21 XI1483_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1447_MP50 (VDD XI1447_s1 XI1447_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1447_MP47 (XI1447_bp3 pp8_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1447_MP49 (XI1447_bsn XI1447_bcon XI1447_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1447_MP52 (XI1447_bp5 cm82_2 XI1447_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1447_MP51 (XI1447_bp4 pp8_20 XI1447_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1447_MP51_1 (XI1447_bp5 pp8_20 XI1447_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1447_MP52_1 (XI1447_bsn cm82_2 XI1447_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1447_MP54 (VDD XI1447_bsn cm86_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1447_MP41 (XI1447_bp1 XI1447_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1447_MP42 (XI1447_bcon pp8_20 XI1447_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1447_MP45 (XI1447_bp2 cm82_2 XI1447_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1447_MP43 (VDD XI1447_s1 XI1447_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1447_MP44 (XI1447_bp2 pp8_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1447_MP56 (VDD XI1447_bcon cm86_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1447_MP46 (XI1447_bp3 XI1447_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1447_MP48 (VDD cm82_2 XI1447_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1447_MP50_1 (XI1447_bp4 XI1447_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1447_MP26 (VDD XI1447_asn XI1447_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1447_MP18 (XI1447_ap3 pp5_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1447_MP21 (XI1447_asn XI1447_acon XI1447_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1447_MP24 (XI1447_ap5 pp7_22 XI1447_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1447_MP23 (XI1447_ap4 pp6_24 XI1447_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1447_MP22 (VDD pp5_26 XI1447_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1447_MP22_1 (XI1447_ap4 pp5_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1447_MP23_1 (XI1447_ap5 pp6_24 XI1447_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1447_MP24_1 (XI1447_asn pp7_22 XI1447_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1447_MP17 (XI1447_acon pp7_22 XI1447_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1447_MP14 (XI1447_ap1 pp6_24 XI1447_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1447_MP13 (VDD pp5_26 XI1447_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1447_MP15 (XI1447_ap2 pp5_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1447_MP16 (VDD pp6_24 XI1447_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1447_MP28 (cm86_2 XI1447_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1447_MP19 (XI1447_ap3 pp6_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1447_MP20 (VDD pp7_22 XI1447_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1463_MP50 (VDD XI1463_s1 XI1463_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1463_MP47 (XI1463_bp3 pp11_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1463_MP49 (XI1463_bsn XI1463_bcon XI1463_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1463_MP52 (XI1463_bp5 cm99_2 XI1463_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1463_MP51 (XI1463_bp4 pp11_19 XI1463_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1463_MP51_1 (XI1463_bp5 pp11_19 XI1463_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1463_MP52_1 (XI1463_bsn cm99_2 XI1463_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1463_MP54 (VDD XI1463_bsn cm102_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1463_MP41 (XI1463_bp1 XI1463_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1463_MP42 (XI1463_bcon pp11_19 XI1463_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1463_MP45 (XI1463_bp2 cm99_2 XI1463_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1463_MP43 (VDD XI1463_s1 XI1463_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1463_MP44 (XI1463_bp2 pp11_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1463_MP56 (VDD XI1463_bcon cm102_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1463_MP46 (XI1463_bp3 XI1463_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1463_MP48 (VDD cm99_2 XI1463_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1463_MP50_1 (XI1463_bp4 XI1463_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1463_MP26 (VDD XI1463_asn XI1463_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1463_MP18 (XI1463_ap3 pp8_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1463_MP21 (XI1463_asn XI1463_acon XI1463_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1463_MP24 (XI1463_ap5 pp10_21 XI1463_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1463_MP23 (XI1463_ap4 pp9_23 XI1463_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1463_MP22 (VDD pp8_25 XI1463_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1463_MP22_1 (XI1463_ap4 pp8_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1463_MP23_1 (XI1463_ap5 pp9_23 XI1463_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1463_MP24_1 (XI1463_asn pp10_21 XI1463_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1463_MP17 (XI1463_acon pp10_21 XI1463_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1463_MP14 (XI1463_ap1 pp9_23 XI1463_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1463_MP13 (VDD pp8_25 XI1463_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1463_MP15 (XI1463_ap2 pp8_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1463_MP16 (VDD pp9_23 XI1463_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1463_MP28 (cm102_2 XI1463_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1463_MP19 (XI1463_ap3 pp9_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1463_MP20 (VDD pp10_21 XI1463_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1550_MP50 (VDD XI1550_s1 XI1550_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1550_MP47 (XI1550_bp3 cm101_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1550_MP49 (XI1550_bsn XI1550_bcon XI1550_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1550_MP52 (XI1550_bp5 cm187_2 XI1550_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1550_MP51 (XI1550_bp4 cm101_0 XI1550_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1550_MP51_1 (XI1550_bp5 cm101_0 XI1550_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1550_MP52_1 (XI1550_bsn cm187_2 XI1550_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1550_MP54 (VDD XI1550_bsn cm189_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1550_MP41 (XI1550_bp1 XI1550_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1550_MP42 (XI1550_bcon cm101_0 XI1550_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1550_MP45 (XI1550_bp2 cm187_2 XI1550_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1550_MP43 (VDD XI1550_s1 XI1550_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1550_MP44 (XI1550_bp2 cm101_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1550_MP56 (VDD XI1550_bcon cm189_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1550_MP46 (XI1550_bp3 XI1550_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1550_MP48 (VDD cm187_2 XI1550_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1550_MP50_1 (XI1550_bp4 XI1550_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1550_MP26 (VDD XI1550_asn XI1550_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1550_MP18 (XI1550_ap3 cm98_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1550_MP21 (XI1550_asn XI1550_acon XI1550_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1550_MP24 (XI1550_ap5 cm100_1 XI1550_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1550_MP23 (XI1550_ap4 cm99_1 XI1550_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1550_MP22 (VDD cm98_1 XI1550_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1550_MP22_1 (XI1550_ap4 cm98_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1550_MP23_1 (XI1550_ap5 cm99_1 XI1550_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1550_MP24_1 (XI1550_asn cm100_1 XI1550_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1550_MP17 (XI1550_acon cm100_1 XI1550_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1550_MP14 (XI1550_ap1 cm99_1 XI1550_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1550_MP13 (VDD cm98_1 XI1550_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1550_MP15 (XI1550_ap2 cm98_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1550_MP16 (VDD cm99_1 XI1550_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1550_MP28 (cm189_2 XI1550_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1550_MP19 (XI1550_ap3 cm99_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1550_MP20 (VDD cm100_1 XI1550_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1469_MP50 (VDD XI1469_s1 XI1469_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1469_MP47 (XI1469_bp3 pp12_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1469_MP49 (XI1469_bsn XI1469_bcon XI1469_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1469_MP52 (XI1469_bp5 cm105_2 XI1469_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1469_MP51 (XI1469_bp4 pp12_19 XI1469_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1469_MP51_1 (XI1469_bp5 pp12_19 XI1469_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1469_MP52_1 (XI1469_bsn cm105_2 XI1469_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1469_MP54 (VDD XI1469_bsn cm108_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1469_MP41 (XI1469_bp1 XI1469_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1469_MP42 (XI1469_bcon pp12_19 XI1469_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1469_MP45 (XI1469_bp2 cm105_2 XI1469_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1469_MP43 (VDD XI1469_s1 XI1469_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1469_MP44 (XI1469_bp2 pp12_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1469_MP56 (VDD XI1469_bcon cm108_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1469_MP46 (XI1469_bp3 XI1469_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1469_MP48 (VDD cm105_2 XI1469_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1469_MP50_1 (XI1469_bp4 XI1469_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1469_MP26 (VDD XI1469_asn XI1469_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1469_MP18 (XI1469_ap3 pp9_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1469_MP21 (XI1469_asn XI1469_acon XI1469_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1469_MP24 (XI1469_ap5 pp11_21 XI1469_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1469_MP23 (XI1469_ap4 pp10_23 XI1469_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1469_MP22 (VDD pp9_25 XI1469_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1469_MP22_1 (XI1469_ap4 pp9_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1469_MP23_1 (XI1469_ap5 pp10_23 XI1469_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1469_MP24_1 (XI1469_asn pp11_21 XI1469_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1469_MP17 (XI1469_acon pp11_21 XI1469_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1469_MP14 (XI1469_ap1 pp10_23 XI1469_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1469_MP13 (VDD pp9_25 XI1469_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1469_MP15 (XI1469_ap2 pp9_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1469_MP16 (VDD pp10_23 XI1469_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1469_MP28 (cm108_2 XI1469_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1469_MP19 (XI1469_ap3 pp10_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1469_MP20 (VDD pp11_21 XI1469_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1466_MP50 (VDD XI1466_s1 XI1466_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1466_MP47 (XI1466_bp3 pp11_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1466_MP49 (XI1466_bsn XI1466_bcon XI1466_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1466_MP52 (XI1466_bp5 cm102_2 XI1466_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1466_MP51 (XI1466_bp4 pp11_20 XI1466_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1466_MP51_1 (XI1466_bp5 pp11_20 XI1466_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1466_MP52_1 (XI1466_bsn cm102_2 XI1466_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1466_MP54 (VDD XI1466_bsn cm105_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1466_MP41 (XI1466_bp1 XI1466_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1466_MP42 (XI1466_bcon pp11_20 XI1466_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1466_MP45 (XI1466_bp2 cm102_2 XI1466_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1466_MP43 (VDD XI1466_s1 XI1466_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1466_MP44 (XI1466_bp2 pp11_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1466_MP56 (VDD XI1466_bcon cm105_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1466_MP46 (XI1466_bp3 XI1466_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1466_MP48 (VDD cm102_2 XI1466_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1466_MP50_1 (XI1466_bp4 XI1466_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1466_MP26 (VDD XI1466_asn XI1466_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1466_MP18 (XI1466_ap3 pp8_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1466_MP21 (XI1466_asn XI1466_acon XI1466_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1466_MP24 (XI1466_ap5 pp10_22 XI1466_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1466_MP23 (XI1466_ap4 pp9_24 XI1466_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1466_MP22 (VDD pp8_26 XI1466_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1466_MP22_1 (XI1466_ap4 pp8_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1466_MP23_1 (XI1466_ap5 pp9_24 XI1466_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1466_MP24_1 (XI1466_asn pp10_22 XI1466_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1466_MP17 (XI1466_acon pp10_22 XI1466_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1466_MP14 (XI1466_ap1 pp9_24 XI1466_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1466_MP13 (VDD pp8_26 XI1466_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1466_MP15 (XI1466_ap2 pp8_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1466_MP16 (VDD pp9_24 XI1466_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1466_MP28 (cm105_2 XI1466_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1466_MP19 (XI1466_ap3 pp9_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1466_MP20 (VDD pp10_22 XI1466_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1555_MP50 (VDD XI1555_s1 XI1555_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1555_MP47 (XI1555_bp3 cm113_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1555_MP49 (XI1555_bsn XI1555_bcon XI1555_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1555_MP52 (XI1555_bp5 cm193_2 XI1555_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1555_MP51 (XI1555_bp4 cm113_0 XI1555_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1555_MP51_1 (XI1555_bp5 cm113_0 XI1555_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1555_MP52_1 (XI1555_bsn cm193_2 XI1555_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1555_MP54 (VDD XI1555_bsn cm194_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1555_MP41 (XI1555_bp1 XI1555_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1555_MP42 (XI1555_bcon cm113_0 XI1555_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1555_MP45 (XI1555_bp2 cm193_2 XI1555_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1555_MP43 (VDD XI1555_s1 XI1555_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1555_MP44 (XI1555_bp2 cm113_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1555_MP56 (VDD XI1555_bcon cm194_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1555_MP46 (XI1555_bp3 XI1555_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1555_MP48 (VDD cm193_2 XI1555_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1555_MP50_1 (XI1555_bp4 XI1555_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1555_MP26 (VDD XI1555_asn XI1555_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1555_MP18 (XI1555_ap3 cm110_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1555_MP21 (XI1555_asn XI1555_acon XI1555_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1555_MP24 (XI1555_ap5 fa112_1 XI1555_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1555_MP23 (XI1555_ap4 cm111_1 XI1555_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1555_MP22 (VDD cm110_1 XI1555_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1555_MP22_1 (XI1555_ap4 cm110_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1555_MP23_1 (XI1555_ap5 cm111_1 XI1555_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1555_MP24_1 (XI1555_asn fa112_1 XI1555_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1555_MP17 (XI1555_acon fa112_1 XI1555_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1555_MP14 (XI1555_ap1 cm111_1 XI1555_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1555_MP13 (VDD cm110_1 XI1555_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1555_MP15 (XI1555_ap2 cm110_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1555_MP16 (VDD cm111_1 XI1555_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1555_MP28 (cm194_2 XI1555_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1555_MP19 (XI1555_ap3 cm111_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1555_MP20 (VDD fa112_1 XI1555_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1475_MP50 (VDD XI1475_s1 XI1475_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1475_MP47 (XI1475_bp3 pp13_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1475_MP49 (XI1475_bsn XI1475_bcon XI1475_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1475_MP52 (XI1475_bp5 cm111_2 XI1475_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1475_MP51 (XI1475_bp4 pp13_19 XI1475_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1475_MP51_1 (XI1475_bp5 pp13_19 XI1475_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1475_MP52_1 (XI1475_bsn cm111_2 XI1475_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1475_MP54 (VDD XI1475_bsn cm114_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1475_MP41 (XI1475_bp1 XI1475_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1475_MP42 (XI1475_bcon pp13_19 XI1475_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1475_MP45 (XI1475_bp2 cm111_2 XI1475_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1475_MP43 (VDD XI1475_s1 XI1475_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1475_MP44 (XI1475_bp2 pp13_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1475_MP56 (VDD XI1475_bcon cm114_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1475_MP46 (XI1475_bp3 XI1475_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1475_MP48 (VDD cm111_2 XI1475_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1475_MP50_1 (XI1475_bp4 XI1475_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1475_MP26 (VDD XI1475_asn XI1475_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1475_MP18 (XI1475_ap3 pp10_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1475_MP21 (XI1475_asn XI1475_acon XI1475_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1475_MP24 (XI1475_ap5 pp12_21 XI1475_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1475_MP23 (XI1475_ap4 pp11_23 XI1475_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1475_MP22 (VDD pp10_25 XI1475_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1475_MP22_1 (XI1475_ap4 pp10_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1475_MP23_1 (XI1475_ap5 pp11_23 XI1475_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1475_MP24_1 (XI1475_asn pp12_21 XI1475_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1475_MP17 (XI1475_acon pp12_21 XI1475_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1475_MP14 (XI1475_ap1 pp11_23 XI1475_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1475_MP13 (VDD pp10_25 XI1475_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1475_MP15 (XI1475_ap2 pp10_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1475_MP16 (VDD pp11_23 XI1475_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1475_MP28 (cm114_2 XI1475_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1475_MP19 (XI1475_ap3 pp11_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1475_MP20 (VDD pp12_21 XI1475_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1477_MP50 (VDD XI1477_s1 XI1477_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1477_MP47 (XI1477_bp3 pp13_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1477_MP49 (XI1477_bsn XI1477_bcon XI1477_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1477_MP52 (XI1477_bp5 cm114_2 XI1477_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1477_MP51 (XI1477_bp4 pp13_20 XI1477_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1477_MP51_1 (XI1477_bp5 pp13_20 XI1477_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1477_MP52_1 (XI1477_bsn cm114_2 XI1477_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1477_MP54 (VDD XI1477_bsn cm116_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1477_MP41 (XI1477_bp1 XI1477_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1477_MP42 (XI1477_bcon pp13_20 XI1477_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1477_MP45 (XI1477_bp2 cm114_2 XI1477_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1477_MP43 (VDD XI1477_s1 XI1477_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1477_MP44 (XI1477_bp2 pp13_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1477_MP56 (VDD XI1477_bcon cm116_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1477_MP46 (XI1477_bp3 XI1477_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1477_MP48 (VDD cm114_2 XI1477_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1477_MP50_1 (XI1477_bp4 XI1477_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1477_MP26 (VDD XI1477_asn XI1477_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1477_MP18 (XI1477_ap3 pp10_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1477_MP21 (XI1477_asn XI1477_acon XI1477_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1477_MP24 (XI1477_ap5 pp12_22 XI1477_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1477_MP23 (XI1477_ap4 pp11_24 XI1477_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1477_MP22 (VDD pp10_26 XI1477_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1477_MP22_1 (XI1477_ap4 pp10_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1477_MP23_1 (XI1477_ap5 pp11_24 XI1477_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1477_MP24_1 (XI1477_asn pp12_22 XI1477_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1477_MP17 (XI1477_acon pp12_22 XI1477_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1477_MP14 (XI1477_ap1 pp11_24 XI1477_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1477_MP13 (VDD pp10_26 XI1477_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1477_MP15 (XI1477_ap2 pp10_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1477_MP16 (VDD pp11_24 XI1477_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1477_MP28 (cm116_2 XI1477_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1477_MP19 (XI1477_ap3 pp11_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1477_MP20 (VDD pp12_22 XI1477_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1486_MP50 (VDD XI1486_s1 XI1486_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1486_MP47 (XI1486_bp3 pp12_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1486_MP49 (XI1486_bsn XI1486_bcon XI1486_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1486_MP52 (XI1486_bp5 cm123_2 XI1486_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1486_MP51 (XI1486_bp4 pp12_27 XI1486_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1486_MP51_1 (XI1486_bp5 pp12_27 XI1486_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1486_MP52_1 (XI1486_bsn cm123_2 XI1486_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1486_MP54 (VDD XI1486_bsn cm125_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1486_MP41 (XI1486_bp1 XI1486_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1486_MP42 (XI1486_bcon pp12_27 XI1486_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1486_MP45 (XI1486_bp2 cm123_2 XI1486_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1486_MP43 (VDD XI1486_s1 XI1486_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1486_MP44 (XI1486_bp2 pp12_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1486_MP56 (VDD XI1486_bcon cm125_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1486_MP46 (XI1486_bp3 XI1486_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1486_MP48 (VDD cm123_2 XI1486_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1486_MP50_1 (XI1486_bp4 XI1486_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1486_MP26 (VDD XI1486_asn XI1486_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1486_MP18 (XI1486_ap3 sn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1486_MP21 (XI1486_asn XI1486_acon XI1486_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1486_MP24 (XI1486_ap5 pp11_29 XI1486_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1486_MP23 (XI1486_ap4 pp10_31 XI1486_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1486_MP22 (VDD sn9 XI1486_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1486_MP22_1 (XI1486_ap4 sn9 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1486_MP23_1 (XI1486_ap5 pp10_31 XI1486_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1486_MP24_1 (XI1486_asn pp11_29 XI1486_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1486_MP17 (XI1486_acon pp11_29 XI1486_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1486_MP14 (XI1486_ap1 pp10_31 XI1486_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1486_MP13 (VDD sn9 XI1486_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1486_MP15 (XI1486_ap2 sn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1486_MP16 (VDD pp10_31 XI1486_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1486_MP28 (cm125_2 XI1486_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1486_MP19 (XI1486_ap3 pp10_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1486_MP20 (VDD pp11_29 XI1486_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1562_MP50 (VDD XI1562_s1 XI1562_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1562_MP47 (XI1562_bp3 fa126_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1562_MP49 (XI1562_bsn XI1562_bcon XI1562_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1562_MP52 (XI1562_bp5 cm200_2 XI1562_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1562_MP51 (XI1562_bp4 fa126_0 XI1562_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1562_MP51_1 (XI1562_bp5 fa126_0 XI1562_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1562_MP52_1 (XI1562_bsn cm200_2 XI1562_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1562_MP54 (VDD XI1562_bsn cm201_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1562_MP41 (XI1562_bp1 XI1562_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1562_MP42 (XI1562_bcon fa126_0 XI1562_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1562_MP45 (XI1562_bp2 cm200_2 XI1562_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1562_MP43 (VDD XI1562_s1 XI1562_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1562_MP44 (XI1562_bp2 fa126_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1562_MP56 (VDD XI1562_bcon cm201_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1562_MP46 (XI1562_bp3 XI1562_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1562_MP48 (VDD cm200_2 XI1562_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1562_MP50_1 (XI1562_bp4 XI1562_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1562_MP26 (VDD XI1562_asn XI1562_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1562_MP18 (XI1562_ap3 cm123_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1562_MP21 (XI1562_asn XI1562_acon XI1562_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1562_MP24 (XI1562_ap5 cm125_0 XI1562_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1562_MP23 (XI1562_ap4 cm124_1 XI1562_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1562_MP22 (VDD cm123_1 XI1562_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1562_MP22_1 (XI1562_ap4 cm123_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1562_MP23_1 (XI1562_ap5 cm124_1 XI1562_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1562_MP24_1 (XI1562_asn cm125_0 XI1562_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1562_MP17 (XI1562_acon cm125_0 XI1562_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1562_MP14 (XI1562_ap1 cm124_1 XI1562_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1562_MP13 (VDD cm123_1 XI1562_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1562_MP15 (XI1562_ap2 cm123_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1562_MP16 (VDD cm124_1 XI1562_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1562_MP28 (cm201_2 XI1562_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1562_MP19 (XI1562_ap3 cm124_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1562_MP20 (VDD cm125_0 XI1562_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1456_MP50 (VDD XI1456_s1 XI1456_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1456_MP47 (XI1456_bp3 pp6_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1456_MP49 (XI1456_bsn XI1456_bcon XI1456_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1456_MP52 (XI1456_bp5 cm92_2 XI1456_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1456_MP51 (XI1456_bp4 pp6_27 XI1456_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1456_MP51_1 (XI1456_bp5 pp6_27 XI1456_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1456_MP52_1 (XI1456_bsn cm92_2 XI1456_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1456_MP54 (VDD XI1456_bsn cm95_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1456_MP41 (XI1456_bp1 XI1456_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1456_MP42 (XI1456_bcon pp6_27 XI1456_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1456_MP45 (XI1456_bp2 cm92_2 XI1456_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1456_MP43 (VDD XI1456_s1 XI1456_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1456_MP44 (XI1456_bp2 pp6_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1456_MP56 (VDD XI1456_bcon cm95_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1456_MP46 (XI1456_bp3 XI1456_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1456_MP48 (VDD cm92_2 XI1456_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1456_MP50_1 (XI1456_bp4 XI1456_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1456_MP26 (VDD XI1456_asn XI1456_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1456_MP18 (XI1456_ap3 sn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1456_MP21 (XI1456_asn XI1456_acon XI1456_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1456_MP24 (XI1456_ap5 pp5_29 XI1456_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1456_MP23 (XI1456_ap4 pp4_31 XI1456_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1456_MP22 (VDD sn3 XI1456_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1456_MP22_1 (XI1456_ap4 sn3 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1456_MP23_1 (XI1456_ap5 pp4_31 XI1456_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1456_MP24_1 (XI1456_asn pp5_29 XI1456_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1456_MP17 (XI1456_acon pp5_29 XI1456_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1456_MP14 (XI1456_ap1 pp4_31 XI1456_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1456_MP13 (VDD sn3 XI1456_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1456_MP15 (XI1456_ap2 sn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1456_MP16 (VDD pp4_31 XI1456_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1456_MP28 (cm95_2 XI1456_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1456_MP19 (XI1456_ap3 pp4_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1456_MP20 (VDD pp5_29 XI1456_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1544_MP50 (VDD XI1544_s1 XI1544_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1544_MP47 (XI1544_bp3 cm92_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1544_MP49 (XI1544_bsn XI1544_bcon XI1544_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1544_MP52 (XI1544_bp5 cm181_2 XI1544_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1544_MP51 (XI1544_bp4 cm92_0 XI1544_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1544_MP51_1 (XI1544_bp5 cm92_0 XI1544_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1544_MP52_1 (XI1544_bsn cm181_2 XI1544_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1544_MP54 (VDD XI1544_bsn cm183_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1544_MP41 (XI1544_bp1 XI1544_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1544_MP42 (XI1544_bcon cm92_0 XI1544_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1544_MP45 (XI1544_bp2 cm181_2 XI1544_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1544_MP43 (VDD XI1544_s1 XI1544_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1544_MP44 (XI1544_bp2 cm92_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1544_MP56 (VDD XI1544_bcon cm183_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1544_MP46 (XI1544_bp3 XI1544_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1544_MP48 (VDD cm181_2 XI1544_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1544_MP50_1 (XI1544_bp4 XI1544_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1544_MP26 (VDD XI1544_asn XI1544_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1544_MP18 (XI1544_ap3 cm89_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1544_MP21 (XI1544_asn XI1544_acon XI1544_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1544_MP24 (XI1544_ap5 cm91_1 XI1544_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1544_MP23 (XI1544_ap4 cm90_1 XI1544_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1544_MP22 (VDD cm89_1 XI1544_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1544_MP22_1 (XI1544_ap4 cm89_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1544_MP23_1 (XI1544_ap5 cm90_1 XI1544_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1544_MP24_1 (XI1544_asn cm91_1 XI1544_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1544_MP17 (XI1544_acon cm91_1 XI1544_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1544_MP14 (XI1544_ap1 cm90_1 XI1544_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1544_MP13 (VDD cm89_1 XI1544_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1544_MP15 (XI1544_ap2 cm89_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1544_MP16 (VDD cm90_1 XI1544_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1544_MP28 (cm183_2 XI1544_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1544_MP19 (XI1544_ap3 cm90_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1544_MP20 (VDD cm91_1 XI1544_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1546_MP50 (VDD XI1546_s1 XI1546_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1546_MP47 (XI1546_bp3 cm95_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1546_MP49 (XI1546_bsn XI1546_bcon XI1546_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1546_MP52 (XI1546_bp5 cm183_2 XI1546_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1546_MP51 (XI1546_bp4 cm95_0 XI1546_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1546_MP51_1 (XI1546_bp5 cm95_0 XI1546_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1546_MP52_1 (XI1546_bsn cm183_2 XI1546_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1546_MP54 (VDD XI1546_bsn cm185_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1546_MP41 (XI1546_bp1 XI1546_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1546_MP42 (XI1546_bcon cm95_0 XI1546_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1546_MP45 (XI1546_bp2 cm183_2 XI1546_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1546_MP43 (VDD XI1546_s1 XI1546_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1546_MP44 (XI1546_bp2 cm95_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1546_MP56 (VDD XI1546_bcon cm185_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1546_MP46 (XI1546_bp3 XI1546_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1546_MP48 (VDD cm183_2 XI1546_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1546_MP50_1 (XI1546_bp4 XI1546_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1546_MP26 (VDD XI1546_asn XI1546_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1546_MP18 (XI1546_ap3 cm92_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1546_MP21 (XI1546_asn XI1546_acon XI1546_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1546_MP24 (XI1546_ap5 cm94_1 XI1546_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1546_MP23 (XI1546_ap4 cm93_1 XI1546_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1546_MP22 (VDD cm92_1 XI1546_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1546_MP22_1 (XI1546_ap4 cm92_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1546_MP23_1 (XI1546_ap5 cm93_1 XI1546_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1546_MP24_1 (XI1546_asn cm94_1 XI1546_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1546_MP17 (XI1546_acon cm94_1 XI1546_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1546_MP14 (XI1546_ap1 cm93_1 XI1546_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1546_MP13 (VDD cm92_1 XI1546_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1546_MP15 (XI1546_ap2 cm92_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1546_MP16 (VDD cm93_1 XI1546_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1546_MP28 (cm185_2 XI1546_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1546_MP19 (XI1546_ap3 cm93_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1546_MP20 (VDD cm94_1 XI1546_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1595_MP50 (VDD XI1595_s1 XI1595_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1595_MP47 (XI1595_bp3 fa188_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1595_MP49 (XI1595_bsn XI1595_bcon XI1595_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1595_MP52 (XI1595_bp5 cm233_2 XI1595_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1595_MP51 (XI1595_bp4 fa188_0 XI1595_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1595_MP51_1 (XI1595_bp5 fa188_0 XI1595_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1595_MP52_1 (XI1595_bsn cm233_2 XI1595_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1595_MP54 (VDD XI1595_bsn cm234_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1595_MP41 (XI1595_bp1 XI1595_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1595_MP42 (XI1595_bcon fa188_0 XI1595_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1595_MP45 (XI1595_bp2 cm233_2 XI1595_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1595_MP43 (VDD XI1595_s1 XI1595_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1595_MP44 (XI1595_bp2 fa188_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1595_MP56 (VDD XI1595_bcon cm234_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1595_MP46 (XI1595_bp3 XI1595_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1595_MP48 (VDD cm233_2 XI1595_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1595_MP50_1 (XI1595_bp4 XI1595_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1595_MP26 (VDD XI1595_asn XI1595_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1595_MP18 (XI1595_ap3 cm185_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1595_MP21 (XI1595_asn XI1595_acon XI1595_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1595_MP24 (XI1595_ap5 cm187_0 XI1595_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1595_MP23 (XI1595_ap4 fa186_1 XI1595_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1595_MP22 (VDD cm185_1 XI1595_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1595_MP22_1 (XI1595_ap4 cm185_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1595_MP23_1 (XI1595_ap5 fa186_1 XI1595_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1595_MP24_1 (XI1595_asn cm187_0 XI1595_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1595_MP17 (XI1595_acon cm187_0 XI1595_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1595_MP14 (XI1595_ap1 fa186_1 XI1595_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1595_MP13 (VDD cm185_1 XI1595_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1595_MP15 (XI1595_ap2 cm185_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1595_MP16 (VDD fa186_1 XI1595_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1595_MP28 (cm234_2 XI1595_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1595_MP19 (XI1595_ap3 fa186_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1595_MP20 (VDD cm187_0 XI1595_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1552_MP50 (VDD XI1552_s1 XI1552_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1552_MP47 (XI1552_bp3 cm107_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1552_MP49 (XI1552_bsn XI1552_bcon XI1552_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1552_MP52 (XI1552_bp5 cm190_2 XI1552_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1552_MP51 (XI1552_bp4 cm107_0 XI1552_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1552_MP51_1 (XI1552_bp5 cm107_0 XI1552_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1552_MP52_1 (XI1552_bsn cm190_2 XI1552_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1552_MP54 (VDD XI1552_bsn cm191_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1552_MP41 (XI1552_bp1 XI1552_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1552_MP42 (XI1552_bcon cm107_0 XI1552_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1552_MP45 (XI1552_bp2 cm190_2 XI1552_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1552_MP43 (VDD XI1552_s1 XI1552_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1552_MP44 (XI1552_bp2 cm107_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1552_MP56 (VDD XI1552_bcon cm191_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1552_MP46 (XI1552_bp3 XI1552_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1552_MP48 (VDD cm190_2 XI1552_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1552_MP50_1 (XI1552_bp4 XI1552_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1552_MP26 (VDD XI1552_asn XI1552_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1552_MP18 (XI1552_ap3 cm104_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1552_MP21 (XI1552_asn XI1552_acon XI1552_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1552_MP24 (XI1552_ap5 cm106_1 XI1552_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1552_MP23 (XI1552_ap4 cm105_1 XI1552_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1552_MP22 (VDD cm104_1 XI1552_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1552_MP22_1 (XI1552_ap4 cm104_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1552_MP23_1 (XI1552_ap5 cm105_1 XI1552_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1552_MP24_1 (XI1552_asn cm106_1 XI1552_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1552_MP17 (XI1552_acon cm106_1 XI1552_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1552_MP14 (XI1552_ap1 cm105_1 XI1552_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1552_MP13 (VDD cm104_1 XI1552_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1552_MP15 (XI1552_ap2 cm104_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1552_MP16 (VDD cm105_1 XI1552_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1552_MP28 (cm191_2 XI1552_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1552_MP19 (XI1552_ap3 cm105_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1552_MP20 (VDD cm106_1 XI1552_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1551_MP50 (VDD XI1551_s1 XI1551_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1551_MP47 (XI1551_bp3 cm104_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1551_MP49 (XI1551_bsn XI1551_bcon XI1551_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1551_MP52 (XI1551_bp5 cm189_2 XI1551_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1551_MP51 (XI1551_bp4 cm104_0 XI1551_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1551_MP51_1 (XI1551_bp5 cm104_0 XI1551_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1551_MP52_1 (XI1551_bsn cm189_2 XI1551_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1551_MP54 (VDD XI1551_bsn cm190_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1551_MP41 (XI1551_bp1 XI1551_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1551_MP42 (XI1551_bcon cm104_0 XI1551_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1551_MP45 (XI1551_bp2 cm189_2 XI1551_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1551_MP43 (VDD XI1551_s1 XI1551_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1551_MP44 (XI1551_bp2 cm104_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1551_MP56 (VDD XI1551_bcon cm190_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1551_MP46 (XI1551_bp3 XI1551_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1551_MP48 (VDD cm189_2 XI1551_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1551_MP50_1 (XI1551_bp4 XI1551_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1551_MP26 (VDD XI1551_asn XI1551_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1551_MP18 (XI1551_ap3 cm101_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1551_MP21 (XI1551_asn XI1551_acon XI1551_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1551_MP24 (XI1551_ap5 cm103_1 XI1551_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1551_MP23 (XI1551_ap4 cm102_1 XI1551_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1551_MP22 (VDD cm101_1 XI1551_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1551_MP22_1 (XI1551_ap4 cm101_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1551_MP23_1 (XI1551_ap5 cm102_1 XI1551_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1551_MP24_1 (XI1551_asn cm103_1 XI1551_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1551_MP17 (XI1551_acon cm103_1 XI1551_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1551_MP14 (XI1551_ap1 cm102_1 XI1551_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1551_MP13 (VDD cm101_1 XI1551_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1551_MP15 (XI1551_ap2 cm101_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1551_MP16 (VDD cm102_1 XI1551_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1551_MP28 (cm190_2 XI1551_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1551_MP19 (XI1551_ap3 cm102_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1551_MP20 (VDD cm103_1 XI1551_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1554_MP50 (VDD XI1554_s1 XI1554_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1554_MP47 (XI1554_bp3 cm110_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1554_MP49 (XI1554_bsn XI1554_bcon XI1554_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1554_MP52 (XI1554_bp5 cm191_2 XI1554_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1554_MP51 (XI1554_bp4 cm110_0 XI1554_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1554_MP51_1 (XI1554_bp5 cm110_0 XI1554_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1554_MP52_1 (XI1554_bsn cm191_2 XI1554_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1554_MP54 (VDD XI1554_bsn cm193_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1554_MP41 (XI1554_bp1 XI1554_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1554_MP42 (XI1554_bcon cm110_0 XI1554_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1554_MP45 (XI1554_bp2 cm191_2 XI1554_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1554_MP43 (VDD XI1554_s1 XI1554_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1554_MP44 (XI1554_bp2 cm110_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1554_MP56 (VDD XI1554_bcon cm193_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1554_MP46 (XI1554_bp3 XI1554_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1554_MP48 (VDD cm191_2 XI1554_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1554_MP50_1 (XI1554_bp4 XI1554_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1554_MP26 (VDD XI1554_asn XI1554_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1554_MP18 (XI1554_ap3 cm107_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1554_MP21 (XI1554_asn XI1554_acon XI1554_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1554_MP24 (XI1554_ap5 fa109_1 XI1554_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1554_MP23 (XI1554_ap4 cm108_1 XI1554_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1554_MP22 (VDD cm107_1 XI1554_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1554_MP22_1 (XI1554_ap4 cm107_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1554_MP23_1 (XI1554_ap5 cm108_1 XI1554_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1554_MP24_1 (XI1554_asn fa109_1 XI1554_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1554_MP17 (XI1554_acon fa109_1 XI1554_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1554_MP14 (XI1554_ap1 cm108_1 XI1554_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1554_MP13 (VDD cm107_1 XI1554_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1554_MP15 (XI1554_ap2 cm107_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1554_MP16 (VDD cm108_1 XI1554_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1554_MP28 (cm193_2 XI1554_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1554_MP19 (XI1554_ap3 cm108_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1554_MP20 (VDD fa109_1 XI1554_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1485_MP50 (VDD XI1485_s1 XI1485_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1485_MP47 (XI1485_bp3 pp15_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1485_MP49 (XI1485_bsn XI1485_bcon XI1485_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1485_MP52 (XI1485_bp5 cm122_2 XI1485_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1485_MP51 (XI1485_bp4 pp15_20 XI1485_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1485_MP51_1 (XI1485_bp5 pp15_20 XI1485_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1485_MP52_1 (XI1485_bsn cm122_2 XI1485_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1485_MP54 (VDD XI1485_bsn cm124_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1485_MP41 (XI1485_bp1 XI1485_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1485_MP42 (XI1485_bcon pp15_20 XI1485_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1485_MP45 (XI1485_bp2 cm122_2 XI1485_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1485_MP43 (VDD XI1485_s1 XI1485_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1485_MP44 (XI1485_bp2 pp15_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1485_MP56 (VDD XI1485_bcon cm124_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1485_MP46 (XI1485_bp3 XI1485_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1485_MP48 (VDD cm122_2 XI1485_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1485_MP50_1 (XI1485_bp4 XI1485_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1485_MP26 (VDD XI1485_asn XI1485_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1485_MP18 (XI1485_ap3 pp12_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1485_MP21 (XI1485_asn XI1485_acon XI1485_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1485_MP24 (XI1485_ap5 pp14_22 XI1485_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1485_MP23 (XI1485_ap4 pp13_24 XI1485_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1485_MP22 (VDD pp12_26 XI1485_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1485_MP22_1 (XI1485_ap4 pp12_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1485_MP23_1 (XI1485_ap5 pp13_24 XI1485_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1485_MP24_1 (XI1485_asn pp14_22 XI1485_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1485_MP17 (XI1485_acon pp14_22 XI1485_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1485_MP14 (XI1485_ap1 pp13_24 XI1485_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1485_MP13 (VDD pp12_26 XI1485_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1485_MP15 (XI1485_ap2 pp12_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1485_MP16 (VDD pp13_24 XI1485_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1485_MP28 (cm124_2 XI1485_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1485_MP19 (XI1485_ap3 pp13_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1485_MP20 (VDD pp14_22 XI1485_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1453_MP50 (VDD XI1453_s1 XI1453_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1453_MP47 (XI1453_bp3 pp5_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1453_MP49 (XI1453_bsn XI1453_bcon XI1453_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1453_MP52 (XI1453_bp5 cm89_2 XI1453_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1453_MP51 (XI1453_bp4 pp5_28 XI1453_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1453_MP51_1 (XI1453_bp5 pp5_28 XI1453_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1453_MP52_1 (XI1453_bsn cm89_2 XI1453_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1453_MP54 (VDD XI1453_bsn cm92_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1453_MP41 (XI1453_bp1 XI1453_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1453_MP42 (XI1453_bcon pp5_28 XI1453_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1453_MP45 (XI1453_bp2 cm89_2 XI1453_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1453_MP43 (VDD XI1453_s1 XI1453_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1453_MP44 (XI1453_bp2 pp5_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1453_MP56 (VDD XI1453_bcon cm92_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1453_MP46 (XI1453_bp3 XI1453_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1453_MP48 (VDD cm89_2 XI1453_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1453_MP50_1 (XI1453_bp4 XI1453_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1453_MP26 (VDD XI1453_asn XI1453_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1453_MP18 (XI1453_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1453_MP21 (XI1453_asn XI1453_acon XI1453_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1453_MP24 (XI1453_ap5 pp4_30 XI1453_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1453_MP23 (XI1453_ap4 pp3_32 XI1453_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1453_MP22 (VDD VDD XI1453_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1453_MP22_1 (XI1453_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1453_MP23_1 (XI1453_ap5 pp3_32 XI1453_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1453_MP24_1 (XI1453_asn pp4_30 XI1453_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1453_MP17 (XI1453_acon pp4_30 XI1453_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1453_MP14 (XI1453_ap1 pp3_32 XI1453_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1453_MP13 (VDD VDD XI1453_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1453_MP15 (XI1453_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1453_MP16 (VDD pp3_32 XI1453_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1453_MP28 (cm92_2 XI1453_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1453_MP19 (XI1453_ap3 pp3_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1453_MP20 (VDD pp4_30 XI1453_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1594_MP50 (VDD XI1594_s1 XI1594_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1594_MP47 (XI1594_bp3 fa186_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1594_MP49 (XI1594_bsn XI1594_bcon XI1594_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1594_MP52 (XI1594_bp5 cm232_2 XI1594_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1594_MP51 (XI1594_bp4 fa186_0 XI1594_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1594_MP51_1 (XI1594_bp5 fa186_0 XI1594_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1594_MP52_1 (XI1594_bsn cm232_2 XI1594_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1594_MP54 (VDD XI1594_bsn cm233_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1594_MP41 (XI1594_bp1 XI1594_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1594_MP42 (XI1594_bcon fa186_0 XI1594_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1594_MP45 (XI1594_bp2 cm232_2 XI1594_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1594_MP43 (VDD XI1594_s1 XI1594_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1594_MP44 (XI1594_bp2 fa186_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1594_MP56 (VDD XI1594_bcon cm233_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1594_MP46 (XI1594_bp3 XI1594_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1594_MP48 (VDD cm232_2 XI1594_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1594_MP50_1 (XI1594_bp4 XI1594_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1594_MP26 (VDD XI1594_asn XI1594_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1594_MP18 (XI1594_ap3 cm183_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1594_MP21 (XI1594_asn XI1594_acon XI1594_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1594_MP24 (XI1594_ap5 cm185_0 XI1594_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1594_MP23 (XI1594_ap4 cm184_1 XI1594_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1594_MP22 (VDD cm183_1 XI1594_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1594_MP22_1 (XI1594_ap4 cm183_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1594_MP23_1 (XI1594_ap5 cm184_1 XI1594_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1594_MP24_1 (XI1594_asn cm185_0 XI1594_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1594_MP17 (XI1594_acon cm185_0 XI1594_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1594_MP14 (XI1594_ap1 cm184_1 XI1594_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1594_MP13 (VDD cm183_1 XI1594_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1594_MP15 (XI1594_ap2 cm183_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1594_MP16 (VDD cm184_1 XI1594_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1594_MP28 (cm233_2 XI1594_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1594_MP19 (XI1594_ap3 cm184_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1594_MP20 (VDD cm185_0 XI1594_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1548_MP50 (VDD XI1548_s1 XI1548_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1548_MP47 (XI1548_bp3 cm98_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1548_MP49 (XI1548_bsn XI1548_bcon XI1548_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1548_MP52 (XI1548_bp5 cm185_2 XI1548_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1548_MP51 (XI1548_bp4 cm98_0 XI1548_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1548_MP51_1 (XI1548_bp5 cm98_0 XI1548_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1548_MP52_1 (XI1548_bsn cm185_2 XI1548_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1548_MP54 (VDD XI1548_bsn cm187_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1548_MP41 (XI1548_bp1 XI1548_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1548_MP42 (XI1548_bcon cm98_0 XI1548_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1548_MP45 (XI1548_bp2 cm185_2 XI1548_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1548_MP43 (VDD XI1548_s1 XI1548_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1548_MP44 (XI1548_bp2 cm98_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1548_MP56 (VDD XI1548_bcon cm187_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1548_MP46 (XI1548_bp3 XI1548_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1548_MP48 (VDD cm185_2 XI1548_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1548_MP50_1 (XI1548_bp4 XI1548_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1548_MP26 (VDD XI1548_asn XI1548_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1548_MP18 (XI1548_ap3 cm95_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1548_MP21 (XI1548_asn XI1548_acon XI1548_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1548_MP24 (XI1548_ap5 cm97_1 XI1548_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1548_MP23 (XI1548_ap4 cm96_1 XI1548_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1548_MP22 (VDD cm95_1 XI1548_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1548_MP22_1 (XI1548_ap4 cm95_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1548_MP23_1 (XI1548_ap5 cm96_1 XI1548_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1548_MP24_1 (XI1548_asn cm97_1 XI1548_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1548_MP17 (XI1548_acon cm97_1 XI1548_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1548_MP14 (XI1548_ap1 cm96_1 XI1548_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1548_MP13 (VDD cm95_1 XI1548_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1548_MP15 (XI1548_ap2 cm95_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1548_MP16 (VDD cm96_1 XI1548_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1548_MP28 (cm187_2 XI1548_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1548_MP19 (XI1548_ap3 cm96_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1548_MP20 (VDD cm97_1 XI1548_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1545_MP50 (VDD XI1545_s1 XI1545_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1545_MP47 (XI1545_bp3 pp15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1545_MP49 (XI1545_bsn XI1545_bcon XI1545_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1545_MP52 (XI1545_bp5 cm182_2 XI1545_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1545_MP51 (XI1545_bp4 pp15_8 XI1545_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1545_MP51_1 (XI1545_bp5 pp15_8 XI1545_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1545_MP52_1 (XI1545_bsn cm182_2 XI1545_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1545_MP54 (VDD XI1545_bsn cm184_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1545_MP41 (XI1545_bp1 XI1545_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1545_MP42 (XI1545_bcon pp15_8 XI1545_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1545_MP45 (XI1545_bp2 cm182_2 XI1545_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1545_MP43 (VDD XI1545_s1 XI1545_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1545_MP44 (XI1545_bp2 pp15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1545_MP56 (VDD XI1545_bcon cm184_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1545_MP46 (XI1545_bp3 XI1545_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1545_MP48 (VDD cm182_2 XI1545_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1545_MP50_1 (XI1545_bp4 XI1545_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1545_MP26 (VDD XI1545_asn XI1545_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1545_MP18 (XI1545_ap3 cm93_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1545_MP21 (XI1545_asn XI1545_acon XI1545_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1545_MP24 (XI1545_ap5 pp14_10 XI1545_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1545_MP23 (XI1545_ap4 cm94_0 XI1545_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1545_MP22 (VDD cm93_0 XI1545_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1545_MP22_1 (XI1545_ap4 cm93_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1545_MP23_1 (XI1545_ap5 cm94_0 XI1545_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1545_MP24_1 (XI1545_asn pp14_10 XI1545_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1545_MP17 (XI1545_acon pp14_10 XI1545_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1545_MP14 (XI1545_ap1 cm94_0 XI1545_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1545_MP13 (VDD cm93_0 XI1545_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1545_MP15 (XI1545_ap2 cm93_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1545_MP16 (VDD cm94_0 XI1545_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1545_MP28 (cm184_2 XI1545_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1545_MP19 (XI1545_ap3 cm94_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1545_MP20 (VDD pp14_10 XI1545_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1596_MP50 (VDD XI1596_s1 XI1596_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1596_MP47 (XI1596_bp3 cm102_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1596_MP49 (XI1596_bsn XI1596_bcon XI1596_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1596_MP52 (XI1596_bp5 cm234_2 XI1596_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1596_MP51 (XI1596_bp4 cm102_0 XI1596_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1596_MP51_1 (XI1596_bp5 cm102_0 XI1596_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1596_MP52_1 (XI1596_bsn cm234_2 XI1596_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1596_MP54 (VDD XI1596_bsn cm235_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1596_MP41 (XI1596_bp1 XI1596_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1596_MP42 (XI1596_bcon cm102_0 XI1596_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1596_MP45 (XI1596_bp2 cm234_2 XI1596_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1596_MP43 (VDD XI1596_s1 XI1596_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1596_MP44 (XI1596_bp2 cm102_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1596_MP56 (VDD XI1596_bcon cm235_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1596_MP46 (XI1596_bp3 XI1596_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1596_MP48 (VDD cm234_2 XI1596_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1596_MP50_1 (XI1596_bp4 XI1596_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1596_MP26 (VDD XI1596_asn XI1596_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1596_MP18 (XI1596_ap3 cm187_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1596_MP21 (XI1596_asn XI1596_acon XI1596_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1596_MP24 (XI1596_ap5 cm189_0 XI1596_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1596_MP23 (XI1596_ap4 fa188_1 XI1596_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1596_MP22 (VDD cm187_1 XI1596_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1596_MP22_1 (XI1596_ap4 cm187_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1596_MP23_1 (XI1596_ap5 fa188_1 XI1596_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1596_MP24_1 (XI1596_asn cm189_0 XI1596_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1596_MP17 (XI1596_acon cm189_0 XI1596_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1596_MP14 (XI1596_ap1 fa188_1 XI1596_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1596_MP13 (VDD cm187_1 XI1596_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1596_MP15 (XI1596_ap2 cm187_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1596_MP16 (VDD fa188_1 XI1596_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1596_MP28 (cm235_2 XI1596_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1596_MP19 (XI1596_ap3 fa188_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1596_MP20 (VDD cm189_0 XI1596_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1597_MP50 (VDD XI1597_s1 XI1597_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1597_MP47 (XI1597_bp3 cm106_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1597_MP49 (XI1597_bsn XI1597_bcon XI1597_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1597_MP52 (XI1597_bp5 cm235_2 XI1597_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1597_MP51 (XI1597_bp4 cm106_0 XI1597_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1597_MP51_1 (XI1597_bp5 cm106_0 XI1597_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1597_MP52_1 (XI1597_bsn cm235_2 XI1597_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1597_MP54 (VDD XI1597_bsn cm236_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1597_MP41 (XI1597_bp1 XI1597_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1597_MP42 (XI1597_bcon cm106_0 XI1597_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1597_MP45 (XI1597_bp2 cm235_2 XI1597_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1597_MP43 (VDD XI1597_s1 XI1597_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1597_MP44 (XI1597_bp2 cm106_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1597_MP56 (VDD XI1597_bcon cm236_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1597_MP46 (XI1597_bp3 XI1597_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1597_MP48 (VDD cm235_2 XI1597_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1597_MP50_1 (XI1597_bp4 XI1597_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1597_MP26 (VDD XI1597_asn XI1597_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1597_MP18 (XI1597_ap3 cm189_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1597_MP21 (XI1597_asn XI1597_acon XI1597_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1597_MP24 (XI1597_ap5 cm105_0 XI1597_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1597_MP23 (XI1597_ap4 cm190_0 XI1597_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1597_MP22 (VDD cm189_1 XI1597_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1597_MP22_1 (XI1597_ap4 cm189_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1597_MP23_1 (XI1597_ap5 cm190_0 XI1597_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1597_MP24_1 (XI1597_asn cm105_0 XI1597_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1597_MP17 (XI1597_acon cm105_0 XI1597_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1597_MP14 (XI1597_ap1 cm190_0 XI1597_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1597_MP13 (VDD cm189_1 XI1597_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1597_MP15 (XI1597_ap2 cm189_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1597_MP16 (VDD cm190_0 XI1597_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1597_MP28 (cm236_2 XI1597_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1597_MP19 (XI1597_ap3 cm190_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1597_MP20 (VDD cm105_0 XI1597_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1563_MP50 (VDD XI1563_s1 XI1563_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1563_MP47 (XI1563_bp3 fa128_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1563_MP49 (XI1563_bsn XI1563_bcon XI1563_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1563_MP52 (XI1563_bp5 cm201_2 XI1563_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1563_MP51 (XI1563_bp4 fa128_0 XI1563_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1563_MP51_1 (XI1563_bp5 fa128_0 XI1563_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1563_MP52_1 (XI1563_bsn cm201_2 XI1563_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1563_MP54 (VDD XI1563_bsn cm202_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1563_MP41 (XI1563_bp1 XI1563_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1563_MP42 (XI1563_bcon fa128_0 XI1563_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1563_MP45 (XI1563_bp2 cm201_2 XI1563_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1563_MP43 (VDD XI1563_s1 XI1563_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1563_MP44 (XI1563_bp2 fa128_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1563_MP56 (VDD XI1563_bcon cm202_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1563_MP46 (XI1563_bp3 XI1563_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1563_MP48 (VDD cm201_2 XI1563_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1563_MP50_1 (XI1563_bp4 XI1563_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1563_MP26 (VDD XI1563_asn XI1563_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1563_MP18 (XI1563_ap3 cm125_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1563_MP21 (XI1563_asn XI1563_acon XI1563_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1563_MP24 (XI1563_ap5 cm127_0 XI1563_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1563_MP23 (XI1563_ap4 fa126_1 XI1563_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1563_MP22 (VDD cm125_1 XI1563_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1563_MP22_1 (XI1563_ap4 cm125_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1563_MP23_1 (XI1563_ap5 fa126_1 XI1563_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1563_MP24_1 (XI1563_asn cm127_0 XI1563_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1563_MP17 (XI1563_acon cm127_0 XI1563_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1563_MP14 (XI1563_ap1 fa126_1 XI1563_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1563_MP13 (VDD cm125_1 XI1563_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1563_MP15 (XI1563_ap2 cm125_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1563_MP16 (VDD fa126_1 XI1563_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1563_MP28 (cm202_2 XI1563_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1563_MP19 (XI1563_ap3 fa126_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1563_MP20 (VDD cm127_0 XI1563_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1450_MP50 (VDD XI1450_s1 XI1450_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1450_MP47 (XI1450_bp3 pp5_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1450_MP49 (XI1450_bsn XI1450_bcon XI1450_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1450_MP52 (XI1450_bp5 cm85_2 XI1450_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1450_MP51 (XI1450_bp4 pp5_27 XI1450_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1450_MP51_1 (XI1450_bp5 pp5_27 XI1450_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1450_MP52_1 (XI1450_bsn cm85_2 XI1450_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1450_MP54 (VDD XI1450_bsn cm89_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1450_MP41 (XI1450_bp1 XI1450_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1450_MP42 (XI1450_bcon pp5_27 XI1450_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1450_MP45 (XI1450_bp2 cm85_2 XI1450_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1450_MP43 (VDD XI1450_s1 XI1450_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1450_MP44 (XI1450_bp2 pp5_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1450_MP56 (VDD XI1450_bcon cm89_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1450_MP46 (XI1450_bp3 XI1450_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1450_MP48 (VDD cm85_2 XI1450_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1450_MP50_1 (XI1450_bp4 XI1450_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1450_MP26 (VDD XI1450_asn XI1450_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1450_MP18 (XI1450_ap3 sn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1450_MP21 (XI1450_asn XI1450_acon XI1450_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1450_MP24 (XI1450_ap5 pp4_29 XI1450_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1450_MP23 (XI1450_ap4 pp3_31 XI1450_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1450_MP22 (VDD sn2 XI1450_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1450_MP22_1 (XI1450_ap4 sn2 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1450_MP23_1 (XI1450_ap5 pp3_31 XI1450_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1450_MP24_1 (XI1450_asn pp4_29 XI1450_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1450_MP17 (XI1450_acon pp4_29 XI1450_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1450_MP14 (XI1450_ap1 pp3_31 XI1450_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1450_MP13 (VDD sn2 XI1450_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1450_MP15 (XI1450_ap2 sn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1450_MP16 (VDD pp3_31 XI1450_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1450_MP28 (cm89_2 XI1450_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1450_MP19 (XI1450_ap3 pp3_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1450_MP20 (VDD pp4_29 XI1450_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1593_MP50 (VDD XI1593_s1 XI1593_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1593_MP47 (XI1593_bp3 cm184_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1593_MP49 (XI1593_bsn XI1593_bcon XI1593_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1593_MP52 (XI1593_bp5 cm231_2 XI1593_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1593_MP51 (XI1593_bp4 cm184_0 XI1593_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1593_MP51_1 (XI1593_bp5 cm184_0 XI1593_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1593_MP52_1 (XI1593_bsn cm231_2 XI1593_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1593_MP54 (VDD XI1593_bsn cm232_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1593_MP41 (XI1593_bp1 XI1593_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1593_MP42 (XI1593_bcon cm184_0 XI1593_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1593_MP45 (XI1593_bp2 cm231_2 XI1593_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1593_MP43 (VDD XI1593_s1 XI1593_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1593_MP44 (XI1593_bp2 cm184_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1593_MP56 (VDD XI1593_bcon cm232_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1593_MP46 (XI1593_bp3 XI1593_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1593_MP48 (VDD cm231_2 XI1593_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1593_MP50_1 (XI1593_bp4 XI1593_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1593_MP26 (VDD XI1593_asn XI1593_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1593_MP18 (XI1593_ap3 cm181_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1593_MP21 (XI1593_asn XI1593_acon XI1593_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1593_MP24 (XI1593_ap5 cm183_0 XI1593_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1593_MP23 (XI1593_ap4 cm182_1 XI1593_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1593_MP22 (VDD cm181_1 XI1593_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1593_MP22_1 (XI1593_ap4 cm181_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1593_MP23_1 (XI1593_ap5 cm182_1 XI1593_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1593_MP24_1 (XI1593_asn cm183_0 XI1593_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1593_MP17 (XI1593_acon cm183_0 XI1593_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1593_MP14 (XI1593_ap1 cm182_1 XI1593_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1593_MP13 (VDD cm181_1 XI1593_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1593_MP15 (XI1593_ap2 cm181_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1593_MP16 (VDD cm182_1 XI1593_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1593_MP28 (cm232_2 XI1593_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1593_MP19 (XI1593_ap3 cm182_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1593_MP20 (VDD cm183_0 XI1593_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1543_MP50 (VDD XI1543_s1 XI1543_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1543_MP47 (XI1543_bp3 pp14_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1543_MP49 (XI1543_bsn XI1543_bcon XI1543_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1543_MP52 (XI1543_bp5 cm180_2 XI1543_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1543_MP51 (XI1543_bp4 pp14_9 XI1543_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1543_MP51_1 (XI1543_bp5 pp14_9 XI1543_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1543_MP52_1 (XI1543_bsn cm180_2 XI1543_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1543_MP54 (VDD XI1543_bsn cm182_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1543_MP41 (XI1543_bp1 XI1543_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1543_MP42 (XI1543_bcon pp14_9 XI1543_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1543_MP45 (XI1543_bp2 cm180_2 XI1543_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1543_MP43 (VDD XI1543_s1 XI1543_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1543_MP44 (XI1543_bp2 pp14_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1543_MP56 (VDD XI1543_bcon cm182_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1543_MP46 (XI1543_bp3 XI1543_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1543_MP48 (VDD cm180_2 XI1543_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1543_MP50_1 (XI1543_bp4 XI1543_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1543_MP26 (VDD XI1543_asn XI1543_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1543_MP18 (XI1543_ap3 cm89_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1543_MP21 (XI1543_asn XI1543_acon XI1543_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1543_MP24 (XI1543_ap5 cm91_0 XI1543_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1543_MP23 (XI1543_ap4 cm90_0 XI1543_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1543_MP22 (VDD cm89_0 XI1543_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1543_MP22_1 (XI1543_ap4 cm89_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1543_MP23_1 (XI1543_ap5 cm90_0 XI1543_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1543_MP24_1 (XI1543_asn cm91_0 XI1543_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1543_MP17 (XI1543_acon cm91_0 XI1543_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1543_MP14 (XI1543_ap1 cm90_0 XI1543_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1543_MP13 (VDD cm89_0 XI1543_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1543_MP15 (XI1543_ap2 cm89_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1543_MP16 (VDD cm90_0 XI1543_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1543_MP28 (cm182_2 XI1543_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1543_MP19 (XI1543_ap3 cm90_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1543_MP20 (VDD cm91_0 XI1543_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1452_MP50 (VDD XI1452_s1 XI1452_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1452_MP47 (XI1452_bp3 pp13_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1452_MP49 (XI1452_bsn XI1452_bcon XI1452_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1452_MP52 (XI1452_bp5 cm87_2 XI1452_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1452_MP51 (XI1452_bp4 pp13_11 XI1452_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1452_MP51_1 (XI1452_bp5 pp13_11 XI1452_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1452_MP52_1 (XI1452_bsn cm87_2 XI1452_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1452_MP54 (VDD XI1452_bsn cm91_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1452_MP41 (XI1452_bp1 XI1452_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1452_MP42 (XI1452_bcon pp13_11 XI1452_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1452_MP45 (XI1452_bp2 cm87_2 XI1452_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1452_MP43 (VDD XI1452_s1 XI1452_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1452_MP44 (XI1452_bp2 pp13_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1452_MP56 (VDD XI1452_bcon cm91_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1452_MP46 (XI1452_bp3 XI1452_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1452_MP48 (VDD cm87_2 XI1452_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1452_MP50_1 (XI1452_bp4 XI1452_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1452_MP26 (VDD XI1452_asn XI1452_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1452_MP18 (XI1452_ap3 pp10_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1452_MP21 (XI1452_asn XI1452_acon XI1452_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1452_MP24 (XI1452_ap5 pp12_13 XI1452_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1452_MP23 (XI1452_ap4 pp11_15 XI1452_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1452_MP22 (VDD pp10_17 XI1452_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1452_MP22_1 (XI1452_ap4 pp10_17 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1452_MP23_1 (XI1452_ap5 pp11_15 XI1452_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1452_MP24_1 (XI1452_asn pp12_13 XI1452_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1452_MP17 (XI1452_acon pp12_13 XI1452_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1452_MP14 (XI1452_ap1 pp11_15 XI1452_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1452_MP13 (VDD pp10_17 XI1452_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1452_MP15 (XI1452_ap2 pp10_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1452_MP16 (VDD pp11_15 XI1452_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1452_MP28 (cm91_2 XI1452_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1452_MP19 (XI1452_ap3 pp11_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1452_MP20 (VDD pp12_13 XI1452_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1455_MP50 (VDD XI1455_s1 XI1455_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1455_MP47 (XI1455_bp3 pp13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1455_MP49 (XI1455_bsn XI1455_bcon XI1455_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1455_MP52 (XI1455_bp5 cm91_2 XI1455_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1455_MP51 (XI1455_bp4 pp13_12 XI1455_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1455_MP51_1 (XI1455_bp5 pp13_12 XI1455_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1455_MP52_1 (XI1455_bsn cm91_2 XI1455_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1455_MP54 (VDD XI1455_bsn cm94_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1455_MP41 (XI1455_bp1 XI1455_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1455_MP42 (XI1455_bcon pp13_12 XI1455_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1455_MP45 (XI1455_bp2 cm91_2 XI1455_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1455_MP43 (VDD XI1455_s1 XI1455_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1455_MP44 (XI1455_bp2 pp13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1455_MP56 (VDD XI1455_bcon cm94_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1455_MP46 (XI1455_bp3 XI1455_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1455_MP48 (VDD cm91_2 XI1455_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1455_MP50_1 (XI1455_bp4 XI1455_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1455_MP26 (VDD XI1455_asn XI1455_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1455_MP18 (XI1455_ap3 pp10_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1455_MP21 (XI1455_asn XI1455_acon XI1455_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1455_MP24 (XI1455_ap5 pp12_14 XI1455_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1455_MP23 (XI1455_ap4 pp11_16 XI1455_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1455_MP22 (VDD pp10_18 XI1455_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1455_MP22_1 (XI1455_ap4 pp10_18 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1455_MP23_1 (XI1455_ap5 pp11_16 XI1455_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1455_MP24_1 (XI1455_asn pp12_14 XI1455_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1455_MP17 (XI1455_acon pp12_14 XI1455_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1455_MP14 (XI1455_ap1 pp11_16 XI1455_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1455_MP13 (VDD pp10_18 XI1455_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1455_MP15 (XI1455_ap2 pp10_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1455_MP16 (VDD pp11_16 XI1455_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1455_MP28 (cm94_2 XI1455_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1455_MP19 (XI1455_ap3 pp11_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1455_MP20 (VDD pp12_14 XI1455_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1461_MP50 (VDD XI1461_s1 XI1461_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1461_MP47 (XI1461_bp3 pp14_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1461_MP49 (XI1461_bsn XI1461_bcon XI1461_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1461_MP52 (XI1461_bp5 cm97_2 XI1461_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1461_MP51 (XI1461_bp4 pp14_12 XI1461_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1461_MP51_1 (XI1461_bp5 pp14_12 XI1461_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1461_MP52_1 (XI1461_bsn cm97_2 XI1461_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1461_MP54 (VDD XI1461_bsn cm100_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1461_MP41 (XI1461_bp1 XI1461_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1461_MP42 (XI1461_bcon pp14_12 XI1461_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1461_MP45 (XI1461_bp2 cm97_2 XI1461_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1461_MP43 (VDD XI1461_s1 XI1461_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1461_MP44 (XI1461_bp2 pp14_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1461_MP56 (VDD XI1461_bcon cm100_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1461_MP46 (XI1461_bp3 XI1461_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1461_MP48 (VDD cm97_2 XI1461_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1461_MP50_1 (XI1461_bp4 XI1461_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1461_MP26 (VDD XI1461_asn XI1461_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1461_MP18 (XI1461_ap3 pp11_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1461_MP21 (XI1461_asn XI1461_acon XI1461_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1461_MP24 (XI1461_ap5 pp13_14 XI1461_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1461_MP23 (XI1461_ap4 pp12_16 XI1461_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1461_MP22 (VDD pp11_18 XI1461_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1461_MP22_1 (XI1461_ap4 pp11_18 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1461_MP23_1 (XI1461_ap5 pp12_16 XI1461_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1461_MP24_1 (XI1461_asn pp13_14 XI1461_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1461_MP17 (XI1461_acon pp13_14 XI1461_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1461_MP14 (XI1461_ap1 pp12_16 XI1461_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1461_MP13 (VDD pp11_18 XI1461_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1461_MP15 (XI1461_ap2 pp11_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1461_MP16 (VDD pp12_16 XI1461_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1461_MP28 (cm100_2 XI1461_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1461_MP19 (XI1461_ap3 pp12_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1461_MP20 (VDD pp13_14 XI1461_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1464_MP50 (VDD XI1464_s1 XI1464_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1464_MP47 (XI1464_bp3 pp15_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1464_MP49 (XI1464_bsn XI1464_bcon XI1464_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1464_MP52 (XI1464_bp5 cm100_2 XI1464_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1464_MP51 (XI1464_bp4 pp15_11 XI1464_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1464_MP51_1 (XI1464_bp5 pp15_11 XI1464_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1464_MP52_1 (XI1464_bsn cm100_2 XI1464_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1464_MP54 (VDD XI1464_bsn cm103_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1464_MP41 (XI1464_bp1 XI1464_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1464_MP42 (XI1464_bcon pp15_11 XI1464_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1464_MP45 (XI1464_bp2 cm100_2 XI1464_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1464_MP43 (VDD XI1464_s1 XI1464_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1464_MP44 (XI1464_bp2 pp15_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1464_MP56 (VDD XI1464_bcon cm103_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1464_MP46 (XI1464_bp3 XI1464_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1464_MP48 (VDD cm100_2 XI1464_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1464_MP50_1 (XI1464_bp4 XI1464_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1464_MP26 (VDD XI1464_asn XI1464_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1464_MP18 (XI1464_ap3 pp12_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1464_MP21 (XI1464_asn XI1464_acon XI1464_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1464_MP24 (XI1464_ap5 pp14_13 XI1464_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1464_MP23 (XI1464_ap4 pp13_15 XI1464_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1464_MP22 (VDD pp12_17 XI1464_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1464_MP22_1 (XI1464_ap4 pp12_17 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1464_MP23_1 (XI1464_ap5 pp13_15 XI1464_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1464_MP24_1 (XI1464_asn pp14_13 XI1464_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1464_MP17 (XI1464_acon pp14_13 XI1464_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1464_MP14 (XI1464_ap1 pp13_15 XI1464_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1464_MP13 (VDD pp12_17 XI1464_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1464_MP15 (XI1464_ap2 pp12_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1464_MP16 (VDD pp13_15 XI1464_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1464_MP28 (cm103_2 XI1464_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1464_MP19 (XI1464_ap3 pp13_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1464_MP20 (VDD pp14_13 XI1464_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1446_MP50 (VDD XI1446_s1 XI1446_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1446_MP47 (XI1446_bp3 pp4_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1446_MP49 (XI1446_bsn XI1446_bcon XI1446_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1446_MP52 (XI1446_bp5 cm81_2 XI1446_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1446_MP51 (XI1446_bp4 pp4_28 XI1446_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1446_MP51_1 (XI1446_bp5 pp4_28 XI1446_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1446_MP52_1 (XI1446_bsn cm81_2 XI1446_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1446_MP54 (VDD XI1446_bsn cm85_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1446_MP41 (XI1446_bp1 XI1446_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1446_MP42 (XI1446_bcon pp4_28 XI1446_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1446_MP45 (XI1446_bp2 cm81_2 XI1446_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1446_MP43 (VDD XI1446_s1 XI1446_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1446_MP44 (XI1446_bp2 pp4_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1446_MP56 (VDD XI1446_bcon cm85_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1446_MP46 (XI1446_bp3 XI1446_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1446_MP48 (VDD cm81_2 XI1446_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1446_MP50_1 (XI1446_bp4 XI1446_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1446_MP26 (VDD XI1446_asn XI1446_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1446_MP18 (XI1446_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1446_MP21 (XI1446_asn XI1446_acon XI1446_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1446_MP24 (XI1446_ap5 pp3_30 XI1446_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1446_MP23 (XI1446_ap4 pp2_32 XI1446_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1446_MP22 (VDD VDD XI1446_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1446_MP22_1 (XI1446_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1446_MP23_1 (XI1446_ap5 pp2_32 XI1446_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1446_MP24_1 (XI1446_asn pp3_30 XI1446_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1446_MP17 (XI1446_acon pp3_30 XI1446_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1446_MP14 (XI1446_ap1 pp2_32 XI1446_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1446_MP13 (VDD VDD XI1446_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1446_MP15 (XI1446_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1446_MP16 (VDD pp2_32 XI1446_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1446_MP28 (cm85_2 XI1446_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1446_MP19 (XI1446_ap3 pp2_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1446_MP20 (VDD pp3_30 XI1446_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1542_MP50 (VDD XI1542_s1 XI1542_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1542_MP47 (XI1542_bp3 fa88_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1542_MP49 (XI1542_bsn XI1542_bcon XI1542_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1542_MP52 (XI1542_bp5 cm179_2 XI1542_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1542_MP51 (XI1542_bp4 fa88_1 XI1542_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1542_MP51_1 (XI1542_bp5 fa88_1 XI1542_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1542_MP52_1 (XI1542_bsn cm179_2 XI1542_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1542_MP54 (VDD XI1542_bsn cm181_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1542_MP41 (XI1542_bp1 XI1542_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1542_MP42 (XI1542_bcon fa88_1 XI1542_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1542_MP45 (XI1542_bp2 cm179_2 XI1542_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1542_MP43 (VDD XI1542_s1 XI1542_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1542_MP44 (XI1542_bp2 fa88_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1542_MP56 (VDD XI1542_bcon cm181_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1542_MP46 (XI1542_bp3 XI1542_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1542_MP48 (VDD cm179_2 XI1542_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1542_MP50_1 (XI1542_bp4 XI1542_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1542_MP26 (VDD XI1542_asn XI1542_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1542_MP18 (XI1542_ap3 cm85_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1542_MP21 (XI1542_asn XI1542_acon XI1542_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1542_MP24 (XI1542_ap5 cm87_1 XI1542_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1542_MP23 (XI1542_ap4 cm86_1 XI1542_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1542_MP22 (VDD cm85_1 XI1542_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1542_MP22_1 (XI1542_ap4 cm85_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1542_MP23_1 (XI1542_ap5 cm86_1 XI1542_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1542_MP24_1 (XI1542_asn cm87_1 XI1542_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1542_MP17 (XI1542_acon cm87_1 XI1542_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1542_MP14 (XI1542_ap1 cm86_1 XI1542_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1542_MP13 (VDD cm85_1 XI1542_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1542_MP15 (XI1542_ap2 cm85_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1542_MP16 (VDD cm86_1 XI1542_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1542_MP28 (cm181_2 XI1542_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1542_MP19 (XI1542_ap3 cm86_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1542_MP20 (VDD cm87_1 XI1542_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1592_MP50 (VDD XI1592_s1 XI1592_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1592_MP47 (XI1592_bp3 cm182_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1592_MP49 (XI1592_bsn XI1592_bcon XI1592_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1592_MP52 (XI1592_bp5 cm230_2 XI1592_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1592_MP51 (XI1592_bp4 cm182_0 XI1592_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1592_MP51_1 (XI1592_bp5 cm182_0 XI1592_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1592_MP52_1 (XI1592_bsn cm230_2 XI1592_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1592_MP54 (VDD XI1592_bsn cm231_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1592_MP41 (XI1592_bp1 XI1592_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1592_MP42 (XI1592_bcon cm182_0 XI1592_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1592_MP45 (XI1592_bp2 cm230_2 XI1592_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1592_MP43 (VDD XI1592_s1 XI1592_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1592_MP44 (XI1592_bp2 cm182_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1592_MP56 (VDD XI1592_bcon cm231_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1592_MP46 (XI1592_bp3 XI1592_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1592_MP48 (VDD cm230_2 XI1592_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1592_MP50_1 (XI1592_bp4 XI1592_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1592_MP26 (VDD XI1592_asn XI1592_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1592_MP18 (XI1592_ap3 cm179_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1592_MP21 (XI1592_asn XI1592_acon XI1592_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1592_MP24 (XI1592_ap5 cm181_0 XI1592_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1592_MP23 (XI1592_ap4 cm180_1 XI1592_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1592_MP22 (VDD cm179_1 XI1592_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1592_MP22_1 (XI1592_ap4 cm179_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1592_MP23_1 (XI1592_ap5 cm180_1 XI1592_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1592_MP24_1 (XI1592_asn cm181_0 XI1592_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1592_MP17 (XI1592_acon cm181_0 XI1592_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1592_MP14 (XI1592_ap1 cm180_1 XI1592_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1592_MP13 (VDD cm179_1 XI1592_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1592_MP15 (XI1592_ap2 cm179_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1592_MP16 (VDD cm180_1 XI1592_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1592_MP28 (cm231_2 XI1592_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1592_MP19 (XI1592_ap3 cm180_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1592_MP20 (VDD cm181_0 XI1592_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1458_MP50 (VDD XI1458_s1 XI1458_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1458_MP47 (XI1458_bp3 pp14_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1458_MP49 (XI1458_bsn XI1458_bcon XI1458_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1458_MP52 (XI1458_bp5 cm94_2 XI1458_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1458_MP51 (XI1458_bp4 pp14_11 XI1458_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1458_MP51_1 (XI1458_bp5 pp14_11 XI1458_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1458_MP52_1 (XI1458_bsn cm94_2 XI1458_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1458_MP54 (VDD XI1458_bsn cm97_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1458_MP41 (XI1458_bp1 XI1458_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1458_MP42 (XI1458_bcon pp14_11 XI1458_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1458_MP45 (XI1458_bp2 cm94_2 XI1458_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1458_MP43 (VDD XI1458_s1 XI1458_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1458_MP44 (XI1458_bp2 pp14_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1458_MP56 (VDD XI1458_bcon cm97_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1458_MP46 (XI1458_bp3 XI1458_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1458_MP48 (VDD cm94_2 XI1458_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1458_MP50_1 (XI1458_bp4 XI1458_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1458_MP26 (VDD XI1458_asn XI1458_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1458_MP18 (XI1458_ap3 pp11_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1458_MP21 (XI1458_asn XI1458_acon XI1458_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1458_MP24 (XI1458_ap5 pp13_13 XI1458_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1458_MP23 (XI1458_ap4 pp12_15 XI1458_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1458_MP22 (VDD pp11_17 XI1458_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1458_MP22_1 (XI1458_ap4 pp11_17 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1458_MP23_1 (XI1458_ap5 pp12_15 XI1458_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1458_MP24_1 (XI1458_asn pp13_13 XI1458_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1458_MP17 (XI1458_acon pp13_13 XI1458_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1458_MP14 (XI1458_ap1 pp12_15 XI1458_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1458_MP13 (VDD pp11_17 XI1458_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1458_MP15 (XI1458_ap2 pp11_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1458_MP16 (VDD pp12_15 XI1458_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1458_MP28 (cm97_2 XI1458_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1458_MP19 (XI1458_ap3 pp12_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1458_MP20 (VDD pp13_13 XI1458_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1467_MP50 (VDD XI1467_s1 XI1467_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1467_MP47 (XI1467_bp3 pp15_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1467_MP49 (XI1467_bsn XI1467_bcon XI1467_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1467_MP52 (XI1467_bp5 cm103_2 XI1467_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1467_MP51 (XI1467_bp4 pp15_12 XI1467_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1467_MP51_1 (XI1467_bp5 pp15_12 XI1467_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1467_MP52_1 (XI1467_bsn cm103_2 XI1467_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1467_MP54 (VDD XI1467_bsn cm106_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1467_MP41 (XI1467_bp1 XI1467_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1467_MP42 (XI1467_bcon pp15_12 XI1467_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1467_MP45 (XI1467_bp2 cm103_2 XI1467_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1467_MP43 (VDD XI1467_s1 XI1467_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1467_MP44 (XI1467_bp2 pp15_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1467_MP56 (VDD XI1467_bcon cm106_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1467_MP46 (XI1467_bp3 XI1467_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1467_MP48 (VDD cm103_2 XI1467_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1467_MP50_1 (XI1467_bp4 XI1467_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1467_MP26 (VDD XI1467_asn XI1467_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1467_MP18 (XI1467_ap3 pp12_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1467_MP21 (XI1467_asn XI1467_acon XI1467_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1467_MP24 (XI1467_ap5 pp14_14 XI1467_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1467_MP23 (XI1467_ap4 pp13_16 XI1467_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1467_MP22 (VDD pp12_18 XI1467_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1467_MP22_1 (XI1467_ap4 pp12_18 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1467_MP23_1 (XI1467_ap5 pp13_16 XI1467_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1467_MP24_1 (XI1467_asn pp14_14 XI1467_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1467_MP17 (XI1467_acon pp14_14 XI1467_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1467_MP14 (XI1467_ap1 pp13_16 XI1467_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1467_MP13 (VDD pp12_18 XI1467_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1467_MP15 (XI1467_ap2 pp12_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1467_MP16 (VDD pp13_16 XI1467_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1467_MP28 (cm106_2 XI1467_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1467_MP19 (XI1467_ap3 pp13_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1467_MP20 (VDD pp14_14 XI1467_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1488_MP50 (VDD XI1488_s1 XI1488_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1488_MP47 (XI1488_bp3 pp12_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1488_MP49 (XI1488_bsn XI1488_bcon XI1488_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1488_MP52 (XI1488_bp5 cm125_2 XI1488_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1488_MP51 (XI1488_bp4 pp12_28 XI1488_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1488_MP51_1 (XI1488_bp5 pp12_28 XI1488_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1488_MP52_1 (XI1488_bsn cm125_2 XI1488_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1488_MP54 (VDD XI1488_bsn cm127_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1488_MP41 (XI1488_bp1 XI1488_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1488_MP42 (XI1488_bcon pp12_28 XI1488_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1488_MP45 (XI1488_bp2 cm125_2 XI1488_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1488_MP43 (VDD XI1488_s1 XI1488_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1488_MP44 (XI1488_bp2 pp12_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1488_MP56 (VDD XI1488_bcon cm127_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1488_MP46 (XI1488_bp3 XI1488_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1488_MP48 (VDD cm125_2 XI1488_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1488_MP50_1 (XI1488_bp4 XI1488_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1488_MP26 (VDD XI1488_asn XI1488_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1488_MP18 (XI1488_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1488_MP21 (XI1488_asn XI1488_acon XI1488_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1488_MP24 (XI1488_ap5 pp11_30 XI1488_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1488_MP23 (XI1488_ap4 pp10_32 XI1488_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1488_MP22 (VDD VDD XI1488_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1488_MP22_1 (XI1488_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1488_MP23_1 (XI1488_ap5 pp10_32 XI1488_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1488_MP24_1 (XI1488_asn pp11_30 XI1488_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1488_MP17 (XI1488_acon pp11_30 XI1488_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1488_MP14 (XI1488_ap1 pp10_32 XI1488_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1488_MP13 (VDD VDD XI1488_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1488_MP15 (XI1488_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1488_MP16 (VDD pp10_32 XI1488_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1488_MP28 (cm127_2 XI1488_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1488_MP19 (XI1488_ap3 pp10_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1488_MP20 (VDD pp11_30 XI1488_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1564_MP50 (VDD XI1564_s1 XI1564_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1564_MP47 (XI1564_bp3 pp14_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1564_MP49 (XI1564_bsn XI1564_bcon XI1564_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1564_MP52 (XI1564_bp5 cm202_2 XI1564_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1564_MP51 (XI1564_bp4 pp14_25 XI1564_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1564_MP51_1 (XI1564_bp5 pp14_25 XI1564_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1564_MP52_1 (XI1564_bsn cm202_2 XI1564_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1564_MP54 (VDD XI1564_bsn cm203_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1564_MP41 (XI1564_bp1 XI1564_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1564_MP42 (XI1564_bcon pp14_25 XI1564_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1564_MP45 (XI1564_bp2 cm202_2 XI1564_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1564_MP43 (VDD XI1564_s1 XI1564_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1564_MP44 (XI1564_bp2 pp14_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1564_MP56 (VDD XI1564_bcon cm203_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1564_MP46 (XI1564_bp3 XI1564_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1564_MP48 (VDD cm202_2 XI1564_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1564_MP50_1 (XI1564_bp4 XI1564_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1564_MP26 (VDD XI1564_asn XI1564_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1564_MP18 (XI1564_ap3 cm127_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1564_MP21 (XI1564_asn XI1564_acon XI1564_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1564_MP24 (XI1564_ap5 cm129_0 XI1564_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1564_MP23 (XI1564_ap4 fa128_1 XI1564_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1564_MP22 (VDD cm127_1 XI1564_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1564_MP22_1 (XI1564_ap4 cm127_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1564_MP23_1 (XI1564_ap5 fa128_1 XI1564_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1564_MP24_1 (XI1564_asn cm129_0 XI1564_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1564_MP17 (XI1564_acon cm129_0 XI1564_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1564_MP14 (XI1564_ap1 fa128_1 XI1564_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1564_MP13 (VDD cm127_1 XI1564_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1564_MP15 (XI1564_ap2 cm127_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1564_MP16 (VDD fa128_1 XI1564_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1564_MP28 (cm203_2 XI1564_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1564_MP19 (XI1564_ap3 fa128_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1564_MP20 (VDD cm129_0 XI1564_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1443_MP50 (VDD XI1443_s1 XI1443_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1443_MP47 (XI1443_bp3 pp7_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1443_MP49 (XI1443_bsn XI1443_bcon XI1443_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1443_MP52 (XI1443_bp5 cm78_2 XI1443_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1443_MP51 (XI1443_bp4 pp7_21 XI1443_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1443_MP51_1 (XI1443_bp5 pp7_21 XI1443_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1443_MP52_1 (XI1443_bsn cm78_2 XI1443_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1443_MP54 (VDD XI1443_bsn cm82_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1443_MP41 (XI1443_bp1 XI1443_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1443_MP42 (XI1443_bcon pp7_21 XI1443_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1443_MP45 (XI1443_bp2 cm78_2 XI1443_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1443_MP43 (VDD XI1443_s1 XI1443_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1443_MP44 (XI1443_bp2 pp7_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1443_MP56 (VDD XI1443_bcon cm82_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1443_MP46 (XI1443_bp3 XI1443_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1443_MP48 (VDD cm78_2 XI1443_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1443_MP50_1 (XI1443_bp4 XI1443_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1443_MP26 (VDD XI1443_asn XI1443_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1443_MP18 (XI1443_ap3 pp4_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1443_MP21 (XI1443_asn XI1443_acon XI1443_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1443_MP24 (XI1443_ap5 pp6_23 XI1443_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1443_MP23 (XI1443_ap4 pp5_25 XI1443_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1443_MP22 (VDD pp4_27 XI1443_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1443_MP22_1 (XI1443_ap4 pp4_27 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1443_MP23_1 (XI1443_ap5 pp5_25 XI1443_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1443_MP24_1 (XI1443_asn pp6_23 XI1443_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1443_MP17 (XI1443_acon pp6_23 XI1443_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1443_MP14 (XI1443_ap1 pp5_25 XI1443_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1443_MP13 (VDD pp4_27 XI1443_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1443_MP15 (XI1443_ap2 pp4_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1443_MP16 (VDD pp5_25 XI1443_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1443_MP28 (cm82_2 XI1443_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1443_MP19 (XI1443_ap3 pp5_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1443_MP20 (VDD pp6_23 XI1443_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1442_MP50 (VDD XI1442_s1 XI1442_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1442_MP47 (XI1442_bp3 pp3_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1442_MP49 (XI1442_bsn XI1442_bcon XI1442_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1442_MP52 (XI1442_bp5 cm77_2 XI1442_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1442_MP51 (XI1442_bp4 pp3_29 XI1442_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1442_MP51_1 (XI1442_bp5 pp3_29 XI1442_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1442_MP52_1 (XI1442_bsn cm77_2 XI1442_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1442_MP54 (VDD XI1442_bsn cm81_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1442_MP41 (XI1442_bp1 XI1442_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1442_MP42 (XI1442_bcon pp3_29 XI1442_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1442_MP45 (XI1442_bp2 cm77_2 XI1442_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1442_MP43 (VDD XI1442_s1 XI1442_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1442_MP44 (XI1442_bp2 pp3_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1442_MP56 (VDD XI1442_bcon cm81_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1442_MP46 (XI1442_bp3 XI1442_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1442_MP48 (VDD cm77_2 XI1442_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1442_MP50_1 (XI1442_bp4 XI1442_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1442_MP26 (VDD XI1442_asn XI1442_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1442_MP18 (XI1442_ap3 sn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1442_MP21 (XI1442_asn XI1442_acon XI1442_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1442_MP24 (XI1442_ap5 pp2_31 XI1442_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1442_MP23 (XI1442_ap4 sn1 XI1442_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1442_MP22 (VDD sn0 XI1442_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1442_MP22_1 (XI1442_ap4 sn0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1442_MP23_1 (XI1442_ap5 sn1 XI1442_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1442_MP24_1 (XI1442_asn pp2_31 XI1442_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1442_MP17 (XI1442_acon pp2_31 XI1442_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1442_MP14 (XI1442_ap1 sn1 XI1442_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1442_MP13 (VDD sn0 XI1442_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1442_MP15 (XI1442_ap2 sn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1442_MP16 (VDD sn1 XI1442_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1442_MP28 (cm81_2 XI1442_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1442_MP19 (XI1442_ap3 sn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1442_MP20 (VDD pp2_31 XI1442_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1541_MP50 (VDD XI1541_s1 XI1541_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1541_MP47 (XI1541_bp3 fa88_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1541_MP49 (XI1541_bsn XI1541_bcon XI1541_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1541_MP52 (XI1541_bp5 cm178_2 XI1541_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1541_MP51 (XI1541_bp4 fa88_0 XI1541_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1541_MP51_1 (XI1541_bp5 fa88_0 XI1541_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1541_MP52_1 (XI1541_bsn cm178_2 XI1541_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1541_MP54 (VDD XI1541_bsn cm180_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1541_MP41 (XI1541_bp1 XI1541_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1541_MP42 (XI1541_bcon fa88_0 XI1541_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1541_MP45 (XI1541_bp2 cm178_2 XI1541_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1541_MP43 (VDD XI1541_s1 XI1541_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1541_MP44 (XI1541_bp2 fa88_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1541_MP56 (VDD XI1541_bcon cm180_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1541_MP46 (XI1541_bp3 XI1541_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1541_MP48 (VDD cm178_2 XI1541_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1541_MP50_1 (XI1541_bp4 XI1541_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1541_MP26 (VDD XI1541_asn XI1541_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1541_MP18 (XI1541_ap3 cm85_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1541_MP21 (XI1541_asn XI1541_acon XI1541_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1541_MP24 (XI1541_ap5 cm87_0 XI1541_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1541_MP23 (XI1541_ap4 cm86_0 XI1541_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1541_MP22 (VDD cm85_0 XI1541_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1541_MP22_1 (XI1541_ap4 cm85_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1541_MP23_1 (XI1541_ap5 cm86_0 XI1541_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1541_MP24_1 (XI1541_asn cm87_0 XI1541_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1541_MP17 (XI1541_acon cm87_0 XI1541_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1541_MP14 (XI1541_ap1 cm86_0 XI1541_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1541_MP13 (VDD cm85_0 XI1541_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1541_MP15 (XI1541_ap2 cm85_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1541_MP16 (VDD cm86_0 XI1541_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1541_MP28 (cm180_2 XI1541_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1541_MP19 (XI1541_ap3 cm86_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1541_MP20 (VDD cm87_0 XI1541_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1540_MP50 (VDD XI1540_s1 XI1540_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1540_MP47 (XI1540_bp3 cm84_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1540_MP49 (XI1540_bsn XI1540_bcon XI1540_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1540_MP52 (XI1540_bp5 cm177_2 XI1540_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1540_MP51 (XI1540_bp4 cm84_1 XI1540_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1540_MP51_1 (XI1540_bp5 cm84_1 XI1540_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1540_MP52_1 (XI1540_bsn cm177_2 XI1540_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1540_MP54 (VDD XI1540_bsn cm179_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1540_MP41 (XI1540_bp1 XI1540_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1540_MP42 (XI1540_bcon cm84_1 XI1540_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1540_MP45 (XI1540_bp2 cm177_2 XI1540_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1540_MP43 (VDD XI1540_s1 XI1540_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1540_MP44 (XI1540_bp2 cm84_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1540_MP56 (VDD XI1540_bcon cm179_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1540_MP46 (XI1540_bp3 XI1540_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1540_MP48 (VDD cm177_2 XI1540_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1540_MP50_1 (XI1540_bp4 XI1540_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1540_MP26 (VDD XI1540_asn XI1540_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1540_MP18 (XI1540_ap3 cm81_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1540_MP21 (XI1540_asn XI1540_acon XI1540_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1540_MP24 (XI1540_ap5 cm83_1 XI1540_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1540_MP23 (XI1540_ap4 cm82_1 XI1540_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1540_MP22 (VDD cm81_1 XI1540_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1540_MP22_1 (XI1540_ap4 cm81_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1540_MP23_1 (XI1540_ap5 cm82_1 XI1540_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1540_MP24_1 (XI1540_asn cm83_1 XI1540_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1540_MP17 (XI1540_acon cm83_1 XI1540_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1540_MP14 (XI1540_ap1 cm82_1 XI1540_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1540_MP13 (VDD cm81_1 XI1540_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1540_MP15 (XI1540_ap2 cm81_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1540_MP16 (VDD cm82_1 XI1540_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1540_MP28 (cm179_2 XI1540_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1540_MP19 (XI1540_ap3 cm82_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1540_MP20 (VDD cm83_1 XI1540_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1444_MP50 (VDD XI1444_s1 XI1444_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1444_MP47 (XI1444_bp3 pp11_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1444_MP49 (XI1444_bsn XI1444_bcon XI1444_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1444_MP52 (XI1444_bp5 cm79_2 XI1444_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1444_MP51 (XI1444_bp4 pp11_13 XI1444_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1444_MP51_1 (XI1444_bp5 pp11_13 XI1444_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1444_MP52_1 (XI1444_bsn cm79_2 XI1444_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1444_MP54 (VDD XI1444_bsn cm83_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1444_MP41 (XI1444_bp1 XI1444_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1444_MP42 (XI1444_bcon pp11_13 XI1444_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1444_MP45 (XI1444_bp2 cm79_2 XI1444_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1444_MP43 (VDD XI1444_s1 XI1444_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1444_MP44 (XI1444_bp2 pp11_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1444_MP56 (VDD XI1444_bcon cm83_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1444_MP46 (XI1444_bp3 XI1444_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1444_MP48 (VDD cm79_2 XI1444_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1444_MP50_1 (XI1444_bp4 XI1444_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1444_MP26 (VDD XI1444_asn XI1444_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1444_MP18 (XI1444_ap3 pp8_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1444_MP21 (XI1444_asn XI1444_acon XI1444_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1444_MP24 (XI1444_ap5 pp10_15 XI1444_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1444_MP23 (XI1444_ap4 pp9_17 XI1444_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1444_MP22 (VDD pp8_19 XI1444_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1444_MP22_1 (XI1444_ap4 pp8_19 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1444_MP23_1 (XI1444_ap5 pp9_17 XI1444_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1444_MP24_1 (XI1444_asn pp10_15 XI1444_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1444_MP17 (XI1444_acon pp10_15 XI1444_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1444_MP14 (XI1444_ap1 pp9_17 XI1444_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1444_MP13 (VDD pp8_19 XI1444_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1444_MP15 (XI1444_ap2 pp8_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1444_MP16 (VDD pp9_17 XI1444_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1444_MP28 (cm83_2 XI1444_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1444_MP19 (XI1444_ap3 pp9_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1444_MP20 (VDD pp10_15 XI1444_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1448_MP50 (VDD XI1448_s1 XI1448_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1448_MP47 (XI1448_bp3 pp12_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1448_MP49 (XI1448_bsn XI1448_bcon XI1448_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1448_MP52 (XI1448_bp5 cm83_2 XI1448_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1448_MP51 (XI1448_bp4 pp12_12 XI1448_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1448_MP51_1 (XI1448_bp5 pp12_12 XI1448_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1448_MP52_1 (XI1448_bsn cm83_2 XI1448_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1448_MP54 (VDD XI1448_bsn cm87_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1448_MP41 (XI1448_bp1 XI1448_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1448_MP42 (XI1448_bcon pp12_12 XI1448_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1448_MP45 (XI1448_bp2 cm83_2 XI1448_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1448_MP43 (VDD XI1448_s1 XI1448_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1448_MP44 (XI1448_bp2 pp12_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1448_MP56 (VDD XI1448_bcon cm87_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1448_MP46 (XI1448_bp3 XI1448_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1448_MP48 (VDD cm83_2 XI1448_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1448_MP50_1 (XI1448_bp4 XI1448_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1448_MP26 (VDD XI1448_asn XI1448_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1448_MP18 (XI1448_ap3 pp9_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1448_MP21 (XI1448_asn XI1448_acon XI1448_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1448_MP24 (XI1448_ap5 pp11_14 XI1448_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1448_MP23 (XI1448_ap4 pp10_16 XI1448_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1448_MP22 (VDD pp9_18 XI1448_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1448_MP22_1 (XI1448_ap4 pp9_18 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1448_MP23_1 (XI1448_ap5 pp10_16 XI1448_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1448_MP24_1 (XI1448_asn pp11_14 XI1448_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1448_MP17 (XI1448_acon pp11_14 XI1448_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1448_MP14 (XI1448_ap1 pp10_16 XI1448_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1448_MP13 (VDD pp9_18 XI1448_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1448_MP15 (XI1448_ap2 pp9_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1448_MP16 (VDD pp10_16 XI1448_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1448_MP28 (cm87_2 XI1448_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1448_MP19 (XI1448_ap3 pp10_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1448_MP20 (VDD pp11_14 XI1448_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1599_MP50 (VDD XI1599_s1 XI1599_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1599_MP47 (XI1599_bp3 cm111_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1599_MP49 (XI1599_bsn XI1599_bcon XI1599_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1599_MP52 (XI1599_bp5 fa112_0 XI1599_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1599_MP51 (XI1599_bp4 cm111_0 XI1599_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1599_MP51_1 (XI1599_bp5 cm111_0 XI1599_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1599_MP52_1 (XI1599_bsn fa112_0 XI1599_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1599_MP54 (VDD XI1599_bsn cm238_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1599_MP41 (XI1599_bp1 XI1599_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1599_MP42 (XI1599_bcon cm111_0 XI1599_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1599_MP45 (XI1599_bp2 fa112_0 XI1599_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1599_MP43 (VDD XI1599_s1 XI1599_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1599_MP44 (XI1599_bp2 cm111_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1599_MP56 (VDD XI1599_bcon cm238_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1599_MP46 (XI1599_bp3 XI1599_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1599_MP48 (VDD fa112_0 XI1599_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1599_MP50_1 (XI1599_bp4 XI1599_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1599_MP26 (VDD XI1599_asn XI1599_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1599_MP18 (XI1599_ap3 cm191_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1599_MP21 (XI1599_asn XI1599_acon XI1599_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1599_MP24 (XI1599_ap5 cm193_0 XI1599_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1599_MP23 (XI1599_ap4 fa192_1 XI1599_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1599_MP22 (VDD cm191_1 XI1599_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1599_MP22_1 (XI1599_ap4 cm191_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1599_MP23_1 (XI1599_ap5 fa192_1 XI1599_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1599_MP24_1 (XI1599_asn cm193_0 XI1599_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1599_MP17 (XI1599_acon cm193_0 XI1599_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1599_MP14 (XI1599_ap1 fa192_1 XI1599_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1599_MP13 (VDD cm191_1 XI1599_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1599_MP15 (XI1599_ap2 cm191_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1599_MP16 (VDD fa192_1 XI1599_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1599_MP28 (cm238_2 XI1599_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1599_MP19 (XI1599_ap3 fa192_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1599_MP20 (VDD cm193_0 XI1599_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1490_MP50 (VDD XI1490_s1 XI1490_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1490_MP47 (XI1490_bp3 pp13_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1490_MP49 (XI1490_bsn XI1490_bcon XI1490_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1490_MP52 (XI1490_bp5 cm127_2 XI1490_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1490_MP51 (XI1490_bp4 pp13_27 XI1490_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1490_MP51_1 (XI1490_bp5 pp13_27 XI1490_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1490_MP52_1 (XI1490_bsn cm127_2 XI1490_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1490_MP54 (VDD XI1490_bsn cm129_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1490_MP41 (XI1490_bp1 XI1490_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1490_MP42 (XI1490_bcon pp13_27 XI1490_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1490_MP45 (XI1490_bp2 cm127_2 XI1490_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1490_MP43 (VDD XI1490_s1 XI1490_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1490_MP44 (XI1490_bp2 pp13_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1490_MP56 (VDD XI1490_bcon cm129_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1490_MP46 (XI1490_bp3 XI1490_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1490_MP48 (VDD cm127_2 XI1490_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1490_MP50_1 (XI1490_bp4 XI1490_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1490_MP26 (VDD XI1490_asn XI1490_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1490_MP18 (XI1490_ap3 sn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1490_MP21 (XI1490_asn XI1490_acon XI1490_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1490_MP24 (XI1490_ap5 pp12_29 XI1490_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1490_MP23 (XI1490_ap4 pp11_31 XI1490_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1490_MP22 (VDD sn10 XI1490_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1490_MP22_1 (XI1490_ap4 sn10 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1490_MP23_1 (XI1490_ap5 pp11_31 XI1490_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1490_MP24_1 (XI1490_asn pp12_29 XI1490_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1490_MP17 (XI1490_acon pp12_29 XI1490_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1490_MP14 (XI1490_ap1 pp11_31 XI1490_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1490_MP13 (VDD sn10 XI1490_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1490_MP15 (XI1490_ap2 sn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1490_MP16 (VDD pp11_31 XI1490_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1490_MP28 (cm129_2 XI1490_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1490_MP19 (XI1490_ap3 pp11_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1490_MP20 (VDD pp12_29 XI1490_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1439_MP50 (VDD XI1439_s1 XI1439_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1439_MP47 (XI1439_bp3 pp7_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1439_MP49 (XI1439_bsn XI1439_bcon XI1439_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1439_MP52 (XI1439_bp5 cm74_2 XI1439_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1439_MP51 (XI1439_bp4 pp7_20 XI1439_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1439_MP51_1 (XI1439_bp5 pp7_20 XI1439_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1439_MP52_1 (XI1439_bsn cm74_2 XI1439_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1439_MP54 (VDD XI1439_bsn cm78_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1439_MP41 (XI1439_bp1 XI1439_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1439_MP42 (XI1439_bcon pp7_20 XI1439_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1439_MP45 (XI1439_bp2 cm74_2 XI1439_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1439_MP43 (VDD XI1439_s1 XI1439_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1439_MP44 (XI1439_bp2 pp7_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1439_MP56 (VDD XI1439_bcon cm78_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1439_MP46 (XI1439_bp3 XI1439_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1439_MP48 (VDD cm74_2 XI1439_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1439_MP50_1 (XI1439_bp4 XI1439_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1439_MP26 (VDD XI1439_asn XI1439_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1439_MP18 (XI1439_ap3 pp4_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1439_MP21 (XI1439_asn XI1439_acon XI1439_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1439_MP24 (XI1439_ap5 pp6_22 XI1439_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1439_MP23 (XI1439_ap4 pp5_24 XI1439_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1439_MP22 (VDD pp4_26 XI1439_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1439_MP22_1 (XI1439_ap4 pp4_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1439_MP23_1 (XI1439_ap5 pp5_24 XI1439_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1439_MP24_1 (XI1439_asn pp6_22 XI1439_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1439_MP17 (XI1439_acon pp6_22 XI1439_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1439_MP14 (XI1439_ap1 pp5_24 XI1439_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1439_MP13 (VDD pp4_26 XI1439_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1439_MP15 (XI1439_ap2 pp4_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1439_MP16 (VDD pp5_24 XI1439_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1439_MP28 (cm78_2 XI1439_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1439_MP19 (XI1439_ap3 pp5_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1439_MP20 (VDD pp6_22 XI1439_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1539_MP50 (VDD XI1539_s1 XI1539_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1539_MP47 (XI1539_bp3 cm84_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1539_MP49 (XI1539_bsn XI1539_bcon XI1539_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1539_MP52 (XI1539_bp5 cm176_2 XI1539_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1539_MP51 (XI1539_bp4 cm84_0 XI1539_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1539_MP51_1 (XI1539_bp5 cm84_0 XI1539_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1539_MP52_1 (XI1539_bsn cm176_2 XI1539_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1539_MP54 (VDD XI1539_bsn cm178_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1539_MP41 (XI1539_bp1 XI1539_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1539_MP42 (XI1539_bcon cm84_0 XI1539_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1539_MP45 (XI1539_bp2 cm176_2 XI1539_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1539_MP43 (VDD XI1539_s1 XI1539_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1539_MP44 (XI1539_bp2 cm84_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1539_MP56 (VDD XI1539_bcon cm178_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1539_MP46 (XI1539_bp3 XI1539_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1539_MP48 (VDD cm176_2 XI1539_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1539_MP50_1 (XI1539_bp4 XI1539_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1539_MP26 (VDD XI1539_asn XI1539_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1539_MP18 (XI1539_ap3 cm81_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1539_MP21 (XI1539_asn XI1539_acon XI1539_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1539_MP24 (XI1539_ap5 cm83_0 XI1539_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1539_MP23 (XI1539_ap4 cm82_0 XI1539_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1539_MP22 (VDD cm81_0 XI1539_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1539_MP22_1 (XI1539_ap4 cm81_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1539_MP23_1 (XI1539_ap5 cm82_0 XI1539_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1539_MP24_1 (XI1539_asn cm83_0 XI1539_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1539_MP17 (XI1539_acon cm83_0 XI1539_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1539_MP14 (XI1539_ap1 cm82_0 XI1539_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1539_MP13 (VDD cm81_0 XI1539_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1539_MP15 (XI1539_ap2 cm81_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1539_MP16 (VDD cm82_0 XI1539_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1539_MP28 (cm178_2 XI1539_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1539_MP19 (XI1539_ap3 cm82_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1539_MP20 (VDD cm83_0 XI1539_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1591_MP50 (VDD XI1591_s1 XI1591_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1591_MP47 (XI1591_bp3 cm180_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1591_MP49 (XI1591_bsn XI1591_bcon XI1591_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1591_MP52 (XI1591_bp5 cm229_2 XI1591_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1591_MP51 (XI1591_bp4 cm180_0 XI1591_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1591_MP51_1 (XI1591_bp5 cm180_0 XI1591_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1591_MP52_1 (XI1591_bsn cm229_2 XI1591_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1591_MP54 (VDD XI1591_bsn cm230_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1591_MP41 (XI1591_bp1 XI1591_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1591_MP42 (XI1591_bcon cm180_0 XI1591_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1591_MP45 (XI1591_bp2 cm229_2 XI1591_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1591_MP43 (VDD XI1591_s1 XI1591_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1591_MP44 (XI1591_bp2 cm180_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1591_MP56 (VDD XI1591_bcon cm230_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1591_MP46 (XI1591_bp3 XI1591_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1591_MP48 (VDD cm229_2 XI1591_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1591_MP50_1 (XI1591_bp4 XI1591_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1591_MP26 (VDD XI1591_asn XI1591_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1591_MP18 (XI1591_ap3 cm177_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1591_MP21 (XI1591_asn XI1591_acon XI1591_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1591_MP24 (XI1591_ap5 cm179_0 XI1591_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1591_MP23 (XI1591_ap4 cm178_1 XI1591_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1591_MP22 (VDD cm177_1 XI1591_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1591_MP22_1 (XI1591_ap4 cm177_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1591_MP23_1 (XI1591_ap5 cm178_1 XI1591_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1591_MP24_1 (XI1591_asn cm179_0 XI1591_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1591_MP17 (XI1591_acon cm179_0 XI1591_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1591_MP14 (XI1591_ap1 cm178_1 XI1591_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1591_MP13 (VDD cm177_1 XI1591_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1591_MP15 (XI1591_ap2 cm177_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1591_MP16 (VDD cm178_1 XI1591_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1591_MP28 (cm230_2 XI1591_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1591_MP19 (XI1591_ap3 cm178_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1591_MP20 (VDD cm179_0 XI1591_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1565_MP50 (VDD XI1565_s1 XI1565_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1565_MP47 (XI1565_bp3 pp15_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1565_MP49 (XI1565_bsn XI1565_bcon XI1565_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1565_MP52 (XI1565_bp5 cm203_2 XI1565_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1565_MP51 (XI1565_bp4 pp15_24 XI1565_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1565_MP51_1 (XI1565_bp5 pp15_24 XI1565_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1565_MP52_1 (XI1565_bsn cm203_2 XI1565_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1565_MP54 (VDD XI1565_bsn cm204_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1565_MP41 (XI1565_bp1 XI1565_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1565_MP42 (XI1565_bcon pp15_24 XI1565_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1565_MP45 (XI1565_bp2 cm203_2 XI1565_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1565_MP43 (VDD XI1565_s1 XI1565_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1565_MP44 (XI1565_bp2 pp15_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1565_MP56 (VDD XI1565_bcon cm204_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1565_MP46 (XI1565_bp3 XI1565_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1565_MP48 (VDD cm203_2 XI1565_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1565_MP50_1 (XI1565_bp4 XI1565_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1565_MP26 (VDD XI1565_asn XI1565_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1565_MP18 (XI1565_ap3 cm129_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1565_MP21 (XI1565_asn XI1565_acon XI1565_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1565_MP24 (XI1565_ap5 pp14_26 XI1565_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1565_MP23 (XI1565_ap4 cm130_0 XI1565_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1565_MP22 (VDD cm129_1 XI1565_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1565_MP22_1 (XI1565_ap4 cm129_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1565_MP23_1 (XI1565_ap5 cm130_0 XI1565_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1565_MP24_1 (XI1565_asn pp14_26 XI1565_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1565_MP17 (XI1565_acon pp14_26 XI1565_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1565_MP14 (XI1565_ap1 cm130_0 XI1565_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1565_MP13 (VDD cm129_1 XI1565_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1565_MP15 (XI1565_ap2 cm129_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1565_MP16 (VDD cm130_0 XI1565_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1565_MP28 (cm204_2 XI1565_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1565_MP19 (XI1565_ap3 cm130_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1565_MP20 (VDD pp14_26 XI1565_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1435_MP50 (VDD XI1435_s1 XI1435_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1435_MP47 (XI1435_bp3 pp7_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1435_MP49 (XI1435_bsn XI1435_bcon XI1435_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1435_MP52 (XI1435_bp5 cm70_2 XI1435_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1435_MP51 (XI1435_bp4 pp7_19 XI1435_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1435_MP51_1 (XI1435_bp5 pp7_19 XI1435_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1435_MP52_1 (XI1435_bsn cm70_2 XI1435_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1435_MP54 (VDD XI1435_bsn cm74_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1435_MP41 (XI1435_bp1 XI1435_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1435_MP42 (XI1435_bcon pp7_19 XI1435_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1435_MP45 (XI1435_bp2 cm70_2 XI1435_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1435_MP43 (VDD XI1435_s1 XI1435_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1435_MP44 (XI1435_bp2 pp7_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1435_MP56 (VDD XI1435_bcon cm74_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1435_MP46 (XI1435_bp3 XI1435_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1435_MP48 (VDD cm70_2 XI1435_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1435_MP50_1 (XI1435_bp4 XI1435_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1435_MP26 (VDD XI1435_asn XI1435_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1435_MP18 (XI1435_ap3 pp4_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1435_MP21 (XI1435_asn XI1435_acon XI1435_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1435_MP24 (XI1435_ap5 pp6_21 XI1435_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1435_MP23 (XI1435_ap4 pp5_23 XI1435_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1435_MP22 (VDD pp4_25 XI1435_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1435_MP22_1 (XI1435_ap4 pp4_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1435_MP23_1 (XI1435_ap5 pp5_23 XI1435_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1435_MP24_1 (XI1435_asn pp6_21 XI1435_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1435_MP17 (XI1435_acon pp6_21 XI1435_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1435_MP14 (XI1435_ap1 pp5_23 XI1435_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1435_MP13 (VDD pp4_25 XI1435_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1435_MP15 (XI1435_ap2 pp4_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1435_MP16 (VDD pp5_23 XI1435_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1435_MP28 (cm74_2 XI1435_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1435_MP19 (XI1435_ap3 pp5_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1435_MP20 (VDD pp6_21 XI1435_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1438_MP50 (VDD XI1438_s1 XI1438_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1438_MP47 (XI1438_bp3 pp3_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1438_MP49 (XI1438_bsn XI1438_bcon XI1438_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1438_MP52 (XI1438_bp5 cm73_2 XI1438_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1438_MP51 (XI1438_bp4 pp3_28 XI1438_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1438_MP51_1 (XI1438_bp5 pp3_28 XI1438_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1438_MP52_1 (XI1438_bsn cm73_2 XI1438_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1438_MP54 (VDD XI1438_bsn cm77_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1438_MP41 (XI1438_bp1 XI1438_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1438_MP42 (XI1438_bcon pp3_28 XI1438_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1438_MP45 (XI1438_bp2 cm73_2 XI1438_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1438_MP43 (VDD XI1438_s1 XI1438_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1438_MP44 (XI1438_bp2 pp3_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1438_MP56 (VDD XI1438_bcon cm77_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1438_MP46 (XI1438_bp3 XI1438_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1438_MP48 (VDD cm73_2 XI1438_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1438_MP50_1 (XI1438_bp4 XI1438_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1438_MP26 (VDD XI1438_asn XI1438_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1438_MP18 (XI1438_ap3 pp0_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1438_MP21 (XI1438_asn XI1438_acon XI1438_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1438_MP24 (XI1438_ap5 pp2_30 XI1438_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1438_MP23 (XI1438_ap4 pp1_32 XI1438_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1438_MP22 (VDD pp0_32 XI1438_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1438_MP22_1 (XI1438_ap4 pp0_32 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1438_MP23_1 (XI1438_ap5 pp1_32 XI1438_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1438_MP24_1 (XI1438_asn pp2_30 XI1438_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1438_MP17 (XI1438_acon pp2_30 XI1438_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1438_MP14 (XI1438_ap1 pp1_32 XI1438_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1438_MP13 (VDD pp0_32 XI1438_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1438_MP15 (XI1438_ap2 pp0_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1438_MP16 (VDD pp1_32 XI1438_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1438_MP28 (cm77_2 XI1438_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1438_MP19 (XI1438_ap3 pp1_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1438_MP20 (VDD pp2_30 XI1438_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1538_MP50 (VDD XI1538_s1 XI1538_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1538_MP47 (XI1538_bp3 cm80_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1538_MP49 (XI1538_bsn XI1538_bcon XI1538_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1538_MP52 (XI1538_bp5 cm175_2 XI1538_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1538_MP51 (XI1538_bp4 cm80_1 XI1538_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1538_MP51_1 (XI1538_bp5 cm80_1 XI1538_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1538_MP52_1 (XI1538_bsn cm175_2 XI1538_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1538_MP54 (VDD XI1538_bsn cm177_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1538_MP41 (XI1538_bp1 XI1538_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1538_MP42 (XI1538_bcon cm80_1 XI1538_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1538_MP45 (XI1538_bp2 cm175_2 XI1538_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1538_MP43 (VDD XI1538_s1 XI1538_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1538_MP44 (XI1538_bp2 cm80_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1538_MP56 (VDD XI1538_bcon cm177_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1538_MP46 (XI1538_bp3 XI1538_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1538_MP48 (VDD cm175_2 XI1538_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1538_MP50_1 (XI1538_bp4 XI1538_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1538_MP26 (VDD XI1538_asn XI1538_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1538_MP18 (XI1538_ap3 cm77_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1538_MP21 (XI1538_asn XI1538_acon XI1538_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1538_MP24 (XI1538_ap5 cm79_1 XI1538_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1538_MP23 (XI1538_ap4 cm78_1 XI1538_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1538_MP22 (VDD cm77_1 XI1538_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1538_MP22_1 (XI1538_ap4 cm77_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1538_MP23_1 (XI1538_ap5 cm78_1 XI1538_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1538_MP24_1 (XI1538_asn cm79_1 XI1538_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1538_MP17 (XI1538_acon cm79_1 XI1538_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1538_MP14 (XI1538_ap1 cm78_1 XI1538_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1538_MP13 (VDD cm77_1 XI1538_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1538_MP15 (XI1538_ap2 cm77_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1538_MP16 (VDD cm78_1 XI1538_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1538_MP28 (cm177_2 XI1538_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1538_MP19 (XI1538_ap3 cm78_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1538_MP20 (VDD cm79_1 XI1538_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1537_MP50 (VDD XI1537_s1 XI1537_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1537_MP47 (XI1537_bp3 cm80_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1537_MP49 (XI1537_bsn XI1537_bcon XI1537_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1537_MP52 (XI1537_bp5 cm174_2 XI1537_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1537_MP51 (XI1537_bp4 cm80_0 XI1537_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1537_MP51_1 (XI1537_bp5 cm80_0 XI1537_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1537_MP52_1 (XI1537_bsn cm174_2 XI1537_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1537_MP54 (VDD XI1537_bsn cm176_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1537_MP41 (XI1537_bp1 XI1537_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1537_MP42 (XI1537_bcon cm80_0 XI1537_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1537_MP45 (XI1537_bp2 cm174_2 XI1537_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1537_MP43 (VDD XI1537_s1 XI1537_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1537_MP44 (XI1537_bp2 cm80_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1537_MP56 (VDD XI1537_bcon cm176_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1537_MP46 (XI1537_bp3 XI1537_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1537_MP48 (VDD cm174_2 XI1537_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1537_MP50_1 (XI1537_bp4 XI1537_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1537_MP26 (VDD XI1537_asn XI1537_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1537_MP18 (XI1537_ap3 cm77_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1537_MP21 (XI1537_asn XI1537_acon XI1537_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1537_MP24 (XI1537_ap5 cm79_0 XI1537_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1537_MP23 (XI1537_ap4 cm78_0 XI1537_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1537_MP22 (VDD cm77_0 XI1537_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1537_MP22_1 (XI1537_ap4 cm77_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1537_MP23_1 (XI1537_ap5 cm78_0 XI1537_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1537_MP24_1 (XI1537_asn cm79_0 XI1537_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1537_MP17 (XI1537_acon cm79_0 XI1537_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1537_MP14 (XI1537_ap1 cm78_0 XI1537_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1537_MP13 (VDD cm77_0 XI1537_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1537_MP15 (XI1537_ap2 cm77_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1537_MP16 (VDD cm78_0 XI1537_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1537_MP28 (cm176_2 XI1537_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1537_MP19 (XI1537_ap3 cm78_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1537_MP20 (VDD cm79_0 XI1537_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1440_MP50 (VDD XI1440_s1 XI1440_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1440_MP47 (XI1440_bp3 pp11_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1440_MP49 (XI1440_bsn XI1440_bcon XI1440_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1440_MP52 (XI1440_bp5 cm75_2 XI1440_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1440_MP51 (XI1440_bp4 pp11_12 XI1440_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1440_MP51_1 (XI1440_bp5 pp11_12 XI1440_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1440_MP52_1 (XI1440_bsn cm75_2 XI1440_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1440_MP54 (VDD XI1440_bsn cm79_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1440_MP41 (XI1440_bp1 XI1440_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1440_MP42 (XI1440_bcon pp11_12 XI1440_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1440_MP45 (XI1440_bp2 cm75_2 XI1440_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1440_MP43 (VDD XI1440_s1 XI1440_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1440_MP44 (XI1440_bp2 pp11_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1440_MP56 (VDD XI1440_bcon cm79_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1440_MP46 (XI1440_bp3 XI1440_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1440_MP48 (VDD cm75_2 XI1440_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1440_MP50_1 (XI1440_bp4 XI1440_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1440_MP26 (VDD XI1440_asn XI1440_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1440_MP18 (XI1440_ap3 pp8_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1440_MP21 (XI1440_asn XI1440_acon XI1440_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1440_MP24 (XI1440_ap5 pp10_14 XI1440_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1440_MP23 (XI1440_ap4 pp9_16 XI1440_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1440_MP22 (VDD pp8_18 XI1440_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1440_MP22_1 (XI1440_ap4 pp8_18 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1440_MP23_1 (XI1440_ap5 pp9_16 XI1440_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1440_MP24_1 (XI1440_asn pp10_14 XI1440_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1440_MP17 (XI1440_acon pp10_14 XI1440_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1440_MP14 (XI1440_ap1 pp9_16 XI1440_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1440_MP13 (VDD pp8_18 XI1440_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1440_MP15 (XI1440_ap2 pp8_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1440_MP16 (VDD pp9_16 XI1440_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1440_MP28 (cm79_2 XI1440_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1440_MP19 (XI1440_ap3 pp9_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1440_MP20 (VDD pp10_14 XI1440_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1601_MP50 (VDD XI1601_s1 XI1601_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1601_MP47 (XI1601_bp3 pp14_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1601_MP49 (XI1601_bsn XI1601_bcon XI1601_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1601_MP52 (XI1601_bp5 pp15_16 XI1601_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1601_MP51 (XI1601_bp4 pp14_18 XI1601_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1601_MP51_1 (XI1601_bp5 pp14_18 XI1601_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1601_MP52_1 (XI1601_bsn pp15_16 XI1601_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1601_MP54 (VDD XI1601_bsn cm240_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1601_MP41 (XI1601_bp1 XI1601_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1601_MP42 (XI1601_bcon pp14_18 XI1601_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1601_MP45 (XI1601_bp2 pp15_16 XI1601_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1601_MP43 (VDD XI1601_s1 XI1601_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1601_MP44 (XI1601_bp2 pp14_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1601_MP56 (VDD XI1601_bcon cm240_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1601_MP46 (XI1601_bp3 XI1601_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1601_MP48 (VDD pp15_16 XI1601_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1601_MP50_1 (XI1601_bp4 XI1601_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1601_MP26 (VDD XI1601_asn XI1601_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1601_MP18 (XI1601_ap3 cm194_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1601_MP21 (XI1601_asn XI1601_acon XI1601_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1601_MP24 (XI1601_ap5 cm196_0 XI1601_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1601_MP23 (XI1601_ap4 fa195_1 XI1601_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1601_MP22 (VDD cm194_1 XI1601_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1601_MP22_1 (XI1601_ap4 cm194_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1601_MP23_1 (XI1601_ap5 fa195_1 XI1601_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1601_MP24_1 (XI1601_asn cm196_0 XI1601_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1601_MP17 (XI1601_acon cm196_0 XI1601_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1601_MP14 (XI1601_ap1 fa195_1 XI1601_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1601_MP13 (VDD cm194_1 XI1601_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1601_MP15 (XI1601_ap2 cm194_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1601_MP16 (VDD fa195_1 XI1601_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1601_MP28 (cm240_2 XI1601_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1601_MP19 (XI1601_ap3 fa195_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1601_MP20 (VDD cm196_0 XI1601_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1491_MP50 (VDD XI1491_s1 XI1491_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1491_MP47 (XI1491_bp3 pp13_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1491_MP49 (XI1491_bsn XI1491_bcon XI1491_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1491_MP52 (XI1491_bp5 cm129_2 XI1491_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1491_MP51 (XI1491_bp4 pp13_28 XI1491_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1491_MP51_1 (XI1491_bp5 pp13_28 XI1491_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1491_MP52_1 (XI1491_bsn cm129_2 XI1491_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1491_MP54 (VDD XI1491_bsn cm130_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1491_MP41 (XI1491_bp1 XI1491_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1491_MP42 (XI1491_bcon pp13_28 XI1491_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1491_MP45 (XI1491_bp2 cm129_2 XI1491_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1491_MP43 (VDD XI1491_s1 XI1491_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1491_MP44 (XI1491_bp2 pp13_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1491_MP56 (VDD XI1491_bcon cm130_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1491_MP46 (XI1491_bp3 XI1491_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1491_MP48 (VDD cm129_2 XI1491_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1491_MP50_1 (XI1491_bp4 XI1491_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1491_MP26 (VDD XI1491_asn XI1491_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1491_MP18 (XI1491_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1491_MP21 (XI1491_asn XI1491_acon XI1491_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1491_MP24 (XI1491_ap5 pp12_30 XI1491_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1491_MP23 (XI1491_ap4 pp11_32 XI1491_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1491_MP22 (VDD VDD XI1491_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1491_MP22_1 (XI1491_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1491_MP23_1 (XI1491_ap5 pp11_32 XI1491_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1491_MP24_1 (XI1491_asn pp12_30 XI1491_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1491_MP17 (XI1491_acon pp12_30 XI1491_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1491_MP14 (XI1491_ap1 pp11_32 XI1491_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1491_MP13 (VDD VDD XI1491_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1491_MP15 (XI1491_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1491_MP16 (VDD pp11_32 XI1491_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1491_MP28 (cm130_2 XI1491_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1491_MP19 (XI1491_ap3 pp11_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1491_MP20 (VDD pp12_30 XI1491_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1434_MP50 (VDD XI1434_s1 XI1434_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1434_MP47 (XI1434_bp3 pp3_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1434_MP49 (XI1434_bsn XI1434_bcon XI1434_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1434_MP52 (XI1434_bp5 cm69_2 XI1434_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1434_MP51 (XI1434_bp4 pp3_27 XI1434_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1434_MP51_1 (XI1434_bp5 pp3_27 XI1434_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1434_MP52_1 (XI1434_bsn cm69_2 XI1434_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1434_MP54 (VDD XI1434_bsn cm73_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1434_MP41 (XI1434_bp1 XI1434_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1434_MP42 (XI1434_bcon pp3_27 XI1434_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1434_MP45 (XI1434_bp2 cm69_2 XI1434_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1434_MP43 (VDD XI1434_s1 XI1434_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1434_MP44 (XI1434_bp2 pp3_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1434_MP56 (VDD XI1434_bcon cm73_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1434_MP46 (XI1434_bp3 XI1434_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1434_MP48 (VDD cm69_2 XI1434_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1434_MP50_1 (XI1434_bp4 XI1434_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1434_MP26 (VDD XI1434_asn XI1434_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1434_MP18 (XI1434_ap3 pp0_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1434_MP21 (XI1434_asn XI1434_acon XI1434_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1434_MP24 (XI1434_ap5 pp2_29 XI1434_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1434_MP23 (XI1434_ap4 pp1_31 XI1434_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1434_MP22 (VDD pp0_32 XI1434_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1434_MP22_1 (XI1434_ap4 pp0_32 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1434_MP23_1 (XI1434_ap5 pp1_31 XI1434_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1434_MP24_1 (XI1434_asn pp2_29 XI1434_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1434_MP17 (XI1434_acon pp2_29 XI1434_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1434_MP14 (XI1434_ap1 pp1_31 XI1434_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1434_MP13 (VDD pp0_32 XI1434_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1434_MP15 (XI1434_ap2 pp0_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1434_MP16 (VDD pp1_31 XI1434_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1434_MP28 (cm73_2 XI1434_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1434_MP19 (XI1434_ap3 pp1_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1434_MP20 (VDD pp2_29 XI1434_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1536_MP50 (VDD XI1536_s1 XI1536_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1536_MP47 (XI1536_bp3 cm76_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1536_MP49 (XI1536_bsn XI1536_bcon XI1536_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1536_MP52 (XI1536_bp5 cm173_2 XI1536_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1536_MP51 (XI1536_bp4 cm76_1 XI1536_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1536_MP51_1 (XI1536_bp5 cm76_1 XI1536_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1536_MP52_1 (XI1536_bsn cm173_2 XI1536_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1536_MP54 (VDD XI1536_bsn cm175_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1536_MP41 (XI1536_bp1 XI1536_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1536_MP42 (XI1536_bcon cm76_1 XI1536_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1536_MP45 (XI1536_bp2 cm173_2 XI1536_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1536_MP43 (VDD XI1536_s1 XI1536_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1536_MP44 (XI1536_bp2 cm76_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1536_MP56 (VDD XI1536_bcon cm175_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1536_MP46 (XI1536_bp3 XI1536_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1536_MP48 (VDD cm173_2 XI1536_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1536_MP50_1 (XI1536_bp4 XI1536_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1536_MP26 (VDD XI1536_asn XI1536_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1536_MP18 (XI1536_ap3 cm73_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1536_MP21 (XI1536_asn XI1536_acon XI1536_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1536_MP24 (XI1536_ap5 cm75_1 XI1536_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1536_MP23 (XI1536_ap4 cm74_1 XI1536_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1536_MP22 (VDD cm73_1 XI1536_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1536_MP22_1 (XI1536_ap4 cm73_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1536_MP23_1 (XI1536_ap5 cm74_1 XI1536_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1536_MP24_1 (XI1536_asn cm75_1 XI1536_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1536_MP17 (XI1536_acon cm75_1 XI1536_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1536_MP14 (XI1536_ap1 cm74_1 XI1536_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1536_MP13 (VDD cm73_1 XI1536_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1536_MP15 (XI1536_ap2 cm73_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1536_MP16 (VDD cm74_1 XI1536_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1536_MP28 (cm175_2 XI1536_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1536_MP19 (XI1536_ap3 cm74_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1536_MP20 (VDD cm75_1 XI1536_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1590_MP50 (VDD XI1590_s1 XI1590_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1590_MP47 (XI1590_bp3 cm178_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1590_MP49 (XI1590_bsn XI1590_bcon XI1590_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1590_MP52 (XI1590_bp5 cm228_2 XI1590_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1590_MP51 (XI1590_bp4 cm178_0 XI1590_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1590_MP51_1 (XI1590_bp5 cm178_0 XI1590_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1590_MP52_1 (XI1590_bsn cm228_2 XI1590_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1590_MP54 (VDD XI1590_bsn cm229_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1590_MP41 (XI1590_bp1 XI1590_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1590_MP42 (XI1590_bcon cm178_0 XI1590_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1590_MP45 (XI1590_bp2 cm228_2 XI1590_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1590_MP43 (VDD XI1590_s1 XI1590_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1590_MP44 (XI1590_bp2 cm178_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1590_MP56 (VDD XI1590_bcon cm229_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1590_MP46 (XI1590_bp3 XI1590_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1590_MP48 (VDD cm228_2 XI1590_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1590_MP50_1 (XI1590_bp4 XI1590_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1590_MP26 (VDD XI1590_asn XI1590_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1590_MP18 (XI1590_ap3 cm175_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1590_MP21 (XI1590_asn XI1590_acon XI1590_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1590_MP24 (XI1590_ap5 cm177_0 XI1590_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1590_MP23 (XI1590_ap4 cm176_1 XI1590_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1590_MP22 (VDD cm175_1 XI1590_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1590_MP22_1 (XI1590_ap4 cm175_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1590_MP23_1 (XI1590_ap5 cm176_1 XI1590_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1590_MP24_1 (XI1590_asn cm177_0 XI1590_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1590_MP17 (XI1590_acon cm177_0 XI1590_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1590_MP14 (XI1590_ap1 cm176_1 XI1590_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1590_MP13 (VDD cm175_1 XI1590_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1590_MP15 (XI1590_ap2 cm175_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1590_MP16 (VDD cm176_1 XI1590_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1590_MP28 (cm229_2 XI1590_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1590_MP19 (XI1590_ap3 cm176_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1590_MP20 (VDD cm177_0 XI1590_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1436_MP50 (VDD XI1436_s1 XI1436_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1436_MP47 (XI1436_bp3 pp11_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1436_MP49 (XI1436_bsn XI1436_bcon XI1436_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1436_MP52 (XI1436_bp5 cm71_2 XI1436_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1436_MP51 (XI1436_bp4 pp11_11 XI1436_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1436_MP51_1 (XI1436_bp5 pp11_11 XI1436_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1436_MP52_1 (XI1436_bsn cm71_2 XI1436_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1436_MP54 (VDD XI1436_bsn cm75_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1436_MP41 (XI1436_bp1 XI1436_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1436_MP42 (XI1436_bcon pp11_11 XI1436_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1436_MP45 (XI1436_bp2 cm71_2 XI1436_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1436_MP43 (VDD XI1436_s1 XI1436_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1436_MP44 (XI1436_bp2 pp11_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1436_MP56 (VDD XI1436_bcon cm75_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1436_MP46 (XI1436_bp3 XI1436_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1436_MP48 (VDD cm71_2 XI1436_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1436_MP50_1 (XI1436_bp4 XI1436_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1436_MP26 (VDD XI1436_asn XI1436_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1436_MP18 (XI1436_ap3 pp8_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1436_MP21 (XI1436_asn XI1436_acon XI1436_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1436_MP24 (XI1436_ap5 pp10_13 XI1436_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1436_MP23 (XI1436_ap4 pp9_15 XI1436_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1436_MP22 (VDD pp8_17 XI1436_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1436_MP22_1 (XI1436_ap4 pp8_17 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1436_MP23_1 (XI1436_ap5 pp9_15 XI1436_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1436_MP24_1 (XI1436_asn pp10_13 XI1436_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1436_MP17 (XI1436_acon pp10_13 XI1436_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1436_MP14 (XI1436_ap1 pp9_15 XI1436_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1436_MP13 (VDD pp8_17 XI1436_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1436_MP15 (XI1436_ap2 pp8_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1436_MP16 (VDD pp9_15 XI1436_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1436_MP28 (cm75_2 XI1436_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1436_MP19 (XI1436_ap3 pp9_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1436_MP20 (VDD pp10_13 XI1436_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1431_MP50 (VDD XI1431_s1 XI1431_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1431_MP47 (XI1431_bp3 pp7_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1431_MP49 (XI1431_bsn XI1431_bcon XI1431_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1431_MP52 (XI1431_bp5 cm66_2 XI1431_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1431_MP51 (XI1431_bp4 pp7_18 XI1431_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1431_MP51_1 (XI1431_bp5 pp7_18 XI1431_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1431_MP52_1 (XI1431_bsn cm66_2 XI1431_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1431_MP54 (VDD XI1431_bsn cm70_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1431_MP41 (XI1431_bp1 XI1431_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1431_MP42 (XI1431_bcon pp7_18 XI1431_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1431_MP45 (XI1431_bp2 cm66_2 XI1431_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1431_MP43 (VDD XI1431_s1 XI1431_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1431_MP44 (XI1431_bp2 pp7_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1431_MP56 (VDD XI1431_bcon cm70_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1431_MP46 (XI1431_bp3 XI1431_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1431_MP48 (VDD cm66_2 XI1431_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1431_MP50_1 (XI1431_bp4 XI1431_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1431_MP26 (VDD XI1431_asn XI1431_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1431_MP18 (XI1431_ap3 pp4_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1431_MP21 (XI1431_asn XI1431_acon XI1431_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1431_MP24 (XI1431_ap5 pp6_20 XI1431_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1431_MP23 (XI1431_ap4 pp5_22 XI1431_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1431_MP22 (VDD pp4_24 XI1431_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1431_MP22_1 (XI1431_ap4 pp4_24 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1431_MP23_1 (XI1431_ap5 pp5_22 XI1431_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1431_MP24_1 (XI1431_asn pp6_20 XI1431_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1431_MP17 (XI1431_acon pp6_20 XI1431_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1431_MP14 (XI1431_ap1 pp5_22 XI1431_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1431_MP13 (VDD pp4_24 XI1431_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1431_MP15 (XI1431_ap2 pp4_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1431_MP16 (VDD pp5_22 XI1431_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1431_MP28 (cm70_2 XI1431_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1431_MP19 (XI1431_ap3 pp5_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1431_MP20 (VDD pp6_20 XI1431_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1535_MP50 (VDD XI1535_s1 XI1535_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1535_MP47 (XI1535_bp3 cm76_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1535_MP49 (XI1535_bsn XI1535_bcon XI1535_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1535_MP52 (XI1535_bp5 cm172_2 XI1535_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1535_MP51 (XI1535_bp4 cm76_0 XI1535_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1535_MP51_1 (XI1535_bp5 cm76_0 XI1535_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1535_MP52_1 (XI1535_bsn cm172_2 XI1535_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1535_MP54 (VDD XI1535_bsn cm174_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1535_MP41 (XI1535_bp1 XI1535_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1535_MP42 (XI1535_bcon cm76_0 XI1535_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1535_MP45 (XI1535_bp2 cm172_2 XI1535_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1535_MP43 (VDD XI1535_s1 XI1535_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1535_MP44 (XI1535_bp2 cm76_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1535_MP56 (VDD XI1535_bcon cm174_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1535_MP46 (XI1535_bp3 XI1535_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1535_MP48 (VDD cm172_2 XI1535_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1535_MP50_1 (XI1535_bp4 XI1535_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1535_MP26 (VDD XI1535_asn XI1535_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1535_MP18 (XI1535_ap3 cm73_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1535_MP21 (XI1535_asn XI1535_acon XI1535_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1535_MP24 (XI1535_ap5 cm75_0 XI1535_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1535_MP23 (XI1535_ap4 cm74_0 XI1535_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1535_MP22 (VDD cm73_0 XI1535_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1535_MP22_1 (XI1535_ap4 cm73_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1535_MP23_1 (XI1535_ap5 cm74_0 XI1535_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1535_MP24_1 (XI1535_asn cm75_0 XI1535_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1535_MP17 (XI1535_acon cm75_0 XI1535_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1535_MP14 (XI1535_ap1 cm74_0 XI1535_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1535_MP13 (VDD cm73_0 XI1535_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1535_MP15 (XI1535_ap2 cm73_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1535_MP16 (VDD cm74_0 XI1535_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1535_MP28 (cm174_2 XI1535_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1535_MP19 (XI1535_ap3 cm74_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1535_MP20 (VDD cm75_0 XI1535_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1589_MP50 (VDD XI1589_s1 XI1589_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1589_MP47 (XI1589_bp3 cm176_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1589_MP49 (XI1589_bsn XI1589_bcon XI1589_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1589_MP52 (XI1589_bp5 cm227_2 XI1589_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1589_MP51 (XI1589_bp4 cm176_0 XI1589_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1589_MP51_1 (XI1589_bp5 cm176_0 XI1589_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1589_MP52_1 (XI1589_bsn cm227_2 XI1589_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1589_MP54 (VDD XI1589_bsn cm228_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1589_MP41 (XI1589_bp1 XI1589_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1589_MP42 (XI1589_bcon cm176_0 XI1589_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1589_MP45 (XI1589_bp2 cm227_2 XI1589_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1589_MP43 (VDD XI1589_s1 XI1589_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1589_MP44 (XI1589_bp2 cm176_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1589_MP56 (VDD XI1589_bcon cm228_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1589_MP46 (XI1589_bp3 XI1589_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1589_MP48 (VDD cm227_2 XI1589_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1589_MP50_1 (XI1589_bp4 XI1589_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1589_MP26 (VDD XI1589_asn XI1589_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1589_MP18 (XI1589_ap3 cm173_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1589_MP21 (XI1589_asn XI1589_acon XI1589_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1589_MP24 (XI1589_ap5 cm175_0 XI1589_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1589_MP23 (XI1589_ap4 cm174_1 XI1589_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1589_MP22 (VDD cm173_1 XI1589_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1589_MP22_1 (XI1589_ap4 cm173_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1589_MP23_1 (XI1589_ap5 cm174_1 XI1589_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1589_MP24_1 (XI1589_asn cm175_0 XI1589_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1589_MP17 (XI1589_acon cm175_0 XI1589_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1589_MP14 (XI1589_ap1 cm174_1 XI1589_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1589_MP13 (VDD cm173_1 XI1589_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1589_MP15 (XI1589_ap2 cm173_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1589_MP16 (VDD cm174_1 XI1589_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1589_MP28 (cm228_2 XI1589_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1589_MP19 (XI1589_ap3 cm174_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1589_MP20 (VDD cm175_0 XI1589_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1445_MP50 (VDD XI1445_s1 XI1445_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1445_MP47 (XI1445_bp3 pp15_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1445_MP49 (XI1445_bsn XI1445_bcon XI1445_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1445_MP52 (XI1445_bp5 cm80_2 XI1445_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1445_MP51 (XI1445_bp4 pp15_5 XI1445_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1445_MP51_1 (XI1445_bp5 pp15_5 XI1445_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1445_MP52_1 (XI1445_bsn cm80_2 XI1445_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1445_MP54 (VDD XI1445_bsn cm84_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1445_MP41 (XI1445_bp1 XI1445_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1445_MP42 (XI1445_bcon pp15_5 XI1445_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1445_MP45 (XI1445_bp2 cm80_2 XI1445_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1445_MP43 (VDD XI1445_s1 XI1445_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1445_MP44 (XI1445_bp2 pp15_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1445_MP56 (VDD XI1445_bcon cm84_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1445_MP46 (XI1445_bp3 XI1445_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1445_MP48 (VDD cm80_2 XI1445_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1445_MP50_1 (XI1445_bp4 XI1445_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1445_MP26 (VDD XI1445_asn XI1445_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1445_MP18 (XI1445_ap3 pp12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1445_MP21 (XI1445_asn XI1445_acon XI1445_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1445_MP24 (XI1445_ap5 pp14_7 XI1445_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1445_MP23 (XI1445_ap4 pp13_9 XI1445_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1445_MP22 (VDD pp12_11 XI1445_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1445_MP22_1 (XI1445_ap4 pp12_11 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1445_MP23_1 (XI1445_ap5 pp13_9 XI1445_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1445_MP24_1 (XI1445_asn pp14_7 XI1445_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1445_MP17 (XI1445_acon pp14_7 XI1445_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1445_MP14 (XI1445_ap1 pp13_9 XI1445_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1445_MP13 (VDD pp12_11 XI1445_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1445_MP15 (XI1445_ap2 pp12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1445_MP16 (VDD pp13_9 XI1445_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1445_MP28 (cm84_2 XI1445_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1445_MP19 (XI1445_ap3 pp13_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1445_MP20 (VDD pp14_7 XI1445_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1441_MP50 (VDD XI1441_s1 XI1441_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1441_MP47 (XI1441_bp3 pp15_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1441_MP49 (XI1441_bsn XI1441_bcon XI1441_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1441_MP52 (XI1441_bp5 cm76_2 XI1441_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1441_MP51 (XI1441_bp4 pp15_4 XI1441_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1441_MP51_1 (XI1441_bp5 pp15_4 XI1441_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1441_MP52_1 (XI1441_bsn cm76_2 XI1441_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1441_MP54 (VDD XI1441_bsn cm80_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1441_MP41 (XI1441_bp1 XI1441_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1441_MP42 (XI1441_bcon pp15_4 XI1441_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1441_MP45 (XI1441_bp2 cm76_2 XI1441_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1441_MP43 (VDD XI1441_s1 XI1441_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1441_MP44 (XI1441_bp2 pp15_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1441_MP56 (VDD XI1441_bcon cm80_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1441_MP46 (XI1441_bp3 XI1441_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1441_MP48 (VDD cm76_2 XI1441_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1441_MP50_1 (XI1441_bp4 XI1441_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1441_MP26 (VDD XI1441_asn XI1441_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1441_MP18 (XI1441_ap3 pp12_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1441_MP21 (XI1441_asn XI1441_acon XI1441_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1441_MP24 (XI1441_ap5 pp14_6 XI1441_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1441_MP23 (XI1441_ap4 pp13_8 XI1441_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1441_MP22 (VDD pp12_10 XI1441_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1441_MP22_1 (XI1441_ap4 pp12_10 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1441_MP23_1 (XI1441_ap5 pp13_8 XI1441_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1441_MP24_1 (XI1441_asn pp14_6 XI1441_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1441_MP17 (XI1441_acon pp14_6 XI1441_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1441_MP14 (XI1441_ap1 pp13_8 XI1441_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1441_MP13 (VDD pp12_10 XI1441_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1441_MP15 (XI1441_ap2 pp12_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1441_MP16 (VDD pp13_8 XI1441_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1441_MP28 (cm80_2 XI1441_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1441_MP19 (XI1441_ap3 pp13_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1441_MP20 (VDD pp14_6 XI1441_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1492_MP50 (VDD XI1492_s1 XI1492_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1492_MP47 (XI1492_bp3 pp14_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1492_MP49 (XI1492_bsn XI1492_bcon XI1492_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1492_MP52 (XI1492_bp5 cm130_2 XI1492_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1492_MP51 (XI1492_bp4 pp14_27 XI1492_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1492_MP51_1 (XI1492_bp5 pp14_27 XI1492_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1492_MP52_1 (XI1492_bsn cm130_2 XI1492_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1492_MP54 (VDD XI1492_bsn cm131_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1492_MP41 (XI1492_bp1 XI1492_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1492_MP42 (XI1492_bcon pp14_27 XI1492_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1492_MP45 (XI1492_bp2 cm130_2 XI1492_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1492_MP43 (VDD XI1492_s1 XI1492_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1492_MP44 (XI1492_bp2 pp14_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1492_MP56 (VDD XI1492_bcon cm131_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1492_MP46 (XI1492_bp3 XI1492_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1492_MP48 (VDD cm130_2 XI1492_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1492_MP50_1 (XI1492_bp4 XI1492_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1492_MP26 (VDD XI1492_asn XI1492_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1492_MP18 (XI1492_ap3 sn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1492_MP21 (XI1492_asn XI1492_acon XI1492_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1492_MP24 (XI1492_ap5 pp13_29 XI1492_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1492_MP23 (XI1492_ap4 pp12_31 XI1492_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1492_MP22 (VDD sn11 XI1492_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1492_MP22_1 (XI1492_ap4 sn11 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1492_MP23_1 (XI1492_ap5 pp12_31 XI1492_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1492_MP24_1 (XI1492_asn pp13_29 XI1492_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1492_MP17 (XI1492_acon pp13_29 XI1492_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1492_MP14 (XI1492_ap1 pp12_31 XI1492_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1492_MP13 (VDD sn11 XI1492_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1492_MP15 (XI1492_ap2 sn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1492_MP16 (VDD pp12_31 XI1492_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1492_MP28 (cm131_2 XI1492_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1492_MP19 (XI1492_ap3 pp12_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1492_MP20 (VDD pp13_29 XI1492_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1430_MP50 (VDD XI1430_s1 XI1430_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1430_MP47 (XI1430_bp3 pp3_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1430_MP49 (XI1430_bsn XI1430_bcon XI1430_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1430_MP52 (XI1430_bp5 cm65_2 XI1430_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1430_MP51 (XI1430_bp4 pp3_26 XI1430_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1430_MP51_1 (XI1430_bp5 pp3_26 XI1430_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1430_MP52_1 (XI1430_bsn cm65_2 XI1430_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1430_MP54 (VDD XI1430_bsn cm69_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1430_MP41 (XI1430_bp1 XI1430_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1430_MP42 (XI1430_bcon pp3_26 XI1430_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1430_MP45 (XI1430_bp2 cm65_2 XI1430_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1430_MP43 (VDD XI1430_s1 XI1430_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1430_MP44 (XI1430_bp2 pp3_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1430_MP56 (VDD XI1430_bcon cm69_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1430_MP46 (XI1430_bp3 XI1430_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1430_MP48 (VDD cm65_2 XI1430_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1430_MP50_1 (XI1430_bp4 XI1430_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1430_MP26 (VDD XI1430_asn XI1430_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1430_MP18 (XI1430_ap3 pp0_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1430_MP21 (XI1430_asn XI1430_acon XI1430_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1430_MP24 (XI1430_ap5 pp2_28 XI1430_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1430_MP23 (XI1430_ap4 pp1_30 XI1430_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1430_MP22 (VDD pp0_32 XI1430_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1430_MP22_1 (XI1430_ap4 pp0_32 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1430_MP23_1 (XI1430_ap5 pp1_30 XI1430_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1430_MP24_1 (XI1430_asn pp2_28 XI1430_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1430_MP17 (XI1430_acon pp2_28 XI1430_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1430_MP14 (XI1430_ap1 pp1_30 XI1430_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1430_MP13 (VDD pp0_32 XI1430_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1430_MP15 (XI1430_ap2 pp0_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1430_MP16 (VDD pp1_30 XI1430_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1430_MP28 (cm69_2 XI1430_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1430_MP19 (XI1430_ap3 pp1_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1430_MP20 (VDD pp2_28 XI1430_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1533_MP50 (VDD XI1533_s1 XI1533_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1533_MP47 (XI1533_bp3 cm72_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1533_MP49 (XI1533_bsn XI1533_bcon XI1533_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1533_MP52 (XI1533_bp5 cm170_2 XI1533_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1533_MP51 (XI1533_bp4 cm72_0 XI1533_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1533_MP51_1 (XI1533_bp5 cm72_0 XI1533_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1533_MP52_1 (XI1533_bsn cm170_2 XI1533_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1533_MP54 (VDD XI1533_bsn cm172_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1533_MP41 (XI1533_bp1 XI1533_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1533_MP42 (XI1533_bcon cm72_0 XI1533_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1533_MP45 (XI1533_bp2 cm170_2 XI1533_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1533_MP43 (VDD XI1533_s1 XI1533_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1533_MP44 (XI1533_bp2 cm72_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1533_MP56 (VDD XI1533_bcon cm172_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1533_MP46 (XI1533_bp3 XI1533_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1533_MP48 (VDD cm170_2 XI1533_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1533_MP50_1 (XI1533_bp4 XI1533_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1533_MP26 (VDD XI1533_asn XI1533_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1533_MP18 (XI1533_ap3 cm69_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1533_MP21 (XI1533_asn XI1533_acon XI1533_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1533_MP24 (XI1533_ap5 cm71_0 XI1533_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1533_MP23 (XI1533_ap4 cm70_0 XI1533_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1533_MP22 (VDD cm69_0 XI1533_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1533_MP22_1 (XI1533_ap4 cm69_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1533_MP23_1 (XI1533_ap5 cm70_0 XI1533_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1533_MP24_1 (XI1533_asn cm71_0 XI1533_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1533_MP17 (XI1533_acon cm71_0 XI1533_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1533_MP14 (XI1533_ap1 cm70_0 XI1533_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1533_MP13 (VDD cm69_0 XI1533_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1533_MP15 (XI1533_ap2 cm69_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1533_MP16 (VDD cm70_0 XI1533_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1533_MP28 (cm172_2 XI1533_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1533_MP19 (XI1533_ap3 cm70_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1533_MP20 (VDD cm71_0 XI1533_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1534_MP50 (VDD XI1534_s1 XI1534_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1534_MP47 (XI1534_bp3 cm72_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1534_MP49 (XI1534_bsn XI1534_bcon XI1534_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1534_MP52 (XI1534_bp5 cm171_2 XI1534_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1534_MP51 (XI1534_bp4 cm72_1 XI1534_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1534_MP51_1 (XI1534_bp5 cm72_1 XI1534_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1534_MP52_1 (XI1534_bsn cm171_2 XI1534_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1534_MP54 (VDD XI1534_bsn cm173_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1534_MP41 (XI1534_bp1 XI1534_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1534_MP42 (XI1534_bcon cm72_1 XI1534_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1534_MP45 (XI1534_bp2 cm171_2 XI1534_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1534_MP43 (VDD XI1534_s1 XI1534_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1534_MP44 (XI1534_bp2 cm72_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1534_MP56 (VDD XI1534_bcon cm173_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1534_MP46 (XI1534_bp3 XI1534_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1534_MP48 (VDD cm171_2 XI1534_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1534_MP50_1 (XI1534_bp4 XI1534_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1534_MP26 (VDD XI1534_asn XI1534_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1534_MP18 (XI1534_ap3 cm69_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1534_MP21 (XI1534_asn XI1534_acon XI1534_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1534_MP24 (XI1534_ap5 cm71_1 XI1534_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1534_MP23 (XI1534_ap4 cm70_1 XI1534_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1534_MP22 (VDD cm69_1 XI1534_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1534_MP22_1 (XI1534_ap4 cm69_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1534_MP23_1 (XI1534_ap5 cm70_1 XI1534_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1534_MP24_1 (XI1534_asn cm71_1 XI1534_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1534_MP17 (XI1534_acon cm71_1 XI1534_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1534_MP14 (XI1534_ap1 cm70_1 XI1534_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1534_MP13 (VDD cm69_1 XI1534_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1534_MP15 (XI1534_ap2 cm69_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1534_MP16 (VDD cm70_1 XI1534_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1534_MP28 (cm173_2 XI1534_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1534_MP19 (XI1534_ap3 cm70_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1534_MP20 (VDD cm71_1 XI1534_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1432_MP50 (VDD XI1432_s1 XI1432_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1432_MP47 (XI1432_bp3 pp11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1432_MP49 (XI1432_bsn XI1432_bcon XI1432_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1432_MP52 (XI1432_bp5 cm67_2 XI1432_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1432_MP51 (XI1432_bp4 pp11_10 XI1432_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1432_MP51_1 (XI1432_bp5 pp11_10 XI1432_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1432_MP52_1 (XI1432_bsn cm67_2 XI1432_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1432_MP54 (VDD XI1432_bsn cm71_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1432_MP41 (XI1432_bp1 XI1432_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1432_MP42 (XI1432_bcon pp11_10 XI1432_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1432_MP45 (XI1432_bp2 cm67_2 XI1432_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1432_MP43 (VDD XI1432_s1 XI1432_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1432_MP44 (XI1432_bp2 pp11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1432_MP56 (VDD XI1432_bcon cm71_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1432_MP46 (XI1432_bp3 XI1432_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1432_MP48 (VDD cm67_2 XI1432_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1432_MP50_1 (XI1432_bp4 XI1432_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1432_MP26 (VDD XI1432_asn XI1432_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1432_MP18 (XI1432_ap3 pp8_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1432_MP21 (XI1432_asn XI1432_acon XI1432_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1432_MP24 (XI1432_ap5 pp10_12 XI1432_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1432_MP23 (XI1432_ap4 pp9_14 XI1432_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1432_MP22 (VDD pp8_16 XI1432_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1432_MP22_1 (XI1432_ap4 pp8_16 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1432_MP23_1 (XI1432_ap5 pp9_14 XI1432_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1432_MP24_1 (XI1432_asn pp10_12 XI1432_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1432_MP17 (XI1432_acon pp10_12 XI1432_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1432_MP14 (XI1432_ap1 pp9_14 XI1432_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1432_MP13 (VDD pp8_16 XI1432_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1432_MP15 (XI1432_ap2 pp8_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1432_MP16 (VDD pp9_14 XI1432_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1432_MP28 (cm71_2 XI1432_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1432_MP19 (XI1432_ap3 pp9_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1432_MP20 (VDD pp10_12 XI1432_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1437_MP50 (VDD XI1437_s1 XI1437_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1437_MP47 (XI1437_bp3 pp15_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1437_MP49 (XI1437_bsn XI1437_bcon XI1437_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1437_MP52 (XI1437_bp5 cm72_2 XI1437_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1437_MP51 (XI1437_bp4 pp15_3 XI1437_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1437_MP51_1 (XI1437_bp5 pp15_3 XI1437_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1437_MP52_1 (XI1437_bsn cm72_2 XI1437_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1437_MP54 (VDD XI1437_bsn cm76_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1437_MP41 (XI1437_bp1 XI1437_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1437_MP42 (XI1437_bcon pp15_3 XI1437_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1437_MP45 (XI1437_bp2 cm72_2 XI1437_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1437_MP43 (VDD XI1437_s1 XI1437_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1437_MP44 (XI1437_bp2 pp15_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1437_MP56 (VDD XI1437_bcon cm76_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1437_MP46 (XI1437_bp3 XI1437_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1437_MP48 (VDD cm72_2 XI1437_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1437_MP50_1 (XI1437_bp4 XI1437_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1437_MP26 (VDD XI1437_asn XI1437_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1437_MP18 (XI1437_ap3 pp12_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1437_MP21 (XI1437_asn XI1437_acon XI1437_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1437_MP24 (XI1437_ap5 pp14_5 XI1437_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1437_MP23 (XI1437_ap4 pp13_7 XI1437_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1437_MP22 (VDD pp12_9 XI1437_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1437_MP22_1 (XI1437_ap4 pp12_9 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1437_MP23_1 (XI1437_ap5 pp13_7 XI1437_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1437_MP24_1 (XI1437_asn pp14_5 XI1437_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1437_MP17 (XI1437_acon pp14_5 XI1437_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1437_MP14 (XI1437_ap1 pp13_7 XI1437_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1437_MP13 (VDD pp12_9 XI1437_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1437_MP15 (XI1437_ap2 pp12_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1437_MP16 (VDD pp13_7 XI1437_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1437_MP28 (cm76_2 XI1437_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1437_MP19 (XI1437_ap3 pp13_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1437_MP20 (VDD pp14_5 XI1437_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1494_MP50 (VDD XI1494_s1 XI1494_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1494_MP47 (XI1494_bp3 pp15_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1494_MP49 (XI1494_bsn XI1494_bcon XI1494_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1494_MP52 (XI1494_bp5 cm132_2 XI1494_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1494_MP51 (XI1494_bp4 pp15_27 XI1494_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1494_MP51_1 (XI1494_bp5 pp15_27 XI1494_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1494_MP52_1 (XI1494_bsn cm132_2 XI1494_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1494_MP54 (VDD XI1494_bsn cm133_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1494_MP41 (XI1494_bp1 XI1494_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1494_MP42 (XI1494_bcon pp15_27 XI1494_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1494_MP45 (XI1494_bp2 cm132_2 XI1494_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1494_MP43 (VDD XI1494_s1 XI1494_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1494_MP44 (XI1494_bp2 pp15_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1494_MP56 (VDD XI1494_bcon cm133_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1494_MP46 (XI1494_bp3 XI1494_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1494_MP48 (VDD cm132_2 XI1494_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1494_MP50_1 (XI1494_bp4 XI1494_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1494_MP26 (VDD XI1494_asn XI1494_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1494_MP18 (XI1494_ap3 sn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1494_MP21 (XI1494_asn XI1494_acon XI1494_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1494_MP24 (XI1494_ap5 pp14_29 XI1494_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1494_MP23 (XI1494_ap4 pp13_31 XI1494_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1494_MP22 (VDD sn12 XI1494_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1494_MP22_1 (XI1494_ap4 sn12 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1494_MP23_1 (XI1494_ap5 pp13_31 XI1494_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1494_MP24_1 (XI1494_asn pp14_29 XI1494_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1494_MP17 (XI1494_acon pp14_29 XI1494_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1494_MP14 (XI1494_ap1 pp13_31 XI1494_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1494_MP13 (VDD sn12 XI1494_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1494_MP15 (XI1494_ap2 sn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1494_MP16 (VDD pp13_31 XI1494_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1494_MP28 (cm133_2 XI1494_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1494_MP19 (XI1494_ap3 pp13_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1494_MP20 (VDD pp14_29 XI1494_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1493_MP50 (VDD XI1493_s1 XI1493_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1493_MP47 (XI1493_bp3 pp14_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1493_MP49 (XI1493_bsn XI1493_bcon XI1493_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1493_MP52 (XI1493_bp5 cm131_2 XI1493_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1493_MP51 (XI1493_bp4 pp14_28 XI1493_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1493_MP51_1 (XI1493_bp5 pp14_28 XI1493_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1493_MP52_1 (XI1493_bsn cm131_2 XI1493_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1493_MP54 (VDD XI1493_bsn cm132_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1493_MP41 (XI1493_bp1 XI1493_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1493_MP42 (XI1493_bcon pp14_28 XI1493_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1493_MP45 (XI1493_bp2 cm131_2 XI1493_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1493_MP43 (VDD XI1493_s1 XI1493_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1493_MP44 (XI1493_bp2 pp14_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1493_MP56 (VDD XI1493_bcon cm132_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1493_MP46 (XI1493_bp3 XI1493_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1493_MP48 (VDD cm131_2 XI1493_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1493_MP50_1 (XI1493_bp4 XI1493_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1493_MP26 (VDD XI1493_asn XI1493_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1493_MP18 (XI1493_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1493_MP21 (XI1493_asn XI1493_acon XI1493_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1493_MP24 (XI1493_ap5 pp13_30 XI1493_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1493_MP23 (XI1493_ap4 pp12_32 XI1493_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1493_MP22 (VDD VDD XI1493_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1493_MP22_1 (XI1493_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1493_MP23_1 (XI1493_ap5 pp12_32 XI1493_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1493_MP24_1 (XI1493_asn pp13_30 XI1493_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1493_MP17 (XI1493_acon pp13_30 XI1493_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1493_MP14 (XI1493_ap1 pp12_32 XI1493_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1493_MP13 (VDD VDD XI1493_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1493_MP15 (XI1493_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1493_MP16 (VDD pp12_32 XI1493_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1493_MP28 (cm132_2 XI1493_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1493_MP19 (XI1493_ap3 pp12_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1493_MP20 (VDD pp13_30 XI1493_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1427_MP50 (VDD XI1427_s1 XI1427_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1427_MP47 (XI1427_bp3 pp7_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1427_MP49 (XI1427_bsn XI1427_bcon XI1427_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1427_MP52 (XI1427_bp5 cm62_2 XI1427_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1427_MP51 (XI1427_bp4 pp7_17 XI1427_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1427_MP51_1 (XI1427_bp5 pp7_17 XI1427_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1427_MP52_1 (XI1427_bsn cm62_2 XI1427_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1427_MP54 (VDD XI1427_bsn cm66_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1427_MP41 (XI1427_bp1 XI1427_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1427_MP42 (XI1427_bcon pp7_17 XI1427_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1427_MP45 (XI1427_bp2 cm62_2 XI1427_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1427_MP43 (VDD XI1427_s1 XI1427_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1427_MP44 (XI1427_bp2 pp7_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1427_MP56 (VDD XI1427_bcon cm66_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1427_MP46 (XI1427_bp3 XI1427_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1427_MP48 (VDD cm62_2 XI1427_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1427_MP50_1 (XI1427_bp4 XI1427_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1427_MP26 (VDD XI1427_asn XI1427_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1427_MP18 (XI1427_ap3 pp4_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1427_MP21 (XI1427_asn XI1427_acon XI1427_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1427_MP24 (XI1427_ap5 pp6_19 XI1427_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1427_MP23 (XI1427_ap4 pp5_21 XI1427_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1427_MP22 (VDD pp4_23 XI1427_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1427_MP22_1 (XI1427_ap4 pp4_23 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1427_MP23_1 (XI1427_ap5 pp5_21 XI1427_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1427_MP24_1 (XI1427_asn pp6_19 XI1427_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1427_MP17 (XI1427_acon pp6_19 XI1427_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1427_MP14 (XI1427_ap1 pp5_21 XI1427_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1427_MP13 (VDD pp4_23 XI1427_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1427_MP15 (XI1427_ap2 pp4_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1427_MP16 (VDD pp5_21 XI1427_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1427_MP28 (cm66_2 XI1427_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1427_MP19 (XI1427_ap3 pp5_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1427_MP20 (VDD pp6_19 XI1427_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1532_MP50 (VDD XI1532_s1 XI1532_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1532_MP47 (XI1532_bp3 cm68_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1532_MP49 (XI1532_bsn XI1532_bcon XI1532_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1532_MP52 (XI1532_bp5 cm169_2 XI1532_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1532_MP51 (XI1532_bp4 cm68_1 XI1532_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1532_MP51_1 (XI1532_bp5 cm68_1 XI1532_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1532_MP52_1 (XI1532_bsn cm169_2 XI1532_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1532_MP54 (VDD XI1532_bsn cm171_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1532_MP41 (XI1532_bp1 XI1532_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1532_MP42 (XI1532_bcon cm68_1 XI1532_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1532_MP45 (XI1532_bp2 cm169_2 XI1532_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1532_MP43 (VDD XI1532_s1 XI1532_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1532_MP44 (XI1532_bp2 cm68_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1532_MP56 (VDD XI1532_bcon cm171_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1532_MP46 (XI1532_bp3 XI1532_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1532_MP48 (VDD cm169_2 XI1532_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1532_MP50_1 (XI1532_bp4 XI1532_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1532_MP26 (VDD XI1532_asn XI1532_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1532_MP18 (XI1532_ap3 cm65_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1532_MP21 (XI1532_asn XI1532_acon XI1532_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1532_MP24 (XI1532_ap5 cm67_1 XI1532_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1532_MP23 (XI1532_ap4 cm66_1 XI1532_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1532_MP22 (VDD cm65_1 XI1532_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1532_MP22_1 (XI1532_ap4 cm65_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1532_MP23_1 (XI1532_ap5 cm66_1 XI1532_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1532_MP24_1 (XI1532_asn cm67_1 XI1532_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1532_MP17 (XI1532_acon cm67_1 XI1532_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1532_MP14 (XI1532_ap1 cm66_1 XI1532_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1532_MP13 (VDD cm65_1 XI1532_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1532_MP15 (XI1532_ap2 cm65_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1532_MP16 (VDD cm66_1 XI1532_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1532_MP28 (cm171_2 XI1532_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1532_MP19 (XI1532_ap3 cm66_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1532_MP20 (VDD cm67_1 XI1532_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1588_MP50 (VDD XI1588_s1 XI1588_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1588_MP47 (XI1588_bp3 cm174_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1588_MP49 (XI1588_bsn XI1588_bcon XI1588_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1588_MP52 (XI1588_bp5 cm226_2 XI1588_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1588_MP51 (XI1588_bp4 cm174_0 XI1588_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1588_MP51_1 (XI1588_bp5 cm174_0 XI1588_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1588_MP52_1 (XI1588_bsn cm226_2 XI1588_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1588_MP54 (VDD XI1588_bsn cm227_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1588_MP41 (XI1588_bp1 XI1588_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1588_MP42 (XI1588_bcon cm174_0 XI1588_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1588_MP45 (XI1588_bp2 cm226_2 XI1588_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1588_MP43 (VDD XI1588_s1 XI1588_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1588_MP44 (XI1588_bp2 cm174_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1588_MP56 (VDD XI1588_bcon cm227_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1588_MP46 (XI1588_bp3 XI1588_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1588_MP48 (VDD cm226_2 XI1588_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1588_MP50_1 (XI1588_bp4 XI1588_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1588_MP26 (VDD XI1588_asn XI1588_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1588_MP18 (XI1588_ap3 cm171_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1588_MP21 (XI1588_asn XI1588_acon XI1588_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1588_MP24 (XI1588_ap5 cm173_0 XI1588_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1588_MP23 (XI1588_ap4 cm172_1 XI1588_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1588_MP22 (VDD cm171_1 XI1588_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1588_MP22_1 (XI1588_ap4 cm171_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1588_MP23_1 (XI1588_ap5 cm172_1 XI1588_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1588_MP24_1 (XI1588_asn cm173_0 XI1588_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1588_MP17 (XI1588_acon cm173_0 XI1588_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1588_MP14 (XI1588_ap1 cm172_1 XI1588_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1588_MP13 (VDD cm171_1 XI1588_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1588_MP15 (XI1588_ap2 cm171_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1588_MP16 (VDD cm172_1 XI1588_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1588_MP28 (cm227_2 XI1588_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1588_MP19 (XI1588_ap3 cm172_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1588_MP20 (VDD cm173_0 XI1588_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1433_MP50 (VDD XI1433_s1 XI1433_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1433_MP47 (XI1433_bp3 pp15_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1433_MP49 (XI1433_bsn XI1433_bcon XI1433_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1433_MP52 (XI1433_bp5 cm68_2 XI1433_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1433_MP51 (XI1433_bp4 pp15_2 XI1433_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1433_MP51_1 (XI1433_bp5 pp15_2 XI1433_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1433_MP52_1 (XI1433_bsn cm68_2 XI1433_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1433_MP54 (VDD XI1433_bsn cm72_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1433_MP41 (XI1433_bp1 XI1433_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1433_MP42 (XI1433_bcon pp15_2 XI1433_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1433_MP45 (XI1433_bp2 cm68_2 XI1433_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1433_MP43 (VDD XI1433_s1 XI1433_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1433_MP44 (XI1433_bp2 pp15_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1433_MP56 (VDD XI1433_bcon cm72_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1433_MP46 (XI1433_bp3 XI1433_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1433_MP48 (VDD cm68_2 XI1433_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1433_MP50_1 (XI1433_bp4 XI1433_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1433_MP26 (VDD XI1433_asn XI1433_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1433_MP18 (XI1433_ap3 pp12_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1433_MP21 (XI1433_asn XI1433_acon XI1433_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1433_MP24 (XI1433_ap5 pp14_4 XI1433_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1433_MP23 (XI1433_ap4 pp13_6 XI1433_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1433_MP22 (VDD pp12_8 XI1433_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1433_MP22_1 (XI1433_ap4 pp12_8 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1433_MP23_1 (XI1433_ap5 pp13_6 XI1433_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1433_MP24_1 (XI1433_asn pp14_4 XI1433_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1433_MP17 (XI1433_acon pp14_4 XI1433_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1433_MP14 (XI1433_ap1 pp13_6 XI1433_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1433_MP13 (VDD pp12_8 XI1433_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1433_MP15 (XI1433_ap2 pp12_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1433_MP16 (VDD pp13_6 XI1433_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1433_MP28 (cm72_2 XI1433_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1433_MP19 (XI1433_ap3 pp13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1433_MP20 (VDD pp14_4 XI1433_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1426_MP50 (VDD XI1426_s1 XI1426_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1426_MP47 (XI1426_bp3 pp3_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1426_MP49 (XI1426_bsn XI1426_bcon XI1426_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1426_MP52 (XI1426_bp5 cm61_2 XI1426_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1426_MP51 (XI1426_bp4 pp3_25 XI1426_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1426_MP51_1 (XI1426_bp5 pp3_25 XI1426_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1426_MP52_1 (XI1426_bsn cm61_2 XI1426_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1426_MP54 (VDD XI1426_bsn cm65_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1426_MP41 (XI1426_bp1 XI1426_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1426_MP42 (XI1426_bcon pp3_25 XI1426_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1426_MP45 (XI1426_bp2 cm61_2 XI1426_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1426_MP43 (VDD XI1426_s1 XI1426_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1426_MP44 (XI1426_bp2 pp3_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1426_MP56 (VDD XI1426_bcon cm65_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1426_MP46 (XI1426_bp3 XI1426_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1426_MP48 (VDD cm61_2 XI1426_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1426_MP50_1 (XI1426_bp4 XI1426_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1426_MP26 (VDD XI1426_asn XI1426_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1426_MP18 (XI1426_ap3 pp0_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1426_MP21 (XI1426_asn XI1426_acon XI1426_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1426_MP24 (XI1426_ap5 pp2_27 XI1426_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1426_MP23 (XI1426_ap4 pp1_29 XI1426_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1426_MP22 (VDD pp0_31 XI1426_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1426_MP22_1 (XI1426_ap4 pp0_31 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1426_MP23_1 (XI1426_ap5 pp1_29 XI1426_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1426_MP24_1 (XI1426_asn pp2_27 XI1426_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1426_MP17 (XI1426_acon pp2_27 XI1426_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1426_MP14 (XI1426_ap1 pp1_29 XI1426_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1426_MP13 (VDD pp0_31 XI1426_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1426_MP15 (XI1426_ap2 pp0_31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1426_MP16 (VDD pp1_29 XI1426_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1426_MP28 (cm65_2 XI1426_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1426_MP19 (XI1426_ap3 pp1_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1426_MP20 (VDD pp2_27 XI1426_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1531_MP50 (VDD XI1531_s1 XI1531_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1531_MP47 (XI1531_bp3 cm68_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1531_MP49 (XI1531_bsn XI1531_bcon XI1531_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1531_MP52 (XI1531_bp5 cm168_2 XI1531_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1531_MP51 (XI1531_bp4 cm68_0 XI1531_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1531_MP51_1 (XI1531_bp5 cm68_0 XI1531_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1531_MP52_1 (XI1531_bsn cm168_2 XI1531_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1531_MP54 (VDD XI1531_bsn cm170_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1531_MP41 (XI1531_bp1 XI1531_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1531_MP42 (XI1531_bcon cm68_0 XI1531_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1531_MP45 (XI1531_bp2 cm168_2 XI1531_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1531_MP43 (VDD XI1531_s1 XI1531_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1531_MP44 (XI1531_bp2 cm68_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1531_MP56 (VDD XI1531_bcon cm170_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1531_MP46 (XI1531_bp3 XI1531_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1531_MP48 (VDD cm168_2 XI1531_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1531_MP50_1 (XI1531_bp4 XI1531_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1531_MP26 (VDD XI1531_asn XI1531_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1531_MP18 (XI1531_ap3 cm65_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1531_MP21 (XI1531_asn XI1531_acon XI1531_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1531_MP24 (XI1531_ap5 cm67_0 XI1531_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1531_MP23 (XI1531_ap4 cm66_0 XI1531_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1531_MP22 (VDD cm65_0 XI1531_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1531_MP22_1 (XI1531_ap4 cm65_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1531_MP23_1 (XI1531_ap5 cm66_0 XI1531_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1531_MP24_1 (XI1531_asn cm67_0 XI1531_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1531_MP17 (XI1531_acon cm67_0 XI1531_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1531_MP14 (XI1531_ap1 cm66_0 XI1531_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1531_MP13 (VDD cm65_0 XI1531_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1531_MP15 (XI1531_ap2 cm65_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1531_MP16 (VDD cm66_0 XI1531_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1531_MP28 (cm170_2 XI1531_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1531_MP19 (XI1531_ap3 cm66_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1531_MP20 (VDD cm67_0 XI1531_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1587_MP50 (VDD XI1587_s1 XI1587_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1587_MP47 (XI1587_bp3 cm172_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1587_MP49 (XI1587_bsn XI1587_bcon XI1587_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1587_MP52 (XI1587_bp5 cm225_2 XI1587_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1587_MP51 (XI1587_bp4 cm172_0 XI1587_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1587_MP51_1 (XI1587_bp5 cm172_0 XI1587_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1587_MP52_1 (XI1587_bsn cm225_2 XI1587_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1587_MP54 (VDD XI1587_bsn cm226_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1587_MP41 (XI1587_bp1 XI1587_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1587_MP42 (XI1587_bcon cm172_0 XI1587_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1587_MP45 (XI1587_bp2 cm225_2 XI1587_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1587_MP43 (VDD XI1587_s1 XI1587_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1587_MP44 (XI1587_bp2 cm172_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1587_MP56 (VDD XI1587_bcon cm226_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1587_MP46 (XI1587_bp3 XI1587_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1587_MP48 (VDD cm225_2 XI1587_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1587_MP50_1 (XI1587_bp4 XI1587_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1587_MP26 (VDD XI1587_asn XI1587_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1587_MP18 (XI1587_ap3 cm169_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1587_MP21 (XI1587_asn XI1587_acon XI1587_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1587_MP24 (XI1587_ap5 cm171_0 XI1587_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1587_MP23 (XI1587_ap4 cm170_1 XI1587_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1587_MP22 (VDD cm169_1 XI1587_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1587_MP22_1 (XI1587_ap4 cm169_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1587_MP23_1 (XI1587_ap5 cm170_1 XI1587_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1587_MP24_1 (XI1587_asn cm171_0 XI1587_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1587_MP17 (XI1587_acon cm171_0 XI1587_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1587_MP14 (XI1587_ap1 cm170_1 XI1587_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1587_MP13 (VDD cm169_1 XI1587_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1587_MP15 (XI1587_ap2 cm169_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1587_MP16 (VDD cm170_1 XI1587_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1587_MP28 (cm226_2 XI1587_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1587_MP19 (XI1587_ap3 cm170_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1587_MP20 (VDD cm171_0 XI1587_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1428_MP50 (VDD XI1428_s1 XI1428_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1428_MP47 (XI1428_bp3 pp11_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1428_MP49 (XI1428_bsn XI1428_bcon XI1428_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1428_MP52 (XI1428_bp5 cm63_2 XI1428_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1428_MP51 (XI1428_bp4 pp11_9 XI1428_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1428_MP51_1 (XI1428_bp5 pp11_9 XI1428_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1428_MP52_1 (XI1428_bsn cm63_2 XI1428_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1428_MP54 (VDD XI1428_bsn cm67_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1428_MP41 (XI1428_bp1 XI1428_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1428_MP42 (XI1428_bcon pp11_9 XI1428_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1428_MP45 (XI1428_bp2 cm63_2 XI1428_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1428_MP43 (VDD XI1428_s1 XI1428_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1428_MP44 (XI1428_bp2 pp11_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1428_MP56 (VDD XI1428_bcon cm67_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1428_MP46 (XI1428_bp3 XI1428_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1428_MP48 (VDD cm63_2 XI1428_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1428_MP50_1 (XI1428_bp4 XI1428_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1428_MP26 (VDD XI1428_asn XI1428_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1428_MP18 (XI1428_ap3 pp8_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1428_MP21 (XI1428_asn XI1428_acon XI1428_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1428_MP24 (XI1428_ap5 pp10_11 XI1428_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1428_MP23 (XI1428_ap4 pp9_13 XI1428_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1428_MP22 (VDD pp8_15 XI1428_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1428_MP22_1 (XI1428_ap4 pp8_15 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1428_MP23_1 (XI1428_ap5 pp9_13 XI1428_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1428_MP24_1 (XI1428_asn pp10_11 XI1428_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1428_MP17 (XI1428_acon pp10_11 XI1428_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1428_MP14 (XI1428_ap1 pp9_13 XI1428_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1428_MP13 (VDD pp8_15 XI1428_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1428_MP15 (XI1428_ap2 pp8_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1428_MP16 (VDD pp9_13 XI1428_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1428_MP28 (cm67_2 XI1428_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1428_MP19 (XI1428_ap3 pp9_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1428_MP20 (VDD pp10_11 XI1428_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1429_MP50 (VDD XI1429_s1 XI1429_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1429_MP47 (XI1429_bp3 pp15_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1429_MP49 (XI1429_bsn XI1429_bcon XI1429_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1429_MP52 (XI1429_bp5 cm64_2 XI1429_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1429_MP51 (XI1429_bp4 pp15_1 XI1429_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1429_MP51_1 (XI1429_bp5 pp15_1 XI1429_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1429_MP52_1 (XI1429_bsn cm64_2 XI1429_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1429_MP54 (VDD XI1429_bsn cm68_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1429_MP41 (XI1429_bp1 XI1429_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1429_MP42 (XI1429_bcon pp15_1 XI1429_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1429_MP45 (XI1429_bp2 cm64_2 XI1429_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1429_MP43 (VDD XI1429_s1 XI1429_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1429_MP44 (XI1429_bp2 pp15_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1429_MP56 (VDD XI1429_bcon cm68_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1429_MP46 (XI1429_bp3 XI1429_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1429_MP48 (VDD cm64_2 XI1429_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1429_MP50_1 (XI1429_bp4 XI1429_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1429_MP26 (VDD XI1429_asn XI1429_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1429_MP18 (XI1429_ap3 pp12_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1429_MP21 (XI1429_asn XI1429_acon XI1429_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1429_MP24 (XI1429_ap5 pp14_3 XI1429_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1429_MP23 (XI1429_ap4 pp13_5 XI1429_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1429_MP22 (VDD pp12_7 XI1429_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1429_MP22_1 (XI1429_ap4 pp12_7 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1429_MP23_1 (XI1429_ap5 pp13_5 XI1429_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1429_MP24_1 (XI1429_asn pp14_3 XI1429_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1429_MP17 (XI1429_acon pp14_3 XI1429_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1429_MP14 (XI1429_ap1 pp13_5 XI1429_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1429_MP13 (VDD pp12_7 XI1429_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1429_MP15 (XI1429_ap2 pp12_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1429_MP16 (VDD pp13_5 XI1429_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1429_MP28 (cm68_2 XI1429_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1429_MP19 (XI1429_ap3 pp13_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1429_MP20 (VDD pp14_3 XI1429_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1495_MP50 (VDD XI1495_s1 XI1495_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1495_MP47 (XI1495_bp3 pp15_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1495_MP49 (XI1495_bsn XI1495_bcon XI1495_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1495_MP52 (XI1495_bp5 cm133_2 XI1495_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1495_MP51 (XI1495_bp4 pp15_28 XI1495_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1495_MP51_1 (XI1495_bp5 pp15_28 XI1495_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1495_MP52_1 (XI1495_bsn cm133_2 XI1495_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1495_MP54 (VDD XI1495_bsn cm134_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1495_MP41 (XI1495_bp1 XI1495_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1495_MP42 (XI1495_bcon pp15_28 XI1495_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1495_MP45 (XI1495_bp2 cm133_2 XI1495_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1495_MP43 (VDD XI1495_s1 XI1495_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1495_MP44 (XI1495_bp2 pp15_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1495_MP56 (VDD XI1495_bcon cm134_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1495_MP46 (XI1495_bp3 XI1495_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1495_MP48 (VDD cm133_2 XI1495_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1495_MP50_1 (XI1495_bp4 XI1495_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1495_MP26 (VDD XI1495_asn XI1495_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1495_MP18 (XI1495_ap3 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1495_MP21 (XI1495_asn XI1495_acon XI1495_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1495_MP24 (XI1495_ap5 pp14_30 XI1495_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1495_MP23 (XI1495_ap4 pp13_32 XI1495_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1495_MP22 (VDD VDD XI1495_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1495_MP22_1 (XI1495_ap4 VDD VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1495_MP23_1 (XI1495_ap5 pp13_32 XI1495_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
