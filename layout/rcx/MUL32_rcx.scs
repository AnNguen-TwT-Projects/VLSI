// MUL32 sau layout: Assura RCX -> layout/rcx2scs.py - khong sua tay
simulator lang=spectre
subckt MUL32 A_0 A_1 A_2 A_3 A_4 A_5 A_6 A_7 A_8 A_9 A_10 A_11 A_12 A_13 A_14 A_15 A_16 A_17 A_18 A_19 A_20 A_21 A_22 A_23 A_24 A_25 A_26 A_27 A_28 A_29 A_30 A_31 B_0 B_1 B_2 B_3 B_4 B_5 B_6 B_7 B_8 B_9 B_10 B_11 B_12 B_13 B_14 B_15 B_16 B_17 B_18 B_19 B_20 B_21 B_22 B_23 B_24 B_25 B_26 B_27 B_28 B_29 B_30 B_31 P_0 P_1 P_2 P_3 P_4 P_5 P_6 P_7 P_8 P_9 P_10 P_11 P_12 P_13 P_14 P_15 P_16 P_17 P_18 P_19 P_20 P_21 P_22 P_23 P_24 P_25 P_26 P_27 P_28 P_29 P_30 P_31 P_32 P_33 P_34 P_35 P_36 P_37 P_38 P_39 P_40 P_41 P_42 P_43 P_44 P_45 P_46 P_47 P_48 P_49 P_50 P_51 P_52 P_53 P_54 P_55 P_56 P_57 P_58 P_59 P_60 P_61 P_62 P_63 VDD VSS
    I_MXI931_MN1 (one8_b3_4 one8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI931_MN1_1 (VSS one8_b2_1 one8_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI941_MN1 (two8_b3_4 two8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI941_MN1_1 (VSS two8_b2_1 two8_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI272_MN1 (A_26_b2_0 A_26_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI272_MN1_1 (VSS A_26_b1_0 A_26_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI232_MN1 (A_22_b2_0 A_22_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI232_MN1_1 (VSS A_22_b1_0 A_22_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI207_MN1 (A_19_b3_3 A_19_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI207_MN1_1 (VSS A_19_b2_1 A_19_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI404_MN1 (B_17_b2_0 B_17_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI404_MN1_1 (VSS B_17_b1_0 B_17_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI262_MN1 (A_25_b2_0 A_25_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI262_MN1_1 (VSS A_25_b1_0 A_25_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI242_MN1 (A_23_b2_0 A_23_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI242_MN1_1 (VSS A_23_b1_0 A_23_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI298_MN1 (A_28_b3_4 A_28_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI298_MN1_1 (VSS A_28_b2_1 A_28_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI289_MN1 (A_27_b3_5 A_27_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI289_MN1_1 (VSS A_27_b2_1 A_27_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1325_MN1 (two15_b3_3 two15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1325_MN1_1 (VSS two15_b2_1 two15_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI318_MN1 (A_30_b3_4 A_30_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI318_MN1_1 (VSS A_30_b2_1 A_30_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI137_MN1 (A_12_b3_3 A_12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI137_MN1_1 (VSS A_12_b2_1 A_12_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI414_MN1 (B_19_b2_0 B_19_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI414_MN1_1 (VSS B_19_b1_0 B_19_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI710_MN1 (one4_b3_3 one4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI710_MN1_1 (VSS one4_b2_1 one4_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI185_MN1 (A_17_b3_1 A_17_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI185_MN1_1 (VSS A_17_b2_0 A_17_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI114_MN1 (A_10_b3_0 A_10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI114_MN1_1 (VSS A_10_b2_0 A_10_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI112_MN1 (A_10_b2_0 A_10_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI112_MN1_1 (VSS A_10_b1_0 A_10_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI347_MN1 (B_5_b3_1 B_5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI347_MN1_1 (VSS B_5_b2_0 B_5_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI84_MN1 (A_7_b3_0 A_7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI84_MN1_1 (VSS A_7_b2_0 A_7_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI74_MN1 (A_6_b3_0 A_6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI74_MN1_1 (VSS A_6_b2_0 A_6_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I107_MN1 (XI1660_I107_Bn fa287_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I107_MN5 (XI1660_I107_n2 fa287_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I107_MN4 (I1660_pn43 XI1660_I107_An XI1660_I107_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I107_MN2 (XI1660_I107_n1 ha286_1 I1660_pn43 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I107_MN3 (VSS XI1660_I107_Bn XI1660_I107_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I107_MN0 (XI1660_I107_An ha286_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I119_MN1 (XI1660_I119_Bn fa245_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I119_MN5 (XI1660_I119_n2 fa245_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I119_MN4 (I1660_pn55 XI1660_I119_An XI1660_I119_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I119_MN2 (XI1660_I119_n1 fa296_1 I1660_pn55 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I119_MN3 (VSS XI1660_I119_Bn XI1660_I119_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I119_MN0 (XI1660_I119_An fa296_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I102_MN1 (XI1660_I102_Bn ha282_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I102_MN5 (XI1660_I102_n2 ha282_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I102_MN4 (I1660_pn38 XI1660_I102_An XI1660_I102_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I102_MN2 (XI1660_I102_n1 fa281_1 I1660_pn38 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I102_MN3 (VSS XI1660_I102_Bn XI1660_I102_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I102_MN0 (XI1660_I102_An fa281_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I104_MN1 (XI1660_I104_Bn ha284_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I104_MN5 (XI1660_I104_n2 ha284_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I104_MN4 (I1660_pn40 XI1660_I104_An XI1660_I104_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I104_MN2 (XI1660_I104_n1 fa283_1 I1660_pn40 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I104_MN3 (VSS XI1660_I104_Bn XI1660_I104_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I104_MN0 (XI1660_I104_An fa283_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I106_MN1 (XI1660_I106_Bn ha286_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I106_MN5 (XI1660_I106_n2 ha286_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I106_MN4 (I1660_pn42 XI1660_I106_An XI1660_I106_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I106_MN2 (XI1660_I106_n1 fa285_1 I1660_pn42 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I106_MN3 (VSS XI1660_I106_Bn XI1660_I106_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I106_MN0 (XI1660_I106_An fa285_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I108_MN1 (XI1660_I108_Bn ha288_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I108_MN5 (XI1660_I108_n2 ha288_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I108_MN4 (I1660_pn44 XI1660_I108_An XI1660_I108_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I108_MN2 (XI1660_I108_n1 fa287_1 I1660_pn44 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I108_MN3 (VSS XI1660_I108_Bn XI1660_I108_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I108_MN0 (XI1660_I108_An fa287_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I110_MN1 (XI1660_I110_Bn ha290_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I110_MN5 (XI1660_I110_n2 ha290_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I110_MN4 (I1660_pn46 XI1660_I110_An XI1660_I110_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I110_MN2 (XI1660_I110_n1 fa289_1 I1660_pn46 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I110_MN3 (VSS XI1660_I110_Bn XI1660_I110_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I110_MN0 (XI1660_I110_An fa289_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I112_MN1 (XI1660_I112_Bn ha292_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I112_MN5 (XI1660_I112_n2 ha292_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I112_MN4 (I1660_pn48 XI1660_I112_An XI1660_I112_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I112_MN2 (XI1660_I112_n1 fa291_1 I1660_pn48 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I112_MN3 (VSS XI1660_I112_Bn XI1660_I112_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I112_MN0 (XI1660_I112_An fa291_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I117_MN1 (XI1660_I117_Bn fa244_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I117_MN5 (XI1660_I117_n2 fa244_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I117_MN4 (I1660_pn53 XI1660_I117_An XI1660_I117_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I117_MN2 (XI1660_I117_n1 fa295_1 I1660_pn53 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I117_MN3 (VSS XI1660_I117_Bn XI1660_I117_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I117_MN0 (XI1660_I117_An fa295_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I121_MN1 (XI1660_I121_Bn fa246_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I121_MN5 (XI1660_I121_n2 fa246_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I121_MN4 (I1660_pn57 XI1660_I121_An XI1660_I121_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I121_MN2 (XI1660_I121_n1 fa297_1 I1660_pn57 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I121_MN3 (VSS XI1660_I121_Bn XI1660_I121_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I121_MN0 (XI1660_I121_An fa297_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I103_MN1 (XI1660_I103_Bn fa283_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I103_MN5 (XI1660_I103_n2 fa283_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I103_MN4 (I1660_pn39 XI1660_I103_An XI1660_I103_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I103_MN2 (XI1660_I103_n1 ha282_1 I1660_pn39 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I103_MN3 (VSS XI1660_I103_Bn XI1660_I103_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I103_MN0 (XI1660_I103_An ha282_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I105_MN1 (XI1660_I105_Bn fa285_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I105_MN5 (XI1660_I105_n2 fa285_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I105_MN4 (I1660_pn41 XI1660_I105_An XI1660_I105_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I105_MN2 (XI1660_I105_n1 ha284_1 I1660_pn41 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I105_MN3 (VSS XI1660_I105_Bn XI1660_I105_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I105_MN0 (XI1660_I105_An ha284_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I109_MN1 (XI1660_I109_Bn fa289_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I109_MN5 (XI1660_I109_n2 fa289_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I109_MN4 (I1660_pn45 XI1660_I109_An XI1660_I109_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I109_MN2 (XI1660_I109_n1 ha288_1 I1660_pn45 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I109_MN3 (VSS XI1660_I109_Bn XI1660_I109_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I109_MN0 (XI1660_I109_An ha288_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I111_MN1 (XI1660_I111_Bn fa291_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I111_MN5 (XI1660_I111_n2 fa291_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I111_MN4 (I1660_pn47 XI1660_I111_An XI1660_I111_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I111_MN2 (XI1660_I111_n1 ha290_1 I1660_pn47 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I111_MN3 (VSS XI1660_I111_Bn XI1660_I111_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I111_MN0 (XI1660_I111_An ha290_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I123_MN1 (XI1660_I123_Bn fa207_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I123_MN5 (XI1660_I123_n2 fa207_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I123_MN4 (I1660_pn59 XI1660_I123_An XI1660_I123_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I123_MN2 (XI1660_I123_n1 fa298_1 I1660_pn59 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I123_MN3 (VSS XI1660_I123_Bn XI1660_I123_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I123_MN0 (XI1660_I123_An fa298_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I116_MN1 (XI1660_I116_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I116_MN5 (XI1660_I116_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I116_MN4 (I1660_pn52 XI1660_I116_An XI1660_I116_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I116_MN2 (XI1660_I116_n1 fa295_0 I1660_pn52 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I116_MN3 (VSS XI1660_I116_Bn XI1660_I116_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I116_MN0 (XI1660_I116_An fa295_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I118_MN1 (XI1660_I118_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I118_MN5 (XI1660_I118_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I118_MN4 (I1660_pn54 XI1660_I118_An XI1660_I118_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I118_MN2 (XI1660_I118_n1 fa296_0 I1660_pn54 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I118_MN3 (VSS XI1660_I118_Bn XI1660_I118_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I118_MN0 (XI1660_I118_An fa296_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I100_MN1 (XI1660_I100_Bn fa280_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I100_MN5 (XI1660_I100_n2 fa280_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I100_MN4 (I1660_pn36 XI1660_I100_An XI1660_I100_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I100_MN2 (XI1660_I100_n1 ha279_1 I1660_pn36 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I100_MN3 (VSS XI1660_I100_Bn XI1660_I100_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I100_MN0 (XI1660_I100_An ha279_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I101_MN1 (XI1660_I101_Bn fa281_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I101_MN5 (XI1660_I101_n2 fa281_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I101_MN4 (I1660_pn37 XI1660_I101_An XI1660_I101_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I101_MN2 (XI1660_I101_n1 fa280_1 I1660_pn37 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I101_MN3 (VSS XI1660_I101_Bn XI1660_I101_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I101_MN0 (XI1660_I101_An fa280_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I113_MN1 (XI1660_I113_Bn fa293_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I113_MN5 (XI1660_I113_n2 fa293_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I113_MN4 (I1660_pn49 XI1660_I113_An XI1660_I113_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I113_MN2 (XI1660_I113_n1 ha292_1 I1660_pn49 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I113_MN3 (VSS XI1660_I113_Bn XI1660_I113_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I113_MN0 (XI1660_I113_An ha292_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I114_MN1 (XI1660_I114_Bn ha294_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I114_MN5 (XI1660_I114_n2 ha294_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I114_MN4 (I1660_pn50 XI1660_I114_An XI1660_I114_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I114_MN2 (XI1660_I114_n1 fa293_1 I1660_pn50 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I114_MN3 (VSS XI1660_I114_Bn XI1660_I114_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I114_MN0 (XI1660_I114_An fa293_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I115_MN1 (XI1660_I115_Bn fa243_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I115_MN5 (XI1660_I115_n2 fa243_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I115_MN4 (I1660_pn51 XI1660_I115_An XI1660_I115_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I115_MN2 (XI1660_I115_n1 ha294_1 I1660_pn51 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I115_MN3 (VSS XI1660_I115_Bn XI1660_I115_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I115_MN0 (XI1660_I115_An ha294_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I99_MN1 (XI1660_I99_Bn ha279_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I99_MN5 (XI1660_I99_n2 ha279_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I99_MN4 (I1660_pn35 XI1660_I99_An XI1660_I99_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I99_MN2 (XI1660_I99_n1 ha278_1 I1660_pn35 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I99_MN3 (VSS XI1660_I99_Bn XI1660_I99_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I99_MN0 (XI1660_I99_An ha278_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I125_MN1 (XI1660_I125_Bn fa208_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I125_MN5 (XI1660_I125_n2 fa208_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I125_MN4 (I1660_pn61 XI1660_I125_An XI1660_I125_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I125_MN2 (XI1660_I125_n1 fa247_1 I1660_pn61 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I125_MN3 (VSS XI1660_I125_Bn XI1660_I125_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I125_MN0 (XI1660_I125_An fa247_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I122_MN1 (XI1660_I122_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I122_MN5 (XI1660_I122_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I122_MN4 (I1660_pn58 XI1660_I122_An XI1660_I122_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I122_MN2 (XI1660_I122_n1 fa298_0 I1660_pn58 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I122_MN3 (VSS XI1660_I122_Bn XI1660_I122_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I122_MN0 (XI1660_I122_An fa298_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I120_MN1 (XI1660_I120_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I120_MN5 (XI1660_I120_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I120_MN4 (I1660_pn56 XI1660_I120_An XI1660_I120_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I120_MN2 (XI1660_I120_n1 fa297_0 I1660_pn56 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I120_MN3 (VSS XI1660_I120_Bn XI1660_I120_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I120_MN0 (XI1660_I120_An fa297_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I98_MN1 (XI1660_I98_Bn ha278_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I98_MN5 (XI1660_I98_n2 ha278_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I98_MN4 (I1660_pn34 XI1660_I98_An XI1660_I98_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I98_MN2 (XI1660_I98_n1 ha277_1 I1660_pn34 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I98_MN3 (VSS XI1660_I98_Bn XI1660_I98_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I98_MN0 (XI1660_I98_An ha277_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I124_MN1 (XI1660_I124_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I124_MN5 (XI1660_I124_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I124_MN4 (I1660_pn60 XI1660_I124_An XI1660_I124_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I124_MN2 (XI1660_I124_n1 fa247_0 I1660_pn60 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I124_MN3 (VSS XI1660_I124_Bn XI1660_I124_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I124_MN0 (XI1660_I124_An fa247_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I96_MN1 (XI1660_I96_Bn ha276_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I96_MN5 (XI1660_I96_n2 ha276_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I96_MN4 (I1660_pn32 XI1660_I96_An XI1660_I96_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I96_MN2 (XI1660_I96_n1 ha275_1 I1660_pn32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I96_MN3 (VSS XI1660_I96_Bn XI1660_I96_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I96_MN0 (XI1660_I96_An ha275_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I97_MN1 (XI1660_I97_Bn ha277_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I97_MN5 (XI1660_I97_n2 ha277_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I97_MN4 (I1660_pn33 XI1660_I97_An XI1660_I97_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I97_MN2 (XI1660_I97_n1 ha276_1 I1660_pn33 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I97_MN3 (VSS XI1660_I97_Bn XI1660_I97_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I97_MN0 (XI1660_I97_An ha276_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I126_MN1 (XI1660_I126_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I126_MN5 (XI1660_I126_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I126_MN4 (I1660_pn62 XI1660_I126_An XI1660_I126_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I126_MN2 (XI1660_I126_n1 fa248_0 I1660_pn62 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I126_MN3 (VSS XI1660_I126_Bn XI1660_I126_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I126_MN0 (XI1660_I126_An fa248_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I127_MN1 (XI1660_I127_Bn sn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I127_MN5 (XI1660_I127_n2 sn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I127_MN4 (I1660_pn63 XI1660_I127_An XI1660_I127_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I127_MN2 (XI1660_I127_n1 fa248_1 I1660_pn63 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I127_MN3 (VSS XI1660_I127_Bn XI1660_I127_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I127_MN0 (XI1660_I127_An fa248_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I95_MN1 (XI1660_I95_Bn ha275_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I95_MN5 (XI1660_I95_n2 ha275_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I95_MN4 (I1660_pn31 XI1660_I95_An XI1660_I95_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I95_MN2 (XI1660_I95_n1 ha274_1 I1660_pn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I95_MN3 (VSS XI1660_I95_Bn XI1660_I95_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I95_MN0 (XI1660_I95_An ha274_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I94_MN1 (XI1660_I94_Bn ha274_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I94_MN5 (XI1660_I94_n2 ha274_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I94_MN4 (I1660_pn30 XI1660_I94_An XI1660_I94_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I94_MN2 (XI1660_I94_n1 ha273_1 I1660_pn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I94_MN3 (VSS XI1660_I94_Bn XI1660_I94_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I94_MN0 (XI1660_I94_An ha273_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I93_MN1 (XI1660_I93_Bn ha273_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I93_MN5 (XI1660_I93_n2 ha273_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I93_MN4 (I1660_pn29 XI1660_I93_An XI1660_I93_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I93_MN2 (XI1660_I93_n1 ha272_1 I1660_pn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I93_MN3 (VSS XI1660_I93_Bn XI1660_I93_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I93_MN0 (XI1660_I93_An ha272_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I496_MN1 (XI1660_I496_Bn I1660_G28_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I496_MN5 (XI1660_I496_n2 I1660_G28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I496_MN4 (P_29 XI1660_I496_An XI1660_I496_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I496_MN2 (XI1660_I496_n1 I1660_pn29 P_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I496_MN3 (VSS XI1660_I496_Bn XI1660_I496_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I496_MN0 (XI1660_I496_An I1660_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I498_MN1 (XI1660_I498_Bn I1660_G30_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I498_MN5 (XI1660_I498_n2 I1660_G30_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I498_MN4 (P_31 XI1660_I498_An XI1660_I498_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I498_MN2 (XI1660_I498_n1 I1660_pn31 P_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I498_MN3 (VSS XI1660_I498_Bn XI1660_I498_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I498_MN0 (XI1660_I498_An I1660_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I92_MN1 (XI1660_I92_Bn ha272_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I92_MN5 (XI1660_I92_n2 ha272_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I92_MN4 (I1660_pn28 XI1660_I92_An XI1660_I92_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I92_MN2 (XI1660_I92_n1 ha271_1 I1660_pn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I92_MN3 (VSS XI1660_I92_Bn XI1660_I92_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I92_MN0 (XI1660_I92_An ha271_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I91_MN1 (XI1660_I91_Bn ha271_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I91_MN5 (XI1660_I91_n2 ha271_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I91_MN4 (I1660_pn27 XI1660_I91_An XI1660_I91_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I91_MN2 (XI1660_I91_n1 ha270_1 I1660_pn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I91_MN3 (VSS XI1660_I91_Bn XI1660_I91_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I91_MN0 (XI1660_I91_An ha270_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I90_MN1 (XI1660_I90_Bn ha270_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I90_MN5 (XI1660_I90_n2 ha270_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I90_MN4 (I1660_pn26 XI1660_I90_An XI1660_I90_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I90_MN2 (XI1660_I90_n1 ha269_1 I1660_pn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I90_MN3 (VSS XI1660_I90_Bn XI1660_I90_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I90_MN0 (XI1660_I90_An ha269_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I494_MN1 (XI1660_I494_Bn I1660_G26_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I494_MN5 (XI1660_I494_n2 I1660_G26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I494_MN4 (P_27 XI1660_I494_An XI1660_I494_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I494_MN2 (XI1660_I494_n1 I1660_pn27 P_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I494_MN3 (VSS XI1660_I494_Bn XI1660_I494_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I494_MN0 (XI1660_I494_An I1660_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I497_MN1 (XI1660_I497_Bn I1660_G29_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I497_MN5 (XI1660_I497_n2 I1660_G29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I497_MN4 (P_30 XI1660_I497_An XI1660_I497_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I497_MN2 (XI1660_I497_n1 I1660_pn30 P_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I497_MN3 (VSS XI1660_I497_Bn XI1660_I497_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I497_MN0 (XI1660_I497_An I1660_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I88_MN1 (XI1660_I88_Bn ha268_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I88_MN5 (XI1660_I88_n2 ha268_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I88_MN4 (I1660_pn24 XI1660_I88_An XI1660_I88_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I88_MN2 (XI1660_I88_n1 ha267_1 I1660_pn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I88_MN3 (VSS XI1660_I88_Bn XI1660_I88_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I88_MN0 (XI1660_I88_An ha267_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I89_MN1 (XI1660_I89_Bn ha269_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I89_MN5 (XI1660_I89_n2 ha269_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I89_MN4 (I1660_pn25 XI1660_I89_An XI1660_I89_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I89_MN2 (XI1660_I89_n1 ha268_1 I1660_pn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I89_MN3 (VSS XI1660_I89_Bn XI1660_I89_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I89_MN0 (XI1660_I89_An ha268_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I87_MN1 (XI1660_I87_Bn ha267_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I87_MN5 (XI1660_I87_n2 ha267_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I87_MN4 (I1660_pn23 XI1660_I87_An XI1660_I87_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I87_MN2 (XI1660_I87_n1 ha266_1 I1660_pn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I87_MN3 (VSS XI1660_I87_Bn XI1660_I87_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I87_MN0 (XI1660_I87_An ha266_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I490_MN1 (XI1660_I490_Bn I1660_G22_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I490_MN5 (XI1660_I490_n2 I1660_G22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I490_MN4 (P_23 XI1660_I490_An XI1660_I490_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I490_MN2 (XI1660_I490_n1 I1660_pn23 P_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I490_MN3 (VSS XI1660_I490_Bn XI1660_I490_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I490_MN0 (XI1660_I490_An I1660_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I495_MN1 (XI1660_I495_Bn I1660_G27_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I495_MN5 (XI1660_I495_n2 I1660_G27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I495_MN4 (P_28 XI1660_I495_An XI1660_I495_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I495_MN2 (XI1660_I495_n1 I1660_pn28 P_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I495_MN3 (VSS XI1660_I495_Bn XI1660_I495_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I495_MN0 (XI1660_I495_An I1660_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I85_MN1 (XI1660_I85_Bn ha265_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I85_MN5 (XI1660_I85_n2 ha265_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I85_MN4 (I1660_pn21 XI1660_I85_An XI1660_I85_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I85_MN2 (XI1660_I85_n1 ha264_1 I1660_pn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I85_MN3 (VSS XI1660_I85_Bn XI1660_I85_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I85_MN0 (XI1660_I85_An ha264_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I86_MN1 (XI1660_I86_Bn ha266_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I86_MN5 (XI1660_I86_n2 ha266_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I86_MN4 (I1660_pn22 XI1660_I86_An XI1660_I86_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I86_MN2 (XI1660_I86_n1 ha265_1 I1660_pn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I86_MN3 (VSS XI1660_I86_Bn XI1660_I86_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I86_MN0 (XI1660_I86_An ha265_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I492_MN1 (XI1660_I492_Bn I1660_G24_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I492_MN5 (XI1660_I492_n2 I1660_G24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I492_MN4 (P_25 XI1660_I492_An XI1660_I492_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I492_MN2 (XI1660_I492_n1 I1660_pn25 P_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I492_MN3 (VSS XI1660_I492_Bn XI1660_I492_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I492_MN0 (XI1660_I492_An I1660_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I493_MN1 (XI1660_I493_Bn I1660_G25_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I493_MN5 (XI1660_I493_n2 I1660_G25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I493_MN4 (P_26 XI1660_I493_An XI1660_I493_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I493_MN2 (XI1660_I493_n1 I1660_pn26 P_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I493_MN3 (VSS XI1660_I493_Bn XI1660_I493_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I493_MN0 (XI1660_I493_An I1660_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I84_MN1 (XI1660_I84_Bn ha264_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I84_MN5 (XI1660_I84_n2 ha264_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I84_MN4 (I1660_pn20 XI1660_I84_An XI1660_I84_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I84_MN2 (XI1660_I84_n1 ha263_1 I1660_pn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I84_MN3 (VSS XI1660_I84_Bn XI1660_I84_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I84_MN0 (XI1660_I84_An ha263_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I499_MN1 (XI1660_I499_Bn I1660_G31_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I499_MN5 (XI1660_I499_n2 I1660_G31_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I499_MN4 (P_32 XI1660_I499_An XI1660_I499_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I499_MN2 (XI1660_I499_n1 I1660_pn32 P_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I499_MN3 (VSS XI1660_I499_Bn XI1660_I499_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I499_MN0 (XI1660_I499_An I1660_pn32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I83_MN1 (XI1660_I83_Bn ha263_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I83_MN5 (XI1660_I83_n2 ha263_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I83_MN4 (I1660_pn19 XI1660_I83_An XI1660_I83_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I83_MN2 (XI1660_I83_n1 ha262_1 I1660_pn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I83_MN3 (VSS XI1660_I83_Bn XI1660_I83_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I83_MN0 (XI1660_I83_An ha262_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I488_MN1 (XI1660_I488_Bn I1660_G20_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I488_MN5 (XI1660_I488_n2 I1660_G20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I488_MN4 (P_21 XI1660_I488_An XI1660_I488_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I488_MN2 (XI1660_I488_n1 I1660_pn21 P_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I488_MN3 (VSS XI1660_I488_Bn XI1660_I488_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I488_MN0 (XI1660_I488_An I1660_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I64_MN1 (XI1660_I64_Bn B_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I64_MN5 (XI1660_I64_n2 B_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I64_MN4 (I1660_pn0 XI1660_I64_An XI1660_I64_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I64_MN2 (XI1660_I64_n1 pp0_0 I1660_pn0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I64_MN3 (VSS XI1660_I64_Bn XI1660_I64_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I64_MN0 (XI1660_I64_An pp0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I82_MN1 (XI1660_I82_Bn ha262_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I82_MN5 (XI1660_I82_n2 ha262_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I82_MN4 (I1660_pn18 XI1660_I82_An XI1660_I82_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I82_MN2 (XI1660_I82_n1 ha261_1 I1660_pn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I82_MN3 (VSS XI1660_I82_Bn XI1660_I82_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I82_MN0 (XI1660_I82_An ha261_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I81_MN1 (XI1660_I81_Bn ha261_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I81_MN5 (XI1660_I81_n2 ha261_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I81_MN4 (I1660_pn17 XI1660_I81_An XI1660_I81_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I81_MN2 (XI1660_I81_n1 ha260_1 I1660_pn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I81_MN3 (VSS XI1660_I81_Bn XI1660_I81_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I81_MN0 (XI1660_I81_An ha260_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I486_MN1 (XI1660_I486_Bn I1660_G18_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I486_MN5 (XI1660_I486_n2 I1660_G18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I486_MN4 (P_19 XI1660_I486_An XI1660_I486_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I486_MN2 (XI1660_I486_n1 I1660_pn19 P_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I486_MN3 (VSS XI1660_I486_Bn XI1660_I486_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I486_MN0 (XI1660_I486_An I1660_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I489_MN1 (XI1660_I489_Bn I1660_G21_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I489_MN5 (XI1660_I489_n2 I1660_G21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I489_MN4 (P_22 XI1660_I489_An XI1660_I489_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I489_MN2 (XI1660_I489_n1 I1660_pn22 P_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I489_MN3 (VSS XI1660_I489_Bn XI1660_I489_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I489_MN0 (XI1660_I489_An I1660_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I467_MN1 (XI1660_I467_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I467_MN5 (XI1660_I467_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I467_MN4 (P_0 XI1660_I467_An XI1660_I467_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I467_MN2 (XI1660_I467_n1 I1660_pn0 P_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I467_MN3 (VSS XI1660_I467_Bn XI1660_I467_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I467_MN0 (XI1660_I467_An I1660_pn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I80_MN1 (XI1660_I80_Bn ha260_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I80_MN5 (XI1660_I80_n2 ha260_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I80_MN4 (I1660_pn16 XI1660_I80_An XI1660_I80_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I80_MN2 (XI1660_I80_n1 ha259_1 I1660_pn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I80_MN3 (VSS XI1660_I80_Bn XI1660_I80_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I80_MN0 (XI1660_I80_An ha259_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I484_MN1 (XI1660_I484_Bn I1660_G16_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I484_MN5 (XI1660_I484_n2 I1660_G16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I484_MN4 (P_17 XI1660_I484_An XI1660_I484_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I484_MN2 (XI1660_I484_n1 I1660_pn17 P_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I484_MN3 (VSS XI1660_I484_Bn XI1660_I484_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I484_MN0 (XI1660_I484_An I1660_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I491_MN1 (XI1660_I491_Bn I1660_G23_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I491_MN5 (XI1660_I491_n2 I1660_G23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I491_MN4 (P_24 XI1660_I491_An XI1660_I491_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I491_MN2 (XI1660_I491_n1 I1660_pn24 P_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I491_MN3 (VSS XI1660_I491_Bn XI1660_I491_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I491_MN0 (XI1660_I491_An I1660_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I487_MN1 (XI1660_I487_Bn I1660_G19_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I487_MN5 (XI1660_I487_n2 I1660_G19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I487_MN4 (P_20 XI1660_I487_An XI1660_I487_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I487_MN2 (XI1660_I487_n1 I1660_pn20 P_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I487_MN3 (VSS XI1660_I487_Bn XI1660_I487_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I487_MN0 (XI1660_I487_An I1660_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I79_MN1 (XI1660_I79_Bn ha259_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I79_MN5 (XI1660_I79_n2 ha259_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I79_MN4 (I1660_pn15 XI1660_I79_An XI1660_I79_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I79_MN2 (XI1660_I79_n1 ha258_1 I1660_pn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I79_MN3 (VSS XI1660_I79_Bn XI1660_I79_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I79_MN0 (XI1660_I79_An ha258_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I485_MN1 (XI1660_I485_Bn I1660_G17_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I485_MN5 (XI1660_I485_n2 I1660_G17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I485_MN4 (P_18 XI1660_I485_An XI1660_I485_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I485_MN2 (XI1660_I485_n1 I1660_pn18 P_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I485_MN3 (VSS XI1660_I485_Bn XI1660_I485_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I485_MN0 (XI1660_I485_An I1660_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I78_MN1 (XI1660_I78_Bn ha258_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I78_MN5 (XI1660_I78_n2 ha258_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I78_MN4 (I1660_pn14 XI1660_I78_An XI1660_I78_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I78_MN2 (XI1660_I78_n1 ha257_1 I1660_pn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I78_MN3 (VSS XI1660_I78_Bn XI1660_I78_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I78_MN0 (XI1660_I78_An ha257_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I65_MN1 (XI1660_I65_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I65_MN5 (XI1660_I65_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I65_MN4 (I1660_pn1 XI1660_I65_An XI1660_I65_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I65_MN2 (XI1660_I65_n1 pp0_1 I1660_pn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I65_MN3 (VSS XI1660_I65_Bn XI1660_I65_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I65_MN0 (XI1660_I65_An pp0_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I468_MN1 (XI1660_I468_Bn I1660_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I468_MN5 (XI1660_I468_n2 I1660_G0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I468_MN4 (P_1 XI1660_I468_An XI1660_I468_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I468_MN2 (XI1660_I468_n1 I1660_pn1 P_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I468_MN3 (VSS XI1660_I468_Bn XI1660_I468_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I468_MN0 (XI1660_I468_An I1660_pn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I77_MN1 (XI1660_I77_Bn ha257_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I77_MN5 (XI1660_I77_n2 ha257_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I77_MN4 (I1660_pn13 XI1660_I77_An XI1660_I77_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I77_MN2 (XI1660_I77_n1 ha256_1 I1660_pn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I77_MN3 (VSS XI1660_I77_Bn XI1660_I77_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I77_MN0 (XI1660_I77_An ha256_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I66_MN1 (XI1660_I66_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I66_MN5 (XI1660_I66_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I66_MN4 (I1660_pn2 XI1660_I66_An XI1660_I66_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I66_MN2 (XI1660_I66_n1 fa1_0 I1660_pn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I66_MN3 (VSS XI1660_I66_Bn XI1660_I66_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I66_MN0 (XI1660_I66_An fa1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I67_MN1 (XI1660_I67_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I67_MN5 (XI1660_I67_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I67_MN4 (I1660_pn3 XI1660_I67_An XI1660_I67_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I67_MN2 (XI1660_I67_n1 fa137_0 I1660_pn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I67_MN3 (VSS XI1660_I67_Bn XI1660_I67_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I67_MN0 (XI1660_I67_An fa137_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I76_MN1 (XI1660_I76_Bn ha256_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I76_MN5 (XI1660_I76_n2 ha256_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I76_MN4 (I1660_pn12 XI1660_I76_An XI1660_I76_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I76_MN2 (XI1660_I76_n1 ha255_1 I1660_pn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I76_MN3 (VSS XI1660_I76_Bn XI1660_I76_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I76_MN0 (XI1660_I76_An ha255_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I75_MN1 (XI1660_I75_Bn ha255_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I75_MN5 (XI1660_I75_n2 ha255_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I75_MN4 (I1660_pn11 XI1660_I75_An XI1660_I75_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I75_MN2 (XI1660_I75_n1 ha254_1 I1660_pn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I75_MN3 (VSS XI1660_I75_Bn XI1660_I75_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I75_MN0 (XI1660_I75_An ha254_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I70_MN1 (XI1660_I70_Bn ha250_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I70_MN5 (XI1660_I70_n2 ha250_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I70_MN4 (I1660_pn6 XI1660_I70_An XI1660_I70_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I70_MN2 (XI1660_I70_n1 fa249_1 I1660_pn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I70_MN3 (VSS XI1660_I70_Bn XI1660_I70_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I70_MN0 (XI1660_I70_An fa249_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I74_MN1 (XI1660_I74_Bn ha254_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I74_MN5 (XI1660_I74_n2 ha254_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I74_MN4 (I1660_pn10 XI1660_I74_An XI1660_I74_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I74_MN2 (XI1660_I74_n1 ha253_1 I1660_pn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I74_MN3 (VSS XI1660_I74_Bn XI1660_I74_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I74_MN0 (XI1660_I74_An ha253_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I73_MN1 (XI1660_I73_Bn ha253_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I73_MN5 (XI1660_I73_n2 ha253_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I73_MN4 (I1660_pn9 XI1660_I73_An XI1660_I73_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I73_MN2 (XI1660_I73_n1 ha252_1 I1660_pn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I73_MN3 (VSS XI1660_I73_Bn XI1660_I73_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I73_MN0 (XI1660_I73_An ha252_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I72_MN1 (XI1660_I72_Bn ha252_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I72_MN5 (XI1660_I72_n2 ha252_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I72_MN4 (I1660_pn8 XI1660_I72_An XI1660_I72_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I72_MN2 (XI1660_I72_n1 ha251_1 I1660_pn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I72_MN3 (VSS XI1660_I72_Bn XI1660_I72_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I72_MN0 (XI1660_I72_An ha251_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I71_MN1 (XI1660_I71_Bn ha251_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I71_MN5 (XI1660_I71_n2 ha251_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I71_MN4 (I1660_pn7 XI1660_I71_An XI1660_I71_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I71_MN2 (XI1660_I71_n1 ha250_1 I1660_pn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I71_MN3 (VSS XI1660_I71_Bn XI1660_I71_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I71_MN0 (XI1660_I71_An ha250_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I472_MN1 (XI1660_I472_Bn I1660_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I472_MN5 (XI1660_I472_n2 I1660_G4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I472_MN4 (P_5 XI1660_I472_An XI1660_I472_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I472_MN2 (XI1660_I472_n1 I1660_pn5 P_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I472_MN3 (VSS XI1660_I472_Bn XI1660_I472_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I472_MN0 (XI1660_I472_An I1660_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I69_MN1 (XI1660_I69_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I69_MN5 (XI1660_I69_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I69_MN4 (I1660_pn5 XI1660_I69_An XI1660_I69_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I69_MN2 (XI1660_I69_n1 fa249_0 I1660_pn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I69_MN3 (VSS XI1660_I69_Bn XI1660_I69_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I69_MN0 (XI1660_I69_An fa249_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I68_MN1 (XI1660_I68_Bn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I68_MN5 (XI1660_I68_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I68_MN4 (I1660_pn4 XI1660_I68_An XI1660_I68_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I68_MN2 (XI1660_I68_n1 fa209_0 I1660_pn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I68_MN3 (VSS XI1660_I68_Bn XI1660_I68_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I68_MN0 (XI1660_I68_An fa209_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I474_MN1 (XI1660_I474_Bn I1660_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I474_MN5 (XI1660_I474_n2 I1660_G6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I474_MN4 (P_7 XI1660_I474_An XI1660_I474_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I474_MN2 (XI1660_I474_n1 I1660_pn7 P_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I474_MN3 (VSS XI1660_I474_Bn XI1660_I474_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I474_MN0 (XI1660_I474_An I1660_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I469_MN1 (XI1660_I469_Bn I1660_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I469_MN5 (XI1660_I469_n2 I1660_G1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I469_MN4 (P_2 XI1660_I469_An XI1660_I469_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I469_MN2 (XI1660_I469_n1 I1660_pn2 P_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I469_MN3 (VSS XI1660_I469_Bn XI1660_I469_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I469_MN0 (XI1660_I469_An I1660_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I473_MN1 (XI1660_I473_Bn I1660_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I473_MN5 (XI1660_I473_n2 I1660_G5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I473_MN4 (P_6 XI1660_I473_An XI1660_I473_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I473_MN2 (XI1660_I473_n1 I1660_pn6 P_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I473_MN3 (VSS XI1660_I473_Bn XI1660_I473_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I473_MN0 (XI1660_I473_An I1660_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I475_MN1 (XI1660_I475_Bn I1660_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I475_MN5 (XI1660_I475_n2 I1660_G7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1660_I475_MN4 (P_8 XI1660_I475_An XI1660_I475_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I475_MN2 (XI1660_I475_n1 I1660_pn8 P_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1660_I475_MN3 (VSS XI1660_I475_Bn XI1660_I475_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I475_MN0 (XI1660_I475_An I1660_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI413_MN1 (B_19_b1_0 B_19_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI413_MN1_1 (VSS B_19_b0 B_19_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI415_MN1 (B_19_b2_1 B_19_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI415_MN1_1 (VSS B_19_b1_0 B_19_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI423_MN1 (B_21_b1_0 B_21_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI423_MN1_1 (VSS B_21_b0 B_21_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI411_MN1 (B_17_b3_5 B_17_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI411_MN1_1 (VSS B_17_b2_1 B_17_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI997_MN1 (two9_b3_5 two9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI997_MN1_1 (VSS two9_b2_1 two9_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI421_MN1 (B_19_b3_5 B_19_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI421_MN1_1 (VSS B_19_b2_1 B_19_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI987_MN1 (one9_b3_5 one9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI987_MN1_1 (VSS one9_b2_1 one9_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI887_MN1 (two7_b3_5 two7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI887_MN1_1 (VSS two7_b2_1 two7_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI251_MN1 (A_24_b1_0 A_24_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI251_MN1_1 (VSS A_24_b0 A_24_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI985_MN1 (one9_b3_3 one9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI985_MN1_1 (VSS one9_b2_1 one9_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI403_MN1 (B_17_b1_0 B_17_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI403_MN1_1 (VSS B_17_b0 B_17_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI409_MN1 (B_17_b3_3 B_17_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI409_MN1_1 (VSS B_17_b2_1 B_17_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI405_MN1 (B_17_b2_1 B_17_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI405_MN1_1 (VSS B_17_b1_0 B_17_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI932_MN1 (one8_b3_5 one8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI932_MN1_1 (VSS one8_b2_1 one8_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI942_MN1 (two8_b3_5 two8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI942_MN1_1 (VSS two8_b2_1 two8_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI419_MN1 (B_19_b3_3 B_19_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI419_MN1_1 (VSS B_19_b2_1 B_19_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI995_MN1 (two9_b3_3 two9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI995_MN1_1 (VSS two9_b2_1 two9_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI996_MN1 (two9_b3_4 two9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI996_MN1_1 (VSS two9_b2_1 two9_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI410_MN1 (B_17_b3_4 B_17_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI410_MN1_1 (VSS B_17_b2_1 B_17_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI991_MN1 (two9_b2_1 two9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI991_MN1_1 (VSS two9_b1_0 two9_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI986_MN1 (one9_b3_4 one9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI986_MN1_1 (VSS one9_b2_1 one9_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI420_MN1 (B_19_b3_4 B_19_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI420_MN1_1 (VSS B_19_b2_1 B_19_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI876_MN1 (one7_b3_4 one7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI876_MN1_1 (VSS one7_b2_1 one7_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI877_MN1 (one7_b3_5 one7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI877_MN1_1 (VSS one7_b2_1 one7_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI886_MN1 (two7_b3_4 two7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI886_MN1_1 (VSS two7_b2_1 two7_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI241_MN1 (A_23_b1_0 A_23_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI241_MN1_1 (VSS A_23_b0 A_23_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI327_MN1 (A_31_b3_3 A_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI327_MN1_1 (VSS A_31_b2_0 A_31_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI981_MN1 (one9_b2_1 one9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI981_MN1_1 (VSS one9_b1_0 one9_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI277_MN1 (A_26_b3_3 A_26_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI277_MN1_1 (VSS A_26_b2_1 A_26_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI287_MN1 (A_27_b3_3 A_27_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI287_MN1_1 (VSS A_27_b2_1 A_27_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI832_MN1 (two6_b3_5 two6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI832_MN1_1 (VSS two6_b2_1 two6_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI400_MN1 (B_15_b3_4 B_15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI400_MN1_1 (VSS B_15_b2_1 B_15_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI191_MN1 (A_18_b1_0 A_18_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI191_MN1_1 (VSS A_18_b0 A_18_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI316_MN1 (A_30_b3_2 A_30_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI316_MN1_1 (VSS A_30_b2_0 A_30_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI261_MN1 (A_25_b1_0 A_25_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI261_MN1_1 (VSS A_25_b0 A_25_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI227_MN1 (A_21_b3_3 A_21_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI227_MN1_1 (VSS A_21_b2_1 A_21_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1050_MN1 (two10_b3_3 two10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1050_MN1_1 (VSS two10_b2_1 two10_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1040_MN1 (one10_b3_3 one10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1040_MN1_1 (VSS one10_b2_1 one10_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI425_MN1 (B_21_b2_1 B_21_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI425_MN1_1 (VSS B_21_b1_0 B_21_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI429_MN1 (B_21_b3_3 B_21_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI429_MN1_1 (VSS B_21_b2_1 B_21_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI430_MN1 (B_21_b3_4 B_21_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI430_MN1_1 (VSS B_21_b2_1 B_21_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI431_MN1 (B_21_b3_5 B_21_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI431_MN1_1 (VSS B_21_b2_1 B_21_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1036_MN1 (one10_b2_1 one10_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1036_MN1_1 (VSS one10_b1_0 one10_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI247_MN1 (A_23_b3_3 A_23_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI247_MN1_1 (VSS A_23_b2_1 A_23_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1046_MN1 (two10_b2_1 two10_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1046_MN1_1 (VSS two10_b1_0 two10_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1041_MN1 (one10_b3_4 one10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1041_MN1_1 (VSS one10_b2_1 one10_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1051_MN1 (two10_b3_4 two10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1051_MN1_1 (VSS two10_b2_1 two10_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI257_MN1 (A_24_b3_3 A_24_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI257_MN1_1 (VSS A_24_b2_1 A_24_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI267_MN1 (A_25_b3_3 A_25_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI267_MN1_1 (VSS A_25_b2_1 A_25_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1042_MN1 (one10_b3_5 one10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1042_MN1_1 (VSS one10_b2_1 one10_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1052_MN1 (two10_b3_5 two10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1052_MN1_1 (VSS two10_b2_1 two10_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI822_MN1 (one6_b3_5 one6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI822_MN1_1 (VSS one6_b2_1 one6_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI399_MN1 (B_15_b3_3 B_15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI399_MN1_1 (VSS B_15_b2_1 B_15_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI401_MN1 (B_15_b3_5 B_15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI401_MN1_1 (VSS B_15_b2_1 B_15_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI326_MN1 (A_31_b3_2 A_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI326_MN1_1 (VSS A_31_b2_0 A_31_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI306_MN1 (A_29_b3_2 A_29_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI306_MN1_1 (VSS A_29_b2_0 A_29_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI271_MN1 (A_26_b1_0 A_26_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI271_MN1_1 (VSS A_26_b0 A_26_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI231_MN1 (A_22_b1_0 A_22_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI231_MN1_1 (VSS A_22_b0 A_22_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI263_MN1 (A_25_b2_1 A_25_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI263_MN1_1 (VSS A_25_b1_0 A_25_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI233_MN1 (A_22_b2_1 A_22_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI233_MN1_1 (VSS A_22_b1_0 A_22_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI243_MN1 (A_23_b2_1 A_23_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI243_MN1_1 (VSS A_23_b1_0 A_23_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI282_MN1 (A_27_b2_0 A_27_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI282_MN1_1 (VSS A_27_b1_0 A_27_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI930_MN1 (one8_b3_3 one8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI930_MN1_1 (VSS one8_b2_1 one8_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI940_MN1 (two8_b3_3 two8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI940_MN1_1 (VSS two8_b2_1 two8_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI253_MN1 (A_24_b2_1 A_24_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI253_MN1_1 (VSS A_24_b1_0 A_24_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI237_MN1 (A_22_b3_3 A_22_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI237_MN1_1 (VSS A_22_b2_1 A_22_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI221_MN1 (A_21_b1_0 A_21_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI221_MN1_1 (VSS A_21_b0 A_21_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI395_MN1 (B_15_b2_1 B_15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI395_MN1_1 (VSS B_15_b1_0 B_15_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI821_MN1 (one6_b3_4 one6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI821_MN1_1 (VSS one6_b2_1 one6_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI831_MN1 (two6_b3_4 two6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI831_MN1_1 (VSS two6_b2_1 two6_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI315_MN1 (A_30_b3_1 A_30_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI315_MN1_1 (VSS A_30_b2_0 A_30_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI223_MN1 (A_21_b2_1 A_21_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI223_MN1_1 (VSS A_21_b1_0 A_21_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI217_MN1 (A_20_b3_3 A_20_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI217_MN1_1 (VSS A_20_b2_1 A_20_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI197_MN1 (A_18_b3_3 A_18_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI197_MN1_1 (VSS A_18_b2_1 A_18_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI187_MN1 (A_17_b3_3 A_17_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI187_MN1_1 (VSS A_17_b2_1 A_17_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI926_MN1 (one8_b2_1 one8_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI926_MN1_1 (VSS one8_b1_0 one8_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI936_MN1 (two8_b2_1 two8_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI936_MN1_1 (VSS two8_b1_0 two8_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI273_MN1 (A_26_b2_1 A_26_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI273_MN1_1 (VSS A_26_b1_0 A_26_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI218_MN1 (A_20_b3_4 A_20_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI218_MN1_1 (VSS A_20_b2_1 A_20_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI228_MN1 (A_21_b3_4 A_21_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI228_MN1_1 (VSS A_21_b2_1 A_21_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI219_MN1 (A_20_b3_5 A_20_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI219_MN1_1 (VSS A_20_b2_1 A_20_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI238_MN1 (A_22_b3_4 A_22_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI238_MN1_1 (VSS A_22_b2_1 A_22_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI258_MN1 (A_24_b3_4 A_24_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI258_MN1_1 (VSS A_24_b2_1 A_24_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI268_MN1 (A_25_b3_4 A_25_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI268_MN1_1 (VSS A_25_b2_1 A_25_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI393_MN1 (B_15_b1_0 B_15_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI393_MN1_1 (VSS B_15_b0 B_15_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI394_MN1 (B_15_b2_0 B_15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI394_MN1_1 (VSS B_15_b1_0 B_15_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI391_MN1 (B_13_b3_5 B_13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI391_MN1_1 (VSS B_13_b2_1 B_13_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI390_MN1 (B_13_b3_4 B_13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI390_MN1_1 (VSS B_13_b2_1 B_13_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI777_MN1 (two5_b3_5 two5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI777_MN1_1 (VSS two5_b2_1 two5_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI767_MN1 (one5_b3_5 one5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI767_MN1_1 (VSS one5_b2_1 one5_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI236_MN1 (A_22_b3_2 A_22_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI236_MN1_1 (VSS A_22_b2_0 A_22_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI276_MN1 (A_26_b3_2 A_26_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI276_MN1_1 (VSS A_26_b2_0 A_26_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI286_MN1 (A_27_b3_2 A_27_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI286_MN1_1 (VSS A_27_b2_0 A_27_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI296_MN1 (A_28_b3_2 A_28_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI296_MN1_1 (VSS A_28_b2_0 A_28_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI305_MN1 (A_29_b3_1 A_29_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI305_MN1_1 (VSS A_29_b2_0 A_29_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI193_MN1 (A_18_b2_1 A_18_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI193_MN1_1 (VSS A_18_b1_0 A_18_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI203_MN1 (A_19_b2_1 A_19_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI203_MN1_1 (VSS A_19_b1_0 A_19_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI213_MN1 (A_20_b2_1 A_20_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI213_MN1_1 (VSS A_20_b1_0 A_20_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI281_MN1 (A_27_b1_0 A_27_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI281_MN1_1 (VSS A_27_b0 A_27_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI283_MN1 (A_27_b2_1 A_27_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI283_MN1_1 (VSS A_27_b1_0 A_27_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI198_MN1 (A_18_b3_4 A_18_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI198_MN1_1 (VSS A_18_b2_1 A_18_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI199_MN1 (A_18_b3_5 A_18_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI199_MN1_1 (VSS A_18_b2_1 A_18_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI229_MN1 (A_21_b3_5 A_21_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI229_MN1_1 (VSS A_21_b2_1 A_21_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1161_MN1 (two12_b3_4 two12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1161_MN1_1 (VSS two12_b2_1 two12_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI248_MN1 (A_23_b3_4 A_23_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI248_MN1_1 (VSS A_23_b2_1 A_23_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI239_MN1 (A_22_b3_5 A_22_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI239_MN1_1 (VSS A_22_b2_1 A_22_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI259_MN1 (A_24_b3_5 A_24_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI259_MN1_1 (VSS A_24_b2_1 A_24_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI278_MN1 (A_26_b3_4 A_26_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI278_MN1_1 (VSS A_26_b2_1 A_26_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI249_MN1 (A_23_b3_5 A_23_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI249_MN1_1 (VSS A_23_b2_1 A_23_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI383_MN1 (B_13_b1_0 B_13_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI383_MN1_1 (VSS B_13_b0 B_13_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI385_MN1 (B_13_b2_1 B_13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI385_MN1_1 (VSS B_13_b1_0 B_13_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI389_MN1 (B_13_b3_3 B_13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI389_MN1_1 (VSS B_13_b2_1 B_13_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI776_MN1 (two5_b3_4 two5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI776_MN1_1 (VSS two5_b2_1 two5_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI766_MN1 (one5_b3_4 one5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI766_MN1_1 (VSS one5_b2_1 one5_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI246_MN1 (A_23_b3_2 A_23_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI246_MN1_1 (VSS A_23_b2_0 A_23_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI266_MN1 (A_25_b3_2 A_25_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI266_MN1_1 (VSS A_25_b2_0 A_25_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI285_MN1 (A_27_b3_1 A_27_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI285_MN1_1 (VSS A_27_b2_0 A_27_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI274_MN1 (A_26_b3_0 A_26_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI274_MN1_1 (VSS A_26_b2_0 A_26_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI252_MN1 (A_24_b2_0 A_24_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI252_MN1_1 (VSS A_24_b1_0 A_24_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI292_MN1 (A_28_b2_0 A_28_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI292_MN1_1 (VSS A_28_b1_0 A_28_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI208_MN1 (A_19_b3_4 A_19_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI208_MN1_1 (VSS A_19_b2_1 A_19_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI291_MN1 (A_28_b1_0 A_28_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI291_MN1_1 (VSS A_28_b0 A_28_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1150_MN1 (one12_b3_3 one12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1150_MN1_1 (VSS one12_b2_1 one12_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1160_MN1 (two12_b3_3 two12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1160_MN1_1 (VSS two12_b2_1 two12_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI293_MN1 (A_28_b2_1 A_28_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI293_MN1_1 (VSS A_28_b1_0 A_28_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI209_MN1 (A_19_b3_5 A_19_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI209_MN1_1 (VSS A_19_b2_1 A_19_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1151_MN1 (one12_b3_4 one12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1151_MN1_1 (VSS one12_b2_1 one12_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI297_MN1 (A_28_b3_3 A_28_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI297_MN1_1 (VSS A_28_b2_1 A_28_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI269_MN1 (A_25_b3_5 A_25_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI269_MN1_1 (VSS A_25_b2_1 A_25_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI288_MN1 (A_27_b3_4 A_27_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI288_MN1_1 (VSS A_27_b2_1 A_27_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI279_MN1 (A_26_b3_5 A_26_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI279_MN1_1 (VSS A_26_b2_1 A_26_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI201_MN1 (A_19_b1_0 A_19_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI201_MN1_1 (VSS A_19_b0 A_19_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI211_MN1 (A_20_b1_0 A_20_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI211_MN1_1 (VSS A_20_b0 A_20_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI275_MN1 (A_26_b3_1 A_26_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI275_MN1_1 (VSS A_26_b2_0 A_26_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI222_MN1 (A_21_b2_0 A_21_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI222_MN1_1 (VSS A_21_b1_0 A_21_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI256_MN1 (A_24_b3_2 A_24_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI256_MN1_1 (VSS A_24_b2_0 A_24_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI245_MN1 (A_23_b3_1 A_23_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI245_MN1_1 (VSS A_23_b2_0 A_23_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI255_MN1 (A_24_b3_1 A_24_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI255_MN1_1 (VSS A_24_b2_0 A_24_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI244_MN1 (A_23_b3_0 A_23_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI244_MN1_1 (VSS A_23_b2_0 A_23_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI284_MN1 (A_27_b3_0 A_27_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI284_MN1_1 (VSS A_27_b2_0 A_27_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI177_MN1 (A_16_b3_3 A_16_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI177_MN1_1 (VSS A_16_b2_1 A_16_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI178_MN1 (A_16_b3_4 A_16_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI178_MN1_1 (VSS A_16_b2_1 A_16_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI312_MN1 (A_30_b2_0 A_30_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI312_MN1_1 (VSS A_30_b1_0 A_30_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI188_MN1 (A_17_b3_4 A_17_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI188_MN1_1 (VSS A_17_b2_1 A_17_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1095_MN1 (one11_b3_3 one11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1095_MN1_1 (VSS one11_b2_1 one11_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1105_MN1 (two11_b3_3 two11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1105_MN1_1 (VSS two11_b2_1 two11_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI189_MN1 (A_17_b3_5 A_17_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI189_MN1_1 (VSS A_17_b2_1 A_17_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI311_MN1 (A_30_b1_0 A_30_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI311_MN1_1 (VSS A_30_b0 A_30_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1215_MN1 (two13_b3_3 two13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1215_MN1_1 (VSS two13_b2_1 two13_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI439_MN1 (B_23_b3_3 B_23_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI439_MN1_1 (VSS B_23_b2_1 B_23_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI313_MN1 (A_30_b2_1 A_30_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI313_MN1_1 (VSS A_30_b1_0 A_30_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1096_MN1 (one11_b3_4 one11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1096_MN1_1 (VSS one11_b2_1 one11_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1106_MN1 (two11_b3_4 two11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1106_MN1_1 (VSS two11_b2_1 two11_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI317_MN1 (A_30_b3_3 A_30_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI317_MN1_1 (VSS A_30_b2_1 A_30_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI328_MN1 (A_31_b3_4 A_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI328_MN1_1 (VSS A_31_b2_1 A_31_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1216_MN1 (two13_b3_4 two13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1216_MN1_1 (VSS two13_b2_1 two13_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1206_MN1 (one13_b3_4 one13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1206_MN1_1 (VSS one13_b2_1 one13_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI384_MN1 (B_13_b2_0 B_13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI384_MN1_1 (VSS B_13_b1_0 B_13_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI181_MN1 (A_17_b1_0 A_17_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI181_MN1_1 (VSS A_17_b0 A_17_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI380_MN1 (B_11_b3_4 B_11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI380_MN1_1 (VSS B_11_b2_1 B_11_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI226_MN1 (A_21_b3_2 A_21_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI226_MN1_1 (VSS A_21_b2_0 A_21_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI212_MN1 (A_20_b2_0 A_20_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI212_MN1_1 (VSS A_20_b1_0 A_20_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI265_MN1 (A_25_b3_1 A_25_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI265_MN1_1 (VSS A_25_b2_0 A_25_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI325_MN1 (A_31_b3_1 A_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI325_MN1_1 (VSS A_31_b2_0 A_31_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI264_MN1 (A_25_b3_0 A_25_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI264_MN1_1 (VSS A_25_b2_0 A_25_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI254_MN1 (A_24_b3_0 A_24_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI254_MN1_1 (VSS A_24_b2_0 A_24_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI183_MN1 (A_17_b2_1 A_17_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI183_MN1_1 (VSS A_17_b1_0 A_17_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI149_MN1 (A_13_b3_5 A_13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI149_MN1_1 (VSS A_13_b2_1 A_13_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI158_MN1 (A_14_b3_4 A_14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI158_MN1_1 (VSS A_14_b2_1 A_14_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI168_MN1 (A_15_b3_4 A_15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI168_MN1_1 (VSS A_15_b2_1 A_15_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI159_MN1 (A_14_b3_5 A_14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI159_MN1_1 (VSS A_14_b2_1 A_14_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI179_MN1 (A_16_b3_5 A_16_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI179_MN1_1 (VSS A_16_b2_1 A_16_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1205_MN1 (one13_b3_3 one13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1205_MN1_1 (VSS one13_b2_1 one13_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI449_MN1 (B_25_b3_3 B_25_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI449_MN1_1 (VSS B_25_b2_1 B_25_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI440_MN1 (B_23_b3_4 B_23_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI440_MN1_1 (VSS B_23_b2_1 B_23_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI307_MN1 (A_29_b3_3 A_29_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI307_MN1_1 (VSS A_29_b2_1 A_29_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI450_MN1 (B_25_b3_4 B_25_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI450_MN1_1 (VSS B_25_b2_1 B_25_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI329_MN1 (A_31_b3_5 A_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI329_MN1_1 (VSS A_31_b2_1 A_31_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI885_MN1 (two7_b3_3 two7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI885_MN1_1 (VSS two7_b2_1 two7_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI295_MN1 (A_28_b3_1 A_28_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI295_MN1_1 (VSS A_28_b2_0 A_28_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI294_MN1 (A_28_b3_0 A_28_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI294_MN1_1 (VSS A_28_b2_0 A_28_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI314_MN1 (A_30_b3_0 A_30_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI314_MN1_1 (VSS A_30_b2_0 A_30_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI173_MN1 (A_16_b2_1 A_16_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI173_MN1_1 (VSS A_16_b1_0 A_16_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI148_MN1 (A_13_b3_4 A_13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI148_MN1_1 (VSS A_13_b2_1 A_13_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI169_MN1 (A_15_b3_5 A_15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI169_MN1_1 (VSS A_15_b2_1 A_15_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1259_MN1 (one14_b3_2 one14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1259_MN1_1 (VSS one14_b2_0 one14_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1091_MN1 (one11_b2_1 one11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1091_MN1_1 (VSS one11_b1_0 one11_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1101_MN1 (two11_b2_1 two11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1101_MN1_1 (VSS two11_b1_0 two11_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI434_MN1 (B_23_b2_0 B_23_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI434_MN1_1 (VSS B_23_b1_0 B_23_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI433_MN1 (B_23_b1_0 B_23_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI433_MN1_1 (VSS B_23_b0 B_23_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI302_MN1 (A_29_b2_0 A_29_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI302_MN1_1 (VSS A_29_b1_0 A_29_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI301_MN1 (A_29_b1_0 A_29_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI301_MN1_1 (VSS A_29_b0 A_29_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI435_MN1 (B_23_b2_1 B_23_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI435_MN1_1 (VSS B_23_b1_0 B_23_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI441_MN1 (B_23_b3_5 B_23_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI441_MN1_1 (VSS B_23_b2_1 B_23_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI303_MN1 (A_29_b2_1 A_29_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI303_MN1_1 (VSS A_29_b1_0 A_29_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1097_MN1 (one11_b3_5 one11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1097_MN1_1 (VSS one11_b2_1 one11_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1107_MN1 (two11_b3_5 two11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1107_MN1_1 (VSS two11_b2_1 two11_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI881_MN1 (two7_b2_1 two7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI881_MN1_1 (VSS two7_b1_0 two7_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI171_MN1 (A_16_b1_0 A_16_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI171_MN1_1 (VSS A_16_b0 A_16_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI875_MN1 (one7_b3_3 one7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI875_MN1_1 (VSS one7_b2_1 one7_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI381_MN1 (B_11_b3_5 B_11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI381_MN1_1 (VSS B_11_b2_1 B_11_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI722_MN1 (two4_b3_5 two4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI722_MN1_1 (VSS two4_b2_1 two4_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI667_MN1 (two3_b3_5 two3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI667_MN1_1 (VSS two3_b2_1 two3_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI304_MN1 (A_29_b3_0 A_29_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI304_MN1_1 (VSS A_29_b2_0 A_29_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI139_MN1 (A_12_b3_5 A_12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI139_MN1_1 (VSS A_12_b2_1 A_12_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI138_MN1 (A_12_b3_4 A_12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI138_MN1_1 (VSS A_12_b2_1 A_12_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1094_MN1 (one11_b3_2 one11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1094_MN1_1 (VSS one11_b2_0 one11_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI438_MN1 (B_23_b3_2 B_23_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI438_MN1_1 (VSS B_23_b2_0 B_23_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI129_MN1 (A_11_b3_5 A_11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI129_MN1_1 (VSS A_11_b2_1 A_11_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1269_MN1 (two14_b3_2 two14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1269_MN1_1 (VSS two14_b2_0 two14_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1313_MN1 (one15_b3_1 one15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1313_MN1_1 (VSS one15_b2_0 one15_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1324_MN1 (two15_b3_2 two15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1324_MN1_1 (VSS two15_b2_0 two15_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1314_MN1 (one15_b3_2 one15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1314_MN1_1 (VSS one15_b2_0 one15_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1089_MN1 (one11_b1_0 one11_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1089_MN1_1 (VSS one11_b0 one11_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1099_MN1 (two11_b1_0 two11_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1099_MN1_1 (VSS two11_b0 two11_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1260_MN1 (one14_b3_3 one14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1260_MN1_1 (VSS one14_b2_1 one14_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI459_MN1 (B_27_b3_3 B_27_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI459_MN1_1 (VSS B_27_b2_1 B_27_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1162_MN1 (two12_b3_5 two12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1162_MN1_1 (VSS two12_b2_1 two12_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1270_MN1 (two14_b3_3 two14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1270_MN1_1 (VSS two14_b2_1 two14_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1315_MN1 (one15_b3_3 one15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1315_MN1_1 (VSS one15_b2_1 one15_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1261_MN1 (one14_b3_4 one14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1261_MN1_1 (VSS one14_b2_1 one14_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1271_MN1 (two14_b3_4 two14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1271_MN1_1 (VSS two14_b2_1 two14_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1326_MN1 (two15_b3_4 two15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1326_MN1_1 (VSS two15_b2_1 two15_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI308_MN1 (A_29_b3_4 A_29_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI308_MN1_1 (VSS A_29_b2_1 A_29_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI871_MN1 (one7_b2_1 one7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI871_MN1_1 (VSS one7_b1_0 one7_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI235_MN1 (A_22_b3_1 A_22_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI235_MN1_1 (VSS A_22_b2_0 A_22_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI712_MN1 (one4_b3_5 one4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI712_MN1_1 (VSS one4_b2_1 one4_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI721_MN1 (two4_b3_4 two4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI721_MN1_1 (VSS two4_b2_1 two4_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI657_MN1 (one3_b3_5 one3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI657_MN1_1 (VSS one3_b2_1 one3_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI167_MN1 (A_15_b3_3 A_15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI167_MN1_1 (VSS A_15_b2_1 A_15_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI147_MN1 (A_13_b3_3 A_13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI147_MN1_1 (VSS A_13_b2_1 A_13_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI157_MN1 (A_14_b3_3 A_14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI157_MN1_1 (VSS A_14_b2_1 A_14_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI128_MN1 (A_11_b3_4 A_11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI128_MN1_1 (VSS A_11_b2_1 A_11_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1104_MN1 (two11_b3_2 two11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1104_MN1_1 (VSS two11_b2_0 two11_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1159_MN1 (two12_b3_2 two12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1159_MN1_1 (VSS two12_b2_0 two12_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1149_MN1 (one12_b3_2 one12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1149_MN1_1 (VSS one12_b2_0 one12_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1100_MN1 (two11_b2_0 two11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1100_MN1_1 (VSS two11_b1_0 two11_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1214_MN1 (two13_b3_2 two13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1214_MN1_1 (VSS two13_b2_0 two13_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI448_MN1 (B_25_b3_2 B_25_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI448_MN1_1 (VSS B_25_b2_0 B_25_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1204_MN1 (one13_b3_2 one13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1204_MN1_1 (VSS one13_b2_0 one13_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1268_MN1 (two14_b3_1 two14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1268_MN1_1 (VSS two14_b2_0 two14_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI458_MN1 (B_27_b3_2 B_27_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI458_MN1_1 (VSS B_27_b2_0 B_27_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1258_MN1 (one14_b3_1 one14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1258_MN1_1 (VSS one14_b2_0 one14_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1323_MN1 (two15_b3_1 two15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1323_MN1_1 (VSS two15_b2_0 two15_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI467_MN1 (B_29_b3_1 B_29_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI467_MN1_1 (VSS B_29_b2_0 B_29_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI468_MN1 (B_29_b3_2 B_29_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI468_MN1_1 (VSS B_29_b2_0 B_29_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI477_MN1 (B_31_b3_1 B_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI477_MN1_1 (VSS B_31_b2_0 B_31_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1090_MN1 (one11_b2_0 one11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1090_MN1_1 (VSS one11_b1_0 one11_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1155_MN1 (two12_b2_0 two12_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1155_MN1_1 (VSS two12_b1_0 two12_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI478_MN1 (B_31_b3_2 B_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI478_MN1_1 (VSS B_31_b2_0 B_31_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI322_MN1 (A_31_b2_0 A_31_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI322_MN1_1 (VSS A_31_b1_0 A_31_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1146_MN1 (one12_b2_1 one12_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1146_MN1_1 (VSS one12_b1_0 one12_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1156_MN1 (two12_b2_1 two12_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1156_MN1_1 (VSS two12_b1_0 two12_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1201_MN1 (one13_b2_1 one13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1201_MN1_1 (VSS one13_b1_0 one13_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI445_MN1 (B_25_b2_1 B_25_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI445_MN1_1 (VSS B_25_b1_0 B_25_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI451_MN1 (B_25_b3_5 B_25_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI451_MN1_1 (VSS B_25_b2_1 B_25_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1152_MN1 (one12_b3_5 one12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1152_MN1_1 (VSS one12_b2_1 one12_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI469_MN1 (B_29_b3_3 B_29_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI469_MN1_1 (VSS B_29_b2_1 B_29_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI461_MN1 (B_27_b3_5 B_27_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI461_MN1_1 (VSS B_27_b2_1 B_27_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI460_MN1 (B_27_b3_4 B_27_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI460_MN1_1 (VSS B_27_b2_1 B_27_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI323_MN1 (A_31_b2_1 A_31_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI323_MN1_1 (VSS A_31_b1_0 A_31_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI479_MN1 (B_31_b3_3 B_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI479_MN1_1 (VSS B_31_b2_1 B_31_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1217_MN1 (two13_b3_5 two13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1217_MN1_1 (VSS two13_b2_1 two13_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1316_MN1 (one15_b3_4 one15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1316_MN1_1 (VSS one15_b2_1 one15_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI299_MN1 (A_28_b3_5 A_28_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI299_MN1_1 (VSS A_28_b2_1 A_28_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1207_MN1 (one13_b3_5 one13_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1207_MN1_1 (VSS one13_b2_1 one13_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI820_MN1 (one6_b3_3 one6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI820_MN1_1 (VSS one6_b2_1 one6_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI375_MN1 (B_11_b2_1 B_11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI375_MN1_1 (VSS B_11_b1_0 B_11_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI830_MN1 (two6_b3_3 two6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI830_MN1_1 (VSS two6_b2_1 two6_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI216_MN1 (A_20_b3_2 A_20_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI216_MN1_1 (VSS A_20_b2_0 A_20_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI202_MN1 (A_19_b2_0 A_19_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI202_MN1_1 (VSS A_19_b1_0 A_19_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI234_MN1 (A_22_b3_0 A_22_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI234_MN1_1 (VSS A_22_b2_0 A_22_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI324_MN1 (A_31_b3_0 A_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI324_MN1_1 (VSS A_31_b2_0 A_31_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI163_MN1 (A_15_b2_1 A_15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI163_MN1_1 (VSS A_15_b1_0 A_15_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI133_MN1 (A_12_b2_1 A_12_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI133_MN1_1 (VSS A_12_b1_0 A_12_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI153_MN1 (A_14_b2_1 A_14_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI153_MN1_1 (VSS A_14_b1_0 A_14_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI143_MN1 (A_13_b2_1 A_13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI143_MN1_1 (VSS A_13_b1_0 A_13_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI119_MN1 (A_10_b3_5 A_10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI119_MN1_1 (VSS A_10_b2_1 A_10_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI424_MN1 (B_21_b2_0 B_21_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI424_MN1_1 (VSS B_21_b1_0 B_21_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI437_MN1 (B_23_b3_1 B_23_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI437_MN1_1 (VSS B_23_b2_0 B_23_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1257_MN1 (one14_b3_0 one14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1257_MN1_1 (VSS one14_b2_0 one14_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1267_MN1 (two14_b3_0 two14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1267_MN1_1 (VSS two14_b2_0 two14_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1322_MN1 (two15_b3_0 two15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1322_MN1_1 (VSS two15_b2_0 two15_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI436_MN1 (B_23_b3_0 B_23_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI436_MN1_1 (VSS B_23_b2_0 B_23_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1145_MN1 (one12_b2_0 one12_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1145_MN1_1 (VSS one12_b1_0 one12_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1144_MN1 (one12_b1_0 one12_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1144_MN1_1 (VSS one12_b0 one12_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1154_MN1 (two12_b1_0 two12_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1154_MN1_1 (VSS two12_b0 two12_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1255_MN1 (one14_b2_0 one14_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1255_MN1_1 (VSS one14_b1_0 one14_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1210_MN1 (two13_b2_0 two13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1210_MN1_1 (VSS two13_b1_0 two13_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1265_MN1 (two14_b2_0 two14_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1265_MN1_1 (VSS two14_b1_0 two14_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI444_MN1 (B_25_b2_0 B_25_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI444_MN1_1 (VSS B_25_b1_0 B_25_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI454_MN1 (B_27_b2_0 B_27_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI454_MN1_1 (VSS B_27_b1_0 B_27_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1211_MN1 (two13_b2_1 two13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1211_MN1_1 (VSS two13_b1_0 two13_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1264_MN1 (two14_b1_0 two14_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1264_MN1_1 (VSS two14_b0 two14_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1310_MN1 (one15_b2_0 one15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1310_MN1_1 (VSS one15_b1_0 one15_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI443_MN1 (B_25_b1_0 B_25_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI443_MN1_1 (VSS B_25_b0 B_25_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1256_MN1 (one14_b2_1 one14_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1256_MN1_1 (VSS one14_b1_0 one14_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1266_MN1 (two14_b2_1 two14_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1266_MN1_1 (VSS two14_b1_0 two14_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI455_MN1 (B_27_b2_1 B_27_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI455_MN1_1 (VSS B_27_b1_0 B_27_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI453_MN1 (B_27_b1_0 B_27_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI453_MN1_1 (VSS B_27_b0 B_27_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI470_MN1 (B_29_b3_4 B_29_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI470_MN1_1 (VSS B_29_b2_1 B_29_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1262_MN1 (one14_b3_5 one14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1262_MN1_1 (VSS one14_b2_1 one14_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI321_MN1 (A_31_b1_0 A_31_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI321_MN1_1 (VSS A_31_b0 A_31_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI319_MN1 (A_30_b3_5 A_30_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI319_MN1_1 (VSS A_30_b2_1 A_30_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI309_MN1 (A_29_b3_5 A_29_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI309_MN1_1 (VSS A_29_b2_1 A_29_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI379_MN1 (B_11_b3_3 B_11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI379_MN1_1 (VSS B_11_b2_1 B_11_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI371_MN1 (B_9_b3_5 B_9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI371_MN1_1 (VSS B_9_b2_1 B_9_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI370_MN1 (B_9_b3_4 B_9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI370_MN1_1 (VSS B_9_b2_1 B_9_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI161_MN1 (A_15_b1_0 A_15_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI161_MN1_1 (VSS A_15_b0 A_15_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI151_MN1 (A_14_b1_0 A_14_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI151_MN1_1 (VSS A_14_b0 A_14_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI711_MN1 (one4_b3_4 one4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI711_MN1_1 (VSS one4_b2_1 one4_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI418_MN1 (B_19_b3_2 B_19_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI418_MN1_1 (VSS B_19_b2_0 B_19_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI118_MN1 (A_10_b3_4 A_10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI118_MN1_1 (VSS A_10_b2_1 A_10_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI428_MN1 (B_21_b3_2 B_21_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI428_MN1_1 (VSS B_21_b2_0 B_21_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI127_MN1 (A_11_b3_3 A_11_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI127_MN1_1 (VSS A_11_b2_1 A_11_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI108_MN1 (A_9_b3_4 A_9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI108_MN1_1 (VSS A_9_b2_1 A_9_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI109_MN1 (A_9_b3_5 A_9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI109_MN1_1 (VSS A_9_b2_1 A_9_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1213_MN1 (two13_b3_1 two13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1213_MN1_1 (VSS two13_b2_0 two13_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1203_MN1 (one13_b3_1 one13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1203_MN1_1 (VSS one13_b2_0 one13_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI457_MN1 (B_27_b3_1 B_27_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI457_MN1_1 (VSS B_27_b2_0 B_27_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1312_MN1 (one15_b3_0 one15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1312_MN1_1 (VSS one15_b2_0 one15_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1200_MN1 (one13_b2_0 one13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1200_MN1_1 (VSS one13_b1_0 one13_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI466_MN1 (B_29_b3_0 B_29_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI466_MN1_1 (VSS B_29_b2_0 B_29_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI456_MN1 (B_27_b3_0 B_27_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI456_MN1_1 (VSS B_27_b2_0 B_27_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1199_MN1 (one13_b1_0 one13_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1199_MN1_1 (VSS one13_b0 one13_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1209_MN1 (two13_b1_0 two13_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1209_MN1_1 (VSS two13_b0 two13_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI464_MN1 (B_29_b2_0 B_29_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI464_MN1_1 (VSS B_29_b1_0 B_29_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1320_MN1 (two15_b2_0 two15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1320_MN1_1 (VSS two15_b1_0 two15_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1254_MN1 (one14_b1_0 one14_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1254_MN1_1 (VSS one14_b0 one14_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1309_MN1 (one15_b1_0 one15_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1309_MN1_1 (VSS one15_b0 one15_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1319_MN1 (two15_b1_0 two15_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1319_MN1_1 (VSS two15_b0 two15_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI465_MN1 (B_29_b2_1 B_29_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI465_MN1_1 (VSS B_29_b1_0 B_29_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1311_MN1 (one15_b2_1 one15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1311_MN1_1 (VSS one15_b1_0 one15_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI463_MN1 (B_29_b1_0 B_29_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI463_MN1_1 (VSS B_29_b0 B_29_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1321_MN1 (two15_b2_1 two15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1321_MN1_1 (VSS two15_b1_0 two15_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI480_MN1 (B_31_b3_4 B_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI480_MN1_1 (VSS B_31_b2_1 B_31_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1317_MN1 (one15_b3_5 one15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1317_MN1_1 (VSS one15_b2_1 one15_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1327_MN1 (two15_b3_5 two15_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1327_MN1_1 (VSS two15_b2_1 two15_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1272_MN1 (two14_b3_5 two14_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1272_MN1_1 (VSS two14_b2_1 two14_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI206_MN1 (A_19_b3_2 A_19_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI206_MN1_1 (VSS A_19_b2_0 A_19_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI666_MN1 (two3_b3_4 two3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI666_MN1_1 (VSS two3_b2_1 two3_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI656_MN1 (one3_b3_4 one3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI656_MN1_1 (VSS one3_b2_1 one3_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI612_MN1 (two2_b3_5 two2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI612_MN1_1 (VSS two2_b2_1 two2_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI602_MN1 (one2_b3_5 one2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI602_MN1_1 (VSS one2_b2_1 one2_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI192_MN1 (A_18_b2_0 A_18_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI192_MN1_1 (VSS A_18_b1_0 A_18_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI123_MN1 (A_11_b2_1 A_11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI123_MN1_1 (VSS A_11_b1_0 A_11_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1049_MN1 (two10_b3_2 two10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1049_MN1_1 (VSS two10_b2_0 two10_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI99_MN1 (A_8_b3_5 A_8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI99_MN1_1 (VSS A_8_b2_1 A_8_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI89_MN1 (A_7_b3_5 A_7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI89_MN1_1 (VSS A_7_b2_1 A_7_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI447_MN1 (B_25_b3_1 B_25_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI447_MN1_1 (VSS B_25_b2_0 B_25_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI446_MN1 (B_25_b3_0 B_25_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI446_MN1_1 (VSS B_25_b2_0 B_25_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI476_MN1 (B_31_b3_0 B_31_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI476_MN1_1 (VSS B_31_b2_0 B_31_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI471_MN1 (B_29_b3_5 B_29_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI471_MN1_1 (VSS B_29_b2_1 B_29_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI473_MN1 (B_31_b1_0 B_31_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI473_MN1_1 (VSS B_31_b0 B_31_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI330_MN1 (A_31_b3_6 A_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI330_MN1_1 (VSS A_31_b2_1 A_31_b3_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI373_MN1 (B_11_b1_0 B_11_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI373_MN1_1 (VSS B_11_b0 B_11_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI816_MN1 (one6_b2_1 one6_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI816_MN1_1 (VSS one6_b1_0 one6_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI369_MN1 (B_9_b3_3 B_9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI369_MN1_1 (VSS B_9_b2_1 B_9_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI225_MN1 (A_21_b3_1 A_21_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI225_MN1_1 (VSS A_21_b2_0 A_21_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI141_MN1 (A_13_b1_0 A_13_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI141_MN1_1 (VSS A_13_b0 A_13_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI224_MN1 (A_21_b3_0 A_21_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI224_MN1_1 (VSS A_21_b2_0 A_21_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI131_MN1 (A_12_b1_0 A_12_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI131_MN1_1 (VSS A_12_b0 A_12_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI360_MN1 (B_7_b3_4 B_7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI360_MN1_1 (VSS B_7_b2_1 B_7_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI172_MN1 (A_16_b2_0 A_16_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI172_MN1_1 (VSS A_16_b1_0 A_16_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1039_MN1 (one10_b3_2 one10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1039_MN1_1 (VSS one10_b2_0 one10_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1103_MN1 (two11_b3_1 two11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1103_MN1_1 (VSS two11_b2_0 two11_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI98_MN1 (A_8_b3_4 A_8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI98_MN1_1 (VSS A_8_b2_1 A_8_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1035_MN1 (one10_b2_0 one10_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1035_MN1_1 (VSS one10_b1_0 one10_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1045_MN1 (two10_b2_0 two10_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1045_MN1_1 (VSS two10_b1_0 two10_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1034_MN1 (one10_b1_0 one10_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1034_MN1_1 (VSS one10_b0 one10_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1044_MN1 (two10_b1_0 two10_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1044_MN1_1 (VSS two10_b0 two10_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1212_MN1 (two13_b3_0 two13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1212_MN1_1 (VSS two13_b2_0 two13_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1202_MN1 (one13_b3_0 one13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1202_MN1_1 (VSS one13_b2_0 one13_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI474_MN1 (B_31_b2_0 B_31_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI474_MN1_1 (VSS B_31_b1_0 B_31_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI475_MN1 (B_31_b2_1 B_31_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI475_MN1_1 (VSS B_31_b1_0 B_31_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI331_MN1 (A_31_b3_7 A_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI331_MN1_1 (VSS A_31_b2_1 A_31_b3_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI869_MN1 (one7_b1_0 one7_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI869_MN1_1 (VSS one7_b0 one7_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI374_MN1 (B_11_b2_0 B_11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI374_MN1_1 (VSS B_11_b1_0 B_11_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI365_MN1 (B_9_b2_1 B_9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI365_MN1_1 (VSS B_9_b1_0 B_9_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI826_MN1 (two6_b2_1 two6_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI826_MN1_1 (VSS two6_b1_0 two6_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI765_MN1 (one5_b3_3 one5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI765_MN1_1 (VSS one5_b2_1 one5_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI186_MN1 (A_17_b3_2 A_17_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI186_MN1_1 (VSS A_17_b2_0 A_17_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI196_MN1 (A_18_b3_2 A_18_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI196_MN1_1 (VSS A_18_b2_0 A_18_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI182_MN1 (A_17_b2_0 A_17_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI182_MN1_1 (VSS A_17_b1_0 A_17_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI215_MN1 (A_20_b3_1 A_20_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI215_MN1_1 (VSS A_20_b2_0 A_20_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI195_MN1 (A_18_b3_1 A_18_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI195_MN1_1 (VSS A_18_b2_0 A_18_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI152_MN1 (A_14_b2_0 A_14_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI152_MN1_1 (VSS A_14_b1_0 A_14_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI361_MN1 (B_7_b3_5 B_7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI361_MN1_1 (VSS B_7_b2_1 B_7_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI359_MN1 (B_7_b3_3 B_7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI359_MN1_1 (VSS B_7_b2_1 B_7_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI408_MN1 (B_17_b3_2 B_17_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI408_MN1_1 (VSS B_17_b2_0 B_17_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1093_MN1 (one11_b3_1 one11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1093_MN1_1 (VSS one11_b2_0 one11_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI994_MN1 (two9_b3_2 two9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI994_MN1_1 (VSS two9_b2_0 two9_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI88_MN1 (A_7_b3_4 A_7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI88_MN1_1 (VSS A_7_b2_1 A_7_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI984_MN1 (one9_b3_2 one9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI984_MN1_1 (VSS one9_b2_0 one9_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1148_MN1 (one12_b3_1 one12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1148_MN1_1 (VSS one12_b2_0 one12_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI69_MN1 (A_5_b3_5 A_5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI69_MN1_1 (VSS A_5_b2_1 A_5_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI79_MN1 (A_6_b3_5 A_6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI79_MN1_1 (VSS A_6_b2_1 A_6_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1158_MN1 (two12_b3_1 two12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1158_MN1_1 (VSS two12_b2_0 two12_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI481_MN1 (B_31_b3_5 B_31_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI481_MN1_1 (VSS B_31_b2_1 B_31_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI879_MN1 (two7_b1_0 two7_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI879_MN1_1 (VSS two7_b0 two7_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI363_MN1 (B_9_b1_0 B_9_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI363_MN1_1 (VSS B_9_b0 B_9_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI761_MN1 (one5_b2_1 one5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI761_MN1_1 (VSS one5_b1_0 one5_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI775_MN1 (two5_b3_3 two5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI775_MN1_1 (VSS two5_b2_1 two5_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI205_MN1 (A_19_b3_1 A_19_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI205_MN1_1 (VSS A_19_b2_0 A_19_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI204_MN1 (A_19_b3_0 A_19_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI204_MN1_1 (VSS A_19_b2_0 A_19_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI176_MN1 (A_16_b3_2 A_16_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI176_MN1_1 (VSS A_16_b2_0 A_16_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI665_MN1 (two3_b3_3 two3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI665_MN1_1 (VSS two3_b2_1 two3_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI355_MN1 (B_7_b2_1 B_7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI355_MN1_1 (VSS B_7_b1_0 B_7_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI214_MN1 (A_20_b3_0 A_20_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI214_MN1_1 (VSS A_20_b2_0 A_20_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI162_MN1 (A_15_b2_0 A_15_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI162_MN1_1 (VSS A_15_b1_0 A_15_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI611_MN1 (two2_b3_4 two2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI611_MN1_1 (VSS two2_b2_1 two2_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI601_MN1 (one2_b3_4 one2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI601_MN1_1 (VSS one2_b2_1 one2_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI980_MN1 (one9_b2_0 one9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI980_MN1_1 (VSS one9_b1_0 one9_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI78_MN1 (A_6_b3_4 A_6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI78_MN1_1 (VSS A_6_b2_1 A_6_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1092_MN1 (one11_b3_0 one11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1092_MN1_1 (VSS one11_b2_0 one11_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1102_MN1 (two11_b3_0 two11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1102_MN1_1 (VSS two11_b2_0 two11_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1147_MN1 (one12_b3_0 one12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1147_MN1_1 (VSS one12_b2_0 one12_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1157_MN1 (two12_b3_0 two12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1157_MN1_1 (VSS two12_b2_0 two12_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI59_MN1 (A_4_b3_5 A_4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI59_MN1_1 (VSS A_4_b2_1 A_4_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI771_MN1 (two5_b2_1 two5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI771_MN1_1 (VSS two5_b1_0 two5_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI655_MN1 (one3_b3_3 one3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI655_MN1_1 (VSS one3_b2_1 one3_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI194_MN1 (A_18_b3_0 A_18_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI194_MN1_1 (VSS A_18_b2_0 A_18_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI121_MN1 (A_11_b1_0 A_11_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI121_MN1_1 (VSS A_11_b0 A_11_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI547_MN1 (one1_b3_5 one1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI547_MN1_1 (VSS one1_b2_1 one1_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI924_MN1 (one8_b1_0 one8_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI924_MN1_1 (VSS one8_b0 one8_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI925_MN1 (one8_b2_0 one8_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI925_MN1_1 (VSS one8_b1_0 one8_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI934_MN1 (two8_b1_0 two8_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI934_MN1_1 (VSS two8_b0 two8_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI929_MN1 (one8_b3_2 one8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI929_MN1_1 (VSS one8_b2_0 one8_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI935_MN1 (two8_b2_0 two8_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI935_MN1_1 (VSS two8_b1_0 two8_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI939_MN1 (two8_b3_2 two8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI939_MN1_1 (VSS two8_b2_0 two8_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI107_MN1 (A_9_b3_3 A_9_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI107_MN1_1 (VSS A_9_b2_1 A_9_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI427_MN1 (B_21_b3_1 B_21_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI427_MN1_1 (VSS B_21_b2_0 B_21_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI426_MN1 (B_21_b3_0 B_21_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI426_MN1_1 (VSS B_21_b2_0 B_21_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1038_MN1 (one10_b3_1 one10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1038_MN1_1 (VSS one10_b2_0 one10_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1048_MN1 (two10_b3_1 two10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1048_MN1_1 (VSS two10_b2_0 two10_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI68_MN1 (A_5_b3_4 A_5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI68_MN1_1 (VSS A_5_b2_1 A_5_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI979_MN1 (one9_b1_0 one9_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI979_MN1_1 (VSS one9_b0 one9_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI990_MN1 (two9_b2_0 two9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI990_MN1_1 (VSS two9_b1_0 two9_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI989_MN1 (two9_b1_0 two9_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI989_MN1_1 (VSS two9_b0 two9_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI870_MN1 (one7_b2_0 one7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI870_MN1_1 (VSS one7_b1_0 one7_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI880_MN1 (two7_b2_0 two7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI880_MN1_1 (VSS two7_b1_0 two7_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI396_MN1 (B_15_b3_0 B_15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI396_MN1_1 (VSS B_15_b2_0 B_15_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI364_MN1 (B_9_b2_0 B_9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI364_MN1_1 (VSS B_9_b1_0 B_9_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI720_MN1 (two4_b3_3 two4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI720_MN1_1 (VSS two4_b2_1 two4_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI492_MN1 (one0_b3_5 one0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI492_MN1_1 (VSS one0_b2_1 one0_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI350_MN1 (B_5_b3_4 B_5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI350_MN1_1 (VSS B_5_b2_1 B_5_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1037_MN1 (one10_b3_0 one10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1037_MN1_1 (VSS one10_b2_0 one10_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1047_MN1 (two10_b3_0 two10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1047_MN1_1 (VSS two10_b2_0 two10_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI87_MN1 (A_7_b3_3 A_7_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI87_MN1_1 (VSS A_7_b2_1 A_7_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI58_MN1 (A_4_b3_4 A_4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI58_MN1_1 (VSS A_4_b2_1 A_4_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI49_MN1 (A_3_b3_5 A_3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI49_MN1_1 (VSS A_3_b2_1 A_3_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI884_MN1 (two7_b3_2 two7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI884_MN1_1 (VSS two7_b2_0 two7_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI398_MN1 (B_15_b3_2 B_15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI398_MN1_1 (VSS B_15_b2_0 B_15_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI406_MN1 (B_17_b3_0 B_17_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI406_MN1_1 (VSS B_17_b2_0 B_17_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI117_MN1 (A_10_b3_3 A_10_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI117_MN1_1 (VSS A_10_b2_1 A_10_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI77_MN1 (A_6_b3_3 A_6_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI77_MN1_1 (VSS A_6_b2_1 A_6_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI416_MN1 (B_19_b3_0 B_19_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI416_MN1_1 (VSS B_19_b2_0 B_19_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI48_MN1 (A_3_b3_4 A_3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI48_MN1_1 (VSS A_3_b2_1 A_3_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI397_MN1 (B_15_b3_1 B_15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI397_MN1_1 (VSS B_15_b2_0 B_15_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI706_MN1 (one4_b2_1 one4_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI706_MN1_1 (VSS one4_b1_0 one4_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI353_MN1 (B_7_b1_0 B_7_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI353_MN1_1 (VSS B_7_b0 B_7_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI156_MN1 (A_14_b3_2 A_14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI156_MN1_1 (VSS A_14_b2_0 A_14_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI716_MN1 (two4_b2_1 two4_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI716_MN1_1 (VSS two4_b1_0 two4_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI166_MN1 (A_15_b3_2 A_15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI166_MN1_1 (VSS A_15_b2_0 A_15_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI175_MN1 (A_16_b3_1 A_16_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI175_MN1_1 (VSS A_16_b2_0 A_16_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI184_MN1 (A_17_b3_0 A_17_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI184_MN1_1 (VSS A_17_b2_0 A_17_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI502_MN1 (two0_b3_5 two0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI502_MN1_1 (VSS two0_b2_1 two0_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI546_MN1 (one1_b3_4 one1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI546_MN1_1 (VSS one1_b2_1 one1_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI557_MN1 (two1_b3_5 two1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI557_MN1_1 (VSS two1_b2_1 two1_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI349_MN1 (B_5_b3_3 B_5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI349_MN1_1 (VSS B_5_b2_1 B_5_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI993_MN1 (two9_b3_1 two9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI993_MN1_1 (VSS two9_b2_0 two9_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI983_MN1 (one9_b3_1 one9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI983_MN1_1 (VSS one9_b2_0 one9_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI982_MN1 (one9_b3_0 one9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI982_MN1_1 (VSS one9_b2_0 one9_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI417_MN1 (B_19_b3_1 B_19_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI417_MN1_1 (VSS B_19_b2_0 B_19_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI815_MN1 (one6_b2_0 one6_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI815_MN1_1 (VSS one6_b1_0 one6_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI874_MN1 (one7_b3_2 one7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI874_MN1_1 (VSS one7_b2_0 one7_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI388_MN1 (B_13_b3_2 B_13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI388_MN1_1 (VSS B_13_b2_0 B_13_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI174_MN1 (A_16_b3_0 A_16_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI174_MN1_1 (VSS A_16_b2_0 A_16_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI491_MN1 (one0_b3_4 one0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI491_MN1_1 (VSS one0_b2_1 one0_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI556_MN1 (two1_b3_4 two1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI556_MN1_1 (VSS two1_b2_1 two1_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI340_MN1 (B_3_b3_4 B_3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI340_MN1_1 (VSS B_3_b2_1 B_3_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI407_MN1 (B_17_b3_1 B_17_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI407_MN1_1 (VSS B_17_b2_0 B_17_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI992_MN1 (two9_b3_0 two9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI992_MN1_1 (VSS two9_b2_0 two9_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI38_MN1 (A_2_b3_4 A_2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI38_MN1_1 (VSS A_2_b2_1 A_2_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI39_MN1 (A_2_b3_5 A_2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI39_MN1_1 (VSS A_2_b2_1 A_2_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI814_MN1 (one6_b1_0 one6_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI814_MN1_1 (VSS one6_b0 one6_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI824_MN1 (two6_b1_0 two6_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI824_MN1_1 (VSS two6_b0 two6_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI825_MN1 (two6_b2_0 two6_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI825_MN1_1 (VSS two6_b1_0 two6_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI819_MN1 (one6_b3_2 one6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI819_MN1_1 (VSS one6_b2_0 one6_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI829_MN1 (two6_b3_2 two6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI829_MN1_1 (VSS two6_b2_0 two6_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI146_MN1 (A_13_b3_2 A_13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI146_MN1_1 (VSS A_13_b2_0 A_13_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI661_MN1 (two3_b2_1 two3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI661_MN1_1 (VSS two3_b1_0 two3_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI142_MN1 (A_13_b2_0 A_13_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI142_MN1_1 (VSS A_13_b1_0 A_13_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI651_MN1 (one3_b2_1 one3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI651_MN1_1 (VSS one3_b1_0 one3_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI501_MN1 (two0_b3_4 two0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI501_MN1_1 (VSS two0_b2_1 two0_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI339_MN1 (B_3_b3_3 B_3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI339_MN1_1 (VSS B_3_b2_1 B_3_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI341_MN1 (B_3_b3_5 B_3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI341_MN1_1 (VSS B_3_b2_1 B_3_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI97_MN1 (A_8_b3_3 A_8_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI97_MN1_1 (VSS A_8_b2_1 A_8_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI67_MN1 (A_5_b3_3 A_5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI67_MN1_1 (VSS A_5_b2_1 A_5_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI18_MN1 (A_0_b3_4 A_0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI18_MN1_1 (VSS A_0_b2_1 A_0_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI28_MN1 (A_1_b3_4 A_1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI28_MN1_1 (VSS A_1_b2_1 A_1_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI29_MN1 (A_1_b3_5 A_1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI29_MN1_1 (VSS A_1_b2_1 A_1_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI19_MN1 (A_0_b3_5 A_0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI19_MN1_1 (VSS A_0_b2_1 A_0_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI769_MN1 (two5_b1_0 two5_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI769_MN1_1 (VSS two5_b0 two5_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI386_MN1 (B_13_b3_0 B_13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI386_MN1_1 (VSS B_13_b2_0 B_13_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI387_MN1 (B_13_b3_1 B_13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI387_MN1_1 (VSS B_13_b2_0 B_13_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI136_MN1 (A_12_b3_2 A_12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI136_MN1_1 (VSS A_12_b2_0 A_12_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI354_MN1 (B_7_b2_0 B_7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI354_MN1_1 (VSS B_7_b1_0 B_7_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI164_MN1 (A_15_b3_0 A_15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI164_MN1_1 (VSS A_15_b2_0 A_15_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI132_MN1 (A_12_b2_0 A_12_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI132_MN1_1 (VSS A_12_b1_0 A_12_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI928_MN1 (one8_b3_1 one8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI928_MN1_1 (VSS one8_b2_0 one8_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI938_MN1 (two8_b3_1 two8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI938_MN1_1 (VSS two8_b2_0 two8_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI759_MN1 (one5_b1_0 one5_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI759_MN1_1 (VSS one5_b0 one5_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI770_MN1 (two5_b2_0 two5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI770_MN1_1 (VSS two5_b1_0 two5_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI774_MN1 (two5_b3_2 two5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI774_MN1_1 (VSS two5_b2_0 two5_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI378_MN1 (B_11_b3_2 B_11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI378_MN1_1 (VSS B_11_b2_0 B_11_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI145_MN1 (A_13_b3_1 A_13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI145_MN1_1 (VSS A_13_b2_0 A_13_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI165_MN1 (A_15_b3_1 A_15_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI165_MN1_1 (VSS A_15_b2_0 A_15_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI144_MN1 (A_13_b3_0 A_13_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI144_MN1_1 (VSS A_13_b2_0 A_13_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI155_MN1 (A_14_b3_1 A_14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI155_MN1_1 (VSS A_14_b2_0 A_14_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI358_MN1 (B_7_b3_2 B_7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI358_MN1_1 (VSS B_7_b2_0 B_7_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI610_MN1 (two2_b3_3 two2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI610_MN1_1 (VSS two2_b2_1 two2_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI600_MN1 (one2_b3_3 one2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI600_MN1_1 (VSS one2_b2_1 one2_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI122_MN1 (A_11_b2_0 A_11_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI122_MN1_1 (VSS A_11_b1_0 A_11_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI7_MN1 (B_1_b3_3 B_1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI7_MN1_1 (VSS B_1_b2_1 B_1_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI8_MN1 (B_1_b3_4 B_1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI8_MN1_1 (VSS B_1_b2_1 B_1_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI545_MN1 (one1_b3_3 one1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI545_MN1_1 (VSS one1_b2_1 one1_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI555_MN1 (two1_b3_3 two1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI555_MN1_1 (VSS two1_b2_1 two1_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI9_MN1 (B_1_b3_5 B_1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI9_MN1_1 (VSS B_1_b2_1 B_1_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI351_MN1 (B_5_b3_5 B_5_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI351_MN1_1 (VSS B_5_b2_1 B_5_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI606_MN1 (two2_b2_1 two2_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI606_MN1_1 (VSS two2_b1_0 two2_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI335_MN1 (B_3_b2_1 B_3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI335_MN1_1 (VSS B_3_b1_0 B_3_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI551_MN1 (two1_b2_1 two1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI551_MN1_1 (VSS two1_b1_0 two1_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI937_MN1 (two8_b3_0 two8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI937_MN1_1 (VSS two8_b2_0 two8_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI760_MN1 (one5_b2_0 one5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI760_MN1_1 (VSS one5_b1_0 one5_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI764_MN1 (one5_b3_2 one5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI764_MN1_1 (VSS one5_b2_0 one5_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI376_MN1 (B_11_b3_0 B_11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI376_MN1_1 (VSS B_11_b2_0 B_11_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI126_MN1 (A_11_b3_2 A_11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI126_MN1_1 (VSS A_11_b2_0 A_11_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI135_MN1 (A_12_b3_1 A_12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI135_MN1_1 (VSS A_12_b2_0 A_12_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI500_MN1 (two0_b3_3 two0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI500_MN1_1 (VSS two0_b2_1 two0_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI927_MN1 (one8_b3_0 one8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI927_MN1_1 (VSS one8_b2_0 one8_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI57_MN1 (A_4_b3_3 A_4_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI57_MN1_1 (VSS A_4_b2_1 A_4_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI873_MN1 (one7_b3_1 one7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI873_MN1_1 (VSS one7_b2_0 one7_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI125_MN1 (A_11_b3_1 A_11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI125_MN1_1 (VSS A_11_b2_0 A_11_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI134_MN1 (A_12_b3_0 A_12_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI134_MN1_1 (VSS A_12_b2_0 A_12_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI490_MN1 (one0_b3_3 one0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI490_MN1_1 (VSS one0_b2_1 one0_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI883_MN1 (two7_b3_1 two7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI883_MN1_1 (VSS two7_b2_0 two7_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI116_MN1 (A_10_b3_2 A_10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI116_MN1_1 (VSS A_10_b2_0 A_10_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI377_MN1 (B_11_b3_1 B_11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI377_MN1_1 (VSS B_11_b2_0 B_11_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI115_MN1 (A_10_b3_1 A_10_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI115_MN1_1 (VSS A_10_b2_0 A_10_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI124_MN1 (A_11_b3_0 A_11_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI124_MN1_1 (VSS A_11_b2_0 A_11_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI3_MN1 (B_1_b2_1 B_1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI3_MN1_1 (VSS B_1_b1_0 B_1_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI345_MN1 (B_5_b2_1 B_5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI345_MN1_1 (VSS B_5_b1_0 B_5_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI541_MN1 (one1_b2_1 one1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI541_MN1_1 (VSS one1_b1_0 one1_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI103_MN1 (A_9_b2_1 A_9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI103_MN1_1 (VSS A_9_b1_0 A_9_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI47_MN1 (A_3_b3_3 A_3_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI47_MN1_1 (VSS A_3_b2_1 A_3_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI882_MN1 (two7_b3_0 two7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI882_MN1_1 (VSS two7_b2_0 two7_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI818_MN1 (one6_b3_1 one6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI818_MN1_1 (VSS one6_b2_0 one6_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI828_MN1 (two6_b3_1 two6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI828_MN1_1 (VSS two6_b2_0 two6_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI368_MN1 (B_9_b3_2 B_9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI368_MN1_1 (VSS B_9_b2_0 B_9_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI719_MN1 (two4_b3_2 two4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI719_MN1_1 (VSS two4_b2_0 two4_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI715_MN1 (two4_b2_0 two4_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI715_MN1_1 (VSS two4_b1_0 two4_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI660_MN1 (two3_b2_0 two3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI660_MN1_1 (VSS two3_b1_0 two3_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI664_MN1 (two3_b3_2 two3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI664_MN1_1 (VSS two3_b2_0 two3_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_MN1 (one3_b3_2 one3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI654_MN1_1 (VSS one3_b2_0 one3_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI650_MN1 (one3_b2_0 one3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI650_MN1_1 (VSS one3_b1_0 one3_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI154_MN1 (A_14_b3_0 A_14_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI154_MN1_1 (VSS A_14_b2_0 A_14_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI596_MN1 (one2_b2_1 one2_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI596_MN1_1 (VSS one2_b1_0 one2_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI872_MN1 (one7_b3_0 one7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI872_MN1_1 (VSS one7_b2_0 one7_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI705_MN1 (one4_b2_0 one4_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI705_MN1_1 (VSS one4_b1_0 one4_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI709_MN1 (one4_b3_2 one4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI709_MN1_1 (VSS one4_b2_0 one4_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI714_MN1 (two4_b1_0 two4_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI714_MN1_1 (VSS two4_b0 two4_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI106_MN1 (A_9_b3_2 A_9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI106_MN1_1 (VSS A_9_b2_0 A_9_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI659_MN1 (two3_b1_0 two3_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI659_MN1_1 (VSS two3_b0 two3_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI649_MN1 (one3_b1_0 one3_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI649_MN1_1 (VSS one3_b0 one3_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI486_MN1 (one0_b2_1 one0_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI486_MN1_1 (VSS one0_b1_0 one0_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI111_MN1 (A_10_b1_0 A_10_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI111_MN1_1 (VSS A_10_b0 A_10_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI102_MN1 (A_9_b2_0 A_9_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI102_MN1_1 (VSS A_9_b1_0 A_9_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI113_MN1 (A_10_b2_1 A_10_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI113_MN1_1 (VSS A_10_b1_0 A_10_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI93_MN1 (A_8_b2_1 A_8_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI93_MN1_1 (VSS A_8_b1_0 A_8_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI83_MN1 (A_7_b2_1 A_7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI83_MN1_1 (VSS A_7_b1_0 A_7_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI37_MN1 (A_2_b3_3 A_2_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI37_MN1_1 (VSS A_2_b2_1 A_2_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI27_MN1 (A_1_b3_3 A_1_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI27_MN1_1 (VSS A_1_b2_1 A_1_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI53_MN1 (A_4_b2_1 A_4_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI53_MN1_1 (VSS A_4_b1_0 A_4_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI817_MN1 (one6_b3_0 one6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI817_MN1_1 (VSS one6_b2_0 one6_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI96_MN1 (A_8_b3_2 A_8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI96_MN1_1 (VSS A_8_b2_0 A_8_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI827_MN1 (two6_b3_0 two6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI827_MN1_1 (VSS two6_b2_0 two6_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI763_MN1 (one5_b3_1 one5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI763_MN1_1 (VSS one5_b2_0 one5_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI704_MN1 (one4_b1_0 one4_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI704_MN1_1 (VSS one4_b0 one4_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI356_MN1 (B_7_b3_0 B_7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI356_MN1_1 (VSS B_7_b2_0 B_7_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI599_MN1 (one2_b3_2 one2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI599_MN1_1 (VSS one2_b2_0 one2_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI348_MN1 (B_5_b3_2 B_5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI348_MN1_1 (VSS B_5_b2_0 B_5_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI609_MN1 (two2_b3_2 two2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI609_MN1_1 (VSS two2_b2_0 two2_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI344_MN1 (B_5_b2_0 B_5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI344_MN1_1 (VSS B_5_b1_0 B_5_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI605_MN1 (two2_b2_0 two2_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI605_MN1_1 (VSS two2_b1_0 two2_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI595_MN1 (one2_b2_0 one2_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI595_MN1_1 (VSS one2_b1_0 one2_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI604_MN1 (two2_b1_0 two2_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI604_MN1_1 (VSS two2_b0 two2_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI101_MN1 (A_9_b1_0 A_9_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI101_MN1_1 (VSS A_9_b0 A_9_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI92_MN1 (A_8_b2_0 A_8_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI92_MN1_1 (VSS A_8_b1_0 A_8_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI91_MN1 (A_8_b1_0 A_8_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI91_MN1_1 (VSS A_8_b0 A_8_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI82_MN1 (A_7_b2_0 A_7_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI82_MN1_1 (VSS A_7_b1_0 A_7_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI81_MN1 (A_7_b1_0 A_7_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI81_MN1_1 (VSS A_7_b0 A_7_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI63_MN1 (A_5_b2_1 A_5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI63_MN1_1 (VSS A_5_b1_0 A_5_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI73_MN1 (A_6_b2_1 A_6_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI73_MN1_1 (VSS A_6_b1_0 A_6_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI33_MN1 (A_2_b2_1 A_2_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI33_MN1_1 (VSS A_2_b1_0 A_2_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI17_MN1 (A_0_b3_3 A_0_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI17_MN1_1 (VSS A_0_b2_1 A_0_b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI367_MN1 (B_9_b3_1 B_9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI367_MN1_1 (VSS B_9_b2_0 B_9_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI366_MN1 (B_9_b3_0 B_9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI366_MN1_1 (VSS B_9_b2_0 B_9_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI86_MN1 (A_7_b3_2 A_7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI86_MN1_1 (VSS A_7_b2_0 A_7_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI105_MN1 (A_9_b3_1 A_9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI105_MN1_1 (VSS A_9_b2_0 A_9_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI544_MN1 (one1_b3_2 one1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI544_MN1_1 (VSS one1_b2_0 one1_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI554_MN1 (two1_b3_2 two1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI554_MN1_1 (VSS two1_b2_0 two1_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI343_MN1 (B_5_b1_0 B_5_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI343_MN1_1 (VSS B_5_b0 B_5_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI540_MN1 (one1_b2_0 one1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI540_MN1_1 (VSS one1_b1_0 one1_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI346_MN1 (B_5_b3_0 B_5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI346_MN1_1 (VSS B_5_b2_0 B_5_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI594_MN1 (one2_b1_0 one2_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI594_MN1_1 (VSS one2_b0 one2_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI496_MN1 (two0_b2_1 two0_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI496_MN1_1 (VSS two0_b1_0 two0_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI550_MN1 (two1_b2_0 two1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI550_MN1_1 (VSS two1_b1_0 two1_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI549_MN1 (two1_b1_0 two1_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI549_MN1_1 (VSS two1_b0 two1_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI539_MN1 (one1_b1_0 one1_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI539_MN1_1 (VSS one1_b0 one1_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI72_MN1 (A_6_b2_0 A_6_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI72_MN1_1 (VSS A_6_b1_0 A_6_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI71_MN1 (A_6_b1_0 A_6_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI71_MN1_1 (VSS A_6_b0 A_6_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI43_MN1 (A_3_b2_1 A_3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI43_MN1_1 (VSS A_3_b1_0 A_3_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI13_MN1 (A_0_b2_1 A_0_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI13_MN1_1 (VSS A_0_b1_0 A_0_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI23_MN1 (A_1_b2_1 A_1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI23_MN1_1 (VSS A_1_b1_0 A_1_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI773_MN1 (two5_b3_1 two5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI773_MN1_1 (VSS two5_b2_0 two5_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI762_MN1 (one5_b3_0 one5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI762_MN1_1 (VSS one5_b2_0 one5_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI708_MN1 (one4_b3_1 one4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI708_MN1_1 (VSS one4_b2_0 one4_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI66_MN1 (A_5_b3_2 A_5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI66_MN1_1 (VSS A_5_b2_0 A_5_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI76_MN1 (A_6_b3_2 A_6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI76_MN1_1 (VSS A_6_b2_0 A_6_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI95_MN1 (A_8_b3_1 A_8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI95_MN1_1 (VSS A_8_b2_0 A_8_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI357_MN1 (B_7_b3_1 B_7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI357_MN1_1 (VSS B_7_b2_0 B_7_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI338_MN1 (B_3_b3_2 B_3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI338_MN1_1 (VSS B_3_b2_0 B_3_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI104_MN1 (A_9_b3_0 A_9_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI104_MN1_1 (VSS A_9_b2_0 A_9_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI334_MN1 (B_3_b2_0 B_3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI334_MN1_1 (VSS B_3_b1_0 B_3_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI333_MN1 (B_3_b1_0 B_3_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI333_MN1_1 (VSS B_3_b0 B_3_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI499_MN1 (two0_b3_2 two0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI499_MN1_1 (VSS two0_b2_0 two0_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI94_MN1 (A_8_b3_0 A_8_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI94_MN1_1 (VSS A_8_b2_0 A_8_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI495_MN1 (two0_b2_0 two0_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI495_MN1_1 (VSS two0_b1_0 two0_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI494_MN1 (two0_b1_0 two0_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI494_MN1_1 (VSS two0_b0 two0_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI336_MN1 (B_3_b3_0 B_3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI336_MN1_1 (VSS B_3_b2_0 B_3_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI62_MN1 (A_5_b2_0 A_5_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI62_MN1_1 (VSS A_5_b1_0 A_5_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI61_MN1 (A_5_b1_0 A_5_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI61_MN1_1 (VSS A_5_b0 A_5_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI42_MN1 (A_3_b2_0 A_3_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI42_MN1_1 (VSS A_3_b1_0 A_3_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI32_MN1 (A_2_b2_0 A_2_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI32_MN1_1 (VSS A_2_b1_0 A_2_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI41_MN1 (A_3_b1_0 A_3_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI41_MN1_1 (VSS A_3_b0 A_3_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI31_MN1 (A_2_b1_0 A_2_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI31_MN1_1 (VSS A_2_b0 A_2_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI11_MN1 (A_0_b1_0 A_0_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI11_MN1_1 (VSS A_0_b0 A_0_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI12_MN1 (A_0_b2_0 A_0_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI12_MN1_1 (VSS A_0_b1_0 A_0_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI772_MN1 (two5_b3_0 two5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI772_MN1_1 (VSS two5_b2_0 two5_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI718_MN1 (two4_b3_1 two4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI718_MN1_1 (VSS two4_b2_0 two4_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI85_MN1 (A_7_b3_1 A_7_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI85_MN1_1 (VSS A_7_b2_0 A_7_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI75_MN1 (A_6_b3_1 A_6_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI75_MN1_1 (VSS A_6_b2_0 A_6_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI6_MN1 (B_1_b3_2 B_1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI6_MN1_1 (VSS B_1_b2_0 B_1_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_MN1 (B_1_b2_0 B_1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_MN1_1 (VSS B_1_b1_0 B_1_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_MN1 (B_1_b1_0 B_1_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_MN1_1 (VSS B_1_b0 B_1_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI489_MN1 (one0_b3_2 one0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI489_MN1_1 (VSS one0_b2_0 one0_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI485_MN1 (one0_b2_0 one0_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI485_MN1_1 (VSS one0_b1_0 one0_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI487_MN1 (one0_b3_0 one0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI487_MN1_1 (VSS one0_b2_0 one0_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI484_MN1 (one0_b1_0 one0_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI484_MN1_1 (VSS one0_b0 one0_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI22_MN1 (A_1_b2_0 A_1_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI22_MN1_1 (VSS A_1_b1_0 A_1_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI51_MN1 (A_4_b1_0 A_4_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI51_MN1_1 (VSS A_4_b0 A_4_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI14_MN1 (A_0_b3_0 A_0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI14_MN1_1 (VSS A_0_b2_0 A_0_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI21_MN1 (A_1_b1_0 A_1_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI21_MN1_1 (VSS A_1_b0 A_1_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI56_MN1 (A_4_b3_2 A_4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI56_MN1_1 (VSS A_4_b2_0 A_4_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI663_MN1 (two3_b3_1 two3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI663_MN1_1 (VSS two3_b2_0 two3_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI653_MN1 (one3_b3_1 one3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI653_MN1_1 (VSS one3_b2_0 one3_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI598_MN1 (one2_b3_1 one2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI598_MN1_1 (VSS one2_b2_0 one2_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_MN1 (two2_b3_1 two2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI608_MN1_1 (VSS two2_b2_0 two2_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI553_MN1 (two1_b3_1 two1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI553_MN1_1 (VSS two1_b2_0 two1_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI543_MN1 (one1_b3_1 one1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI543_MN1_1 (VSS one1_b2_0 one1_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI337_MN1 (B_3_b3_1 B_3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI337_MN1_1 (VSS B_3_b2_0 B_3_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI488_MN1 (one0_b3_1 one0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI488_MN1_1 (VSS one0_b2_0 one0_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI498_MN1 (two0_b3_1 two0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI498_MN1_1 (VSS two0_b2_0 two0_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI542_MN1 (one1_b3_0 one1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI542_MN1_1 (VSS one1_b2_0 one1_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI607_MN1 (two2_b3_0 two2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI607_MN1_1 (VSS two2_b2_0 two2_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI552_MN1 (two1_b3_0 two1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI552_MN1_1 (VSS two1_b2_0 two1_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI497_MN1 (two0_b3_0 two0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI497_MN1_1 (VSS two0_b2_0 two0_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI5_MN1 (B_1_b3_1 B_1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI5_MN1_1 (VSS B_1_b2_0 B_1_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI4_MN1 (B_1_b3_0 B_1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI4_MN1_1 (VSS B_1_b2_0 B_1_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI44_MN1 (A_3_b3_0 A_3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI44_MN1_1 (VSS A_3_b2_0 A_3_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI52_MN1 (A_4_b2_0 A_4_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI52_MN1_1 (VSS A_4_b1_0 A_4_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI24_MN1 (A_1_b3_0 A_1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI24_MN1_1 (VSS A_1_b2_0 A_1_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI34_MN1 (A_2_b3_0 A_2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI34_MN1_1 (VSS A_2_b2_0 A_2_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI46_MN1 (A_3_b3_2 A_3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI46_MN1_1 (VSS A_3_b2_0 A_3_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI36_MN1 (A_2_b3_2 A_2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI36_MN1_1 (VSS A_2_b2_0 A_2_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI707_MN1 (one4_b3_0 one4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI707_MN1_1 (VSS one4_b2_0 one4_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI717_MN1 (two4_b3_0 two4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI717_MN1_1 (VSS two4_b2_0 two4_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI65_MN1 (A_5_b3_1 A_5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI65_MN1_1 (VSS A_5_b2_0 A_5_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI55_MN1 (A_4_b3_1 A_4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI55_MN1_1 (VSS A_4_b2_0 A_4_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI662_MN1 (two3_b3_0 two3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI662_MN1_1 (VSS two3_b2_0 two3_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI652_MN1 (one3_b3_0 one3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI652_MN1_1 (VSS one3_b2_0 one3_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI597_MN1 (one2_b3_0 one2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI597_MN1_1 (VSS one2_b2_0 one2_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI64_MN1 (A_5_b3_0 A_5_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI64_MN1_1 (VSS A_5_b2_0 A_5_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI54_MN1 (A_4_b3_0 A_4_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI54_MN1_1 (VSS A_4_b2_0 A_4_b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI35_MN1 (A_2_b3_1 A_2_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI35_MN1_1 (VSS A_2_b2_0 A_2_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI45_MN1 (A_3_b3_1 A_3_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI45_MN1_1 (VSS A_3_b2_0 A_3_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI16_MN1 (A_0_b3_2 A_0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI16_MN1_1 (VSS A_0_b2_0 A_0_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI15_MN1 (A_0_b3_1 A_0_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI15_MN1_1 (VSS A_0_b2_0 A_0_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI26_MN1 (A_1_b3_2 A_1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI26_MN1_1 (VSS A_1_b2_0 A_1_b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI25_MN1 (A_1_b3_1 A_1_b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI25_MN1_1 (VSS A_1_b2_0 A_1_b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1640_MN5 (ha279_0 cm228_1 XI1640_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1640_MN7 (XI1640_xn2 XI1640_xan ha279_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1640_MN8 (VSS XI1640_xbn XI1640_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1640_MN6 (XI1640_xn1 cm229_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1640_MN1 (VSS cm228_1 XI1640_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1640_MN14 (XI1640_an cm229_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1640_MN13 (XI1640_con cm228_1 XI1640_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1640_MN17 (ha279_1 XI1640_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1640_MN3 (VSS cm229_0 XI1640_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1643_MN5 (ha282_0 cm231_1 XI1643_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1643_MN7 (XI1643_xn2 XI1643_xan ha282_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1643_MN8 (VSS XI1643_xbn XI1643_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1643_MN6 (XI1643_xn1 cm232_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1643_MN1 (VSS cm231_1 XI1643_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1643_MN14 (XI1643_an cm232_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1643_MN13 (XI1643_con cm231_1 XI1643_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1643_MN17 (ha282_1 XI1643_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1643_MN3 (VSS cm232_0 XI1643_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1645_MN5 (ha284_0 cm233_1 XI1645_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1645_MN7 (XI1645_xn2 XI1645_xan ha284_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1645_MN8 (VSS XI1645_xbn XI1645_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1645_MN6 (XI1645_xn1 cm234_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1645_MN1 (VSS cm233_1 XI1645_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1645_MN14 (XI1645_an cm234_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1645_MN13 (XI1645_con cm233_1 XI1645_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1645_MN17 (ha284_1 XI1645_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1645_MN3 (VSS cm234_0 XI1645_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1647_MN5 (ha286_0 cm235_1 XI1647_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1647_MN7 (XI1647_xn2 XI1647_xan ha286_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1647_MN8 (VSS XI1647_xbn XI1647_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1647_MN6 (XI1647_xn1 cm236_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1647_MN1 (VSS cm235_1 XI1647_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1647_MN14 (XI1647_an cm236_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1647_MN13 (XI1647_con cm235_1 XI1647_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1647_MN17 (ha286_1 XI1647_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1647_MN3 (VSS cm236_0 XI1647_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1649_MN5 (ha288_0 fa237_1 XI1649_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1649_MN7 (XI1649_xn2 XI1649_xan ha288_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1649_MN8 (VSS XI1649_xbn XI1649_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1649_MN6 (XI1649_xn1 cm238_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1649_MN1 (VSS fa237_1 XI1649_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1649_MN14 (XI1649_an cm238_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1649_MN13 (XI1649_con fa237_1 XI1649_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1649_MN17 (ha288_1 XI1649_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1649_MN3 (VSS cm238_0 XI1649_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1651_MN5 (ha290_0 fa239_1 XI1651_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1651_MN7 (XI1651_xn2 XI1651_xan ha290_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1651_MN8 (VSS XI1651_xbn XI1651_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1651_MN6 (XI1651_xn1 cm240_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1651_MN1 (VSS fa239_1 XI1651_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1651_MN14 (XI1651_an cm240_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1651_MN13 (XI1651_con fa239_1 XI1651_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1651_MN17 (ha290_1 XI1651_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1651_MN3 (VSS cm240_0 XI1651_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1653_MN5 (ha292_0 fa241_1 XI1653_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1653_MN7 (XI1653_xn2 XI1653_xan ha292_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1653_MN8 (VSS XI1653_xbn XI1653_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1653_MN6 (XI1653_xn1 fa242_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1653_MN1 (VSS fa241_1 XI1653_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1653_MN14 (XI1653_an fa242_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1653_MN13 (XI1653_con fa241_1 XI1653_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1653_MN17 (ha292_1 XI1653_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1653_MN3 (VSS fa242_0 XI1653_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1655_MN5 (ha294_0 cm199_1 XI1655_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1655_MN7 (XI1655_xn2 XI1655_xan ha294_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1655_MN8 (VSS XI1655_xbn XI1655_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1655_MN6 (XI1655_xn1 cm200_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1655_MN1 (VSS cm199_1 XI1655_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1655_MN14 (XI1655_an cm200_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1655_MN13 (XI1655_con cm199_1 XI1655_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1655_MN17 (ha294_1 XI1655_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1655_MN3 (VSS cm200_0 XI1655_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1639_MN5 (ha278_0 cm227_1 XI1639_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1639_MN7 (XI1639_xn2 XI1639_xan ha278_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1639_MN8 (VSS XI1639_xbn XI1639_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1639_MN6 (XI1639_xn1 cm228_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1639_MN1 (VSS cm227_1 XI1639_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1639_MN14 (XI1639_an cm228_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1639_MN13 (XI1639_con cm227_1 XI1639_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1639_MN17 (ha278_1 XI1639_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1639_MN3 (VSS cm228_0 XI1639_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1636_MN5 (ha275_0 cm224_1 XI1636_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1636_MN7 (XI1636_xn2 XI1636_xan ha275_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1636_MN8 (VSS XI1636_xbn XI1636_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1636_MN6 (XI1636_xn1 cm225_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1636_MN1 (VSS cm224_1 XI1636_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1636_MN14 (XI1636_an cm225_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1636_MN13 (XI1636_con cm224_1 XI1636_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1636_MN17 (ha275_1 XI1636_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1636_MN3 (VSS cm225_0 XI1636_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1638_MN5 (ha277_0 cm226_1 XI1638_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1638_MN7 (XI1638_xn2 XI1638_xan ha277_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1638_MN8 (VSS XI1638_xbn XI1638_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1638_MN6 (XI1638_xn1 cm227_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1638_MN1 (VSS cm226_1 XI1638_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1638_MN14 (XI1638_an cm227_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1638_MN13 (XI1638_con cm226_1 XI1638_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1638_MN17 (ha277_1 XI1638_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1638_MN3 (VSS cm227_0 XI1638_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1635_MN5 (ha274_0 cm223_1 XI1635_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1635_MN7 (XI1635_xn2 XI1635_xan ha274_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1635_MN8 (VSS XI1635_xbn XI1635_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1635_MN6 (XI1635_xn1 cm224_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1635_MN1 (VSS cm223_1 XI1635_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1635_MN14 (XI1635_an cm224_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1635_MN13 (XI1635_con cm223_1 XI1635_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1635_MN17 (ha274_1 XI1635_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1635_MN3 (VSS cm224_0 XI1635_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1637_MN5 (ha276_0 cm225_1 XI1637_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1637_MN7 (XI1637_xn2 XI1637_xan ha276_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1637_MN8 (VSS XI1637_xbn XI1637_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1637_MN6 (XI1637_xn1 cm226_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1637_MN1 (VSS cm225_1 XI1637_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1637_MN14 (XI1637_an cm226_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1637_MN13 (XI1637_con cm225_1 XI1637_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1637_MN17 (ha276_1 XI1637_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1637_MN3 (VSS cm226_0 XI1637_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1634_MN5 (ha273_0 cm222_1 XI1634_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1634_MN7 (XI1634_xn2 XI1634_xan ha273_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1634_MN8 (VSS XI1634_xbn XI1634_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1634_MN6 (XI1634_xn1 cm223_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1634_MN1 (VSS cm222_1 XI1634_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1634_MN14 (XI1634_an cm223_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1634_MN13 (XI1634_con cm222_1 XI1634_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1634_MN17 (ha273_1 XI1634_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1634_MN3 (VSS cm223_0 XI1634_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1632_MN5 (ha271_0 cm220_1 XI1632_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1632_MN7 (XI1632_xn2 XI1632_xan ha271_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1632_MN8 (VSS XI1632_xbn XI1632_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1632_MN6 (XI1632_xn1 cm221_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1632_MN1 (VSS cm220_1 XI1632_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1632_MN14 (XI1632_an cm221_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1632_MN13 (XI1632_con cm220_1 XI1632_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1632_MN17 (ha271_1 XI1632_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1632_MN3 (VSS cm221_0 XI1632_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1633_MN5 (ha272_0 cm221_1 XI1633_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1633_MN7 (XI1633_xn2 XI1633_xan ha272_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1633_MN8 (VSS XI1633_xbn XI1633_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1633_MN6 (XI1633_xn1 cm222_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1633_MN1 (VSS cm221_1 XI1633_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1633_MN14 (XI1633_an cm222_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1633_MN13 (XI1633_con cm221_1 XI1633_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1633_MN17 (ha272_1 XI1633_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1633_MN3 (VSS cm222_0 XI1633_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1630_MN5 (ha269_0 cm218_1 XI1630_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1630_MN7 (XI1630_xn2 XI1630_xan ha269_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1630_MN8 (VSS XI1630_xbn XI1630_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1630_MN6 (XI1630_xn1 cm219_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1630_MN1 (VSS cm218_1 XI1630_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1630_MN14 (XI1630_an cm219_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1630_MN13 (XI1630_con cm218_1 XI1630_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1630_MN17 (ha269_1 XI1630_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1630_MN3 (VSS cm219_0 XI1630_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1631_MN5 (ha270_0 cm219_1 XI1631_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1631_MN7 (XI1631_xn2 XI1631_xan ha270_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1631_MN8 (VSS XI1631_xbn XI1631_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1631_MN6 (XI1631_xn1 cm220_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1631_MN1 (VSS cm219_1 XI1631_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1631_MN14 (XI1631_an cm220_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1631_MN13 (XI1631_con cm219_1 XI1631_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1631_MN17 (ha270_1 XI1631_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1631_MN3 (VSS cm220_0 XI1631_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1628_MN5 (ha267_0 cm216_1 XI1628_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1628_MN7 (XI1628_xn2 XI1628_xan ha267_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1628_MN8 (VSS XI1628_xbn XI1628_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1628_MN6 (XI1628_xn1 cm217_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1628_MN1 (VSS cm216_1 XI1628_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1628_MN14 (XI1628_an cm217_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1628_MN13 (XI1628_con cm216_1 XI1628_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1628_MN17 (ha267_1 XI1628_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1628_MN3 (VSS cm217_0 XI1628_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1629_MN5 (ha268_0 cm217_1 XI1629_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1629_MN7 (XI1629_xn2 XI1629_xan ha268_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1629_MN8 (VSS XI1629_xbn XI1629_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1629_MN6 (XI1629_xn1 cm218_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1629_MN1 (VSS cm217_1 XI1629_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1629_MN14 (XI1629_an cm218_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1629_MN13 (XI1629_con cm217_1 XI1629_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1629_MN17 (ha268_1 XI1629_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1629_MN3 (VSS cm218_0 XI1629_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1626_MN5 (ha265_0 cm214_1 XI1626_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1626_MN7 (XI1626_xn2 XI1626_xan ha265_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1626_MN8 (VSS XI1626_xbn XI1626_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1626_MN6 (XI1626_xn1 cm215_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1626_MN1 (VSS cm214_1 XI1626_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1626_MN14 (XI1626_an cm215_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1626_MN13 (XI1626_con cm214_1 XI1626_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1626_MN17 (ha265_1 XI1626_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1626_MN3 (VSS cm215_0 XI1626_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1627_MN5 (ha266_0 cm215_1 XI1627_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1627_MN7 (XI1627_xn2 XI1627_xan ha266_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1627_MN8 (VSS XI1627_xbn XI1627_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1627_MN6 (XI1627_xn1 cm216_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1627_MN1 (VSS cm215_1 XI1627_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1627_MN14 (XI1627_an cm216_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1627_MN13 (XI1627_con cm215_1 XI1627_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1627_MN17 (ha266_1 XI1627_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1627_MN3 (VSS cm216_0 XI1627_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1625_MN5 (ha264_0 fa213_1 XI1625_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1625_MN7 (XI1625_xn2 XI1625_xan ha264_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1625_MN8 (VSS XI1625_xbn XI1625_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1625_MN6 (XI1625_xn1 cm214_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1625_MN1 (VSS fa213_1 XI1625_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1625_MN14 (XI1625_an cm214_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1625_MN13 (XI1625_con fa213_1 XI1625_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1625_MN17 (ha264_1 XI1625_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1625_MN3 (VSS cm214_0 XI1625_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1624_MN5 (ha263_0 fa212_1 XI1624_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1624_MN7 (XI1624_xn2 XI1624_xan ha263_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1624_MN8 (VSS XI1624_xbn XI1624_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1624_MN6 (XI1624_xn1 fa213_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1624_MN1 (VSS fa212_1 XI1624_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1624_MN14 (XI1624_an fa213_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1624_MN13 (XI1624_con fa212_1 XI1624_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1624_MN17 (ha263_1 XI1624_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1624_MN3 (VSS fa213_0 XI1624_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1622_MN5 (ha261_0 fa210_1 XI1622_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1622_MN7 (XI1622_xn2 XI1622_xan ha261_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1622_MN8 (VSS XI1622_xbn XI1622_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1622_MN6 (XI1622_xn1 fa211_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1622_MN1 (VSS fa210_1 XI1622_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1622_MN14 (XI1622_an fa211_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1622_MN13 (XI1622_con fa210_1 XI1622_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1622_MN17 (ha261_1 XI1622_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1622_MN3 (VSS fa211_0 XI1622_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1623_MN5 (ha262_0 fa211_1 XI1623_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1623_MN7 (XI1623_xn2 XI1623_xan ha262_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1623_MN8 (VSS XI1623_xbn XI1623_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1623_MN6 (XI1623_xn1 fa212_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1623_MN1 (VSS fa211_1 XI1623_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1623_MN14 (XI1623_an fa212_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1623_MN13 (XI1623_con fa211_1 XI1623_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1623_MN17 (ha262_1 XI1623_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1623_MN3 (VSS fa212_0 XI1623_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1621_MN5 (ha260_0 fa210_0 XI1621_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1621_MN7 (XI1621_xn2 XI1621_xan ha260_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1621_MN8 (VSS XI1621_xbn XI1621_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1621_MN6 (XI1621_xn1 B_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1621_MN1 (VSS fa210_0 XI1621_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1621_MN14 (XI1621_an B_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1621_MN13 (XI1621_con fa210_0 XI1621_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1621_MN17 (ha260_1 XI1621_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1621_MN3 (VSS B_17_b3_5 XI1621_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1620_MN5 (ha259_0 cm144_1 XI1620_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1620_MN7 (XI1620_xn2 XI1620_xan ha259_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1620_MN8 (VSS XI1620_xbn XI1620_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1620_MN6 (XI1620_xn1 cm145_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1620_MN1 (VSS cm144_1 XI1620_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1620_MN14 (XI1620_an cm145_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1620_MN13 (XI1620_con cm144_1 XI1620_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1620_MN17 (ha259_1 XI1620_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1620_MN3 (VSS cm145_0 XI1620_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1619_MN5 (ha258_0 cm143_1 XI1619_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1619_MN7 (XI1619_xn2 XI1619_xan ha258_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1619_MN8 (VSS XI1619_xbn XI1619_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1619_MN6 (XI1619_xn1 cm144_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1619_MN1 (VSS cm143_1 XI1619_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1619_MN14 (XI1619_an cm144_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1619_MN13 (XI1619_con cm143_1 XI1619_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1619_MN17 (ha258_1 XI1619_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1619_MN3 (VSS cm144_0 XI1619_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1618_MN5 (ha257_0 cm142_1 XI1618_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1618_MN7 (XI1618_xn2 XI1618_xan ha257_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1618_MN8 (VSS XI1618_xbn XI1618_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1618_MN6 (XI1618_xn1 cm143_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1618_MN1 (VSS cm142_1 XI1618_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1618_MN14 (XI1618_an cm143_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1618_MN13 (XI1618_con cm142_1 XI1618_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1618_MN17 (ha257_1 XI1618_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1618_MN3 (VSS cm143_0 XI1618_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1617_MN5 (ha256_0 cm141_1 XI1617_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1617_MN7 (XI1617_xn2 XI1617_xan ha256_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1617_MN8 (VSS XI1617_xbn XI1617_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1617_MN6 (XI1617_xn1 cm142_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1617_MN1 (VSS cm141_1 XI1617_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1617_MN14 (XI1617_an cm142_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1617_MN13 (XI1617_con cm141_1 XI1617_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1617_MN17 (ha256_1 XI1617_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1617_MN3 (VSS cm142_0 XI1617_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1611_MN5 (ha250_0 fa3_1 XI1611_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1611_MN7 (XI1611_xn2 XI1611_xan ha250_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1611_MN8 (VSS XI1611_xbn XI1611_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1611_MN6 (XI1611_xn1 cm4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1611_MN1 (VSS fa3_1 XI1611_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1611_MN14 (XI1611_an cm4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1611_MN13 (XI1611_con fa3_1 XI1611_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1611_MN17 (ha250_1 XI1611_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1611_MN3 (VSS cm4_0 XI1611_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1616_MN5 (ha255_0 fa140_1 XI1616_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1616_MN7 (XI1616_xn2 XI1616_xan ha255_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1616_MN8 (VSS XI1616_xbn XI1616_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1616_MN6 (XI1616_xn1 cm141_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1616_MN1 (VSS fa140_1 XI1616_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1616_MN14 (XI1616_an cm141_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1616_MN13 (XI1616_con fa140_1 XI1616_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1616_MN17 (ha255_1 XI1616_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1616_MN3 (VSS cm141_0 XI1616_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1615_MN5 (ha254_0 fa139_1 XI1615_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1615_MN7 (XI1615_xn2 XI1615_xan ha254_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1615_MN8 (VSS XI1615_xbn XI1615_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1615_MN6 (XI1615_xn1 fa140_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1615_MN1 (VSS fa139_1 XI1615_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1615_MN14 (XI1615_an fa140_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1615_MN13 (XI1615_con fa139_1 XI1615_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1615_MN17 (ha254_1 XI1615_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1615_MN3 (VSS fa140_0 XI1615_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1613_MN5 (ha252_0 fa138_0 XI1613_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1613_MN7 (XI1613_xn2 XI1613_xan ha252_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1613_MN8 (VSS XI1613_xbn XI1613_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1613_MN6 (XI1613_xn1 B_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1613_MN1 (VSS fa138_0 XI1613_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1613_MN14 (XI1613_an B_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1613_MN13 (XI1613_con fa138_0 XI1613_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1613_MN17 (ha252_1 XI1613_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1613_MN3 (VSS B_9_b3_5 XI1613_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1612_MN5 (ha251_0 cm4_1 XI1612_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1612_MN7 (XI1612_xn2 XI1612_xan ha251_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1612_MN8 (VSS XI1612_xbn XI1612_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1612_MN6 (XI1612_xn1 cm5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1612_MN1 (VSS cm4_1 XI1612_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1612_MN14 (XI1612_an cm5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1612_MN13 (XI1612_con cm4_1 XI1612_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1612_MN17 (ha251_1 XI1612_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1612_MN3 (VSS cm5_0 XI1612_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1614_MN5 (ha253_0 fa138_1 XI1614_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1614_MN7 (XI1614_xn2 XI1614_xan ha253_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1614_MN8 (VSS XI1614_xbn XI1614_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1614_MN6 (XI1614_xn1 fa139_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1614_MN1 (VSS fa138_1 XI1614_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1614_MN14 (XI1614_an fa139_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1614_MN13 (XI1614_con fa138_1 XI1614_an VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1614_MN17 (ha253_1 XI1614_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1614_MN3 (VSS fa139_0 XI1614_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1660_I234_XG_MN2 (I1660_G42_39n I1660_G42_41 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I234_XG_MN0 (XI1660_I234_XG_n1 I1660_P42_41 I1660_G42_39n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I234_XG_MN1 (VSS I1660_G40_39 XI1660_I234_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I236_XG_MN2 (I1660_G44_41n I1660_G44_43 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I236_XG_MN0 (XI1660_I236_XG_n1 I1660_P44_43 I1660_G44_41n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I236_XG_MN1 (VSS I1660_G42_41 XI1660_I236_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I238_XG_MN2 (I1660_G46_43n I1660_G46_45 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I238_XG_MN0 (XI1660_I238_XG_n1 I1660_P46_45 I1660_G46_43n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I238_XG_MN1 (VSS I1660_G44_43 XI1660_I238_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I232_XG_MN2 (I1660_G40_37n I1660_G40_39 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I232_XG_MN0 (XI1660_I232_XG_n1 I1660_P40_39 I1660_G40_37n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I232_XG_MN1 (VSS I1660_G38_37 XI1660_I232_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I240_XG_MN2 (I1660_G48_45n I1660_G48_47 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I240_XG_MN0 (XI1660_I240_XG_n1 I1660_P48_47 I1660_G48_45n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I240_XG_MN1 (VSS I1660_G46_45 XI1660_I240_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I242_XG_MN2 (I1660_G50_47n I1660_G50_49 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I242_XG_MN0 (XI1660_I242_XG_n1 I1660_P50_49 I1660_G50_47n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I242_XG_MN1 (VSS I1660_G48_47 XI1660_I242_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I244_XG_MN2 (I1660_G52_49n I1660_G52_51 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I244_XG_MN0 (XI1660_I244_XG_n1 I1660_P52_51 I1660_G52_49n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I244_XG_MN1 (VSS I1660_G50_49 XI1660_I244_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I246_XG_MN2 (I1660_G54_51n I1660_G54_53 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I246_XG_MN0 (XI1660_I246_XG_n1 I1660_P54_53 I1660_G54_51n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I246_XG_MN1 (VSS I1660_G52_51 XI1660_I246_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I230_XG_MN2 (I1660_G38_35n I1660_G38_37 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I230_XG_MN0 (XI1660_I230_XG_n1 I1660_P38_37 I1660_G38_35n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I230_XG_MN1 (VSS I1660_G36_35 XI1660_I230_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I363_XG_MN2 (I1660_G52_37n I1660_G52_45 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I363_XG_MN0 (XI1660_I363_XG_n1 I1660_P52_45 I1660_G52_37n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I363_XG_MN1 (VSS I1660_G44_37 XI1660_I363_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I367_XG_MN2 (I1660_G56_41n I1660_G56_49 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I367_XG_MN0 (XI1660_I367_XG_n1 I1660_P56_49 I1660_G56_41n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I367_XG_MN1 (VSS I1660_G48_41 XI1660_I367_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I371_XG_MN2 (I1660_G60_45n I1660_G60_53 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I371_XG_MN0 (XI1660_I371_XG_n1 I1660_P60_53 I1660_G60_45n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I371_XG_MN1 (VSS I1660_G52_45 XI1660_I371_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I248_XG_MN2 (I1660_G56_53n I1660_G56_55 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I248_XG_MN0 (XI1660_I248_XG_n1 I1660_P56_55 I1660_G56_53n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I248_XG_MN1 (VSS I1660_G54_53 XI1660_I248_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I250_XG_MN2 (I1660_G58_55n I1660_G58_57 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I250_XG_MN0 (XI1660_I250_XG_n1 I1660_P58_57 I1660_G58_55n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I250_XG_MN1 (VSS I1660_G56_55 XI1660_I250_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I228_XG_MN2 (I1660_G36_33n I1660_G36_35 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I228_XG_MN0 (XI1660_I228_XG_n1 I1660_P36_35 I1660_G36_33n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I228_XG_MN1 (VSS I1660_G34_33 XI1660_I228_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I252_XG_MN2 (I1660_G60_57n I1660_G60_59 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I252_XG_MN0 (XI1660_I252_XG_n1 I1660_P60_59 I1660_G60_57n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I252_XG_MN1 (VSS I1660_G58_57 XI1660_I252_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I226_XG_MN2 (I1660_G34_31n I1660_G34_33 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I226_XG_MN0 (XI1660_I226_XG_n1 I1660_P34_33 I1660_G34_31n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I226_XG_MN1 (VSS I1660_G32_31 XI1660_I226_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I359_XG_MN2 (I1660_G48_33n I1660_G48_41 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I359_XG_MN0 (XI1660_I359_XG_n1 I1660_P48_41 I1660_G48_33n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I359_XG_MN1 (VSS I1660_G40_33 XI1660_I359_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I355_XG_MN2 (I1660_G44_29n I1660_G44_37 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I355_XG_MN0 (XI1660_I355_XG_n1 I1660_P44_37 I1660_G44_29n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I355_XG_MN1 (VSS I1660_G36_29 XI1660_I355_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I463_XG_MN2 (I1660_G60_0n I1660_G60_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I463_XG_MN0 (XI1660_I463_XG_n1 I1660_P60_29 I1660_G60_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I463_XG_MN1 (VSS I1660_G28_0 XI1660_I463_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I365_XG_MN2 (I1660_G54_39n I1660_G54_47 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I365_XG_MN0 (XI1660_I365_XG_n1 I1660_P54_47 I1660_G54_39n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I365_XG_MN1 (VSS I1660_G46_39 XI1660_I365_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I357_XG_MN2 (I1660_G46_31n I1660_G46_39 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I357_XG_MN0 (XI1660_I357_XG_n1 I1660_P46_39 I1660_G46_31n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I357_XG_MN1 (VSS I1660_G38_31 XI1660_I357_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I369_XG_MN2 (I1660_G58_43n I1660_G58_51 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I369_XG_MN0 (XI1660_I369_XG_n1 I1660_P58_51 I1660_G58_43n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I369_XG_MN1 (VSS I1660_G50_43 XI1660_I369_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I373_XG_MN2 (I1660_G62_47n I1660_G62_55 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I373_XG_MN0 (XI1660_I373_XG_n1 I1660_P62_55 I1660_G62_47n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I373_XG_MN1 (VSS I1660_G54_47 XI1660_I373_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I254_XG_MN2 (I1660_G62_59n I1660_G62_61 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I254_XG_MN0 (XI1660_I254_XG_n1 I1660_P62_61 I1660_G62_59n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I254_XG_MN1 (VSS I1660_G60_59 XI1660_I254_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I253_XG_MN2 (I1660_G61_58n I1660_G61_60 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I253_XG_MN0 (XI1660_I253_XG_n1 I1660_P61_60 I1660_G61_58n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I253_XG_MN1 (VSS I1660_G59_58 XI1660_I253_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I255_XG_MN2 (I1660_G63_60n I1660_G63_62 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I255_XG_MN0 (XI1660_I255_XG_n1 I1660_P63_62 I1660_G63_60n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I255_XG_MN1 (VSS I1660_G61_60 XI1660_I255_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I224_XG_MN2 (I1660_G32_29n I1660_G32_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I224_XG_MN0 (XI1660_I224_XG_n1 I1660_P32_31 I1660_G32_29n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I224_XG_MN1 (VSS I1660_G30_29 XI1660_I224_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I444_XG_MN2 (I1660_G44_0n I1660_G44_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I444_XG_MN0 (XI1660_I444_XG_n1 I1660_P44_13 I1660_G44_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I444_XG_MN1 (VSS I1660_G12_0np XI1660_I444_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I361_XG_MN2 (I1660_G50_35n I1660_G50_43 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I361_XG_MN0 (XI1660_I361_XG_n1 I1660_P50_43 I1660_G50_35n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I361_XG_MN1 (VSS I1660_G42_35 XI1660_I361_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I448_XG_MN2 (I1660_G46_0n I1660_G46_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I448_XG_MN0 (XI1660_I448_XG_n1 I1660_P46_15 I1660_G46_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I448_XG_MN1 (VSS I1660_G14_0np XI1660_I448_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I465_XG_MN2 (I1660_G62_0n I1660_G62_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I465_XG_MN0 (XI1660_I465_XG_n1 I1660_P62_31 I1660_G62_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I465_XG_MN1 (VSS I1660_G30_0 XI1660_I465_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I241_XG_MN2 (I1660_G49_46n I1660_G49_48 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I241_XG_MN0 (XI1660_I241_XG_n1 I1660_P49_48 I1660_G49_46n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I241_XG_MN1 (VSS I1660_G47_46 XI1660_I241_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I243_XG_MN2 (I1660_G51_48n I1660_G51_50 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I243_XG_MN0 (XI1660_I243_XG_n1 I1660_P51_50 I1660_G51_48n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I243_XG_MN1 (VSS I1660_G49_48 XI1660_I243_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I245_XG_MN2 (I1660_G53_50n I1660_G53_52 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I245_XG_MN0 (XI1660_I245_XG_n1 I1660_P53_52 I1660_G53_50n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I245_XG_MN1 (VSS I1660_G51_50 XI1660_I245_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I251_XG_MN2 (I1660_G59_56n I1660_G59_58 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I251_XG_MN0 (XI1660_I251_XG_n1 I1660_P59_58 I1660_G59_56n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I251_XG_MN1 (VSS I1660_G57_56 XI1660_I251_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I249_XG_MN2 (I1660_G57_54n I1660_G57_56 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I249_XG_MN0 (XI1660_I249_XG_n1 I1660_P57_56 I1660_G57_54n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I249_XG_MN1 (VSS I1660_G55_54 XI1660_I249_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I459_XG_MN2 (I1660_G56_0n I1660_G56_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I459_XG_MN0 (XI1660_I459_XG_n1 I1660_P56_25 I1660_G56_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I459_XG_MN1 (VSS I1660_G24_0 XI1660_I459_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I349_XG_MN2 (I1660_G38_23n I1660_G38_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I349_XG_MN0 (XI1660_I349_XG_n1 I1660_P38_31 I1660_G38_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I349_XG_MN1 (VSS I1660_G30_23 XI1660_I349_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I353_XG_MN2 (I1660_G42_27n I1660_G42_35 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I353_XG_MN0 (XI1660_I353_XG_n1 I1660_P42_35 I1660_G42_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I353_XG_MN1 (VSS I1660_G34_27 XI1660_I353_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I461_XG_MN2 (I1660_G58_0n I1660_G58_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I461_XG_MN0 (XI1660_I461_XG_n1 I1660_P58_27 I1660_G58_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I461_XG_MN1 (VSS I1660_G26_0 XI1660_I461_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I239_XG_MN2 (I1660_G47_44n I1660_G47_46 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I239_XG_MN0 (XI1660_I239_XG_n1 I1660_P47_46 I1660_G47_44n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I239_XG_MN1 (VSS I1660_G45_44 XI1660_I239_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I247_XG_MN2 (I1660_G55_52n I1660_G55_54 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I247_XG_MN0 (XI1660_I247_XG_n1 I1660_P55_54 I1660_G55_52n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I247_XG_MN1 (VSS I1660_G53_52 XI1660_I247_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I222_XG_MN2 (I1660_G30_27n I1660_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I222_XG_MN0 (XI1660_I222_XG_n1 I1660_P30_29 I1660_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I222_XG_MN1 (VSS I1660_G28_27 XI1660_I222_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I351_XG_MN2 (I1660_G40_25n I1660_G40_33 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I351_XG_MN0 (XI1660_I351_XG_n1 I1660_P40_33 I1660_G40_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I351_XG_MN1 (VSS I1660_G32_25 XI1660_I351_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I341_XG_MN2 (I1660_G30_15n I1660_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I341_XG_MN0 (XI1660_I341_XG_n1 I1660_P30_23 I1660_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I341_XG_MN1 (VSS I1660_G22_15 XI1660_I341_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I457_XG_MN2 (I1660_G54_0n I1660_G54_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I457_XG_MN0 (XI1660_I457_XG_n1 I1660_P54_23 I1660_G54_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I457_XG_MN1 (VSS I1660_G22_0 XI1660_I457_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I237_XG_MN2 (I1660_G45_42n I1660_G45_44 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I237_XG_MN0 (XI1660_I237_XG_n1 I1660_P45_44 I1660_G45_42n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I237_XG_MN1 (VSS I1660_G43_42 XI1660_I237_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I220_XG_MN2 (I1660_G28_25n I1660_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I220_XG_MN0 (XI1660_I220_XG_n1 I1660_P28_27 I1660_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I220_XG_MN1 (VSS I1660_G26_25 XI1660_I220_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I339_XG_MN2 (I1660_G28_13n I1660_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I339_XG_MN0 (XI1660_I339_XG_n1 I1660_P28_21 I1660_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I339_XG_MN1 (VSS I1660_G20_13 XI1660_I339_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I347_XG_MN2 (I1660_G36_21n I1660_G36_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I347_XG_MN0 (XI1660_I347_XG_n1 I1660_P36_29 I1660_G36_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I347_XG_MN1 (VSS I1660_G28_21 XI1660_I347_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I440_XG_MN2 (I1660_G42_0n I1660_G42_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I440_XG_MN0 (XI1660_I440_XG_n1 I1660_P42_11 I1660_G42_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I440_XG_MN1 (VSS I1660_G10_0np XI1660_I440_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I233_XG_MN2 (I1660_G41_38n I1660_G41_40 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I233_XG_MN0 (XI1660_I233_XG_n1 I1660_P41_40 I1660_G41_38n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I233_XG_MN1 (VSS I1660_G39_38 XI1660_I233_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I235_XG_MN2 (I1660_G43_40n I1660_G43_42 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I235_XG_MN0 (XI1660_I235_XG_n1 I1660_P43_42 I1660_G43_40n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I235_XG_MN1 (VSS I1660_G41_40 XI1660_I235_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I364_XG_MN2 (I1660_G53_38n I1660_G53_46 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I364_XG_MN0 (XI1660_I364_XG_n1 I1660_P53_46 I1660_G53_38n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I364_XG_MN1 (VSS I1660_G45_38 XI1660_I364_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I372_XG_MN2 (I1660_G61_46n I1660_G61_54 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I372_XG_MN0 (XI1660_I372_XG_n1 I1660_P61_54 I1660_G61_46n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I372_XG_MN1 (VSS I1660_G53_46 XI1660_I372_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I374_XG_MN2 (I1660_G63_48n I1660_G63_56 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I374_XG_MN0 (XI1660_I374_XG_n1 I1660_P63_56 I1660_G63_48n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I374_XG_MN1 (VSS I1660_G55_48 XI1660_I374_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I218_XG_MN2 (I1660_G26_23n I1660_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I218_XG_MN0 (XI1660_I218_XG_n1 I1660_P26_25 I1660_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I218_XG_MN1 (VSS I1660_G24_23 XI1660_I218_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I436_XG_MN2 (I1660_G40_0n I1660_G40_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I436_XG_MN0 (XI1660_I436_XG_n1 I1660_P40_9 I1660_G40_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I436_XG_MN1 (VSS I1660_G8_0np XI1660_I436_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I455_XG_MN2 (I1660_G52_0n I1660_G52_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I455_XG_MN0 (XI1660_I455_XG_n1 I1660_P52_21 I1660_G52_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I455_XG_MN1 (VSS I1660_G20_0 XI1660_I455_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I345_XG_MN2 (I1660_G34_19n I1660_G34_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I345_XG_MN0 (XI1660_I345_XG_n1 I1660_P34_27 I1660_G34_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I345_XG_MN1 (VSS I1660_G26_19 XI1660_I345_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I453_XG_MN2 (I1660_G50_0n I1660_G50_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I453_XG_MN0 (XI1660_I453_XG_n1 I1660_P50_19 I1660_G50_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I453_XG_MN1 (VSS I1660_G18_0 XI1660_I453_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I356_XG_MN2 (I1660_G45_30n I1660_G45_38 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I356_XG_MN0 (XI1660_I356_XG_n1 I1660_P45_38 I1660_G45_30n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I356_XG_MN1 (VSS I1660_G37_30 XI1660_I356_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I464_XG_MN2 (I1660_G61_0n I1660_G61_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I464_XG_MN0 (XI1660_I464_XG_n1 I1660_P61_30 I1660_G61_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I464_XG_MN1 (VSS I1660_G29_0 XI1660_I464_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I370_XG_MN2 (I1660_G59_44n I1660_G59_52 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I370_XG_MN0 (XI1660_I370_XG_n1 I1660_P59_52 I1660_G59_44n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I370_XG_MN1 (VSS I1660_G51_44 XI1660_I370_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I343_XG_MN2 (I1660_G32_17n I1660_G32_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I343_XG_MN0 (XI1660_I343_XG_n1 I1660_P32_25 I1660_G32_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I343_XG_MN1 (VSS I1660_G24_17 XI1660_I343_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I337_XG_MN2 (I1660_G26_11n I1660_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I337_XG_MN0 (XI1660_I337_XG_n1 I1660_P26_19 I1660_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I337_XG_MN1 (VSS I1660_G18_11 XI1660_I337_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I433_XG_MN2 (I1660_G38_0n I1660_G38_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I433_XG_MN0 (XI1660_I433_XG_n1 I1660_P38_7 I1660_G38_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I433_XG_MN1 (VSS I1660_G6_0 XI1660_I433_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I229_XG_MN2 (I1660_G37_34n I1660_G37_36 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I229_XG_MN0 (XI1660_I229_XG_n1 I1660_P37_36 I1660_G37_34n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I229_XG_MN1 (VSS I1660_G35_34 XI1660_I229_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I231_XG_MN2 (I1660_G39_36n I1660_G39_38 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I231_XG_MN0 (XI1660_I231_XG_n1 I1660_P39_38 I1660_G39_36n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I231_XG_MN1 (VSS I1660_G37_36 XI1660_I231_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I446_XG_MN2 (I1660_G45_0n I1660_G45_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I446_XG_MN0 (XI1660_I446_XG_n1 I1660_P45_14 I1660_G45_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I446_XG_MN1 (VSS I1660_G13_0np XI1660_I446_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I368_XG_MN2 (I1660_G57_42n I1660_G57_50 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I368_XG_MN0 (XI1660_I368_XG_n1 I1660_P57_50 I1660_G57_42n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I368_XG_MN1 (VSS I1660_G49_42 XI1660_I368_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I460_XG_MN2 (I1660_G57_0n I1660_G57_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I460_XG_MN0 (XI1660_I460_XG_n1 I1660_P57_26 I1660_G57_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I460_XG_MN1 (VSS I1660_G25_0 XI1660_I460_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I362_XG_MN2 (I1660_G51_36n I1660_G51_44 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I362_XG_MN0 (XI1660_I362_XG_n1 I1660_P51_44 I1660_G51_36n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I362_XG_MN1 (VSS I1660_G43_36 XI1660_I362_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I462_XG_MN2 (I1660_G59_0n I1660_G59_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I462_XG_MN0 (XI1660_I462_XG_n1 I1660_P59_28 I1660_G59_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I462_XG_MN1 (VSS I1660_G27_0 XI1660_I462_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I216_XG_MN2 (I1660_G24_21n I1660_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I216_XG_MN0 (XI1660_I216_XG_n1 I1660_P24_23 I1660_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I216_XG_MN1 (VSS I1660_G22_21 XI1660_I216_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I335_XG_MN2 (I1660_G24_9n I1660_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I335_XG_MN0 (XI1660_I335_XG_n1 I1660_P24_17 I1660_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I335_XG_MN1 (VSS I1660_G16_9 XI1660_I335_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I451_XG_MN2 (I1660_G48_0n I1660_G48_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I451_XG_MN0 (XI1660_I451_XG_n1 I1660_P48_17 I1660_G48_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I451_XG_MN1 (VSS I1660_G16_0 XI1660_I451_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I333_XG_MN2 (I1660_G22_7n I1660_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I333_XG_MN0 (XI1660_I333_XG_n1 I1660_P22_15 I1660_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I333_XG_MN1 (VSS I1660_G14_7 XI1660_I333_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I225_XG_MN2 (I1660_G33_30n I1660_G33_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I225_XG_MN0 (XI1660_I225_XG_n1 I1660_P33_32 I1660_G33_30n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I225_XG_MN1 (VSS I1660_G31_30 XI1660_I225_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I227_XG_MN2 (I1660_G35_32n I1660_G35_34 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I227_XG_MN0 (XI1660_I227_XG_n1 I1660_P35_34 I1660_G35_32n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I227_XG_MN1 (VSS I1660_G33_32 XI1660_I227_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I360_XG_MN2 (I1660_G49_34n I1660_G49_42 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I360_XG_MN0 (XI1660_I360_XG_n1 I1660_P49_42 I1660_G49_34n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I360_XG_MN1 (VSS I1660_G41_34 XI1660_I360_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I358_XG_MN2 (I1660_G47_32n I1660_G47_40 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I358_XG_MN0 (XI1660_I358_XG_n1 I1660_P47_40 I1660_G47_32n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I358_XG_MN1 (VSS I1660_G39_32 XI1660_I358_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I354_XG_MN2 (I1660_G43_28n I1660_G43_36 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I354_XG_MN0 (XI1660_I354_XG_n1 I1660_P43_36 I1660_G43_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I354_XG_MN1 (VSS I1660_G35_28 XI1660_I354_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I366_XG_MN2 (I1660_G55_40n I1660_G55_48 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I366_XG_MN0 (XI1660_I366_XG_n1 I1660_P55_48 I1660_G55_40n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I366_XG_MN1 (VSS I1660_G47_40 XI1660_I366_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I214_XG_MN2 (I1660_G22_19n I1660_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I214_XG_MN0 (XI1660_I214_XG_n1 I1660_P22_21 I1660_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I214_XG_MN1 (VSS I1660_G20_19 XI1660_I214_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I331_XG_MN2 (I1660_G20_5n I1660_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I331_XG_MN0 (XI1660_I331_XG_n1 I1660_P20_13 I1660_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I331_XG_MN1 (VSS I1660_G12_5 XI1660_I331_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I325_XG_MN2 (I1660_G14_0n I1660_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I325_XG_MN0 (XI1660_I325_XG_n1 I1660_P14_7 I1660_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I325_XG_MN1 (VSS I1660_G6_0 XI1660_I325_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I221_XG_MN2 (I1660_G29_26n I1660_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I221_XG_MN0 (XI1660_I221_XG_n1 I1660_P29_28 I1660_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I221_XG_MN1 (VSS I1660_G27_26 XI1660_I221_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I223_XG_MN2 (I1660_G31_28n I1660_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I223_XG_MN0 (XI1660_I223_XG_n1 I1660_P31_30 I1660_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I223_XG_MN1 (VSS I1660_G29_28 XI1660_I223_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I352_XG_MN2 (I1660_G41_26n I1660_G41_34 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I352_XG_MN0 (XI1660_I352_XG_n1 I1660_P41_34 I1660_G41_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I352_XG_MN1 (VSS I1660_G33_26 XI1660_I352_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I466_XG_MN2 (I1660_G63_0n I1660_G63_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I466_XG_MN0 (XI1660_I466_XG_n1 I1660_P63_32 I1660_G63_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I466_XG_MN1 (VSS I1660_G31_0 XI1660_I466_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I212_XG_MN2 (I1660_G20_17n I1660_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I212_XG_MN0 (XI1660_I212_XG_n1 I1660_P20_19 I1660_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I212_XG_MN1 (VSS I1660_G18_17 XI1660_I212_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I323_XG_MN2 (I1660_G12_0n I1660_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I323_XG_MN0 (XI1660_I323_XG_n1 I1660_P12_5 I1660_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I323_XG_MN1 (VSS I1660_G4_0 XI1660_I323_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I431_XG_MN2 (I1660_G36_0n I1660_G36_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I431_XG_MN0 (XI1660_I431_XG_n1 I1660_P36_5 I1660_G36_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I431_XG_MN1 (VSS I1660_G4_0 XI1660_I431_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I429_XG_MN2 (I1660_G34_0n I1660_G34_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I429_XG_MN0 (XI1660_I429_XG_n1 I1660_P34_3 I1660_G34_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I429_XG_MN1 (VSS I1660_G2_0np XI1660_I429_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I219_XG_MN2 (I1660_G27_24n I1660_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I219_XG_MN0 (XI1660_I219_XG_n1 I1660_P27_26 I1660_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I219_XG_MN1 (VSS I1660_G25_24 XI1660_I219_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I348_XG_MN2 (I1660_G37_22n I1660_G37_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I348_XG_MN0 (XI1660_I348_XG_n1 I1660_P37_30 I1660_G37_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I348_XG_MN1 (VSS I1660_G29_22 XI1660_I348_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I456_XG_MN2 (I1660_G53_0n I1660_G53_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I456_XG_MN0 (XI1660_I456_XG_n1 I1660_P53_22 I1660_G53_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I456_XG_MN1 (VSS I1660_G21_0 XI1660_I456_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I350_XG_MN2 (I1660_G39_24n I1660_G39_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I350_XG_MN0 (XI1660_I350_XG_n1 I1660_P39_32 I1660_G39_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I350_XG_MN1 (VSS I1660_G31_24 XI1660_I350_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I458_XG_MN2 (I1660_G55_0n I1660_G55_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I458_XG_MN0 (XI1660_I458_XG_n1 I1660_P55_24 I1660_G55_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I458_XG_MN1 (VSS I1660_G23_0 XI1660_I458_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I450_XG_MN2 (I1660_G47_0n I1660_G47_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I450_XG_MN0 (XI1660_I450_XG_n1 I1660_P47_16 I1660_G47_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I450_XG_MN1 (VSS I1660_G15_0np XI1660_I450_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I210_XG_MN2 (I1660_G18_15n I1660_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I210_XG_MN0 (XI1660_I210_XG_n1 I1660_P18_17 I1660_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I210_XG_MN1 (VSS I1660_G16_15 XI1660_I210_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I427_XG_MN2 (I1660_G32_0n I1660_G32_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I427_XG_MN0 (XI1660_I427_XG_n1 I1660_P32_1 I1660_G32_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I427_XG_MN1 (VSS I1660_G0_0 XI1660_I427_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I329_XG_MN2 (I1660_G18_3n I1660_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I329_XG_MN0 (XI1660_I329_XG_n1 I1660_P18_11 I1660_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I329_XG_MN1 (VSS I1660_G10_3 XI1660_I329_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I215_XG_MN2 (I1660_G23_20n I1660_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I215_XG_MN0 (XI1660_I215_XG_n1 I1660_P23_22 I1660_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I215_XG_MN1 (VSS I1660_G21_20 XI1660_I215_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I217_XG_MN2 (I1660_G25_22n I1660_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I217_XG_MN0 (XI1660_I217_XG_n1 I1660_P25_24 I1660_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I217_XG_MN1 (VSS I1660_G23_22 XI1660_I217_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I340_XG_MN2 (I1660_G29_14n I1660_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I340_XG_MN0 (XI1660_I340_XG_n1 I1660_P29_22 I1660_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I340_XG_MN1 (VSS I1660_G21_14 XI1660_I340_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I344_XG_MN2 (I1660_G33_18n I1660_G33_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I344_XG_MN0 (XI1660_I344_XG_n1 I1660_P33_26 I1660_G33_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I344_XG_MN1 (VSS I1660_G25_18 XI1660_I344_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I438_XG_MN2 (I1660_G41_0n I1660_G41_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I438_XG_MN0 (XI1660_I438_XG_n1 I1660_P41_10 I1660_G41_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I438_XG_MN1 (VSS I1660_G9_0np XI1660_I438_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I342_XG_MN2 (I1660_G31_16n I1660_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I342_XG_MN0 (XI1660_I342_XG_n1 I1660_P31_24 I1660_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I342_XG_MN1 (VSS I1660_G23_16 XI1660_I342_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I327_XG_MN2 (I1660_G16_1n I1660_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I327_XG_MN0 (XI1660_I327_XG_n1 I1660_P16_9 I1660_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I327_XG_MN1 (VSS I1660_G8_1 XI1660_I327_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I213_XG_MN2 (I1660_G21_18n I1660_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I213_XG_MN0 (XI1660_I213_XG_n1 I1660_P21_20 I1660_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I213_XG_MN1 (VSS I1660_G19_18 XI1660_I213_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I336_XG_MN2 (I1660_G25_10n I1660_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I336_XG_MN0 (XI1660_I336_XG_n1 I1660_P25_18 I1660_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I336_XG_MN1 (VSS I1660_G17_10 XI1660_I336_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I452_XG_MN2 (I1660_G49_0n I1660_G49_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I452_XG_MN0 (XI1660_I452_XG_n1 I1660_P49_18 I1660_G49_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I452_XG_MN1 (VSS I1660_G17_0 XI1660_I452_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I346_XG_MN2 (I1660_G35_20n I1660_G35_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I346_XG_MN0 (XI1660_I346_XG_n1 I1660_P35_28 I1660_G35_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I346_XG_MN1 (VSS I1660_G27_20 XI1660_I346_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I454_XG_MN2 (I1660_G51_0n I1660_G51_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I454_XG_MN0 (XI1660_I454_XG_n1 I1660_P51_20 I1660_G51_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I454_XG_MN1 (VSS I1660_G19_0 XI1660_I454_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I442_XG_MN2 (I1660_G43_0n I1660_G43_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I442_XG_MN0 (XI1660_I442_XG_n1 I1660_P43_12 I1660_G43_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I442_XG_MN1 (VSS I1660_G11_0np XI1660_I442_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I208_XG_MN2 (I1660_G16_13n I1660_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I208_XG_MN0 (XI1660_I208_XG_n1 I1660_P16_15 I1660_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I208_XG_MN1 (VSS I1660_G14_13 XI1660_I208_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I317_XG_MN2 (I1660_G8_0n I1660_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I317_XG_MN0 (XI1660_I317_XG_n1 I1660_P8_1 I1660_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I317_XG_MN1 (VSS I1660_G0_0 XI1660_I317_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I320_XG_MN2 (I1660_G10_0n I1660_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I320_XG_MN0 (XI1660_I320_XG_n1 I1660_P10_3 I1660_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I320_XG_MN1 (VSS I1660_G2_0np XI1660_I320_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I209_XG_MN2 (I1660_G17_14n I1660_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I209_XG_MN0 (XI1660_I209_XG_n1 I1660_P17_16 I1660_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I209_XG_MN1 (VSS I1660_G15_14 XI1660_I209_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I211_XG_MN2 (I1660_G19_16n I1660_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I211_XG_MN0 (XI1660_I211_XG_n1 I1660_P19_18 I1660_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I211_XG_MN1 (VSS I1660_G17_16 XI1660_I211_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I332_XG_MN2 (I1660_G21_6n I1660_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I332_XG_MN0 (XI1660_I332_XG_n1 I1660_P21_14 I1660_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I332_XG_MN1 (VSS I1660_G13_6 XI1660_I332_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I338_XG_MN2 (I1660_G27_12n I1660_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I338_XG_MN0 (XI1660_I338_XG_n1 I1660_P27_20 I1660_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I338_XG_MN1 (VSS I1660_G19_12 XI1660_I338_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I206_XG_MN2 (I1660_G14_11n I1660_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I206_XG_MN0 (XI1660_I206_XG_n1 I1660_P14_13 I1660_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I206_XG_MN1 (VSS I1660_G12_11 XI1660_I206_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I432_XG_MN2 (I1660_G37_0n I1660_G37_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I432_XG_MN0 (XI1660_I432_XG_n1 I1660_P37_6 I1660_G37_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I432_XG_MN1 (VSS I1660_G5_0 XI1660_I432_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I328_XG_MN2 (I1660_G17_2n I1660_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I328_XG_MN0 (XI1660_I328_XG_n1 I1660_P17_10 I1660_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I328_XG_MN1 (VSS I1660_G9_2 XI1660_I328_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I334_XG_MN2 (I1660_G23_8n I1660_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I334_XG_MN0 (XI1660_I334_XG_n1 I1660_P23_16 I1660_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I334_XG_MN1 (VSS I1660_G15_8 XI1660_I334_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I204_XG_MN2 (I1660_G12_9n I1660_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I204_XG_MN0 (XI1660_I204_XG_n1 I1660_P12_11 I1660_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I204_XG_MN1 (VSS I1660_G10_9 XI1660_I204_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I202_XG_MN2 (I1660_G10_7n I1660_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I202_XG_MN0 (XI1660_I202_XG_n1 I1660_P10_9 I1660_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I202_XG_MN1 (VSS I1660_G8_7 XI1660_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I196_XG_MN2 (I1660_G4_1n I1660_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I196_XG_MN0 (XI1660_I196_XG_n1 I1660_P4_3 I1660_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I196_XG_MN1 (VSS I1660_G2_1 XI1660_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I194_XG_MN2 (I1660_G2_0n I1660_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I194_XG_MN0 (XI1660_I194_XG_n1 I1660_P2_1 I1660_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I194_XG_MN1 (VSS I1660_G0_0 XI1660_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I207_XG_MN2 (I1660_G15_12n I1660_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I207_XG_MN0 (XI1660_I207_XG_n1 I1660_P15_14 I1660_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I207_XG_MN1 (VSS I1660_G13_12 XI1660_I207_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I205_XG_MN2 (I1660_G13_10n I1660_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I205_XG_MN0 (XI1660_I205_XG_n1 I1660_P13_12 I1660_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I205_XG_MN1 (VSS I1660_G11_10 XI1660_I205_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I324_XG_MN2 (I1660_G13_0n I1660_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I324_XG_MN0 (XI1660_I324_XG_n1 I1660_P13_6 I1660_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I324_XG_MN1 (VSS I1660_G5_0 XI1660_I324_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I326_XG_MN2 (I1660_G15_0n I1660_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I326_XG_MN0 (XI1660_I326_XG_n1 I1660_P15_8 I1660_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I326_XG_MN1 (VSS I1660_G7_0 XI1660_I326_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I434_XG_MN2 (I1660_G39_0n I1660_G39_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I434_XG_MN0 (XI1660_I434_XG_n1 I1660_P39_8 I1660_G39_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I434_XG_MN1 (VSS I1660_G7_0 XI1660_I434_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I200_XG_MN2 (I1660_G8_5n I1660_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I200_XG_MN0 (XI1660_I200_XG_n1 I1660_P8_7 I1660_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I200_XG_MN1 (VSS I1660_G6_5 XI1660_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I198_XG_MN2 (I1660_G6_3n I1660_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I198_XG_MN0 (XI1660_I198_XG_n1 I1660_P6_5 I1660_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I198_XG_MN1 (VSS I1660_G4_3 XI1660_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I203_XG_MN2 (I1660_G11_8n I1660_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I203_XG_MN0 (XI1660_I203_XG_n1 I1660_P11_10 I1660_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I203_XG_MN1 (VSS I1660_G9_8 XI1660_I203_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I428_XG_MN2 (I1660_G33_0n I1660_G33_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I428_XG_MN0 (XI1660_I428_XG_n1 I1660_P33_2 I1660_G33_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I428_XG_MN1 (VSS I1660_G1_0 XI1660_I428_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I318_XG_MN2 (I1660_G9_0n I1660_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I318_XG_MN0 (XI1660_I318_XG_n1 I1660_P9_2 I1660_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I318_XG_MN1 (VSS I1660_G1_0 XI1660_I318_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I330_XG_MN2 (I1660_G19_4n I1660_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I330_XG_MN0 (XI1660_I330_XG_n1 I1660_P19_12 I1660_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I330_XG_MN1 (VSS I1660_G11_4 XI1660_I330_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I430_XG_MN2 (I1660_G35_0n I1660_G35_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I430_XG_MN0 (XI1660_I430_XG_n1 I1660_P35_4 I1660_G35_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I430_XG_MN1 (VSS I1660_G3_0np XI1660_I430_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I201_XG_MN2 (I1660_G9_6n I1660_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I201_XG_MN0 (XI1660_I201_XG_n1 I1660_P9_8 I1660_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I201_XG_MN1 (VSS I1660_G7_6 XI1660_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I199_XG_MN2 (I1660_G7_4n I1660_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I199_XG_MN0 (XI1660_I199_XG_n1 I1660_P7_6 I1660_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I199_XG_MN1 (VSS I1660_G5_4 XI1660_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I197_XG_MN2 (I1660_G5_2n I1660_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I197_XG_MN0 (XI1660_I197_XG_n1 I1660_P5_4 I1660_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I197_XG_MN1 (VSS I1660_G3_2 XI1660_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I322_XG_MN2 (I1660_G11_0n I1660_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I322_XG_MN0 (XI1660_I322_XG_n1 I1660_P11_4 I1660_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I322_XG_MN1 (VSS I1660_G3_0np XI1660_I322_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1660_I195_XG_MN2 (I1660_G3_0n I1660_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1660_I195_XG_MN0 (XI1660_I195_XG_n1 I1660_P3_2 I1660_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1660_I195_XG_MN1 (VSS I1660_G1_0 XI1660_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1603_MN12 (XI1603_sn pp15_18 XI1603_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1603_MN25 (fa242_0 XI1603_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1603_MN5 (XI1603_con pp15_18 XI1603_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1603_MN2 (XI1603_n1 cm198_0 XI1603_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1603_MN1 (VSS cm197_1 XI1603_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1603_MN3 (XI1603_n2 cm197_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1603_MN4 (VSS cm198_0 XI1603_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1603_MN27 (fa242_1 XI1603_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1603_MN10 (XI1603_n4 cm197_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1603_MN11 (XI1603_n5 cm198_0 XI1603_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1603_MN11_1 (XI1603_n4 cm198_0 XI1603_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1603_MN10_1 (VSS cm197_1 XI1603_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1603_MN6 (XI1603_n3 cm197_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1603_MN7 (VSS cm198_0 XI1603_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1603_MN8 (XI1603_n3 pp15_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1603_MN9 (XI1603_sn XI1603_con XI1603_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1603_MN12_1 (XI1603_n5 pp15_18 XI1603_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1654_MN12 (XI1654_sn cm199_0 XI1654_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1654_MN25 (fa293_0 XI1654_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1654_MN5 (XI1654_con cm199_0 XI1654_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1654_MN2 (XI1654_n1 cm198_1 XI1654_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1654_MN1 (VSS fa242_1 XI1654_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1654_MN3 (XI1654_n2 fa242_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1654_MN4 (VSS cm198_1 XI1654_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1654_MN27 (fa293_1 XI1654_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1654_MN10 (XI1654_n4 fa242_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1654_MN11 (XI1654_n5 cm198_1 XI1654_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1654_MN11_1 (XI1654_n4 cm198_1 XI1654_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1654_MN10_1 (VSS fa242_1 XI1654_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1654_MN6 (XI1654_n3 fa242_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1654_MN7 (VSS cm198_1 XI1654_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1654_MN8 (XI1654_n3 cm199_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1654_MN9 (XI1654_sn XI1654_con XI1654_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1654_MN12_1 (XI1654_n5 cm199_0 XI1654_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1604_MN12 (XI1604_sn cm124_2 XI1604_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1604_MN25 (fa243_0 XI1604_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1604_MN5 (XI1604_con cm124_2 XI1604_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1604_MN2 (XI1604_n1 cm201_0 XI1604_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1604_MN1 (VSS cm200_1 XI1604_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1604_MN3 (XI1604_n2 cm200_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1604_MN4 (VSS cm201_0 XI1604_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1604_MN27 (fa243_1 XI1604_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1604_MN10 (XI1604_n4 cm200_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1604_MN11 (XI1604_n5 cm201_0 XI1604_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1604_MN11_1 (XI1604_n4 cm201_0 XI1604_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1604_MN10_1 (VSS cm200_1 XI1604_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1604_MN6 (XI1604_n3 cm200_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1604_MN7 (VSS cm201_0 XI1604_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1604_MN8 (XI1604_n3 cm124_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1604_MN9 (XI1604_sn XI1604_con XI1604_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1604_MN12_1 (XI1604_n5 cm124_2 XI1604_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1547_MN12 (XI1547_sn pp15_9 XI1547_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1547_MN25 (fa186_0 XI1547_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1547_MN5 (XI1547_con pp15_9 XI1547_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1547_MN2 (XI1547_n1 cm97_0 XI1547_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1547_MN1 (VSS cm96_0 XI1547_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1547_MN3 (XI1547_n2 cm96_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1547_MN4 (VSS cm97_0 XI1547_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1547_MN27 (fa186_1 XI1547_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1547_MN10 (XI1547_n4 cm96_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1547_MN11 (XI1547_n5 cm97_0 XI1547_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1547_MN11_1 (XI1547_n4 cm97_0 XI1547_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1547_MN10_1 (VSS cm96_0 XI1547_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1547_MN6 (XI1547_n3 cm96_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1547_MN7 (VSS cm97_0 XI1547_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1547_MN8 (XI1547_n3 pp15_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1547_MN9 (XI1547_sn XI1547_con XI1547_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1547_MN12_1 (XI1547_n5 pp15_9 XI1547_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1598_MN12 (XI1598_sn fa192_0 XI1598_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1598_MN25 (fa237_0 XI1598_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1598_MN5 (XI1598_con fa192_0 XI1598_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1598_MN2 (XI1598_n1 cm191_0 XI1598_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1598_MN1 (VSS cm190_1 XI1598_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1598_MN3 (XI1598_n2 cm190_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1598_MN4 (VSS cm191_0 XI1598_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1598_MN27 (fa237_1 XI1598_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1598_MN10 (XI1598_n4 cm190_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1598_MN11 (XI1598_n5 cm191_0 XI1598_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1598_MN11_1 (XI1598_n4 cm191_0 XI1598_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1598_MN10_1 (VSS cm190_1 XI1598_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1598_MN6 (XI1598_n3 cm190_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1598_MN7 (VSS cm191_0 XI1598_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1598_MN8 (XI1598_n3 fa192_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1598_MN9 (XI1598_sn XI1598_con XI1598_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1598_MN12_1 (XI1598_n5 fa192_0 XI1598_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1648_MN12 (XI1648_sn cm236_2 XI1648_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1648_MN25 (fa287_0 XI1648_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1648_MN5 (XI1648_con cm236_2 XI1648_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1648_MN2 (XI1648_n1 fa237_0 XI1648_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1648_MN1 (VSS cm236_1 XI1648_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1648_MN3 (XI1648_n2 cm236_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1648_MN4 (VSS fa237_0 XI1648_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1648_MN27 (fa287_1 XI1648_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1648_MN10 (XI1648_n4 cm236_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1648_MN11 (XI1648_n5 fa237_0 XI1648_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1648_MN11_1 (XI1648_n4 fa237_0 XI1648_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1648_MN10_1 (VSS cm236_1 XI1648_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1648_MN6 (XI1648_n3 cm236_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1648_MN7 (VSS fa237_0 XI1648_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1648_MN8 (XI1648_n3 cm236_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1648_MN9 (XI1648_sn XI1648_con XI1648_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1648_MN12_1 (XI1648_n5 cm236_2 XI1648_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1487_MN12 (XI1487_sn pp15_21 XI1487_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1487_MN25 (fa126_0 XI1487_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1487_MN5 (XI1487_con pp15_21 XI1487_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1487_MN2 (XI1487_n1 pp14_23 XI1487_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1487_MN1 (VSS pp13_25 XI1487_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1487_MN3 (XI1487_n2 pp13_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1487_MN4 (VSS pp14_23 XI1487_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1487_MN27 (fa126_1 XI1487_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1487_MN10 (XI1487_n4 pp13_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1487_MN11 (XI1487_n5 pp14_23 XI1487_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1487_MN11_1 (XI1487_n4 pp14_23 XI1487_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1487_MN10_1 (VSS pp13_25 XI1487_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1487_MN6 (XI1487_n3 pp13_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1487_MN7 (VSS pp14_23 XI1487_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1487_MN8 (XI1487_n3 pp15_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1487_MN9 (XI1487_sn XI1487_con XI1487_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1487_MN12_1 (XI1487_n5 pp15_21 XI1487_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1549_MN12 (XI1549_sn pp15_10 XI1549_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1549_MN25 (fa188_0 XI1549_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1549_MN5 (XI1549_con pp15_10 XI1549_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1549_MN2 (XI1549_n1 cm100_0 XI1549_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1549_MN1 (VSS cm99_0 XI1549_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1549_MN3 (XI1549_n2 cm99_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1549_MN4 (VSS cm100_0 XI1549_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1549_MN27 (fa188_1 XI1549_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1549_MN10 (XI1549_n4 cm99_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1549_MN11 (XI1549_n5 cm100_0 XI1549_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1549_MN11_1 (XI1549_n4 cm100_0 XI1549_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1549_MN10_1 (VSS cm99_0 XI1549_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1549_MN6 (XI1549_n3 cm99_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1549_MN7 (VSS cm100_0 XI1549_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1549_MN8 (XI1549_n3 pp15_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1549_MN9 (XI1549_sn XI1549_con XI1549_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1549_MN12_1 (XI1549_n5 pp15_10 XI1549_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1646_MN12 (XI1646_sn cm103_0 XI1646_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1646_MN25 (fa285_0 XI1646_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1646_MN5 (XI1646_con cm103_0 XI1646_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1646_MN2 (XI1646_n1 cm235_0 XI1646_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1646_MN1 (VSS cm234_1 XI1646_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1646_MN3 (XI1646_n2 cm234_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1646_MN4 (VSS cm235_0 XI1646_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1646_MN27 (fa285_1 XI1646_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1646_MN10 (XI1646_n4 cm234_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1646_MN11 (XI1646_n5 cm235_0 XI1646_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1646_MN11_1 (XI1646_n4 cm235_0 XI1646_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1646_MN10_1 (VSS cm234_1 XI1646_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1646_MN6 (XI1646_n3 cm234_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1646_MN7 (VSS cm235_0 XI1646_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1646_MN8 (XI1646_n3 cm103_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1646_MN9 (XI1646_sn XI1646_con XI1646_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1646_MN12_1 (XI1646_n5 cm103_0 XI1646_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1553_MN12 (XI1553_sn cm106_2 XI1553_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1553_MN25 (fa192_0 XI1553_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1553_MN5 (XI1553_con cm106_2 XI1553_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1553_MN2 (XI1553_n1 fa109_0 XI1553_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1553_MN1 (VSS cm108_0 XI1553_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1553_MN3 (XI1553_n2 cm108_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1553_MN4 (VSS fa109_0 XI1553_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1553_MN27 (fa192_1 XI1553_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1553_MN10 (XI1553_n4 cm108_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1553_MN11 (XI1553_n5 fa109_0 XI1553_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1553_MN11_1 (XI1553_n4 fa109_0 XI1553_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1553_MN10_1 (VSS cm108_0 XI1553_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1553_MN6 (XI1553_n3 cm108_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1553_MN7 (VSS fa109_0 XI1553_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1553_MN8 (XI1553_n3 cm106_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1553_MN9 (XI1553_sn XI1553_con XI1553_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1553_MN12_1 (XI1553_n5 cm106_2 XI1553_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1489_MN12 (XI1489_sn pp15_22 XI1489_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1489_MN25 (fa128_0 XI1489_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1489_MN5 (XI1489_con pp15_22 XI1489_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1489_MN2 (XI1489_n1 pp14_24 XI1489_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1489_MN1 (VSS pp13_26 XI1489_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1489_MN3 (XI1489_n2 pp13_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1489_MN4 (VSS pp14_24 XI1489_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1489_MN27 (fa128_1 XI1489_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1489_MN10 (XI1489_n4 pp13_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1489_MN11 (XI1489_n5 pp14_24 XI1489_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1489_MN11_1 (XI1489_n4 pp14_24 XI1489_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1489_MN10_1 (VSS pp13_26 XI1489_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1489_MN6 (XI1489_n3 pp13_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1489_MN7 (VSS pp14_24 XI1489_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1489_MN8 (XI1489_n3 pp15_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1489_MN9 (XI1489_sn XI1489_con XI1489_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1489_MN12_1 (XI1489_n5 pp15_22 XI1489_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1656_MN12 (XI1656_sn cm202_0 XI1656_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1656_MN25 (fa295_0 XI1656_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1656_MN5 (XI1656_con cm202_0 XI1656_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1656_MN2 (XI1656_n1 cm201_1 XI1656_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1656_MN1 (VSS fa243_1 XI1656_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1656_MN3 (XI1656_n2 fa243_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1656_MN4 (VSS cm201_1 XI1656_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1656_MN27 (fa295_1 XI1656_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1656_MN10 (XI1656_n4 fa243_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1656_MN11 (XI1656_n5 cm201_1 XI1656_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1656_MN11_1 (XI1656_n4 cm201_1 XI1656_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1656_MN10_1 (VSS fa243_1 XI1656_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1656_MN6 (XI1656_n3 fa243_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1656_MN7 (VSS cm201_1 XI1656_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1656_MN8 (XI1656_n3 cm202_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1656_MN9 (XI1656_sn XI1656_con XI1656_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1656_MN12_1 (XI1656_n5 cm202_0 XI1656_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1644_MN12 (XI1644_sn cm184_2 XI1644_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1644_MN25 (fa283_0 XI1644_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1644_MN5 (XI1644_con cm184_2 XI1644_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1644_MN2 (XI1644_n1 cm233_0 XI1644_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1644_MN1 (VSS cm232_1 XI1644_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1644_MN3 (XI1644_n2 cm232_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1644_MN4 (VSS cm233_0 XI1644_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1644_MN27 (fa283_1 XI1644_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1644_MN10 (XI1644_n4 cm232_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1644_MN11 (XI1644_n5 cm233_0 XI1644_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1644_MN11_1 (XI1644_n4 cm233_0 XI1644_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1644_MN10_1 (VSS cm232_1 XI1644_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1644_MN6 (XI1644_n3 cm232_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1644_MN7 (VSS cm233_0 XI1644_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1644_MN8 (XI1644_n3 cm184_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1644_MN9 (XI1644_sn XI1644_con XI1644_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1644_MN12_1 (XI1644_n5 cm184_2 XI1644_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1470_MN12 (XI1470_sn pp15_13 XI1470_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1470_MN25 (fa109_0 XI1470_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1470_MN5 (XI1470_con pp15_13 XI1470_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1470_MN2 (XI1470_n1 pp14_15 XI1470_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1470_MN1 (VSS pp13_17 XI1470_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1470_MN3 (XI1470_n2 pp13_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1470_MN4 (VSS pp14_15 XI1470_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1470_MN27 (fa109_1 XI1470_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1470_MN10 (XI1470_n4 pp13_17 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1470_MN11 (XI1470_n5 pp14_15 XI1470_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1470_MN11_1 (XI1470_n4 pp14_15 XI1470_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1470_MN10_1 (VSS pp13_17 XI1470_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1470_MN6 (XI1470_n3 pp13_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1470_MN7 (VSS pp14_15 XI1470_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1470_MN8 (XI1470_n3 pp15_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1470_MN9 (XI1470_sn XI1470_con XI1470_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1470_MN12_1 (XI1470_n5 pp15_13 XI1470_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1473_MN12 (XI1473_sn pp15_14 XI1473_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1473_MN25 (fa112_0 XI1473_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1473_MN5 (XI1473_con pp15_14 XI1473_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1473_MN2 (XI1473_n1 pp14_16 XI1473_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1473_MN1 (VSS pp13_18 XI1473_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1473_MN3 (XI1473_n2 pp13_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1473_MN4 (VSS pp14_16 XI1473_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1473_MN27 (fa112_1 XI1473_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1473_MN10 (XI1473_n4 pp13_18 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1473_MN11 (XI1473_n5 pp14_16 XI1473_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1473_MN11_1 (XI1473_n4 pp14_16 XI1473_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1473_MN10_1 (VSS pp13_18 XI1473_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1473_MN6 (XI1473_n3 pp13_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1473_MN7 (VSS pp14_16 XI1473_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1473_MN8 (XI1473_n3 pp15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1473_MN9 (XI1473_sn XI1473_con XI1473_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1473_MN12_1 (XI1473_n5 pp15_14 XI1473_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1605_MN12 (XI1605_sn pp15_23 XI1605_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1605_MN25 (fa244_0 XI1605_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1605_MN5 (XI1605_con pp15_23 XI1605_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1605_MN2 (XI1605_n1 cm203_0 XI1605_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1605_MN1 (VSS cm202_1 XI1605_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1605_MN3 (XI1605_n2 cm202_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1605_MN4 (VSS cm203_0 XI1605_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1605_MN27 (fa244_1 XI1605_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1605_MN10 (XI1605_n4 cm202_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1605_MN11 (XI1605_n5 cm203_0 XI1605_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1605_MN11_1 (XI1605_n4 cm203_0 XI1605_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1605_MN10_1 (VSS cm202_1 XI1605_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1605_MN6 (XI1605_n3 cm202_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1605_MN7 (VSS cm203_0 XI1605_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1605_MN8 (XI1605_n3 pp15_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1605_MN9 (XI1605_sn XI1605_con XI1605_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1605_MN12_1 (XI1605_n5 pp15_23 XI1605_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1449_MN12 (XI1449_sn pp15_6 XI1449_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1449_MN25 (fa88_0 XI1449_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1449_MN5 (XI1449_con pp15_6 XI1449_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1449_MN2 (XI1449_n1 pp14_8 XI1449_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1449_MN1 (VSS pp13_10 XI1449_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1449_MN3 (XI1449_n2 pp13_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1449_MN4 (VSS pp14_8 XI1449_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1449_MN27 (fa88_1 XI1449_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1449_MN10 (XI1449_n4 pp13_10 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1449_MN11 (XI1449_n5 pp14_8 XI1449_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1449_MN11_1 (XI1449_n4 pp14_8 XI1449_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1449_MN10_1 (VSS pp13_10 XI1449_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1449_MN6 (XI1449_n3 pp13_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1449_MN7 (VSS pp14_8 XI1449_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1449_MN8 (XI1449_n3 pp15_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1449_MN9 (XI1449_sn XI1449_con XI1449_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1449_MN12_1 (XI1449_n5 pp15_6 XI1449_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1556_MN12 (XI1556_sn pp15_15 XI1556_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1556_MN25 (fa195_0 XI1556_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1556_MN5 (XI1556_con pp15_15 XI1556_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1556_MN2 (XI1556_n1 pp14_17 XI1556_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1556_MN1 (VSS cm114_0 XI1556_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1556_MN3 (XI1556_n2 cm114_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1556_MN4 (VSS pp14_17 XI1556_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1556_MN27 (fa195_1 XI1556_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1556_MN10 (XI1556_n4 cm114_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1556_MN11 (XI1556_n5 pp14_17 XI1556_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1556_MN11_1 (XI1556_n4 pp14_17 XI1556_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1556_MN10_1 (VSS cm114_0 XI1556_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1556_MN6 (XI1556_n3 cm114_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1556_MN7 (VSS pp14_17 XI1556_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1556_MN8 (XI1556_n3 pp15_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1556_MN9 (XI1556_sn XI1556_con XI1556_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1556_MN12_1 (XI1556_n5 pp15_15 XI1556_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1657_MN12 (XI1657_sn cm204_0 XI1657_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1657_MN25 (fa296_0 XI1657_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1657_MN5 (XI1657_con cm204_0 XI1657_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1657_MN2 (XI1657_n1 cm203_1 XI1657_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1657_MN1 (VSS fa244_1 XI1657_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1657_MN3 (XI1657_n2 fa244_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1657_MN4 (VSS cm203_1 XI1657_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1657_MN27 (fa296_1 XI1657_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1657_MN10 (XI1657_n4 fa244_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1657_MN11 (XI1657_n5 cm203_1 XI1657_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1657_MN11_1 (XI1657_n4 cm203_1 XI1657_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1657_MN10_1 (VSS fa244_1 XI1657_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1657_MN6 (XI1657_n3 fa244_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1657_MN7 (VSS cm203_1 XI1657_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1657_MN8 (XI1657_n3 cm204_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1657_MN9 (XI1657_sn XI1657_con XI1657_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1657_MN12_1 (XI1657_n5 cm204_0 XI1657_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1642_MN12 (XI1642_sn pp15_7 XI1642_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1642_MN25 (fa281_0 XI1642_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1642_MN5 (XI1642_con pp15_7 XI1642_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1642_MN2 (XI1642_n1 cm231_0 XI1642_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1642_MN1 (VSS cm230_1 XI1642_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1642_MN3 (XI1642_n2 cm230_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1642_MN4 (VSS cm231_0 XI1642_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1642_MN27 (fa281_1 XI1642_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1642_MN10 (XI1642_n4 cm230_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1642_MN11 (XI1642_n5 cm231_0 XI1642_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1642_MN11_1 (XI1642_n4 cm231_0 XI1642_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1642_MN10_1 (VSS cm230_1 XI1642_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1642_MN6 (XI1642_n3 cm230_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1642_MN7 (VSS cm231_0 XI1642_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1642_MN8 (XI1642_n3 pp15_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1642_MN9 (XI1642_sn XI1642_con XI1642_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1642_MN12_1 (XI1642_n5 pp15_7 XI1642_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1600_MN12 (XI1600_sn fa195_0 XI1600_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1600_MN25 (fa239_0 XI1600_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1600_MN5 (XI1600_con fa195_0 XI1600_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1600_MN2 (XI1600_n1 cm194_0 XI1600_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1600_MN1 (VSS cm193_1 XI1600_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1600_MN3 (XI1600_n2 cm193_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1600_MN4 (VSS cm194_0 XI1600_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1600_MN27 (fa239_1 XI1600_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1600_MN10 (XI1600_n4 cm193_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1600_MN11 (XI1600_n5 cm194_0 XI1600_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1600_MN11_1 (XI1600_n4 cm194_0 XI1600_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1600_MN10_1 (VSS cm193_1 XI1600_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1600_MN6 (XI1600_n3 cm193_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1600_MN7 (VSS cm194_0 XI1600_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1600_MN8 (XI1600_n3 fa195_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1600_MN9 (XI1600_sn XI1600_con XI1600_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1600_MN12_1 (XI1600_n5 fa195_0 XI1600_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1602_MN12 (XI1602_sn pp15_17 XI1602_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1602_MN25 (fa241_0 XI1602_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1602_MN5 (XI1602_con pp15_17 XI1602_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1602_MN2 (XI1602_n1 cm197_0 XI1602_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1602_MN1 (VSS cm196_1 XI1602_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1602_MN3 (XI1602_n2 cm196_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1602_MN4 (VSS cm197_0 XI1602_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1602_MN27 (fa241_1 XI1602_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1602_MN10 (XI1602_n4 cm196_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1602_MN11 (XI1602_n5 cm197_0 XI1602_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1602_MN11_1 (XI1602_n4 cm197_0 XI1602_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1602_MN10_1 (VSS cm196_1 XI1602_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1602_MN6 (XI1602_n3 cm196_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1602_MN7 (VSS cm197_0 XI1602_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1602_MN8 (XI1602_n3 pp15_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1602_MN9 (XI1602_sn XI1602_con XI1602_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1602_MN12_1 (XI1602_n5 pp15_17 XI1602_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1650_MN12 (XI1650_sn cm238_2 XI1650_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1650_MN25 (fa289_0 XI1650_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1650_MN5 (XI1650_con cm238_2 XI1650_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1650_MN2 (XI1650_n1 fa239_0 XI1650_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1650_MN1 (VSS cm238_1 XI1650_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1650_MN3 (XI1650_n2 cm238_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1650_MN4 (VSS fa239_0 XI1650_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1650_MN27 (fa289_1 XI1650_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1650_MN10 (XI1650_n4 cm238_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1650_MN11 (XI1650_n5 fa239_0 XI1650_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1650_MN11_1 (XI1650_n4 fa239_0 XI1650_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1650_MN10_1 (VSS cm238_1 XI1650_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1650_MN6 (XI1650_n3 cm238_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1650_MN7 (VSS fa239_0 XI1650_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1650_MN8 (XI1650_n3 cm238_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1650_MN9 (XI1650_sn XI1650_con XI1650_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1650_MN12_1 (XI1650_n5 cm238_2 XI1650_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1652_MN12 (XI1652_sn cm240_2 XI1652_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1652_MN25 (fa291_0 XI1652_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1652_MN5 (XI1652_con cm240_2 XI1652_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1652_MN2 (XI1652_n1 fa241_0 XI1652_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1652_MN1 (VSS cm240_1 XI1652_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1652_MN3 (XI1652_n2 cm240_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1652_MN4 (VSS fa241_0 XI1652_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1652_MN27 (fa291_1 XI1652_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1652_MN10 (XI1652_n4 cm240_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1652_MN11 (XI1652_n5 fa241_0 XI1652_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1652_MN11_1 (XI1652_n4 fa241_0 XI1652_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1652_MN10_1 (VSS cm240_1 XI1652_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1652_MN6 (XI1652_n3 cm240_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1652_MN7 (VSS fa241_0 XI1652_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1652_MN8 (XI1652_n3 cm240_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1652_MN9 (XI1652_sn XI1652_con XI1652_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1652_MN12_1 (XI1652_n5 cm240_2 XI1652_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1566_MN12 (XI1566_sn pp15_25 XI1566_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1566_MN25 (fa205_0 XI1566_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1566_MN5 (XI1566_con pp15_25 XI1566_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1566_MN2 (XI1566_n1 cm131_0 XI1566_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1566_MN1 (VSS cm130_1 XI1566_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1566_MN3 (XI1566_n2 cm130_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1566_MN4 (VSS cm131_0 XI1566_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1566_MN27 (fa205_1 XI1566_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1566_MN10 (XI1566_n4 cm130_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1566_MN11 (XI1566_n5 cm131_0 XI1566_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1566_MN11_1 (XI1566_n4 cm131_0 XI1566_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1566_MN10_1 (VSS cm130_1 XI1566_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1566_MN6 (XI1566_n3 cm130_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1566_MN7 (VSS cm131_0 XI1566_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1566_MN8 (XI1566_n3 pp15_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1566_MN9 (XI1566_sn XI1566_con XI1566_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1566_MN12_1 (XI1566_n5 pp15_25 XI1566_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1606_MN12 (XI1606_sn cm204_2 XI1606_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1606_MN25 (fa245_0 XI1606_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1606_MN5 (XI1606_con cm204_2 XI1606_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1606_MN2 (XI1606_n1 fa205_0 XI1606_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1606_MN1 (VSS cm204_1 XI1606_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1606_MN3 (XI1606_n2 cm204_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1606_MN4 (VSS fa205_0 XI1606_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1606_MN27 (fa245_1 XI1606_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1606_MN10 (XI1606_n4 cm204_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1606_MN11 (XI1606_n5 fa205_0 XI1606_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1606_MN11_1 (XI1606_n4 fa205_0 XI1606_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1606_MN10_1 (VSS cm204_1 XI1606_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1606_MN6 (XI1606_n3 cm204_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1606_MN7 (VSS fa205_0 XI1606_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1606_MN8 (XI1606_n3 cm204_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1606_MN9 (XI1606_sn XI1606_con XI1606_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1606_MN12_1 (XI1606_n5 cm204_2 XI1606_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1641_MN12 (XI1641_sn cm84_2 XI1641_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1641_MN25 (fa280_0 XI1641_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1641_MN5 (XI1641_con cm84_2 XI1641_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1641_MN2 (XI1641_n1 cm230_0 XI1641_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1641_MN1 (VSS cm229_1 XI1641_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1641_MN3 (XI1641_n2 cm229_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1641_MN4 (VSS cm230_0 XI1641_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1641_MN27 (fa280_1 XI1641_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1641_MN10 (XI1641_n4 cm229_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1641_MN11 (XI1641_n5 cm230_0 XI1641_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1641_MN11_1 (XI1641_n4 cm230_0 XI1641_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1641_MN10_1 (VSS cm229_1 XI1641_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1641_MN6 (XI1641_n3 cm229_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1641_MN7 (VSS cm230_0 XI1641_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1641_MN8 (XI1641_n3 cm84_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1641_MN9 (XI1641_sn XI1641_con XI1641_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1641_MN12_1 (XI1641_n5 cm84_2 XI1641_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1567_MN12 (XI1567_sn pp15_26 XI1567_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1567_MN25 (fa206_0 XI1567_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1567_MN5 (XI1567_con pp15_26 XI1567_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1567_MN2 (XI1567_n1 cm132_0 XI1567_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1567_MN1 (VSS cm131_1 XI1567_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1567_MN3 (XI1567_n2 cm131_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1567_MN4 (VSS cm132_0 XI1567_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1567_MN27 (fa206_1 XI1567_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1567_MN10 (XI1567_n4 cm131_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1567_MN11 (XI1567_n5 cm132_0 XI1567_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1567_MN11_1 (XI1567_n4 cm132_0 XI1567_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1567_MN10_1 (VSS cm131_1 XI1567_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1567_MN6 (XI1567_n3 cm131_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1567_MN7 (VSS cm132_0 XI1567_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1567_MN8 (XI1567_n3 pp15_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1567_MN9 (XI1567_sn XI1567_con XI1567_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1567_MN12_1 (XI1567_n5 pp15_26 XI1567_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1607_MN12 (XI1607_sn cm133_0 XI1607_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1607_MN25 (fa246_0 XI1607_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1607_MN5 (XI1607_con cm133_0 XI1607_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1607_MN2 (XI1607_n1 cm132_1 XI1607_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1607_MN1 (VSS fa206_1 XI1607_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1607_MN3 (XI1607_n2 fa206_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1607_MN4 (VSS cm132_1 XI1607_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1607_MN27 (fa246_1 XI1607_con VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1607_MN10 (XI1607_n4 fa206_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0756p pd=0.68u ps=1.16u
    I_MXI1607_MN11 (XI1607_n5 cm132_1 XI1607_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1607_MN11_1 (XI1607_n4 cm132_1 XI1607_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1607_MN10_1 (VSS fa206_1 XI1607_n4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1607_MN6 (XI1607_n3 fa206_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1607_MN7 (VSS cm132_1 XI1607_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.1176p as=0.0528p pd=1.22u ps=0.68u
    I_MXI1607_MN8 (XI1607_n3 cm133_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.1176p pd=0.68u ps=1.22u
    I_MXI1607_MN9 (XI1607_sn XI1607_con XI1607_n3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1607_MN12_1 (XI1607_n5 cm133_0 XI1607_sn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.68u ps=0.68u
    I_MXI1658_MN12 (XI1658_sn fa206_0 XI1658_n5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.16u ps=0.68u
    I_MXI1658_MN25 (fa297_0 XI1658_sn VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.16u ps=1.16u
    I_MXI1658_MN5 (XI1658_con fa206_0 XI1658_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1658_MN2 (XI1658_n1 fa205_1 XI1658_con VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1658_MN1 (VSS fa245_1 XI1658_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI1658_MN3 (XI1658_n2 fa245_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
