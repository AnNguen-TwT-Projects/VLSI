    I_MXI1495_MP24_1 (XI1495_asn pp14_30 XI1495_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1495_MP17 (XI1495_acon pp14_30 XI1495_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1495_MP14 (XI1495_ap1 pp13_32 XI1495_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1495_MP13 (VDD VDD XI1495_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1495_MP15 (XI1495_ap2 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1495_MP16 (VDD pp13_32 XI1495_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1495_MP28 (cm134_2 XI1495_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1495_MP19 (XI1495_ap3 pp13_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1495_MP20 (VDD pp14_30 XI1495_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1423_MP50 (VDD XI1423_s1 XI1423_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1423_MP47 (XI1423_bp3 pp7_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1423_MP49 (XI1423_bsn XI1423_bcon XI1423_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1423_MP52 (XI1423_bp5 cm58_2 XI1423_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1423_MP51 (XI1423_bp4 pp7_16 XI1423_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1423_MP51_1 (XI1423_bp5 pp7_16 XI1423_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1423_MP52_1 (XI1423_bsn cm58_2 XI1423_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1423_MP54 (VDD XI1423_bsn cm62_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1423_MP41 (XI1423_bp1 XI1423_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1423_MP42 (XI1423_bcon pp7_16 XI1423_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1423_MP45 (XI1423_bp2 cm58_2 XI1423_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1423_MP43 (VDD XI1423_s1 XI1423_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1423_MP44 (XI1423_bp2 pp7_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1423_MP56 (VDD XI1423_bcon cm62_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1423_MP46 (XI1423_bp3 XI1423_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1423_MP48 (VDD cm58_2 XI1423_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1423_MP50_1 (XI1423_bp4 XI1423_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1423_MP26 (VDD XI1423_asn XI1423_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1423_MP18 (XI1423_ap3 pp4_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1423_MP21 (XI1423_asn XI1423_acon XI1423_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1423_MP24 (XI1423_ap5 pp6_18 XI1423_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1423_MP23 (XI1423_ap4 pp5_20 XI1423_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1423_MP22 (VDD pp4_22 XI1423_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1423_MP22_1 (XI1423_ap4 pp4_22 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1423_MP23_1 (XI1423_ap5 pp5_20 XI1423_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1423_MP24_1 (XI1423_asn pp6_18 XI1423_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1423_MP17 (XI1423_acon pp6_18 XI1423_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1423_MP14 (XI1423_ap1 pp5_20 XI1423_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1423_MP13 (VDD pp4_22 XI1423_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1423_MP15 (XI1423_ap2 pp4_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1423_MP16 (VDD pp5_20 XI1423_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1423_MP28 (cm62_2 XI1423_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1423_MP19 (XI1423_ap3 pp5_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1423_MP20 (VDD pp6_18 XI1423_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1422_MP50 (VDD XI1422_s1 XI1422_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1422_MP47 (XI1422_bp3 pp3_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1422_MP49 (XI1422_bsn XI1422_bcon XI1422_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1422_MP52 (XI1422_bp5 cm57_2 XI1422_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1422_MP51 (XI1422_bp4 pp3_24 XI1422_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1422_MP51_1 (XI1422_bp5 pp3_24 XI1422_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1422_MP52_1 (XI1422_bsn cm57_2 XI1422_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1422_MP54 (VDD XI1422_bsn cm61_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1422_MP41 (XI1422_bp1 XI1422_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1422_MP42 (XI1422_bcon pp3_24 XI1422_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1422_MP45 (XI1422_bp2 cm57_2 XI1422_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1422_MP43 (VDD XI1422_s1 XI1422_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1422_MP44 (XI1422_bp2 pp3_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1422_MP56 (VDD XI1422_bcon cm61_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1422_MP46 (XI1422_bp3 XI1422_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1422_MP48 (VDD cm57_2 XI1422_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1422_MP50_1 (XI1422_bp4 XI1422_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1422_MP26 (VDD XI1422_asn XI1422_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1422_MP18 (XI1422_ap3 pp0_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1422_MP21 (XI1422_asn XI1422_acon XI1422_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1422_MP24 (XI1422_ap5 pp2_26 XI1422_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1422_MP23 (XI1422_ap4 pp1_28 XI1422_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1422_MP22 (VDD pp0_30 XI1422_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1422_MP22_1 (XI1422_ap4 pp0_30 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1422_MP23_1 (XI1422_ap5 pp1_28 XI1422_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1422_MP24_1 (XI1422_asn pp2_26 XI1422_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1422_MP17 (XI1422_acon pp2_26 XI1422_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1422_MP14 (XI1422_ap1 pp1_28 XI1422_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1422_MP13 (VDD pp0_30 XI1422_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1422_MP15 (XI1422_ap2 pp0_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1422_MP16 (VDD pp1_28 XI1422_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1422_MP28 (cm61_2 XI1422_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1422_MP19 (XI1422_ap3 pp1_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1422_MP20 (VDD pp2_26 XI1422_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1530_MP50 (VDD XI1530_s1 XI1530_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1530_MP47 (XI1530_bp3 cm64_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1530_MP49 (XI1530_bsn XI1530_bcon XI1530_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1530_MP52 (XI1530_bp5 cm167_2 XI1530_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1530_MP51 (XI1530_bp4 cm64_1 XI1530_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1530_MP51_1 (XI1530_bp5 cm64_1 XI1530_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1530_MP52_1 (XI1530_bsn cm167_2 XI1530_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1530_MP54 (VDD XI1530_bsn cm169_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1530_MP41 (XI1530_bp1 XI1530_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1530_MP42 (XI1530_bcon cm64_1 XI1530_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1530_MP45 (XI1530_bp2 cm167_2 XI1530_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1530_MP43 (VDD XI1530_s1 XI1530_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1530_MP44 (XI1530_bp2 cm64_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1530_MP56 (VDD XI1530_bcon cm169_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1530_MP46 (XI1530_bp3 XI1530_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1530_MP48 (VDD cm167_2 XI1530_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1530_MP50_1 (XI1530_bp4 XI1530_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1530_MP26 (VDD XI1530_asn XI1530_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1530_MP18 (XI1530_ap3 cm61_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1530_MP21 (XI1530_asn XI1530_acon XI1530_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1530_MP24 (XI1530_ap5 cm63_1 XI1530_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1530_MP23 (XI1530_ap4 cm62_1 XI1530_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1530_MP22 (VDD cm61_1 XI1530_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1530_MP22_1 (XI1530_ap4 cm61_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1530_MP23_1 (XI1530_ap5 cm62_1 XI1530_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1530_MP24_1 (XI1530_asn cm63_1 XI1530_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1530_MP17 (XI1530_acon cm63_1 XI1530_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1530_MP14 (XI1530_ap1 cm62_1 XI1530_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1530_MP13 (VDD cm61_1 XI1530_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1530_MP15 (XI1530_ap2 cm61_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1530_MP16 (VDD cm62_1 XI1530_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1530_MP28 (cm169_2 XI1530_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1530_MP19 (XI1530_ap3 cm62_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1530_MP20 (VDD cm63_1 XI1530_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1586_MP50 (VDD XI1586_s1 XI1586_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1586_MP47 (XI1586_bp3 cm170_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1586_MP49 (XI1586_bsn XI1586_bcon XI1586_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1586_MP52 (XI1586_bp5 cm224_2 XI1586_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1586_MP51 (XI1586_bp4 cm170_0 XI1586_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1586_MP51_1 (XI1586_bp5 cm170_0 XI1586_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1586_MP52_1 (XI1586_bsn cm224_2 XI1586_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1586_MP54 (VDD XI1586_bsn cm225_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1586_MP41 (XI1586_bp1 XI1586_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1586_MP42 (XI1586_bcon cm170_0 XI1586_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1586_MP45 (XI1586_bp2 cm224_2 XI1586_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1586_MP43 (VDD XI1586_s1 XI1586_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1586_MP44 (XI1586_bp2 cm170_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1586_MP56 (VDD XI1586_bcon cm225_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1586_MP46 (XI1586_bp3 XI1586_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1586_MP48 (VDD cm224_2 XI1586_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1586_MP50_1 (XI1586_bp4 XI1586_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1586_MP26 (VDD XI1586_asn XI1586_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1586_MP18 (XI1586_ap3 cm167_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1586_MP21 (XI1586_asn XI1586_acon XI1586_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1586_MP24 (XI1586_ap5 cm169_0 XI1586_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1586_MP23 (XI1586_ap4 cm168_1 XI1586_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1586_MP22 (VDD cm167_1 XI1586_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1586_MP22_1 (XI1586_ap4 cm167_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1586_MP23_1 (XI1586_ap5 cm168_1 XI1586_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1586_MP24_1 (XI1586_asn cm169_0 XI1586_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1586_MP17 (XI1586_acon cm169_0 XI1586_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1586_MP14 (XI1586_ap1 cm168_1 XI1586_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1586_MP13 (VDD cm167_1 XI1586_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1586_MP15 (XI1586_ap2 cm167_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1586_MP16 (VDD cm168_1 XI1586_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1586_MP28 (cm225_2 XI1586_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1586_MP19 (XI1586_ap3 cm168_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1586_MP20 (VDD cm169_0 XI1586_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1424_MP50 (VDD XI1424_s1 XI1424_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1424_MP47 (XI1424_bp3 pp11_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1424_MP49 (XI1424_bsn XI1424_bcon XI1424_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1424_MP52 (XI1424_bp5 cm59_2 XI1424_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1424_MP51 (XI1424_bp4 pp11_8 XI1424_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1424_MP51_1 (XI1424_bp5 pp11_8 XI1424_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1424_MP52_1 (XI1424_bsn cm59_2 XI1424_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1424_MP54 (VDD XI1424_bsn cm63_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1424_MP41 (XI1424_bp1 XI1424_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1424_MP42 (XI1424_bcon pp11_8 XI1424_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1424_MP45 (XI1424_bp2 cm59_2 XI1424_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1424_MP43 (VDD XI1424_s1 XI1424_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1424_MP44 (XI1424_bp2 pp11_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1424_MP56 (VDD XI1424_bcon cm63_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1424_MP46 (XI1424_bp3 XI1424_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1424_MP48 (VDD cm59_2 XI1424_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1424_MP50_1 (XI1424_bp4 XI1424_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1424_MP26 (VDD XI1424_asn XI1424_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1424_MP18 (XI1424_ap3 pp8_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1424_MP21 (XI1424_asn XI1424_acon XI1424_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1424_MP24 (XI1424_ap5 pp10_10 XI1424_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1424_MP23 (XI1424_ap4 pp9_12 XI1424_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1424_MP22 (VDD pp8_14 XI1424_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1424_MP22_1 (XI1424_ap4 pp8_14 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1424_MP23_1 (XI1424_ap5 pp9_12 XI1424_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1424_MP24_1 (XI1424_asn pp10_10 XI1424_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1424_MP17 (XI1424_acon pp10_10 XI1424_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1424_MP14 (XI1424_ap1 pp9_12 XI1424_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1424_MP13 (VDD pp8_14 XI1424_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1424_MP15 (XI1424_ap2 pp8_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1424_MP16 (VDD pp9_12 XI1424_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1424_MP28 (cm63_2 XI1424_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1424_MP19 (XI1424_ap3 pp9_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1424_MP20 (VDD pp10_10 XI1424_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1425_MP50 (VDD XI1425_s1 XI1425_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1425_MP47 (XI1425_bp3 pp15_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1425_MP49 (XI1425_bsn XI1425_bcon XI1425_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1425_MP52 (XI1425_bp5 B_31_b3_5 XI1425_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1425_MP51 (XI1425_bp4 pp15_0 XI1425_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1425_MP51_1 (XI1425_bp5 pp15_0 XI1425_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1425_MP52_1 (XI1425_bsn B_31_b3_5 XI1425_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1425_MP54 (VDD XI1425_bsn cm64_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1425_MP41 (XI1425_bp1 XI1425_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1425_MP42 (XI1425_bcon pp15_0 XI1425_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1425_MP45 (XI1425_bp2 B_31_b3_5 XI1425_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1425_MP43 (VDD XI1425_s1 XI1425_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1425_MP44 (XI1425_bp2 pp15_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1425_MP56 (VDD XI1425_bcon cm64_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1425_MP46 (XI1425_bp3 XI1425_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1425_MP48 (VDD B_31_b3_5 XI1425_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1425_MP50_1 (XI1425_bp4 XI1425_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1425_MP26 (VDD XI1425_asn XI1425_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1425_MP18 (XI1425_ap3 pp12_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1425_MP21 (XI1425_asn XI1425_acon XI1425_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1425_MP24 (XI1425_ap5 pp14_2 XI1425_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1425_MP23 (XI1425_ap4 pp13_4 XI1425_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1425_MP22 (VDD pp12_6 XI1425_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1425_MP22_1 (XI1425_ap4 pp12_6 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1425_MP23_1 (XI1425_ap5 pp13_4 XI1425_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1425_MP24_1 (XI1425_asn pp14_2 XI1425_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1425_MP17 (XI1425_acon pp14_2 XI1425_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1425_MP14 (XI1425_ap1 pp13_4 XI1425_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1425_MP13 (VDD pp12_6 XI1425_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1425_MP15 (XI1425_ap2 pp12_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1425_MP16 (VDD pp13_4 XI1425_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1425_MP28 (cm64_2 XI1425_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1425_MP19 (XI1425_ap3 pp13_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1425_MP20 (VDD pp14_2 XI1425_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1418_MP50 (VDD XI1418_s1 XI1418_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1418_MP47 (XI1418_bp3 pp3_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1418_MP49 (XI1418_bsn XI1418_bcon XI1418_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1418_MP52 (XI1418_bp5 cm53_2 XI1418_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1418_MP51 (XI1418_bp4 pp3_23 XI1418_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1418_MP51_1 (XI1418_bp5 pp3_23 XI1418_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1418_MP52_1 (XI1418_bsn cm53_2 XI1418_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1418_MP54 (VDD XI1418_bsn cm57_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1418_MP41 (XI1418_bp1 XI1418_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1418_MP42 (XI1418_bcon pp3_23 XI1418_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1418_MP45 (XI1418_bp2 cm53_2 XI1418_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1418_MP43 (VDD XI1418_s1 XI1418_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1418_MP44 (XI1418_bp2 pp3_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1418_MP56 (VDD XI1418_bcon cm57_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1418_MP46 (XI1418_bp3 XI1418_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1418_MP48 (VDD cm53_2 XI1418_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1418_MP50_1 (XI1418_bp4 XI1418_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1418_MP26 (VDD XI1418_asn XI1418_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1418_MP18 (XI1418_ap3 pp0_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1418_MP21 (XI1418_asn XI1418_acon XI1418_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1418_MP24 (XI1418_ap5 pp2_25 XI1418_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1418_MP23 (XI1418_ap4 pp1_27 XI1418_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1418_MP22 (VDD pp0_29 XI1418_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1418_MP22_1 (XI1418_ap4 pp0_29 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1418_MP23_1 (XI1418_ap5 pp1_27 XI1418_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1418_MP24_1 (XI1418_asn pp2_25 XI1418_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1418_MP17 (XI1418_acon pp2_25 XI1418_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1418_MP14 (XI1418_ap1 pp1_27 XI1418_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1418_MP13 (VDD pp0_29 XI1418_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1418_MP15 (XI1418_ap2 pp0_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1418_MP16 (VDD pp1_27 XI1418_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1418_MP28 (cm57_2 XI1418_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1418_MP19 (XI1418_ap3 pp1_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1418_MP20 (VDD pp2_25 XI1418_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1528_MP50 (VDD XI1528_s1 XI1528_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1528_MP47 (XI1528_bp3 fa60_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1528_MP49 (XI1528_bsn XI1528_bcon XI1528_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1528_MP52 (XI1528_bp5 cm165_2 XI1528_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1528_MP51 (XI1528_bp4 fa60_1 XI1528_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1528_MP51_1 (XI1528_bp5 fa60_1 XI1528_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1528_MP52_1 (XI1528_bsn cm165_2 XI1528_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1528_MP54 (VDD XI1528_bsn cm167_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1528_MP41 (XI1528_bp1 XI1528_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1528_MP42 (XI1528_bcon fa60_1 XI1528_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1528_MP45 (XI1528_bp2 cm165_2 XI1528_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1528_MP43 (VDD XI1528_s1 XI1528_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1528_MP44 (XI1528_bp2 fa60_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1528_MP56 (VDD XI1528_bcon cm167_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1528_MP46 (XI1528_bp3 XI1528_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1528_MP48 (VDD cm165_2 XI1528_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1528_MP50_1 (XI1528_bp4 XI1528_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1528_MP26 (VDD XI1528_asn XI1528_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1528_MP18 (XI1528_ap3 cm57_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1528_MP21 (XI1528_asn XI1528_acon XI1528_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1528_MP24 (XI1528_ap5 cm59_1 XI1528_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1528_MP23 (XI1528_ap4 cm58_1 XI1528_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1528_MP22 (VDD cm57_1 XI1528_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1528_MP22_1 (XI1528_ap4 cm57_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1528_MP23_1 (XI1528_ap5 cm58_1 XI1528_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1528_MP24_1 (XI1528_asn cm59_1 XI1528_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1528_MP17 (XI1528_acon cm59_1 XI1528_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1528_MP14 (XI1528_ap1 cm58_1 XI1528_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1528_MP13 (VDD cm57_1 XI1528_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1528_MP15 (XI1528_ap2 cm57_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1528_MP16 (VDD cm58_1 XI1528_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1528_MP28 (cm167_2 XI1528_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1528_MP19 (XI1528_ap3 cm58_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1528_MP20 (VDD cm59_1 XI1528_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1529_MP50 (VDD XI1529_s1 XI1529_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1529_MP47 (XI1529_bp3 cm64_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1529_MP49 (XI1529_bsn XI1529_bcon XI1529_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1529_MP52 (XI1529_bp5 cm166_2 XI1529_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1529_MP51 (XI1529_bp4 cm64_0 XI1529_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1529_MP51_1 (XI1529_bp5 cm64_0 XI1529_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1529_MP52_1 (XI1529_bsn cm166_2 XI1529_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1529_MP54 (VDD XI1529_bsn cm168_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1529_MP41 (XI1529_bp1 XI1529_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1529_MP42 (XI1529_bcon cm64_0 XI1529_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1529_MP45 (XI1529_bp2 cm166_2 XI1529_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1529_MP43 (VDD XI1529_s1 XI1529_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1529_MP44 (XI1529_bp2 cm64_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1529_MP56 (VDD XI1529_bcon cm168_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1529_MP46 (XI1529_bp3 XI1529_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1529_MP48 (VDD cm166_2 XI1529_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1529_MP50_1 (XI1529_bp4 XI1529_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1529_MP26 (VDD XI1529_asn XI1529_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1529_MP18 (XI1529_ap3 cm61_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1529_MP21 (XI1529_asn XI1529_acon XI1529_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1529_MP24 (XI1529_ap5 cm63_0 XI1529_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1529_MP23 (XI1529_ap4 cm62_0 XI1529_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1529_MP22 (VDD cm61_0 XI1529_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1529_MP22_1 (XI1529_ap4 cm61_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1529_MP23_1 (XI1529_ap5 cm62_0 XI1529_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1529_MP24_1 (XI1529_asn cm63_0 XI1529_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1529_MP17 (XI1529_acon cm63_0 XI1529_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1529_MP14 (XI1529_ap1 cm62_0 XI1529_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1529_MP13 (VDD cm61_0 XI1529_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1529_MP15 (XI1529_ap2 cm61_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1529_MP16 (VDD cm62_0 XI1529_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1529_MP28 (cm168_2 XI1529_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1529_MP19 (XI1529_ap3 cm62_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1529_MP20 (VDD cm63_0 XI1529_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1420_MP50 (VDD XI1420_s1 XI1420_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1420_MP47 (XI1420_bp3 pp11_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1420_MP49 (XI1420_bsn XI1420_bcon XI1420_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1420_MP52 (XI1420_bp5 cm55_2 XI1420_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1420_MP51 (XI1420_bp4 pp11_7 XI1420_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1420_MP51_1 (XI1420_bp5 pp11_7 XI1420_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1420_MP52_1 (XI1420_bsn cm55_2 XI1420_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1420_MP54 (VDD XI1420_bsn cm59_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1420_MP41 (XI1420_bp1 XI1420_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1420_MP42 (XI1420_bcon pp11_7 XI1420_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1420_MP45 (XI1420_bp2 cm55_2 XI1420_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1420_MP43 (VDD XI1420_s1 XI1420_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1420_MP44 (XI1420_bp2 pp11_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1420_MP56 (VDD XI1420_bcon cm59_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1420_MP46 (XI1420_bp3 XI1420_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1420_MP48 (VDD cm55_2 XI1420_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1420_MP50_1 (XI1420_bp4 XI1420_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1420_MP26 (VDD XI1420_asn XI1420_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1420_MP18 (XI1420_ap3 pp8_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1420_MP21 (XI1420_asn XI1420_acon XI1420_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1420_MP24 (XI1420_ap5 pp10_9 XI1420_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1420_MP23 (XI1420_ap4 pp9_11 XI1420_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1420_MP22 (VDD pp8_13 XI1420_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1420_MP22_1 (XI1420_ap4 pp8_13 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1420_MP23_1 (XI1420_ap5 pp9_11 XI1420_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1420_MP24_1 (XI1420_asn pp10_9 XI1420_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1420_MP17 (XI1420_acon pp10_9 XI1420_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1420_MP14 (XI1420_ap1 pp9_11 XI1420_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1420_MP13 (VDD pp8_13 XI1420_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1420_MP15 (XI1420_ap2 pp8_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1420_MP16 (VDD pp9_11 XI1420_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1420_MP28 (cm59_2 XI1420_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1420_MP19 (XI1420_ap3 pp9_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1420_MP20 (VDD pp10_9 XI1420_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1419_MP50 (VDD XI1419_s1 XI1419_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1419_MP47 (XI1419_bp3 pp7_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1419_MP49 (XI1419_bsn XI1419_bcon XI1419_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1419_MP52 (XI1419_bp5 cm54_2 XI1419_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1419_MP51 (XI1419_bp4 pp7_15 XI1419_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1419_MP51_1 (XI1419_bp5 pp7_15 XI1419_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1419_MP52_1 (XI1419_bsn cm54_2 XI1419_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1419_MP54 (VDD XI1419_bsn cm58_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1419_MP41 (XI1419_bp1 XI1419_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1419_MP42 (XI1419_bcon pp7_15 XI1419_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1419_MP45 (XI1419_bp2 cm54_2 XI1419_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1419_MP43 (VDD XI1419_s1 XI1419_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1419_MP44 (XI1419_bp2 pp7_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1419_MP56 (VDD XI1419_bcon cm58_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1419_MP46 (XI1419_bp3 XI1419_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1419_MP48 (VDD cm54_2 XI1419_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1419_MP50_1 (XI1419_bp4 XI1419_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1419_MP26 (VDD XI1419_asn XI1419_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1419_MP18 (XI1419_ap3 pp4_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1419_MP21 (XI1419_asn XI1419_acon XI1419_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1419_MP24 (XI1419_ap5 pp6_17 XI1419_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1419_MP23 (XI1419_ap4 pp5_19 XI1419_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1419_MP22 (VDD pp4_21 XI1419_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1419_MP22_1 (XI1419_ap4 pp4_21 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1419_MP23_1 (XI1419_ap5 pp5_19 XI1419_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1419_MP24_1 (XI1419_asn pp6_17 XI1419_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1419_MP17 (XI1419_acon pp6_17 XI1419_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1419_MP14 (XI1419_ap1 pp5_19 XI1419_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1419_MP13 (VDD pp4_21 XI1419_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1419_MP15 (XI1419_ap2 pp4_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1419_MP16 (VDD pp5_19 XI1419_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1419_MP28 (cm58_2 XI1419_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1419_MP19 (XI1419_ap3 pp5_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1419_MP20 (VDD pp6_17 XI1419_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1585_MP50 (VDD XI1585_s1 XI1585_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1585_MP47 (XI1585_bp3 cm168_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1585_MP49 (XI1585_bsn XI1585_bcon XI1585_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1585_MP52 (XI1585_bp5 cm223_2 XI1585_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1585_MP51 (XI1585_bp4 cm168_0 XI1585_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1585_MP51_1 (XI1585_bp5 cm168_0 XI1585_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1585_MP52_1 (XI1585_bsn cm223_2 XI1585_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1585_MP54 (VDD XI1585_bsn cm224_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1585_MP41 (XI1585_bp1 XI1585_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1585_MP42 (XI1585_bcon cm168_0 XI1585_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1585_MP45 (XI1585_bp2 cm223_2 XI1585_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1585_MP43 (VDD XI1585_s1 XI1585_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1585_MP44 (XI1585_bp2 cm168_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1585_MP56 (VDD XI1585_bcon cm224_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1585_MP46 (XI1585_bp3 XI1585_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1585_MP48 (VDD cm223_2 XI1585_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1585_MP50_1 (XI1585_bp4 XI1585_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1585_MP26 (VDD XI1585_asn XI1585_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1585_MP18 (XI1585_ap3 cm165_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1585_MP21 (XI1585_asn XI1585_acon XI1585_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1585_MP24 (XI1585_ap5 cm167_0 XI1585_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1585_MP23 (XI1585_ap4 cm166_1 XI1585_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1585_MP22 (VDD cm165_1 XI1585_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1585_MP22_1 (XI1585_ap4 cm165_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1585_MP23_1 (XI1585_ap5 cm166_1 XI1585_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1585_MP24_1 (XI1585_asn cm167_0 XI1585_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1585_MP17 (XI1585_acon cm167_0 XI1585_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1585_MP14 (XI1585_ap1 cm166_1 XI1585_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1585_MP13 (VDD cm165_1 XI1585_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1585_MP15 (XI1585_ap2 cm165_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1585_MP16 (VDD cm166_1 XI1585_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1585_MP28 (cm224_2 XI1585_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1585_MP19 (XI1585_ap3 cm166_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1585_MP20 (VDD cm167_0 XI1585_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1527_MP50 (VDD XI1527_s1 XI1527_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1527_MP47 (XI1527_bp3 fa60_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1527_MP49 (XI1527_bsn XI1527_bcon XI1527_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1527_MP52 (XI1527_bp5 cm164_2 XI1527_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1527_MP51 (XI1527_bp4 fa60_0 XI1527_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1527_MP51_1 (XI1527_bp5 fa60_0 XI1527_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1527_MP52_1 (XI1527_bsn cm164_2 XI1527_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1527_MP54 (VDD XI1527_bsn cm166_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1527_MP41 (XI1527_bp1 XI1527_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1527_MP42 (XI1527_bcon fa60_0 XI1527_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1527_MP45 (XI1527_bp2 cm164_2 XI1527_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1527_MP43 (VDD XI1527_s1 XI1527_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1527_MP44 (XI1527_bp2 fa60_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1527_MP56 (VDD XI1527_bcon cm166_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1527_MP46 (XI1527_bp3 XI1527_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1527_MP48 (VDD cm164_2 XI1527_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1527_MP50_1 (XI1527_bp4 XI1527_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1527_MP26 (VDD XI1527_asn XI1527_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1527_MP18 (XI1527_ap3 cm57_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1527_MP21 (XI1527_asn XI1527_acon XI1527_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1527_MP24 (XI1527_ap5 cm59_0 XI1527_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1527_MP23 (XI1527_ap4 cm58_0 XI1527_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1527_MP22 (VDD cm57_0 XI1527_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1527_MP22_1 (XI1527_ap4 cm57_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1527_MP23_1 (XI1527_ap5 cm58_0 XI1527_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1527_MP24_1 (XI1527_asn cm59_0 XI1527_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1527_MP17 (XI1527_acon cm59_0 XI1527_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1527_MP14 (XI1527_ap1 cm58_0 XI1527_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1527_MP13 (VDD cm57_0 XI1527_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1527_MP15 (XI1527_ap2 cm57_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1527_MP16 (VDD cm58_0 XI1527_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1527_MP28 (cm166_2 XI1527_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1527_MP19 (XI1527_ap3 cm58_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1527_MP20 (VDD cm59_0 XI1527_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1415_MP50 (VDD XI1415_s1 XI1415_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1415_MP47 (XI1415_bp3 pp7_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1415_MP49 (XI1415_bsn XI1415_bcon XI1415_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1415_MP52 (XI1415_bp5 cm51_2 XI1415_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1415_MP51 (XI1415_bp4 pp7_14 XI1415_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1415_MP51_1 (XI1415_bp5 pp7_14 XI1415_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1415_MP52_1 (XI1415_bsn cm51_2 XI1415_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1415_MP54 (VDD XI1415_bsn cm54_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1415_MP41 (XI1415_bp1 XI1415_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1415_MP42 (XI1415_bcon pp7_14 XI1415_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1415_MP45 (XI1415_bp2 cm51_2 XI1415_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1415_MP43 (VDD XI1415_s1 XI1415_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1415_MP44 (XI1415_bp2 pp7_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1415_MP56 (VDD XI1415_bcon cm54_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1415_MP46 (XI1415_bp3 XI1415_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1415_MP48 (VDD cm51_2 XI1415_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1415_MP50_1 (XI1415_bp4 XI1415_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1415_MP26 (VDD XI1415_asn XI1415_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1415_MP18 (XI1415_ap3 pp4_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1415_MP21 (XI1415_asn XI1415_acon XI1415_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1415_MP24 (XI1415_ap5 pp6_16 XI1415_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1415_MP23 (XI1415_ap4 pp5_18 XI1415_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1415_MP22 (VDD pp4_20 XI1415_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1415_MP22_1 (XI1415_ap4 pp4_20 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1415_MP23_1 (XI1415_ap5 pp5_18 XI1415_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1415_MP24_1 (XI1415_asn pp6_16 XI1415_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1415_MP17 (XI1415_acon pp6_16 XI1415_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1415_MP14 (XI1415_ap1 pp5_18 XI1415_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1415_MP13 (VDD pp4_20 XI1415_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1415_MP15 (XI1415_ap2 pp4_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1415_MP16 (VDD pp5_18 XI1415_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1415_MP28 (cm54_2 XI1415_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1415_MP19 (XI1415_ap3 pp5_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1415_MP20 (VDD pp6_16 XI1415_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1414_MP50 (VDD XI1414_s1 XI1414_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1414_MP47 (XI1414_bp3 pp3_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1414_MP49 (XI1414_bsn XI1414_bcon XI1414_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1414_MP52 (XI1414_bp5 cm50_2 XI1414_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1414_MP51 (XI1414_bp4 pp3_22 XI1414_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1414_MP51_1 (XI1414_bp5 pp3_22 XI1414_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1414_MP52_1 (XI1414_bsn cm50_2 XI1414_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1414_MP54 (VDD XI1414_bsn cm53_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1414_MP41 (XI1414_bp1 XI1414_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1414_MP42 (XI1414_bcon pp3_22 XI1414_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1414_MP45 (XI1414_bp2 cm50_2 XI1414_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1414_MP43 (VDD XI1414_s1 XI1414_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1414_MP44 (XI1414_bp2 pp3_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1414_MP56 (VDD XI1414_bcon cm53_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1414_MP46 (XI1414_bp3 XI1414_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1414_MP48 (VDD cm50_2 XI1414_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1414_MP50_1 (XI1414_bp4 XI1414_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1414_MP26 (VDD XI1414_asn XI1414_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1414_MP18 (XI1414_ap3 pp0_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1414_MP21 (XI1414_asn XI1414_acon XI1414_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1414_MP24 (XI1414_ap5 pp2_24 XI1414_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1414_MP23 (XI1414_ap4 pp1_26 XI1414_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1414_MP22 (VDD pp0_28 XI1414_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1414_MP22_1 (XI1414_ap4 pp0_28 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1414_MP23_1 (XI1414_ap5 pp1_26 XI1414_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1414_MP24_1 (XI1414_asn pp2_24 XI1414_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1414_MP17 (XI1414_acon pp2_24 XI1414_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1414_MP14 (XI1414_ap1 pp1_26 XI1414_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1414_MP13 (VDD pp0_28 XI1414_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1414_MP15 (XI1414_ap2 pp0_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1414_MP16 (VDD pp1_26 XI1414_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1414_MP28 (cm53_2 XI1414_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1414_MP19 (XI1414_ap3 pp1_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1414_MP20 (VDD pp2_24 XI1414_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1526_MP50 (VDD XI1526_s1 XI1526_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1526_MP47 (XI1526_bp3 fa56_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1526_MP49 (XI1526_bsn XI1526_bcon XI1526_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1526_MP52 (XI1526_bp5 cm163_2 XI1526_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1526_MP51 (XI1526_bp4 fa56_1 XI1526_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1526_MP51_1 (XI1526_bp5 fa56_1 XI1526_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1526_MP52_1 (XI1526_bsn cm163_2 XI1526_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1526_MP54 (VDD XI1526_bsn cm165_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1526_MP41 (XI1526_bp1 XI1526_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1526_MP42 (XI1526_bcon fa56_1 XI1526_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1526_MP45 (XI1526_bp2 cm163_2 XI1526_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1526_MP43 (VDD XI1526_s1 XI1526_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1526_MP44 (XI1526_bp2 fa56_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1526_MP56 (VDD XI1526_bcon cm165_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1526_MP46 (XI1526_bp3 XI1526_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1526_MP48 (VDD cm163_2 XI1526_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1526_MP50_1 (XI1526_bp4 XI1526_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1526_MP26 (VDD XI1526_asn XI1526_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1526_MP18 (XI1526_ap3 cm53_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1526_MP21 (XI1526_asn XI1526_acon XI1526_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1526_MP24 (XI1526_ap5 cm55_1 XI1526_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1526_MP23 (XI1526_ap4 cm54_1 XI1526_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1526_MP22 (VDD cm53_1 XI1526_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1526_MP22_1 (XI1526_ap4 cm53_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1526_MP23_1 (XI1526_ap5 cm54_1 XI1526_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1526_MP24_1 (XI1526_asn cm55_1 XI1526_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1526_MP17 (XI1526_acon cm55_1 XI1526_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1526_MP14 (XI1526_ap1 cm54_1 XI1526_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1526_MP13 (VDD cm53_1 XI1526_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1526_MP15 (XI1526_ap2 cm53_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1526_MP16 (VDD cm54_1 XI1526_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1526_MP28 (cm165_2 XI1526_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1526_MP19 (XI1526_ap3 cm54_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1526_MP20 (VDD cm55_1 XI1526_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1525_MP50 (VDD XI1525_s1 XI1525_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1525_MP47 (XI1525_bp3 B_29_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1525_MP49 (XI1525_bsn XI1525_bcon XI1525_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1525_MP52 (XI1525_bp5 cm162_2 XI1525_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1525_MP51 (XI1525_bp4 B_29_b3_5 XI1525_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1525_MP51_1 (XI1525_bp5 B_29_b3_5 XI1525_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1525_MP52_1 (XI1525_bsn cm162_2 XI1525_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1525_MP54 (VDD XI1525_bsn cm164_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1525_MP41 (XI1525_bp1 XI1525_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1525_MP42 (XI1525_bcon B_29_b3_5 XI1525_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1525_MP45 (XI1525_bp2 cm162_2 XI1525_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1525_MP43 (VDD XI1525_s1 XI1525_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1525_MP44 (XI1525_bp2 B_29_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1525_MP56 (VDD XI1525_bcon cm164_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1525_MP46 (XI1525_bp3 XI1525_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1525_MP48 (VDD cm162_2 XI1525_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1525_MP50_1 (XI1525_bp4 XI1525_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1525_MP26 (VDD XI1525_asn XI1525_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1525_MP18 (XI1525_ap3 cm54_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1525_MP21 (XI1525_asn XI1525_acon XI1525_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1525_MP24 (XI1525_ap5 fa56_0 XI1525_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1525_MP23 (XI1525_ap4 cm55_0 XI1525_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1525_MP22 (VDD cm54_0 XI1525_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1525_MP22_1 (XI1525_ap4 cm54_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1525_MP23_1 (XI1525_ap5 cm55_0 XI1525_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1525_MP24_1 (XI1525_asn fa56_0 XI1525_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1525_MP17 (XI1525_acon fa56_0 XI1525_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1525_MP14 (XI1525_ap1 cm55_0 XI1525_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1525_MP13 (VDD cm54_0 XI1525_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1525_MP15 (XI1525_ap2 cm54_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1525_MP16 (VDD cm55_0 XI1525_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1525_MP28 (cm164_2 XI1525_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1525_MP19 (XI1525_ap3 cm55_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1525_MP20 (VDD fa56_0 XI1525_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1416_MP50 (VDD XI1416_s1 XI1416_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1416_MP47 (XI1416_bp3 pp11_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1416_MP49 (XI1416_bsn XI1416_bcon XI1416_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1416_MP52 (XI1416_bp5 cm52_2 XI1416_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1416_MP51 (XI1416_bp4 pp11_6 XI1416_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1416_MP51_1 (XI1416_bp5 pp11_6 XI1416_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1416_MP52_1 (XI1416_bsn cm52_2 XI1416_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1416_MP54 (VDD XI1416_bsn cm55_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1416_MP41 (XI1416_bp1 XI1416_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1416_MP42 (XI1416_bcon pp11_6 XI1416_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1416_MP45 (XI1416_bp2 cm52_2 XI1416_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1416_MP43 (VDD XI1416_s1 XI1416_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1416_MP44 (XI1416_bp2 pp11_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1416_MP56 (VDD XI1416_bcon cm55_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1416_MP46 (XI1416_bp3 XI1416_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1416_MP48 (VDD cm52_2 XI1416_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1416_MP50_1 (XI1416_bp4 XI1416_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1416_MP26 (VDD XI1416_asn XI1416_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1416_MP18 (XI1416_ap3 pp8_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1416_MP21 (XI1416_asn XI1416_acon XI1416_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1416_MP24 (XI1416_ap5 pp10_8 XI1416_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1416_MP23 (XI1416_ap4 pp9_10 XI1416_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1416_MP22 (VDD pp8_12 XI1416_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1416_MP22_1 (XI1416_ap4 pp8_12 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1416_MP23_1 (XI1416_ap5 pp9_10 XI1416_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1416_MP24_1 (XI1416_asn pp10_8 XI1416_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1416_MP17 (XI1416_acon pp10_8 XI1416_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1416_MP14 (XI1416_ap1 pp9_10 XI1416_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1416_MP13 (VDD pp8_12 XI1416_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1416_MP15 (XI1416_ap2 pp8_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1416_MP16 (VDD pp9_10 XI1416_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1416_MP28 (cm55_2 XI1416_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1416_MP19 (XI1416_ap3 pp9_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1416_MP20 (VDD pp10_8 XI1416_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1412_MP50 (VDD XI1412_s1 XI1412_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1412_MP47 (XI1412_bp3 pp7_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1412_MP49 (XI1412_bsn XI1412_bcon XI1412_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1412_MP52 (XI1412_bp5 cm47_2 XI1412_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1412_MP51 (XI1412_bp4 pp7_13 XI1412_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1412_MP51_1 (XI1412_bp5 pp7_13 XI1412_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1412_MP52_1 (XI1412_bsn cm47_2 XI1412_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1412_MP54 (VDD XI1412_bsn cm51_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1412_MP41 (XI1412_bp1 XI1412_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1412_MP42 (XI1412_bcon pp7_13 XI1412_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1412_MP45 (XI1412_bp2 cm47_2 XI1412_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1412_MP43 (VDD XI1412_s1 XI1412_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1412_MP44 (XI1412_bp2 pp7_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1412_MP56 (VDD XI1412_bcon cm51_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1412_MP46 (XI1412_bp3 XI1412_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1412_MP48 (VDD cm47_2 XI1412_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1412_MP50_1 (XI1412_bp4 XI1412_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1412_MP26 (VDD XI1412_asn XI1412_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1412_MP18 (XI1412_ap3 pp4_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1412_MP21 (XI1412_asn XI1412_acon XI1412_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1412_MP24 (XI1412_ap5 pp6_15 XI1412_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1412_MP23 (XI1412_ap4 pp5_17 XI1412_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1412_MP22 (VDD pp4_19 XI1412_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1412_MP22_1 (XI1412_ap4 pp4_19 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1412_MP23_1 (XI1412_ap5 pp5_17 XI1412_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1412_MP24_1 (XI1412_asn pp6_15 XI1412_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1412_MP17 (XI1412_acon pp6_15 XI1412_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1412_MP14 (XI1412_ap1 pp5_17 XI1412_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1412_MP13 (VDD pp4_19 XI1412_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1412_MP15 (XI1412_ap2 pp4_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1412_MP16 (VDD pp5_17 XI1412_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1412_MP28 (cm51_2 XI1412_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1412_MP19 (XI1412_ap3 pp5_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1412_MP20 (VDD pp6_15 XI1412_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1411_MP50 (VDD XI1411_s1 XI1411_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1411_MP47 (XI1411_bp3 pp3_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1411_MP49 (XI1411_bsn XI1411_bcon XI1411_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1411_MP52 (XI1411_bp5 cm46_2 XI1411_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1411_MP51 (XI1411_bp4 pp3_21 XI1411_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1411_MP51_1 (XI1411_bp5 pp3_21 XI1411_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1411_MP52_1 (XI1411_bsn cm46_2 XI1411_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1411_MP54 (VDD XI1411_bsn cm50_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1411_MP41 (XI1411_bp1 XI1411_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1411_MP42 (XI1411_bcon pp3_21 XI1411_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1411_MP45 (XI1411_bp2 cm46_2 XI1411_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1411_MP43 (VDD XI1411_s1 XI1411_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1411_MP44 (XI1411_bp2 pp3_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1411_MP56 (VDD XI1411_bcon cm50_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1411_MP46 (XI1411_bp3 XI1411_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1411_MP48 (VDD cm46_2 XI1411_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1411_MP50_1 (XI1411_bp4 XI1411_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1411_MP26 (VDD XI1411_asn XI1411_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1411_MP18 (XI1411_ap3 pp0_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1411_MP21 (XI1411_asn XI1411_acon XI1411_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1411_MP24 (XI1411_ap5 pp2_23 XI1411_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1411_MP23 (XI1411_ap4 pp1_25 XI1411_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1411_MP22 (VDD pp0_27 XI1411_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1411_MP22_1 (XI1411_ap4 pp0_27 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1411_MP23_1 (XI1411_ap5 pp1_25 XI1411_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1411_MP24_1 (XI1411_asn pp2_23 XI1411_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1411_MP17 (XI1411_acon pp2_23 XI1411_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1411_MP14 (XI1411_ap1 pp1_25 XI1411_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1411_MP13 (VDD pp0_27 XI1411_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1411_MP15 (XI1411_ap2 pp0_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1411_MP16 (VDD pp1_25 XI1411_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1411_MP28 (cm50_2 XI1411_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1411_MP19 (XI1411_ap3 pp1_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1411_MP20 (VDD pp2_23 XI1411_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1584_MP50 (VDD XI1584_s1 XI1584_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1584_MP47 (XI1584_bp3 cm166_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1584_MP49 (XI1584_bsn XI1584_bcon XI1584_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1584_MP52 (XI1584_bp5 cm222_2 XI1584_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1584_MP51 (XI1584_bp4 cm166_0 XI1584_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1584_MP51_1 (XI1584_bp5 cm166_0 XI1584_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1584_MP52_1 (XI1584_bsn cm222_2 XI1584_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1584_MP54 (VDD XI1584_bsn cm223_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1584_MP41 (XI1584_bp1 XI1584_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1584_MP42 (XI1584_bcon cm166_0 XI1584_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1584_MP45 (XI1584_bp2 cm222_2 XI1584_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1584_MP43 (VDD XI1584_s1 XI1584_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1584_MP44 (XI1584_bp2 cm166_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1584_MP56 (VDD XI1584_bcon cm223_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1584_MP46 (XI1584_bp3 XI1584_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1584_MP48 (VDD cm222_2 XI1584_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1584_MP50_1 (XI1584_bp4 XI1584_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1584_MP26 (VDD XI1584_asn XI1584_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1584_MP18 (XI1584_ap3 cm163_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1584_MP21 (XI1584_asn XI1584_acon XI1584_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1584_MP24 (XI1584_ap5 cm165_0 XI1584_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1584_MP23 (XI1584_ap4 cm164_1 XI1584_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1584_MP22 (VDD cm163_1 XI1584_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1584_MP22_1 (XI1584_ap4 cm163_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1584_MP23_1 (XI1584_ap5 cm164_1 XI1584_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1584_MP24_1 (XI1584_asn cm165_0 XI1584_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1584_MP17 (XI1584_acon cm165_0 XI1584_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1584_MP14 (XI1584_ap1 cm164_1 XI1584_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1584_MP13 (VDD cm163_1 XI1584_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1584_MP15 (XI1584_ap2 cm163_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1584_MP16 (VDD cm164_1 XI1584_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1584_MP28 (cm223_2 XI1584_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1584_MP19 (XI1584_ap3 cm164_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1584_MP20 (VDD cm165_0 XI1584_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1524_MP50 (VDD XI1524_s1 XI1524_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1524_MP47 (XI1524_bp3 cm53_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1524_MP49 (XI1524_bsn XI1524_bcon XI1524_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1524_MP52 (XI1524_bp5 cm161_2 XI1524_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1524_MP51 (XI1524_bp4 cm53_0 XI1524_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1524_MP51_1 (XI1524_bp5 cm53_0 XI1524_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1524_MP52_1 (XI1524_bsn cm161_2 XI1524_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1524_MP54 (VDD XI1524_bsn cm163_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1524_MP41 (XI1524_bp1 XI1524_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1524_MP42 (XI1524_bcon cm53_0 XI1524_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1524_MP45 (XI1524_bp2 cm161_2 XI1524_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1524_MP43 (VDD XI1524_s1 XI1524_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1524_MP44 (XI1524_bp2 cm53_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1524_MP56 (VDD XI1524_bcon cm163_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1524_MP46 (XI1524_bp3 XI1524_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1524_MP48 (VDD cm161_2 XI1524_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1524_MP50_1 (XI1524_bp4 XI1524_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1524_MP26 (VDD XI1524_asn XI1524_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1524_MP18 (XI1524_ap3 cm50_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1524_MP21 (XI1524_asn XI1524_acon XI1524_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1524_MP24 (XI1524_ap5 cm52_1 XI1524_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1524_MP23 (XI1524_ap4 cm51_1 XI1524_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1524_MP22 (VDD cm50_1 XI1524_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1524_MP22_1 (XI1524_ap4 cm50_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1524_MP23_1 (XI1524_ap5 cm51_1 XI1524_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1524_MP24_1 (XI1524_asn cm52_1 XI1524_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1524_MP17 (XI1524_acon cm52_1 XI1524_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1524_MP14 (XI1524_ap1 cm51_1 XI1524_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1524_MP13 (VDD cm50_1 XI1524_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1524_MP15 (XI1524_ap2 cm50_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1524_MP16 (VDD cm51_1 XI1524_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1524_MP28 (cm163_2 XI1524_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1524_MP19 (XI1524_ap3 cm51_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1524_MP20 (VDD cm52_1 XI1524_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1413_MP50 (VDD XI1413_s1 XI1413_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1413_MP47 (XI1413_bp3 pp11_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1413_MP49 (XI1413_bsn XI1413_bcon XI1413_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1413_MP52 (XI1413_bp5 cm48_2 XI1413_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1413_MP51 (XI1413_bp4 pp11_5 XI1413_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1413_MP51_1 (XI1413_bp5 pp11_5 XI1413_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1413_MP52_1 (XI1413_bsn cm48_2 XI1413_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1413_MP54 (VDD XI1413_bsn cm52_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1413_MP41 (XI1413_bp1 XI1413_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1413_MP42 (XI1413_bcon pp11_5 XI1413_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1413_MP45 (XI1413_bp2 cm48_2 XI1413_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1413_MP43 (VDD XI1413_s1 XI1413_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1413_MP44 (XI1413_bp2 pp11_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1413_MP56 (VDD XI1413_bcon cm52_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1413_MP46 (XI1413_bp3 XI1413_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1413_MP48 (VDD cm48_2 XI1413_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1413_MP50_1 (XI1413_bp4 XI1413_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1413_MP26 (VDD XI1413_asn XI1413_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1413_MP18 (XI1413_ap3 pp8_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1413_MP21 (XI1413_asn XI1413_acon XI1413_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1413_MP24 (XI1413_ap5 pp10_7 XI1413_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1413_MP23 (XI1413_ap4 pp9_9 XI1413_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1413_MP22 (VDD pp8_11 XI1413_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1413_MP22_1 (XI1413_ap4 pp8_11 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1413_MP23_1 (XI1413_ap5 pp9_9 XI1413_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1413_MP24_1 (XI1413_asn pp10_7 XI1413_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1413_MP17 (XI1413_acon pp10_7 XI1413_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1413_MP14 (XI1413_ap1 pp9_9 XI1413_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1413_MP13 (VDD pp8_11 XI1413_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1413_MP15 (XI1413_ap2 pp8_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1413_MP16 (VDD pp9_9 XI1413_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1413_MP28 (cm52_2 XI1413_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1413_MP19 (XI1413_ap3 pp9_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1413_MP20 (VDD pp10_7 XI1413_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1407_MP50 (VDD XI1407_s1 XI1407_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1407_MP47 (XI1407_bp3 pp3_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1407_MP49 (XI1407_bsn XI1407_bcon XI1407_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1407_MP52 (XI1407_bp5 cm43_2 XI1407_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1407_MP51 (XI1407_bp4 pp3_20 XI1407_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1407_MP51_1 (XI1407_bp5 pp3_20 XI1407_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1407_MP52_1 (XI1407_bsn cm43_2 XI1407_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1407_MP54 (VDD XI1407_bsn cm46_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1407_MP41 (XI1407_bp1 XI1407_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1407_MP42 (XI1407_bcon pp3_20 XI1407_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1407_MP45 (XI1407_bp2 cm43_2 XI1407_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1407_MP43 (VDD XI1407_s1 XI1407_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1407_MP44 (XI1407_bp2 pp3_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1407_MP56 (VDD XI1407_bcon cm46_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1407_MP46 (XI1407_bp3 XI1407_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1407_MP48 (VDD cm43_2 XI1407_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1407_MP50_1 (XI1407_bp4 XI1407_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1407_MP26 (VDD XI1407_asn XI1407_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1407_MP18 (XI1407_ap3 pp0_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1407_MP21 (XI1407_asn XI1407_acon XI1407_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1407_MP24 (XI1407_ap5 pp2_22 XI1407_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1407_MP23 (XI1407_ap4 pp1_24 XI1407_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1407_MP22 (VDD pp0_26 XI1407_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1407_MP22_1 (XI1407_ap4 pp0_26 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1407_MP23_1 (XI1407_ap5 pp1_24 XI1407_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1407_MP24_1 (XI1407_asn pp2_22 XI1407_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1407_MP17 (XI1407_acon pp2_22 XI1407_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1407_MP14 (XI1407_ap1 pp1_24 XI1407_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1407_MP13 (VDD pp0_26 XI1407_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1407_MP15 (XI1407_ap2 pp0_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1407_MP16 (VDD pp1_24 XI1407_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1407_MP28 (cm46_2 XI1407_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1407_MP19 (XI1407_ap3 pp1_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1407_MP20 (VDD pp2_22 XI1407_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1523_MP50 (VDD XI1523_s1 XI1523_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1523_MP47 (XI1523_bp3 pp12_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1523_MP49 (XI1523_bsn XI1523_bcon XI1523_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1523_MP52 (XI1523_bp5 pp13_1 XI1523_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1523_MP51 (XI1523_bp4 pp12_3 XI1523_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1523_MP51_1 (XI1523_bp5 pp12_3 XI1523_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1523_MP52_1 (XI1523_bsn pp13_1 XI1523_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1523_MP54 (VDD XI1523_bsn cm162_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1523_MP41 (XI1523_bp1 XI1523_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1523_MP42 (XI1523_bcon pp12_3 XI1523_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1523_MP45 (XI1523_bp2 pp13_1 XI1523_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1523_MP43 (VDD XI1523_s1 XI1523_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1523_MP44 (XI1523_bp2 pp12_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1523_MP56 (VDD XI1523_bcon cm162_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1523_MP46 (XI1523_bp3 XI1523_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1523_MP48 (VDD pp13_1 XI1523_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1523_MP50_1 (XI1523_bp4 XI1523_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1523_MP26 (VDD XI1523_asn XI1523_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1523_MP18 (XI1523_ap3 cm50_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1523_MP21 (XI1523_asn XI1523_acon XI1523_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1523_MP24 (XI1523_ap5 cm52_0 XI1523_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1523_MP23 (XI1523_ap4 cm51_0 XI1523_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1523_MP22 (VDD cm50_0 XI1523_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1523_MP22_1 (XI1523_ap4 cm50_0 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1523_MP23_1 (XI1523_ap5 cm51_0 XI1523_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1523_MP24_1 (XI1523_asn cm52_0 XI1523_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1523_MP17 (XI1523_acon cm52_0 XI1523_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1523_MP14 (XI1523_ap1 cm51_0 XI1523_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1523_MP13 (VDD cm50_0 XI1523_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1523_MP15 (XI1523_ap2 cm50_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1523_MP16 (VDD cm51_0 XI1523_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1523_MP28 (cm162_2 XI1523_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1523_MP19 (XI1523_ap3 cm51_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1523_MP20 (VDD cm52_0 XI1523_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1583_MP50 (VDD XI1583_s1 XI1583_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1583_MP47 (XI1583_bp3 cm164_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1583_MP49 (XI1583_bsn XI1583_bcon XI1583_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1583_MP52 (XI1583_bp5 cm221_2 XI1583_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1583_MP51 (XI1583_bp4 cm164_0 XI1583_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1583_MP51_1 (XI1583_bp5 cm164_0 XI1583_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1583_MP52_1 (XI1583_bsn cm221_2 XI1583_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1583_MP54 (VDD XI1583_bsn cm222_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1583_MP41 (XI1583_bp1 XI1583_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1583_MP42 (XI1583_bcon cm164_0 XI1583_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1583_MP45 (XI1583_bp2 cm221_2 XI1583_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1583_MP43 (VDD XI1583_s1 XI1583_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1583_MP44 (XI1583_bp2 cm164_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1583_MP56 (VDD XI1583_bcon cm222_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1583_MP46 (XI1583_bp3 XI1583_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1583_MP48 (VDD cm221_2 XI1583_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1583_MP50_1 (XI1583_bp4 XI1583_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1583_MP26 (VDD XI1583_asn XI1583_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1583_MP18 (XI1583_ap3 cm161_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1583_MP21 (XI1583_asn XI1583_acon XI1583_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1583_MP24 (XI1583_ap5 cm163_0 XI1583_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1583_MP23 (XI1583_ap4 cm162_1 XI1583_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1583_MP22 (VDD cm161_1 XI1583_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1583_MP22_1 (XI1583_ap4 cm161_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1583_MP23_1 (XI1583_ap5 cm162_1 XI1583_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1583_MP24_1 (XI1583_asn cm163_0 XI1583_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1583_MP17 (XI1583_acon cm163_0 XI1583_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1583_MP14 (XI1583_ap1 cm162_1 XI1583_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1583_MP13 (VDD cm161_1 XI1583_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1583_MP15 (XI1583_ap2 cm161_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1583_MP16 (VDD cm162_1 XI1583_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1583_MP28 (cm222_2 XI1583_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1583_MP19 (XI1583_ap3 cm162_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1583_MP20 (VDD cm163_0 XI1583_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1409_MP50 (VDD XI1409_s1 XI1409_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1409_MP47 (XI1409_bp3 pp11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1409_MP49 (XI1409_bsn XI1409_bcon XI1409_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1409_MP52 (XI1409_bp5 cm45_2 XI1409_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1409_MP51 (XI1409_bp4 pp11_4 XI1409_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1409_MP51_1 (XI1409_bp5 pp11_4 XI1409_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1409_MP52_1 (XI1409_bsn cm45_2 XI1409_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1409_MP54 (VDD XI1409_bsn cm48_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1409_MP41 (XI1409_bp1 XI1409_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1409_MP42 (XI1409_bcon pp11_4 XI1409_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1409_MP45 (XI1409_bp2 cm45_2 XI1409_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1409_MP43 (VDD XI1409_s1 XI1409_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1409_MP44 (XI1409_bp2 pp11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1409_MP56 (VDD XI1409_bcon cm48_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1409_MP46 (XI1409_bp3 XI1409_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1409_MP48 (VDD cm45_2 XI1409_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1409_MP50_1 (XI1409_bp4 XI1409_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1409_MP26 (VDD XI1409_asn XI1409_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1409_MP18 (XI1409_ap3 pp8_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1409_MP21 (XI1409_asn XI1409_acon XI1409_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1409_MP24 (XI1409_ap5 pp10_6 XI1409_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1409_MP23 (XI1409_ap4 pp9_8 XI1409_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1409_MP22 (VDD pp8_10 XI1409_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1409_MP22_1 (XI1409_ap4 pp8_10 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1409_MP23_1 (XI1409_ap5 pp9_8 XI1409_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1409_MP24_1 (XI1409_asn pp10_6 XI1409_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1409_MP17 (XI1409_acon pp10_6 XI1409_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1409_MP14 (XI1409_ap1 pp9_8 XI1409_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1409_MP13 (VDD pp8_10 XI1409_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1409_MP15 (XI1409_ap2 pp8_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1409_MP16 (VDD pp9_8 XI1409_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1409_MP28 (cm48_2 XI1409_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1409_MP19 (XI1409_ap3 pp9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1409_MP20 (VDD pp10_6 XI1409_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1408_MP50 (VDD XI1408_s1 XI1408_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1408_MP47 (XI1408_bp3 pp7_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1408_MP49 (XI1408_bsn XI1408_bcon XI1408_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1408_MP52 (XI1408_bp5 cm44_2 XI1408_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1408_MP51 (XI1408_bp4 pp7_12 XI1408_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1408_MP51_1 (XI1408_bp5 pp7_12 XI1408_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1408_MP52_1 (XI1408_bsn cm44_2 XI1408_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1408_MP54 (VDD XI1408_bsn cm47_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1408_MP41 (XI1408_bp1 XI1408_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1408_MP42 (XI1408_bcon pp7_12 XI1408_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1408_MP45 (XI1408_bp2 cm44_2 XI1408_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1408_MP43 (VDD XI1408_s1 XI1408_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1408_MP44 (XI1408_bp2 pp7_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1408_MP56 (VDD XI1408_bcon cm47_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1408_MP46 (XI1408_bp3 XI1408_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1408_MP48 (VDD cm44_2 XI1408_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1408_MP50_1 (XI1408_bp4 XI1408_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1408_MP26 (VDD XI1408_asn XI1408_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1408_MP18 (XI1408_ap3 pp4_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1408_MP21 (XI1408_asn XI1408_acon XI1408_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1408_MP24 (XI1408_ap5 pp6_14 XI1408_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1408_MP23 (XI1408_ap4 pp5_16 XI1408_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1408_MP22 (VDD pp4_18 XI1408_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1408_MP22_1 (XI1408_ap4 pp4_18 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1408_MP23_1 (XI1408_ap5 pp5_16 XI1408_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1408_MP24_1 (XI1408_asn pp6_14 XI1408_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1408_MP17 (XI1408_acon pp6_14 XI1408_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1408_MP14 (XI1408_ap1 pp5_16 XI1408_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1408_MP13 (VDD pp4_18 XI1408_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1408_MP15 (XI1408_ap2 pp4_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1408_MP16 (VDD pp5_16 XI1408_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1408_MP28 (cm47_2 XI1408_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1408_MP19 (XI1408_ap3 pp5_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1408_MP20 (VDD pp6_14 XI1408_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1405_MP50 (VDD XI1405_s1 XI1405_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1405_MP47 (XI1405_bp3 pp7_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1405_MP49 (XI1405_bsn XI1405_bcon XI1405_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1405_MP52 (XI1405_bp5 cm41_2 XI1405_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1405_MP51 (XI1405_bp4 pp7_11 XI1405_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1405_MP51_1 (XI1405_bp5 pp7_11 XI1405_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1405_MP52_1 (XI1405_bsn cm41_2 XI1405_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1405_MP54 (VDD XI1405_bsn cm44_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1405_MP41 (XI1405_bp1 XI1405_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1405_MP42 (XI1405_bcon pp7_11 XI1405_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1405_MP45 (XI1405_bp2 cm41_2 XI1405_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1405_MP43 (VDD XI1405_s1 XI1405_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1405_MP44 (XI1405_bp2 pp7_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1405_MP56 (VDD XI1405_bcon cm44_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1405_MP46 (XI1405_bp3 XI1405_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1405_MP48 (VDD cm41_2 XI1405_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1405_MP50_1 (XI1405_bp4 XI1405_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1405_MP26 (VDD XI1405_asn XI1405_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1405_MP18 (XI1405_ap3 pp4_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1405_MP21 (XI1405_asn XI1405_acon XI1405_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1405_MP24 (XI1405_ap5 pp6_13 XI1405_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1405_MP23 (XI1405_ap4 pp5_15 XI1405_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1405_MP22 (VDD pp4_17 XI1405_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1405_MP22_1 (XI1405_ap4 pp4_17 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1405_MP23_1 (XI1405_ap5 pp5_15 XI1405_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1405_MP24_1 (XI1405_asn pp6_13 XI1405_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1405_MP17 (XI1405_acon pp6_13 XI1405_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1405_MP14 (XI1405_ap1 pp5_15 XI1405_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1405_MP13 (VDD pp4_17 XI1405_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1405_MP15 (XI1405_ap2 pp4_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1405_MP16 (VDD pp5_15 XI1405_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1405_MP28 (cm44_2 XI1405_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1405_MP19 (XI1405_ap3 pp5_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1405_MP20 (VDD pp6_13 XI1405_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1520_MP50 (VDD XI1520_s1 XI1520_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1520_MP47 (XI1520_bp3 cm46_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1520_MP49 (XI1520_bsn XI1520_bcon XI1520_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1520_MP52 (XI1520_bp5 cm157_2 XI1520_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1520_MP51 (XI1520_bp4 cm46_0 XI1520_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1520_MP51_1 (XI1520_bp5 cm46_0 XI1520_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1520_MP52_1 (XI1520_bsn cm157_2 XI1520_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1520_MP54 (VDD XI1520_bsn cm159_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1520_MP41 (XI1520_bp1 XI1520_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1520_MP42 (XI1520_bcon cm46_0 XI1520_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1520_MP45 (XI1520_bp2 cm157_2 XI1520_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1520_MP43 (VDD XI1520_s1 XI1520_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1520_MP44 (XI1520_bp2 cm46_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1520_MP56 (VDD XI1520_bcon cm159_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1520_MP46 (XI1520_bp3 XI1520_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1520_MP48 (VDD cm157_2 XI1520_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1520_MP50_1 (XI1520_bp4 XI1520_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1520_MP26 (VDD XI1520_asn XI1520_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1520_MP18 (XI1520_ap3 cm43_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1520_MP21 (XI1520_asn XI1520_acon XI1520_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1520_MP24 (XI1520_ap5 cm45_1 XI1520_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1520_MP23 (XI1520_ap4 cm44_1 XI1520_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1520_MP22 (VDD cm43_1 XI1520_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1520_MP22_1 (XI1520_ap4 cm43_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1520_MP23_1 (XI1520_ap5 cm44_1 XI1520_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1520_MP24_1 (XI1520_asn cm45_1 XI1520_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1520_MP17 (XI1520_acon cm45_1 XI1520_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1520_MP14 (XI1520_ap1 cm44_1 XI1520_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1520_MP13 (VDD cm43_1 XI1520_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1520_MP15 (XI1520_ap2 cm43_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1520_MP16 (VDD cm44_1 XI1520_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1520_MP28 (cm159_2 XI1520_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1520_MP19 (XI1520_ap3 cm44_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1520_MP20 (VDD cm45_1 XI1520_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1522_MP50 (VDD XI1522_s1 XI1522_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1522_MP47 (XI1522_bp3 fa49_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1522_MP49 (XI1522_bsn XI1522_bcon XI1522_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1522_MP52 (XI1522_bp5 cm159_2 XI1522_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1522_MP51 (XI1522_bp4 fa49_1 XI1522_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1522_MP51_1 (XI1522_bp5 fa49_1 XI1522_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1522_MP52_1 (XI1522_bsn cm159_2 XI1522_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1522_MP54 (VDD XI1522_bsn cm161_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1522_MP41 (XI1522_bp1 XI1522_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1522_MP42 (XI1522_bcon fa49_1 XI1522_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1522_MP45 (XI1522_bp2 cm159_2 XI1522_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1522_MP43 (VDD XI1522_s1 XI1522_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1522_MP44 (XI1522_bp2 fa49_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1522_MP56 (VDD XI1522_bcon cm161_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1522_MP46 (XI1522_bp3 XI1522_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1522_MP48 (VDD cm159_2 XI1522_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1522_MP50_1 (XI1522_bp4 XI1522_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1522_MP26 (VDD XI1522_asn XI1522_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1522_MP18 (XI1522_ap3 cm46_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1522_MP21 (XI1522_asn XI1522_acon XI1522_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1522_MP24 (XI1522_ap5 cm48_1 XI1522_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1522_MP23 (XI1522_ap4 cm47_1 XI1522_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1522_MP22 (VDD cm46_1 XI1522_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1522_MP22_1 (XI1522_ap4 cm46_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1522_MP23_1 (XI1522_ap5 cm47_1 XI1522_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1522_MP24_1 (XI1522_asn cm48_1 XI1522_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1522_MP17 (XI1522_acon cm48_1 XI1522_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1522_MP14 (XI1522_ap1 cm47_1 XI1522_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1522_MP13 (VDD cm46_1 XI1522_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1522_MP15 (XI1522_ap2 cm46_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1522_MP16 (VDD cm47_1 XI1522_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1522_MP28 (cm161_2 XI1522_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1522_MP19 (XI1522_ap3 cm47_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1522_MP20 (VDD cm48_1 XI1522_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1404_MP50 (VDD XI1404_s1 XI1404_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1404_MP47 (XI1404_bp3 pp3_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1404_MP49 (XI1404_bsn XI1404_bcon XI1404_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1404_MP52 (XI1404_bp5 cm40_2 XI1404_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1404_MP51 (XI1404_bp4 pp3_19 XI1404_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1404_MP51_1 (XI1404_bp5 pp3_19 XI1404_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1404_MP52_1 (XI1404_bsn cm40_2 XI1404_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1404_MP54 (VDD XI1404_bsn cm43_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1404_MP41 (XI1404_bp1 XI1404_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1404_MP42 (XI1404_bcon pp3_19 XI1404_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1404_MP45 (XI1404_bp2 cm40_2 XI1404_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1404_MP43 (VDD XI1404_s1 XI1404_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1404_MP44 (XI1404_bp2 pp3_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1404_MP56 (VDD XI1404_bcon cm43_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1404_MP46 (XI1404_bp3 XI1404_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1404_MP48 (VDD cm40_2 XI1404_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1404_MP50_1 (XI1404_bp4 XI1404_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1404_MP26 (VDD XI1404_asn XI1404_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1404_MP18 (XI1404_ap3 pp0_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1404_MP21 (XI1404_asn XI1404_acon XI1404_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1404_MP24 (XI1404_ap5 pp2_21 XI1404_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1404_MP23 (XI1404_ap4 pp1_23 XI1404_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1404_MP22 (VDD pp0_25 XI1404_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1404_MP22_1 (XI1404_ap4 pp0_25 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1404_MP23_1 (XI1404_ap5 pp1_23 XI1404_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1404_MP24_1 (XI1404_asn pp2_21 XI1404_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1404_MP17 (XI1404_acon pp2_21 XI1404_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1404_MP14 (XI1404_ap1 pp1_23 XI1404_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1404_MP13 (VDD pp0_25 XI1404_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1404_MP15 (XI1404_ap2 pp0_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1404_MP16 (VDD pp1_23 XI1404_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1404_MP28 (cm43_2 XI1404_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1404_MP19 (XI1404_ap3 pp1_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1404_MP20 (VDD pp2_21 XI1404_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1582_MP50 (VDD XI1582_s1 XI1582_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1582_MP47 (XI1582_bp3 cm162_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1582_MP49 (XI1582_bsn XI1582_bcon XI1582_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1582_MP52 (XI1582_bp5 cm220_2 XI1582_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1582_MP51 (XI1582_bp4 cm162_0 XI1582_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1582_MP51_1 (XI1582_bp5 cm162_0 XI1582_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1582_MP52_1 (XI1582_bsn cm220_2 XI1582_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1582_MP54 (VDD XI1582_bsn cm221_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1582_MP41 (XI1582_bp1 XI1582_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1582_MP42 (XI1582_bcon cm162_0 XI1582_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1582_MP45 (XI1582_bp2 cm220_2 XI1582_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1582_MP43 (VDD XI1582_s1 XI1582_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1582_MP44 (XI1582_bp2 cm162_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1582_MP56 (VDD XI1582_bcon cm221_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1582_MP46 (XI1582_bp3 XI1582_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1582_MP48 (VDD cm220_2 XI1582_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1582_MP50_1 (XI1582_bp4 XI1582_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1582_MP26 (VDD XI1582_asn XI1582_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1582_MP18 (XI1582_ap3 cm159_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1582_MP21 (XI1582_asn XI1582_acon XI1582_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1582_MP24 (XI1582_ap5 cm161_0 XI1582_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1582_MP23 (XI1582_ap4 fa160_1 XI1582_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1582_MP22 (VDD cm159_1 XI1582_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1582_MP22_1 (XI1582_ap4 cm159_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1582_MP23_1 (XI1582_ap5 fa160_1 XI1582_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1582_MP24_1 (XI1582_asn cm161_0 XI1582_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1582_MP17 (XI1582_acon cm161_0 XI1582_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1582_MP14 (XI1582_ap1 fa160_1 XI1582_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1582_MP13 (VDD cm159_1 XI1582_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1582_MP15 (XI1582_ap2 cm159_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1582_MP16 (VDD fa160_1 XI1582_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1582_MP28 (cm221_2 XI1582_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1582_MP19 (XI1582_ap3 fa160_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1582_MP20 (VDD cm161_0 XI1582_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1406_MP50 (VDD XI1406_s1 XI1406_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1406_MP47 (XI1406_bp3 pp11_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1406_MP49 (XI1406_bsn XI1406_bcon XI1406_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1406_MP52 (XI1406_bp5 cm42_2 XI1406_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1406_MP51 (XI1406_bp4 pp11_3 XI1406_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1406_MP51_1 (XI1406_bp5 pp11_3 XI1406_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1406_MP52_1 (XI1406_bsn cm42_2 XI1406_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1406_MP54 (VDD XI1406_bsn cm45_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1406_MP41 (XI1406_bp1 XI1406_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1406_MP42 (XI1406_bcon pp11_3 XI1406_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1406_MP45 (XI1406_bp2 cm42_2 XI1406_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1406_MP43 (VDD XI1406_s1 XI1406_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1406_MP44 (XI1406_bp2 pp11_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1406_MP56 (VDD XI1406_bcon cm45_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1406_MP46 (XI1406_bp3 XI1406_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1406_MP48 (VDD cm42_2 XI1406_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1406_MP50_1 (XI1406_bp4 XI1406_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1406_MP26 (VDD XI1406_asn XI1406_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1406_MP18 (XI1406_ap3 pp8_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1406_MP21 (XI1406_asn XI1406_acon XI1406_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1406_MP24 (XI1406_ap5 pp10_5 XI1406_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1406_MP23 (XI1406_ap4 pp9_7 XI1406_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1406_MP22 (VDD pp8_9 XI1406_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1406_MP22_1 (XI1406_ap4 pp8_9 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1406_MP23_1 (XI1406_ap5 pp9_7 XI1406_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1406_MP24_1 (XI1406_asn pp10_5 XI1406_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1406_MP17 (XI1406_acon pp10_5 XI1406_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1406_MP14 (XI1406_ap1 pp9_7 XI1406_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1406_MP13 (VDD pp8_9 XI1406_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1406_MP15 (XI1406_ap2 pp8_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1406_MP16 (VDD pp9_7 XI1406_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1406_MP28 (cm45_2 XI1406_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1406_MP19 (XI1406_ap3 pp9_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1406_MP20 (VDD pp10_5 XI1406_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1402_MP50 (VDD XI1402_s1 XI1402_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1402_MP47 (XI1402_bp3 pp7_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1402_MP49 (XI1402_bsn XI1402_bcon XI1402_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1402_MP52 (XI1402_bp5 cm38_2 XI1402_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1402_MP51 (XI1402_bp4 pp7_10 XI1402_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1402_MP51_1 (XI1402_bp5 pp7_10 XI1402_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1402_MP52_1 (XI1402_bsn cm38_2 XI1402_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1402_MP54 (VDD XI1402_bsn cm41_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1402_MP41 (XI1402_bp1 XI1402_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1402_MP42 (XI1402_bcon pp7_10 XI1402_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1402_MP45 (XI1402_bp2 cm38_2 XI1402_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1402_MP43 (VDD XI1402_s1 XI1402_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1402_MP44 (XI1402_bp2 pp7_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1402_MP56 (VDD XI1402_bcon cm41_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1402_MP46 (XI1402_bp3 XI1402_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1402_MP48 (VDD cm38_2 XI1402_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1402_MP50_1 (XI1402_bp4 XI1402_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1402_MP26 (VDD XI1402_asn XI1402_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1402_MP18 (XI1402_ap3 pp4_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1402_MP21 (XI1402_asn XI1402_acon XI1402_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1402_MP24 (XI1402_ap5 pp6_12 XI1402_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1402_MP23 (XI1402_ap4 pp5_14 XI1402_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1402_MP22 (VDD pp4_16 XI1402_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1402_MP22_1 (XI1402_ap4 pp4_16 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1402_MP23_1 (XI1402_ap5 pp5_14 XI1402_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1402_MP24_1 (XI1402_asn pp6_12 XI1402_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1402_MP17 (XI1402_acon pp6_12 XI1402_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1402_MP14 (XI1402_ap1 pp5_14 XI1402_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1402_MP13 (VDD pp4_16 XI1402_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1402_MP15 (XI1402_ap2 pp4_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1402_MP16 (VDD pp5_14 XI1402_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1402_MP28 (cm41_2 XI1402_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1402_MP19 (XI1402_ap3 pp5_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1402_MP20 (VDD pp6_12 XI1402_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1398_MP50 (VDD XI1398_s1 XI1398_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1398_MP47 (XI1398_bp3 pp3_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1398_MP49 (XI1398_bsn XI1398_bcon XI1398_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1398_MP52 (XI1398_bp5 cm34_2 XI1398_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1398_MP51 (XI1398_bp4 pp3_17 XI1398_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1398_MP51_1 (XI1398_bp5 pp3_17 XI1398_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1398_MP52_1 (XI1398_bsn cm34_2 XI1398_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1398_MP54 (VDD XI1398_bsn cm37_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1398_MP41 (XI1398_bp1 XI1398_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1398_MP42 (XI1398_bcon pp3_17 XI1398_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1398_MP45 (XI1398_bp2 cm34_2 XI1398_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1398_MP43 (VDD XI1398_s1 XI1398_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1398_MP44 (XI1398_bp2 pp3_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1398_MP56 (VDD XI1398_bcon cm37_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1398_MP46 (XI1398_bp3 XI1398_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1398_MP48 (VDD cm34_2 XI1398_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1398_MP50_1 (XI1398_bp4 XI1398_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1398_MP26 (VDD XI1398_asn XI1398_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1398_MP18 (XI1398_ap3 pp0_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1398_MP21 (XI1398_asn XI1398_acon XI1398_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1398_MP24 (XI1398_ap5 pp2_19 XI1398_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1398_MP23 (XI1398_ap4 pp1_21 XI1398_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1398_MP22 (VDD pp0_23 XI1398_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1398_MP22_1 (XI1398_ap4 pp0_23 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1398_MP23_1 (XI1398_ap5 pp1_21 XI1398_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1398_MP24_1 (XI1398_asn pp2_19 XI1398_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1398_MP17 (XI1398_acon pp2_19 XI1398_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1398_MP14 (XI1398_ap1 pp1_21 XI1398_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1398_MP13 (VDD pp0_23 XI1398_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1398_MP15 (XI1398_ap2 pp0_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1398_MP16 (VDD pp1_21 XI1398_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1398_MP28 (cm37_2 XI1398_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1398_MP19 (XI1398_ap3 pp1_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1398_MP20 (VDD pp2_19 XI1398_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1401_MP50 (VDD XI1401_s1 XI1401_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1401_MP47 (XI1401_bp3 pp3_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1401_MP49 (XI1401_bsn XI1401_bcon XI1401_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1401_MP52 (XI1401_bp5 cm37_2 XI1401_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1401_MP51 (XI1401_bp4 pp3_18 XI1401_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1401_MP51_1 (XI1401_bp5 pp3_18 XI1401_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1401_MP52_1 (XI1401_bsn cm37_2 XI1401_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1401_MP54 (VDD XI1401_bsn cm40_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1401_MP41 (XI1401_bp1 XI1401_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1401_MP42 (XI1401_bcon pp3_18 XI1401_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1401_MP45 (XI1401_bp2 cm37_2 XI1401_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1401_MP43 (VDD XI1401_s1 XI1401_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1401_MP44 (XI1401_bp2 pp3_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1401_MP56 (VDD XI1401_bcon cm40_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1401_MP46 (XI1401_bp3 XI1401_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1401_MP48 (VDD cm37_2 XI1401_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1401_MP50_1 (XI1401_bp4 XI1401_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1401_MP26 (VDD XI1401_asn XI1401_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1401_MP18 (XI1401_ap3 pp0_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1401_MP21 (XI1401_asn XI1401_acon XI1401_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1401_MP24 (XI1401_ap5 pp2_20 XI1401_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1401_MP23 (XI1401_ap4 pp1_22 XI1401_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1401_MP22 (VDD pp0_24 XI1401_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1401_MP22_1 (XI1401_ap4 pp0_24 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1401_MP23_1 (XI1401_ap5 pp1_22 XI1401_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1401_MP24_1 (XI1401_asn pp2_20 XI1401_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1401_MP17 (XI1401_acon pp2_20 XI1401_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1401_MP14 (XI1401_ap1 pp1_22 XI1401_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1401_MP13 (VDD pp0_24 XI1401_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1401_MP15 (XI1401_ap2 pp0_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1401_MP16 (VDD pp1_22 XI1401_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1401_MP28 (cm40_2 XI1401_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1401_MP19 (XI1401_ap3 pp1_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1401_MP20 (VDD pp2_20 XI1401_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1518_MP50 (VDD XI1518_s1 XI1518_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1518_MP47 (XI1518_bp3 cm43_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1518_MP49 (XI1518_bsn XI1518_bcon XI1518_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1518_MP52 (XI1518_bp5 cm155_2 XI1518_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1518_MP51 (XI1518_bp4 cm43_0 XI1518_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1518_MP51_1 (XI1518_bp5 cm43_0 XI1518_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1518_MP52_1 (XI1518_bsn cm155_2 XI1518_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1518_MP54 (VDD XI1518_bsn cm157_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1518_MP41 (XI1518_bp1 XI1518_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1518_MP42 (XI1518_bcon cm43_0 XI1518_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1518_MP45 (XI1518_bp2 cm155_2 XI1518_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1518_MP43 (VDD XI1518_s1 XI1518_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1518_MP44 (XI1518_bp2 cm43_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1518_MP56 (VDD XI1518_bcon cm157_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1518_MP46 (XI1518_bp3 XI1518_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1518_MP48 (VDD cm155_2 XI1518_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1518_MP50_1 (XI1518_bp4 XI1518_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1518_MP26 (VDD XI1518_asn XI1518_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1518_MP18 (XI1518_ap3 cm40_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1518_MP21 (XI1518_asn XI1518_acon XI1518_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1518_MP24 (XI1518_ap5 cm42_1 XI1518_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1518_MP23 (XI1518_ap4 cm41_1 XI1518_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1518_MP22 (VDD cm40_1 XI1518_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1518_MP22_1 (XI1518_ap4 cm40_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1518_MP23_1 (XI1518_ap5 cm41_1 XI1518_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1518_MP24_1 (XI1518_asn cm42_1 XI1518_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1518_MP17 (XI1518_acon cm42_1 XI1518_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1518_MP14 (XI1518_ap1 cm41_1 XI1518_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1518_MP13 (VDD cm40_1 XI1518_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1518_MP15 (XI1518_ap2 cm40_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1518_MP16 (VDD cm41_1 XI1518_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1518_MP28 (cm157_2 XI1518_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1518_MP19 (XI1518_ap3 cm41_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1518_MP20 (VDD cm42_1 XI1518_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1581_MP50 (VDD XI1581_s1 XI1581_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1581_MP47 (XI1581_bp3 fa160_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1581_MP49 (XI1581_bsn XI1581_bcon XI1581_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1581_MP52 (XI1581_bp5 cm219_2 XI1581_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1581_MP51 (XI1581_bp4 fa160_0 XI1581_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1581_MP51_1 (XI1581_bp5 fa160_0 XI1581_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1581_MP52_1 (XI1581_bsn cm219_2 XI1581_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1581_MP54 (VDD XI1581_bsn cm220_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1581_MP41 (XI1581_bp1 XI1581_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1581_MP42 (XI1581_bcon fa160_0 XI1581_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1581_MP45 (XI1581_bp2 cm219_2 XI1581_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1581_MP43 (VDD XI1581_s1 XI1581_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1581_MP44 (XI1581_bp2 fa160_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1581_MP56 (VDD XI1581_bcon cm220_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1581_MP46 (XI1581_bp3 XI1581_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1581_MP48 (VDD cm219_2 XI1581_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1581_MP50_1 (XI1581_bp4 XI1581_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1581_MP26 (VDD XI1581_asn XI1581_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1581_MP18 (XI1581_ap3 cm157_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1581_MP21 (XI1581_asn XI1581_acon XI1581_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1581_MP24 (XI1581_ap5 cm159_0 XI1581_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1581_MP23 (XI1581_ap4 fa158_1 XI1581_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1581_MP22 (VDD cm157_1 XI1581_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1581_MP22_1 (XI1581_ap4 cm157_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1581_MP23_1 (XI1581_ap5 fa158_1 XI1581_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1581_MP24_1 (XI1581_asn cm159_0 XI1581_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1581_MP17 (XI1581_acon cm159_0 XI1581_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1581_MP14 (XI1581_ap1 fa158_1 XI1581_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1581_MP13 (VDD cm157_1 XI1581_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1581_MP15 (XI1581_ap2 cm157_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1581_MP16 (VDD fa158_1 XI1581_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1581_MP28 (cm220_2 XI1581_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1581_MP19 (XI1581_ap3 fa158_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1581_MP20 (VDD cm159_0 XI1581_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1403_MP50 (VDD XI1403_s1 XI1403_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1403_MP47 (XI1403_bp3 pp11_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1403_MP49 (XI1403_bsn XI1403_bcon XI1403_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1403_MP52 (XI1403_bp5 cm39_2 XI1403_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1403_MP51 (XI1403_bp4 pp11_2 XI1403_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1403_MP51_1 (XI1403_bp5 pp11_2 XI1403_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1403_MP52_1 (XI1403_bsn cm39_2 XI1403_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1403_MP54 (VDD XI1403_bsn cm42_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1403_MP41 (XI1403_bp1 XI1403_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1403_MP42 (XI1403_bcon pp11_2 XI1403_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1403_MP45 (XI1403_bp2 cm39_2 XI1403_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1403_MP43 (VDD XI1403_s1 XI1403_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1403_MP44 (XI1403_bp2 pp11_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1403_MP56 (VDD XI1403_bcon cm42_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1403_MP46 (XI1403_bp3 XI1403_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1403_MP48 (VDD cm39_2 XI1403_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1403_MP50_1 (XI1403_bp4 XI1403_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1403_MP26 (VDD XI1403_asn XI1403_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1403_MP18 (XI1403_ap3 pp8_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1403_MP21 (XI1403_asn XI1403_acon XI1403_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1403_MP24 (XI1403_ap5 pp10_4 XI1403_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1403_MP23 (XI1403_ap4 pp9_6 XI1403_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1403_MP22 (VDD pp8_8 XI1403_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1403_MP22_1 (XI1403_ap4 pp8_8 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1403_MP23_1 (XI1403_ap5 pp9_6 XI1403_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1403_MP24_1 (XI1403_asn pp10_4 XI1403_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1403_MP17 (XI1403_acon pp10_4 XI1403_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1403_MP14 (XI1403_ap1 pp9_6 XI1403_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1403_MP13 (VDD pp8_8 XI1403_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1403_MP15 (XI1403_ap2 pp8_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1403_MP16 (VDD pp9_6 XI1403_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1403_MP28 (cm42_2 XI1403_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1403_MP19 (XI1403_ap3 pp9_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1403_MP20 (VDD pp10_4 XI1403_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1399_MP50 (VDD XI1399_s1 XI1399_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1399_MP47 (XI1399_bp3 pp7_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1399_MP49 (XI1399_bsn XI1399_bcon XI1399_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1399_MP52 (XI1399_bp5 cm35_2 XI1399_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1399_MP51 (XI1399_bp4 pp7_9 XI1399_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1399_MP51_1 (XI1399_bp5 pp7_9 XI1399_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1399_MP52_1 (XI1399_bsn cm35_2 XI1399_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1399_MP54 (VDD XI1399_bsn cm38_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1399_MP41 (XI1399_bp1 XI1399_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1399_MP42 (XI1399_bcon pp7_9 XI1399_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1399_MP45 (XI1399_bp2 cm35_2 XI1399_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1399_MP43 (VDD XI1399_s1 XI1399_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1399_MP44 (XI1399_bp2 pp7_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1399_MP56 (VDD XI1399_bcon cm38_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1399_MP46 (XI1399_bp3 XI1399_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1399_MP48 (VDD cm35_2 XI1399_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1399_MP50_1 (XI1399_bp4 XI1399_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1399_MP26 (VDD XI1399_asn XI1399_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1399_MP18 (XI1399_ap3 pp4_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1399_MP21 (XI1399_asn XI1399_acon XI1399_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1399_MP24 (XI1399_ap5 pp6_11 XI1399_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1399_MP23 (XI1399_ap4 pp5_13 XI1399_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1399_MP22 (VDD pp4_15 XI1399_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1399_MP22_1 (XI1399_ap4 pp4_15 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1399_MP23_1 (XI1399_ap5 pp5_13 XI1399_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1399_MP24_1 (XI1399_asn pp6_11 XI1399_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1399_MP17 (XI1399_acon pp6_11 XI1399_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1399_MP14 (XI1399_ap1 pp5_13 XI1399_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1399_MP13 (VDD pp4_15 XI1399_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1399_MP15 (XI1399_ap2 pp4_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1399_MP16 (VDD pp5_13 XI1399_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1399_MP28 (cm38_2 XI1399_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1399_MP19 (XI1399_ap3 pp5_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1399_MP20 (VDD pp6_11 XI1399_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1516_MP50 (VDD XI1516_s1 XI1516_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1516_MP47 (XI1516_bp3 cm40_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1516_MP49 (XI1516_bsn XI1516_bcon XI1516_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1516_MP52 (XI1516_bp5 cm154_2 XI1516_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1516_MP51 (XI1516_bp4 cm40_0 XI1516_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1516_MP51_1 (XI1516_bp5 cm40_0 XI1516_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1516_MP52_1 (XI1516_bsn cm154_2 XI1516_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1516_MP54 (VDD XI1516_bsn cm155_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1516_MP41 (XI1516_bp1 XI1516_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1516_MP42 (XI1516_bcon cm40_0 XI1516_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1516_MP45 (XI1516_bp2 cm154_2 XI1516_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1516_MP43 (VDD XI1516_s1 XI1516_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1516_MP44 (XI1516_bp2 cm40_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1516_MP56 (VDD XI1516_bcon cm155_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1516_MP46 (XI1516_bp3 XI1516_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1516_MP48 (VDD cm154_2 XI1516_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1516_MP50_1 (XI1516_bp4 XI1516_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1516_MP26 (VDD XI1516_asn XI1516_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1516_MP18 (XI1516_ap3 cm37_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1516_MP21 (XI1516_asn XI1516_acon XI1516_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1516_MP24 (XI1516_ap5 cm39_1 XI1516_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1516_MP23 (XI1516_ap4 cm38_1 XI1516_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1516_MP22 (VDD cm37_1 XI1516_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1516_MP22_1 (XI1516_ap4 cm37_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1516_MP23_1 (XI1516_ap5 cm38_1 XI1516_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1516_MP24_1 (XI1516_asn cm39_1 XI1516_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1516_MP17 (XI1516_acon cm39_1 XI1516_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1516_MP14 (XI1516_ap1 cm38_1 XI1516_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1516_MP13 (VDD cm37_1 XI1516_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1516_MP15 (XI1516_ap2 cm37_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1516_MP16 (VDD cm38_1 XI1516_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1516_MP28 (cm155_2 XI1516_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1516_MP19 (XI1516_ap3 cm38_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1516_MP20 (VDD cm39_1 XI1516_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1580_MP50 (VDD XI1580_s1 XI1580_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1580_MP47 (XI1580_bp3 fa158_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1580_MP49 (XI1580_bsn XI1580_bcon XI1580_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1580_MP52 (XI1580_bp5 cm218_2 XI1580_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1580_MP51 (XI1580_bp4 fa158_0 XI1580_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1580_MP51_1 (XI1580_bp5 fa158_0 XI1580_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1580_MP52_1 (XI1580_bsn cm218_2 XI1580_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1580_MP54 (VDD XI1580_bsn cm219_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1580_MP41 (XI1580_bp1 XI1580_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1580_MP42 (XI1580_bcon fa158_0 XI1580_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1580_MP45 (XI1580_bp2 cm218_2 XI1580_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1580_MP43 (VDD XI1580_s1 XI1580_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1580_MP44 (XI1580_bp2 fa158_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1580_MP56 (VDD XI1580_bcon cm219_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1580_MP46 (XI1580_bp3 XI1580_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1580_MP48 (VDD cm218_2 XI1580_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1580_MP50_1 (XI1580_bp4 XI1580_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1580_MP26 (VDD XI1580_asn XI1580_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1580_MP18 (XI1580_ap3 cm155_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1580_MP21 (XI1580_asn XI1580_acon XI1580_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1580_MP24 (XI1580_ap5 cm157_0 XI1580_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1580_MP23 (XI1580_ap4 fa156_1 XI1580_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1580_MP22 (VDD cm155_1 XI1580_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1580_MP22_1 (XI1580_ap4 cm155_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1580_MP23_1 (XI1580_ap5 fa156_1 XI1580_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1580_MP24_1 (XI1580_asn cm157_0 XI1580_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1580_MP17 (XI1580_acon cm157_0 XI1580_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1580_MP14 (XI1580_ap1 fa156_1 XI1580_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1580_MP13 (VDD cm155_1 XI1580_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1580_MP15 (XI1580_ap2 cm155_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1580_MP16 (VDD fa156_1 XI1580_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1580_MP28 (cm219_2 XI1580_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1580_MP19 (XI1580_ap3 fa156_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1580_MP20 (VDD cm157_0 XI1580_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1400_MP50 (VDD XI1400_s1 XI1400_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1400_MP47 (XI1400_bp3 pp11_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1400_MP49 (XI1400_bsn XI1400_bcon XI1400_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1400_MP52 (XI1400_bp5 cm36_2 XI1400_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1400_MP51 (XI1400_bp4 pp11_1 XI1400_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1400_MP51_1 (XI1400_bp5 pp11_1 XI1400_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1400_MP52_1 (XI1400_bsn cm36_2 XI1400_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1400_MP54 (VDD XI1400_bsn cm39_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1400_MP41 (XI1400_bp1 XI1400_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1400_MP42 (XI1400_bcon pp11_1 XI1400_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1400_MP45 (XI1400_bp2 cm36_2 XI1400_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1400_MP43 (VDD XI1400_s1 XI1400_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1400_MP44 (XI1400_bp2 pp11_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1400_MP56 (VDD XI1400_bcon cm39_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1400_MP46 (XI1400_bp3 XI1400_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1400_MP48 (VDD cm36_2 XI1400_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1400_MP50_1 (XI1400_bp4 XI1400_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1400_MP26 (VDD XI1400_asn XI1400_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1400_MP18 (XI1400_ap3 pp8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1400_MP21 (XI1400_asn XI1400_acon XI1400_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1400_MP24 (XI1400_ap5 pp10_3 XI1400_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1400_MP23 (XI1400_ap4 pp9_5 XI1400_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1400_MP22 (VDD pp8_7 XI1400_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1400_MP22_1 (XI1400_ap4 pp8_7 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1400_MP23_1 (XI1400_ap5 pp9_5 XI1400_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1400_MP24_1 (XI1400_asn pp10_3 XI1400_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1400_MP17 (XI1400_acon pp10_3 XI1400_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1400_MP14 (XI1400_ap1 pp9_5 XI1400_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1400_MP13 (VDD pp8_7 XI1400_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1400_MP15 (XI1400_ap2 pp8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1400_MP16 (VDD pp9_5 XI1400_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1400_MP28 (cm39_2 XI1400_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1400_MP19 (XI1400_ap3 pp9_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1400_MP20 (VDD pp10_3 XI1400_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1397_MP50 (VDD XI1397_s1 XI1397_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1397_MP47 (XI1397_bp3 pp11_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1397_MP49 (XI1397_bsn XI1397_bcon XI1397_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1397_MP52 (XI1397_bp5 B_23_b3_5 XI1397_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1397_MP51 (XI1397_bp4 pp11_0 XI1397_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1397_MP51_1 (XI1397_bp5 pp11_0 XI1397_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1397_MP52_1 (XI1397_bsn B_23_b3_5 XI1397_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1397_MP54 (VDD XI1397_bsn cm36_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1397_MP41 (XI1397_bp1 XI1397_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1397_MP42 (XI1397_bcon pp11_0 XI1397_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1397_MP45 (XI1397_bp2 B_23_b3_5 XI1397_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1397_MP43 (VDD XI1397_s1 XI1397_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1397_MP44 (XI1397_bp2 pp11_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1397_MP56 (VDD XI1397_bcon cm36_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1397_MP46 (XI1397_bp3 XI1397_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1397_MP48 (VDD B_23_b3_5 XI1397_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1397_MP50_1 (XI1397_bp4 XI1397_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1397_MP26 (VDD XI1397_asn XI1397_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1397_MP18 (XI1397_ap3 pp8_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1397_MP21 (XI1397_asn XI1397_acon XI1397_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1397_MP24 (XI1397_ap5 pp10_2 XI1397_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1397_MP23 (XI1397_ap4 pp9_4 XI1397_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1397_MP22 (VDD pp8_6 XI1397_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1397_MP22_1 (XI1397_ap4 pp8_6 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1397_MP23_1 (XI1397_ap5 pp9_4 XI1397_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1397_MP24_1 (XI1397_asn pp10_2 XI1397_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1397_MP17 (XI1397_acon pp10_2 XI1397_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1397_MP14 (XI1397_ap1 pp9_4 XI1397_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1397_MP13 (VDD pp8_6 XI1397_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1397_MP15 (XI1397_ap2 pp8_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1397_MP16 (VDD pp9_4 XI1397_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1397_MP28 (cm36_2 XI1397_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1397_MP19 (XI1397_ap3 pp9_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1397_MP20 (VDD pp10_2 XI1397_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1395_MP50 (VDD XI1395_s1 XI1395_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1395_MP47 (XI1395_bp3 pp3_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1395_MP49 (XI1395_bsn XI1395_bcon XI1395_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1395_MP52 (XI1395_bp5 cm31_2 XI1395_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1395_MP51 (XI1395_bp4 pp3_16 XI1395_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1395_MP51_1 (XI1395_bp5 pp3_16 XI1395_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1395_MP52_1 (XI1395_bsn cm31_2 XI1395_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1395_MP54 (VDD XI1395_bsn cm34_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1395_MP41 (XI1395_bp1 XI1395_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1395_MP42 (XI1395_bcon pp3_16 XI1395_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1395_MP45 (XI1395_bp2 cm31_2 XI1395_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1395_MP43 (VDD XI1395_s1 XI1395_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1395_MP44 (XI1395_bp2 pp3_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1395_MP56 (VDD XI1395_bcon cm34_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1395_MP46 (XI1395_bp3 XI1395_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1395_MP48 (VDD cm31_2 XI1395_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1395_MP50_1 (XI1395_bp4 XI1395_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1395_MP26 (VDD XI1395_asn XI1395_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1395_MP18 (XI1395_ap3 pp0_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1395_MP21 (XI1395_asn XI1395_acon XI1395_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1395_MP24 (XI1395_ap5 pp2_18 XI1395_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1395_MP23 (XI1395_ap4 pp1_20 XI1395_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1395_MP22 (VDD pp0_22 XI1395_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1395_MP22_1 (XI1395_ap4 pp0_22 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1395_MP23_1 (XI1395_ap5 pp1_20 XI1395_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1395_MP24_1 (XI1395_asn pp2_18 XI1395_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1395_MP17 (XI1395_acon pp2_18 XI1395_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1395_MP14 (XI1395_ap1 pp1_20 XI1395_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1395_MP13 (VDD pp0_22 XI1395_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1395_MP15 (XI1395_ap2 pp0_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1395_MP16 (VDD pp1_20 XI1395_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1395_MP28 (cm34_2 XI1395_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1395_MP19 (XI1395_ap3 pp1_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1395_MP20 (VDD pp2_18 XI1395_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1515_MP50 (VDD XI1515_s1 XI1515_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1515_MP47 (XI1515_bp3 cm37_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1515_MP49 (XI1515_bsn XI1515_bcon XI1515_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1515_MP52 (XI1515_bp5 cm153_2 XI1515_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1515_MP51 (XI1515_bp4 cm37_0 XI1515_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1515_MP51_1 (XI1515_bp5 cm37_0 XI1515_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1515_MP52_1 (XI1515_bsn cm153_2 XI1515_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1515_MP54 (VDD XI1515_bsn cm154_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1515_MP41 (XI1515_bp1 XI1515_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1515_MP42 (XI1515_bcon cm37_0 XI1515_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1515_MP45 (XI1515_bp2 cm153_2 XI1515_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1515_MP43 (VDD XI1515_s1 XI1515_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1515_MP44 (XI1515_bp2 cm37_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1515_MP56 (VDD XI1515_bcon cm154_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1515_MP46 (XI1515_bp3 XI1515_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1515_MP48 (VDD cm153_2 XI1515_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1515_MP50_1 (XI1515_bp4 XI1515_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1515_MP26 (VDD XI1515_asn XI1515_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1515_MP18 (XI1515_ap3 cm34_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1515_MP21 (XI1515_asn XI1515_acon XI1515_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1515_MP24 (XI1515_ap5 cm36_1 XI1515_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1515_MP23 (XI1515_ap4 cm35_1 XI1515_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1515_MP22 (VDD cm34_1 XI1515_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1515_MP22_1 (XI1515_ap4 cm34_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1515_MP23_1 (XI1515_ap5 cm35_1 XI1515_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1515_MP24_1 (XI1515_asn cm36_1 XI1515_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1515_MP17 (XI1515_acon cm36_1 XI1515_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1515_MP14 (XI1515_ap1 cm35_1 XI1515_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1515_MP13 (VDD cm34_1 XI1515_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1515_MP15 (XI1515_ap2 cm34_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1515_MP16 (VDD cm35_1 XI1515_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1515_MP28 (cm154_2 XI1515_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1515_MP19 (XI1515_ap3 cm35_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1515_MP20 (VDD cm36_1 XI1515_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1579_MP50 (VDD XI1579_s1 XI1579_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1579_MP47 (XI1579_bp3 B_25_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1579_MP49 (XI1579_bsn XI1579_bcon XI1579_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1579_MP52 (XI1579_bp5 cm217_2 XI1579_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1579_MP51 (XI1579_bp4 B_25_b3_5 XI1579_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1579_MP51_1 (XI1579_bp5 B_25_b3_5 XI1579_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1579_MP52_1 (XI1579_bsn cm217_2 XI1579_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1579_MP54 (VDD XI1579_bsn cm218_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1579_MP41 (XI1579_bp1 XI1579_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1579_MP42 (XI1579_bcon B_25_b3_5 XI1579_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1579_MP45 (XI1579_bp2 cm217_2 XI1579_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1579_MP43 (VDD XI1579_s1 XI1579_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1579_MP44 (XI1579_bp2 B_25_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1579_MP56 (VDD XI1579_bcon cm218_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1579_MP46 (XI1579_bp3 XI1579_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1579_MP48 (VDD cm217_2 XI1579_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1579_MP50_1 (XI1579_bp4 XI1579_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1579_MP26 (VDD XI1579_asn XI1579_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1579_MP18 (XI1579_ap3 cm154_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1579_MP21 (XI1579_asn XI1579_acon XI1579_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1579_MP24 (XI1579_ap5 fa156_0 XI1579_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1579_MP23 (XI1579_ap4 cm155_0 XI1579_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1579_MP22 (VDD cm154_1 XI1579_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1579_MP22_1 (XI1579_ap4 cm154_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1579_MP23_1 (XI1579_ap5 cm155_0 XI1579_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1579_MP24_1 (XI1579_asn fa156_0 XI1579_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1579_MP17 (XI1579_acon fa156_0 XI1579_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1579_MP14 (XI1579_ap1 cm155_0 XI1579_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1579_MP13 (VDD cm154_1 XI1579_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1579_MP15 (XI1579_ap2 cm154_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1579_MP16 (VDD cm155_0 XI1579_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1579_MP28 (cm218_2 XI1579_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1579_MP19 (XI1579_ap3 cm155_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1579_MP20 (VDD fa156_0 XI1579_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1396_MP50 (VDD XI1396_s1 XI1396_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1396_MP47 (XI1396_bp3 pp7_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1396_MP49 (XI1396_bsn XI1396_bcon XI1396_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1396_MP52 (XI1396_bp5 cm32_2 XI1396_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1396_MP51 (XI1396_bp4 pp7_8 XI1396_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1396_MP51_1 (XI1396_bp5 pp7_8 XI1396_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1396_MP52_1 (XI1396_bsn cm32_2 XI1396_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1396_MP54 (VDD XI1396_bsn cm35_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1396_MP41 (XI1396_bp1 XI1396_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1396_MP42 (XI1396_bcon pp7_8 XI1396_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1396_MP45 (XI1396_bp2 cm32_2 XI1396_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1396_MP43 (VDD XI1396_s1 XI1396_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1396_MP44 (XI1396_bp2 pp7_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1396_MP56 (VDD XI1396_bcon cm35_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1396_MP46 (XI1396_bp3 XI1396_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1396_MP48 (VDD cm32_2 XI1396_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1396_MP50_1 (XI1396_bp4 XI1396_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1396_MP26 (VDD XI1396_asn XI1396_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1396_MP18 (XI1396_ap3 pp4_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1396_MP21 (XI1396_asn XI1396_acon XI1396_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1396_MP24 (XI1396_ap5 pp6_10 XI1396_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1396_MP23 (XI1396_ap4 pp5_12 XI1396_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1396_MP22 (VDD pp4_14 XI1396_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1396_MP22_1 (XI1396_ap4 pp4_14 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1396_MP23_1 (XI1396_ap5 pp5_12 XI1396_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1396_MP24_1 (XI1396_asn pp6_10 XI1396_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1396_MP17 (XI1396_acon pp6_10 XI1396_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1396_MP14 (XI1396_ap1 pp5_12 XI1396_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1396_MP13 (VDD pp4_14 XI1396_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1396_MP15 (XI1396_ap2 pp4_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1396_MP16 (VDD pp5_12 XI1396_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1396_MP28 (cm35_2 XI1396_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1396_MP19 (XI1396_ap3 pp5_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1396_MP20 (VDD pp6_10 XI1396_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1392_MP50 (VDD XI1392_s1 XI1392_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1392_MP47 (XI1392_bp3 pp3_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1392_MP49 (XI1392_bsn XI1392_bcon XI1392_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1392_MP52 (XI1392_bp5 cm28_2 XI1392_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1392_MP51 (XI1392_bp4 pp3_15 XI1392_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1392_MP51_1 (XI1392_bp5 pp3_15 XI1392_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1392_MP52_1 (XI1392_bsn cm28_2 XI1392_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1392_MP54 (VDD XI1392_bsn cm31_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1392_MP41 (XI1392_bp1 XI1392_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1392_MP42 (XI1392_bcon pp3_15 XI1392_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1392_MP45 (XI1392_bp2 cm28_2 XI1392_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1392_MP43 (VDD XI1392_s1 XI1392_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1392_MP44 (XI1392_bp2 pp3_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1392_MP56 (VDD XI1392_bcon cm31_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1392_MP46 (XI1392_bp3 XI1392_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1392_MP48 (VDD cm28_2 XI1392_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1392_MP50_1 (XI1392_bp4 XI1392_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1392_MP26 (VDD XI1392_asn XI1392_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1392_MP18 (XI1392_ap3 pp0_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1392_MP21 (XI1392_asn XI1392_acon XI1392_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1392_MP24 (XI1392_ap5 pp2_17 XI1392_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1392_MP23 (XI1392_ap4 pp1_19 XI1392_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1392_MP22 (VDD pp0_21 XI1392_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1392_MP22_1 (XI1392_ap4 pp0_21 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1392_MP23_1 (XI1392_ap5 pp1_19 XI1392_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1392_MP24_1 (XI1392_asn pp2_17 XI1392_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1392_MP17 (XI1392_acon pp2_17 XI1392_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1392_MP14 (XI1392_ap1 pp1_19 XI1392_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1392_MP13 (VDD pp0_21 XI1392_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1392_MP15 (XI1392_ap2 pp0_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1392_MP16 (VDD pp1_19 XI1392_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1392_MP28 (cm31_2 XI1392_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1392_MP19 (XI1392_ap3 pp1_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1392_MP20 (VDD pp2_17 XI1392_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1514_MP50 (VDD XI1514_s1 XI1514_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1514_MP47 (XI1514_bp3 cm34_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1514_MP49 (XI1514_bsn XI1514_bcon XI1514_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1514_MP52 (XI1514_bp5 cm152_2 XI1514_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1514_MP51 (XI1514_bp4 cm34_0 XI1514_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1514_MP51_1 (XI1514_bp5 cm34_0 XI1514_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1514_MP52_1 (XI1514_bsn cm152_2 XI1514_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1514_MP54 (VDD XI1514_bsn cm153_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1514_MP41 (XI1514_bp1 XI1514_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1514_MP42 (XI1514_bcon cm34_0 XI1514_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1514_MP45 (XI1514_bp2 cm152_2 XI1514_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1514_MP43 (VDD XI1514_s1 XI1514_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1514_MP44 (XI1514_bp2 cm34_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1514_MP56 (VDD XI1514_bcon cm153_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1514_MP46 (XI1514_bp3 XI1514_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1514_MP48 (VDD cm152_2 XI1514_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1514_MP50_1 (XI1514_bp4 XI1514_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1514_MP26 (VDD XI1514_asn XI1514_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1514_MP18 (XI1514_ap3 cm31_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1514_MP21 (XI1514_asn XI1514_acon XI1514_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1514_MP24 (XI1514_ap5 fa33_1 XI1514_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1514_MP23 (XI1514_ap4 cm32_1 XI1514_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1514_MP22 (VDD cm31_1 XI1514_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1514_MP22_1 (XI1514_ap4 cm31_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1514_MP23_1 (XI1514_ap5 cm32_1 XI1514_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1514_MP24_1 (XI1514_asn fa33_1 XI1514_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1514_MP17 (XI1514_acon fa33_1 XI1514_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1514_MP14 (XI1514_ap1 cm32_1 XI1514_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1514_MP13 (VDD cm31_1 XI1514_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1514_MP15 (XI1514_ap2 cm31_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1514_MP16 (VDD cm32_1 XI1514_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1514_MP28 (cm153_2 XI1514_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1514_MP19 (XI1514_ap3 cm32_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1514_MP20 (VDD fa33_1 XI1514_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1578_MP50 (VDD XI1578_s1 XI1578_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1578_MP47 (XI1578_bp3 cm39_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1578_MP49 (XI1578_bsn XI1578_bcon XI1578_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1578_MP52 (XI1578_bp5 cm216_2 XI1578_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1578_MP51 (XI1578_bp4 cm39_0 XI1578_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1578_MP51_1 (XI1578_bp5 cm39_0 XI1578_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1578_MP52_1 (XI1578_bsn cm216_2 XI1578_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1578_MP54 (VDD XI1578_bsn cm217_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1578_MP41 (XI1578_bp1 XI1578_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1578_MP42 (XI1578_bcon cm39_0 XI1578_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1578_MP45 (XI1578_bp2 cm216_2 XI1578_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1578_MP43 (VDD XI1578_s1 XI1578_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1578_MP44 (XI1578_bp2 cm39_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1578_MP56 (VDD XI1578_bcon cm217_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1578_MP46 (XI1578_bp3 XI1578_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1578_MP48 (VDD cm216_2 XI1578_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1578_MP50_1 (XI1578_bp4 XI1578_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1578_MP26 (VDD XI1578_asn XI1578_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1578_MP18 (XI1578_ap3 cm153_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1578_MP21 (XI1578_asn XI1578_acon XI1578_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1578_MP24 (XI1578_ap5 cm38_0 XI1578_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1578_MP23 (XI1578_ap4 cm154_0 XI1578_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1578_MP22 (VDD cm153_1 XI1578_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1578_MP22_1 (XI1578_ap4 cm153_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1578_MP23_1 (XI1578_ap5 cm154_0 XI1578_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1578_MP24_1 (XI1578_asn cm38_0 XI1578_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1578_MP17 (XI1578_acon cm38_0 XI1578_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1578_MP14 (XI1578_ap1 cm154_0 XI1578_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1578_MP13 (VDD cm153_1 XI1578_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1578_MP15 (XI1578_ap2 cm153_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1578_MP16 (VDD cm154_0 XI1578_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1578_MP28 (cm217_2 XI1578_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1578_MP19 (XI1578_ap3 cm154_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1578_MP20 (VDD cm38_0 XI1578_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1393_MP50 (VDD XI1393_s1 XI1393_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1393_MP47 (XI1393_bp3 pp7_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1393_MP49 (XI1393_bsn XI1393_bcon XI1393_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1393_MP52 (XI1393_bp5 cm29_2 XI1393_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1393_MP51 (XI1393_bp4 pp7_7 XI1393_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1393_MP51_1 (XI1393_bp5 pp7_7 XI1393_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1393_MP52_1 (XI1393_bsn cm29_2 XI1393_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1393_MP54 (VDD XI1393_bsn cm32_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1393_MP41 (XI1393_bp1 XI1393_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1393_MP42 (XI1393_bcon pp7_7 XI1393_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1393_MP45 (XI1393_bp2 cm29_2 XI1393_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1393_MP43 (VDD XI1393_s1 XI1393_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1393_MP44 (XI1393_bp2 pp7_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1393_MP56 (VDD XI1393_bcon cm32_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1393_MP46 (XI1393_bp3 XI1393_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1393_MP48 (VDD cm29_2 XI1393_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1393_MP50_1 (XI1393_bp4 XI1393_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1393_MP26 (VDD XI1393_asn XI1393_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1393_MP18 (XI1393_ap3 pp4_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1393_MP21 (XI1393_asn XI1393_acon XI1393_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1393_MP24 (XI1393_ap5 pp6_9 XI1393_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1393_MP23 (XI1393_ap4 pp5_11 XI1393_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1393_MP22 (VDD pp4_13 XI1393_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1393_MP22_1 (XI1393_ap4 pp4_13 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1393_MP23_1 (XI1393_ap5 pp5_11 XI1393_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1393_MP24_1 (XI1393_asn pp6_9 XI1393_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1393_MP17 (XI1393_acon pp6_9 XI1393_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1393_MP14 (XI1393_ap1 pp5_11 XI1393_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1393_MP13 (VDD pp4_13 XI1393_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1393_MP15 (XI1393_ap2 pp4_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1393_MP16 (VDD pp5_11 XI1393_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1393_MP28 (cm32_2 XI1393_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1393_MP19 (XI1393_ap3 pp5_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1393_MP20 (VDD pp6_9 XI1393_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1389_MP50 (VDD XI1389_s1 XI1389_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1389_MP47 (XI1389_bp3 pp3_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1389_MP49 (XI1389_bsn XI1389_bcon XI1389_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1389_MP52 (XI1389_bp5 cm26_2 XI1389_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1389_MP51 (XI1389_bp4 pp3_14 XI1389_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1389_MP51_1 (XI1389_bp5 pp3_14 XI1389_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1389_MP52_1 (XI1389_bsn cm26_2 XI1389_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1389_MP54 (VDD XI1389_bsn cm28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1389_MP41 (XI1389_bp1 XI1389_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1389_MP42 (XI1389_bcon pp3_14 XI1389_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1389_MP45 (XI1389_bp2 cm26_2 XI1389_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1389_MP43 (VDD XI1389_s1 XI1389_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1389_MP44 (XI1389_bp2 pp3_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1389_MP56 (VDD XI1389_bcon cm28_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1389_MP46 (XI1389_bp3 XI1389_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1389_MP48 (VDD cm26_2 XI1389_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1389_MP50_1 (XI1389_bp4 XI1389_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1389_MP26 (VDD XI1389_asn XI1389_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1389_MP18 (XI1389_ap3 pp0_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1389_MP21 (XI1389_asn XI1389_acon XI1389_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1389_MP24 (XI1389_ap5 pp2_16 XI1389_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1389_MP23 (XI1389_ap4 pp1_18 XI1389_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1389_MP22 (VDD pp0_20 XI1389_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1389_MP22_1 (XI1389_ap4 pp0_20 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1389_MP23_1 (XI1389_ap5 pp1_18 XI1389_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1389_MP24_1 (XI1389_asn pp2_16 XI1389_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1389_MP17 (XI1389_acon pp2_16 XI1389_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1389_MP14 (XI1389_ap1 pp1_18 XI1389_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1389_MP13 (VDD pp0_20 XI1389_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1389_MP15 (XI1389_ap2 pp0_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1389_MP16 (VDD pp1_18 XI1389_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1389_MP28 (cm28_2 XI1389_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1389_MP19 (XI1389_ap3 pp1_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1389_MP20 (VDD pp2_16 XI1389_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1577_MP50 (VDD XI1577_s1 XI1577_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1577_MP47 (XI1577_bp3 cm36_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1577_MP49 (XI1577_bsn XI1577_bcon XI1577_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1577_MP52 (XI1577_bp5 cm215_2 XI1577_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1577_MP51 (XI1577_bp4 cm36_0 XI1577_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1577_MP51_1 (XI1577_bp5 cm36_0 XI1577_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1577_MP52_1 (XI1577_bsn cm215_2 XI1577_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1577_MP54 (VDD XI1577_bsn cm216_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1577_MP41 (XI1577_bp1 XI1577_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1577_MP42 (XI1577_bcon cm36_0 XI1577_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1577_MP45 (XI1577_bp2 cm215_2 XI1577_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1577_MP43 (VDD XI1577_s1 XI1577_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1577_MP44 (XI1577_bp2 cm36_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1577_MP56 (VDD XI1577_bcon cm216_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1577_MP46 (XI1577_bp3 XI1577_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1577_MP48 (VDD cm215_2 XI1577_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1577_MP50_1 (XI1577_bp4 XI1577_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1577_MP26 (VDD XI1577_asn XI1577_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1577_MP18 (XI1577_ap3 cm152_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1577_MP21 (XI1577_asn XI1577_acon XI1577_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1577_MP24 (XI1577_ap5 cm35_0 XI1577_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1577_MP23 (XI1577_ap4 cm153_0 XI1577_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1577_MP22 (VDD cm152_1 XI1577_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1577_MP22_1 (XI1577_ap4 cm152_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1577_MP23_1 (XI1577_ap5 cm153_0 XI1577_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1577_MP24_1 (XI1577_asn cm35_0 XI1577_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1577_MP17 (XI1577_acon cm35_0 XI1577_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1577_MP14 (XI1577_ap1 cm153_0 XI1577_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1577_MP13 (VDD cm152_1 XI1577_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1577_MP15 (XI1577_ap2 cm152_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1577_MP16 (VDD cm153_0 XI1577_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1577_MP28 (cm216_2 XI1577_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1577_MP19 (XI1577_ap3 cm153_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1577_MP20 (VDD cm35_0 XI1577_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1513_MP50 (VDD XI1513_s1 XI1513_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1513_MP47 (XI1513_bp3 cm31_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1513_MP49 (XI1513_bsn XI1513_bcon XI1513_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1513_MP52 (XI1513_bp5 cm151_2 XI1513_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1513_MP51 (XI1513_bp4 cm31_0 XI1513_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1513_MP51_1 (XI1513_bp5 cm31_0 XI1513_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1513_MP52_1 (XI1513_bsn cm151_2 XI1513_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1513_MP54 (VDD XI1513_bsn cm152_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1513_MP41 (XI1513_bp1 XI1513_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1513_MP42 (XI1513_bcon cm31_0 XI1513_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1513_MP45 (XI1513_bp2 cm151_2 XI1513_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1513_MP43 (VDD XI1513_s1 XI1513_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1513_MP44 (XI1513_bp2 cm31_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1513_MP56 (VDD XI1513_bcon cm152_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1513_MP46 (XI1513_bp3 XI1513_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1513_MP48 (VDD cm151_2 XI1513_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1513_MP50_1 (XI1513_bp4 XI1513_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1513_MP26 (VDD XI1513_asn XI1513_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1513_MP18 (XI1513_ap3 cm28_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1513_MP21 (XI1513_asn XI1513_acon XI1513_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1513_MP24 (XI1513_ap5 fa30_1 XI1513_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1513_MP23 (XI1513_ap4 cm29_1 XI1513_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1513_MP22 (VDD cm28_1 XI1513_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1513_MP22_1 (XI1513_ap4 cm28_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1513_MP23_1 (XI1513_ap5 cm29_1 XI1513_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1513_MP24_1 (XI1513_asn fa30_1 XI1513_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1513_MP17 (XI1513_acon fa30_1 XI1513_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1513_MP14 (XI1513_ap1 cm29_1 XI1513_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1513_MP13 (VDD cm28_1 XI1513_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1513_MP15 (XI1513_ap2 cm28_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1513_MP16 (VDD cm29_1 XI1513_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1513_MP28 (cm152_2 XI1513_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1513_MP19 (XI1513_ap3 cm29_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1513_MP20 (VDD fa30_1 XI1513_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1390_MP50 (VDD XI1390_s1 XI1390_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1390_MP47 (XI1390_bp3 pp7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1390_MP49 (XI1390_bsn XI1390_bcon XI1390_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1390_MP52 (XI1390_bp5 cm27_2 XI1390_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1390_MP51 (XI1390_bp4 pp7_6 XI1390_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1390_MP51_1 (XI1390_bp5 pp7_6 XI1390_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1390_MP52_1 (XI1390_bsn cm27_2 XI1390_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1390_MP54 (VDD XI1390_bsn cm29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1390_MP41 (XI1390_bp1 XI1390_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1390_MP42 (XI1390_bcon pp7_6 XI1390_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1390_MP45 (XI1390_bp2 cm27_2 XI1390_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1390_MP43 (VDD XI1390_s1 XI1390_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1390_MP44 (XI1390_bp2 pp7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1390_MP56 (VDD XI1390_bcon cm29_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1390_MP46 (XI1390_bp3 XI1390_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1390_MP48 (VDD cm27_2 XI1390_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1390_MP50_1 (XI1390_bp4 XI1390_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1390_MP26 (VDD XI1390_asn XI1390_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1390_MP18 (XI1390_ap3 pp4_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1390_MP21 (XI1390_asn XI1390_acon XI1390_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1390_MP24 (XI1390_ap5 pp6_8 XI1390_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1390_MP23 (XI1390_ap4 pp5_10 XI1390_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1390_MP22 (VDD pp4_12 XI1390_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1390_MP22_1 (XI1390_ap4 pp4_12 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1390_MP23_1 (XI1390_ap5 pp5_10 XI1390_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1390_MP24_1 (XI1390_asn pp6_8 XI1390_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1390_MP17 (XI1390_acon pp6_8 XI1390_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1390_MP14 (XI1390_ap1 pp5_10 XI1390_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1390_MP13 (VDD pp4_12 XI1390_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1390_MP15 (XI1390_ap2 pp4_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1390_MP16 (VDD pp5_10 XI1390_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1390_MP28 (cm29_2 XI1390_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1390_MP19 (XI1390_ap3 pp5_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1390_MP20 (VDD pp6_8 XI1390_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1387_MP50 (VDD XI1387_s1 XI1387_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1387_MP47 (XI1387_bp3 pp3_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1387_MP49 (XI1387_bsn XI1387_bcon XI1387_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1387_MP52 (XI1387_bp5 cm23_2 XI1387_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1387_MP51 (XI1387_bp4 pp3_13 XI1387_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1387_MP51_1 (XI1387_bp5 pp3_13 XI1387_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1387_MP52_1 (XI1387_bsn cm23_2 XI1387_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1387_MP54 (VDD XI1387_bsn cm26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1387_MP41 (XI1387_bp1 XI1387_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1387_MP42 (XI1387_bcon pp3_13 XI1387_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1387_MP45 (XI1387_bp2 cm23_2 XI1387_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1387_MP43 (VDD XI1387_s1 XI1387_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1387_MP44 (XI1387_bp2 pp3_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1387_MP56 (VDD XI1387_bcon cm26_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1387_MP46 (XI1387_bp3 XI1387_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1387_MP48 (VDD cm23_2 XI1387_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1387_MP50_1 (XI1387_bp4 XI1387_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1387_MP26 (VDD XI1387_asn XI1387_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1387_MP18 (XI1387_ap3 pp0_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1387_MP21 (XI1387_asn XI1387_acon XI1387_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1387_MP24 (XI1387_ap5 pp2_15 XI1387_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1387_MP23 (XI1387_ap4 pp1_17 XI1387_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1387_MP22 (VDD pp0_19 XI1387_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1387_MP22_1 (XI1387_ap4 pp0_19 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1387_MP23_1 (XI1387_ap5 pp1_17 XI1387_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1387_MP24_1 (XI1387_asn pp2_15 XI1387_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1387_MP17 (XI1387_acon pp2_15 XI1387_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1387_MP14 (XI1387_ap1 pp1_17 XI1387_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1387_MP13 (VDD pp0_19 XI1387_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1387_MP15 (XI1387_ap2 pp0_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1387_MP16 (VDD pp1_17 XI1387_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1387_MP28 (cm26_2 XI1387_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1387_MP19 (XI1387_ap3 pp1_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1387_MP20 (VDD pp2_15 XI1387_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1384_MP50 (VDD XI1384_s1 XI1384_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1384_MP47 (XI1384_bp3 pp3_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1384_MP49 (XI1384_bsn XI1384_bcon XI1384_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1384_MP52 (XI1384_bp5 cm21_2 XI1384_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1384_MP51 (XI1384_bp4 pp3_12 XI1384_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1384_MP51_1 (XI1384_bp5 pp3_12 XI1384_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1384_MP52_1 (XI1384_bsn cm21_2 XI1384_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1384_MP54 (VDD XI1384_bsn cm23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1384_MP41 (XI1384_bp1 XI1384_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1384_MP42 (XI1384_bcon pp3_12 XI1384_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1384_MP45 (XI1384_bp2 cm21_2 XI1384_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1384_MP43 (VDD XI1384_s1 XI1384_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1384_MP44 (XI1384_bp2 pp3_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1384_MP56 (VDD XI1384_bcon cm23_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1384_MP46 (XI1384_bp3 XI1384_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1384_MP48 (VDD cm21_2 XI1384_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1384_MP50_1 (XI1384_bp4 XI1384_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1384_MP26 (VDD XI1384_asn XI1384_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1384_MP18 (XI1384_ap3 pp0_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1384_MP21 (XI1384_asn XI1384_acon XI1384_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1384_MP24 (XI1384_ap5 pp2_14 XI1384_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1384_MP23 (XI1384_ap4 pp1_16 XI1384_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1384_MP22 (VDD pp0_18 XI1384_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1384_MP22_1 (XI1384_ap4 pp0_18 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1384_MP23_1 (XI1384_ap5 pp1_16 XI1384_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1384_MP24_1 (XI1384_asn pp2_14 XI1384_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1384_MP17 (XI1384_acon pp2_14 XI1384_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1384_MP14 (XI1384_ap1 pp1_16 XI1384_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1384_MP13 (VDD pp0_18 XI1384_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1384_MP15 (XI1384_ap2 pp0_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1384_MP16 (VDD pp1_16 XI1384_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1384_MP28 (cm23_2 XI1384_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1384_MP19 (XI1384_ap3 pp1_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1384_MP20 (VDD pp2_14 XI1384_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1512_MP50 (VDD XI1512_s1 XI1512_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1512_MP47 (XI1512_bp3 cm29_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1512_MP49 (XI1512_bsn XI1512_bcon XI1512_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1512_MP52 (XI1512_bp5 cm149_2 XI1512_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1512_MP51 (XI1512_bp4 cm29_0 XI1512_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1512_MP51_1 (XI1512_bp5 cm29_0 XI1512_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1512_MP52_1 (XI1512_bsn cm149_2 XI1512_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1512_MP54 (VDD XI1512_bsn cm151_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1512_MP41 (XI1512_bp1 XI1512_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1512_MP42 (XI1512_bcon cm29_0 XI1512_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1512_MP45 (XI1512_bp2 cm149_2 XI1512_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1512_MP43 (VDD XI1512_s1 XI1512_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1512_MP44 (XI1512_bp2 cm29_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1512_MP56 (VDD XI1512_bcon cm151_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1512_MP46 (XI1512_bp3 XI1512_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1512_MP48 (VDD cm149_2 XI1512_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1512_MP50_1 (XI1512_bp4 XI1512_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1512_MP26 (VDD XI1512_asn XI1512_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1512_MP18 (XI1512_ap3 cm26_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1512_MP21 (XI1512_asn XI1512_acon XI1512_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1512_MP24 (XI1512_ap5 cm28_0 XI1512_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1512_MP23 (XI1512_ap4 cm27_1 XI1512_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1512_MP22 (VDD cm26_1 XI1512_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1512_MP22_1 (XI1512_ap4 cm26_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1512_MP23_1 (XI1512_ap5 cm27_1 XI1512_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1512_MP24_1 (XI1512_asn cm28_0 XI1512_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1512_MP17 (XI1512_acon cm28_0 XI1512_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1512_MP14 (XI1512_ap1 cm27_1 XI1512_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1512_MP13 (VDD cm26_1 XI1512_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1512_MP15 (XI1512_ap2 cm26_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1512_MP16 (VDD cm27_1 XI1512_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1512_MP28 (cm151_2 XI1512_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1512_MP19 (XI1512_ap3 cm27_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1512_MP20 (VDD cm28_0 XI1512_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1576_MP50 (VDD XI1576_s1 XI1576_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1576_MP47 (XI1576_bp3 fa33_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1576_MP49 (XI1576_bsn XI1576_bcon XI1576_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1576_MP52 (XI1576_bp5 cm214_2 XI1576_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1576_MP51 (XI1576_bp4 fa33_0 XI1576_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1576_MP51_1 (XI1576_bp5 fa33_0 XI1576_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1576_MP52_1 (XI1576_bsn cm214_2 XI1576_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1576_MP54 (VDD XI1576_bsn cm215_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1576_MP41 (XI1576_bp1 XI1576_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1576_MP42 (XI1576_bcon fa33_0 XI1576_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1576_MP45 (XI1576_bp2 cm214_2 XI1576_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1576_MP43 (VDD XI1576_s1 XI1576_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1576_MP44 (XI1576_bp2 fa33_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1576_MP56 (VDD XI1576_bcon cm215_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1576_MP46 (XI1576_bp3 XI1576_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1576_MP48 (VDD cm214_2 XI1576_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1576_MP50_1 (XI1576_bp4 XI1576_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1576_MP26 (VDD XI1576_asn XI1576_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1576_MP18 (XI1576_ap3 cm151_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1576_MP21 (XI1576_asn XI1576_acon XI1576_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1576_MP24 (XI1576_ap5 cm32_0 XI1576_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1576_MP23 (XI1576_ap4 cm152_0 XI1576_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1576_MP22 (VDD cm151_1 XI1576_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1576_MP22_1 (XI1576_ap4 cm151_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1576_MP23_1 (XI1576_ap5 cm152_0 XI1576_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1576_MP24_1 (XI1576_asn cm32_0 XI1576_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1576_MP17 (XI1576_acon cm32_0 XI1576_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1576_MP14 (XI1576_ap1 cm152_0 XI1576_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1576_MP13 (VDD cm151_1 XI1576_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1576_MP15 (XI1576_ap2 cm151_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1576_MP16 (VDD cm152_0 XI1576_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1576_MP28 (cm215_2 XI1576_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1576_MP19 (XI1576_ap3 cm152_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1576_MP20 (VDD cm32_0 XI1576_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1575_MP50 (VDD XI1575_s1 XI1575_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1575_MP47 (XI1575_bp3 fa30_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1575_MP49 (XI1575_bsn XI1575_bcon XI1575_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1575_MP52 (XI1575_bp5 B_21_b3_5 XI1575_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1575_MP51 (XI1575_bp4 fa30_0 XI1575_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1575_MP51_1 (XI1575_bp5 fa30_0 XI1575_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1575_MP52_1 (XI1575_bsn B_21_b3_5 XI1575_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1575_MP54 (VDD XI1575_bsn cm214_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1575_MP41 (XI1575_bp1 XI1575_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1575_MP42 (XI1575_bcon fa30_0 XI1575_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1575_MP45 (XI1575_bp2 B_21_b3_5 XI1575_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1575_MP43 (VDD XI1575_s1 XI1575_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1575_MP44 (XI1575_bp2 fa30_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1575_MP56 (VDD XI1575_bcon cm214_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1575_MP46 (XI1575_bp3 XI1575_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1575_MP48 (VDD B_21_b3_5 XI1575_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1575_MP50_1 (XI1575_bp4 XI1575_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1575_MP26 (VDD XI1575_asn XI1575_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1575_MP18 (XI1575_ap3 cm149_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1575_MP21 (XI1575_asn XI1575_acon XI1575_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1575_MP24 (XI1575_ap5 cm151_0 XI1575_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1575_MP23 (XI1575_ap4 fa150_1 XI1575_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1575_MP22 (VDD cm149_1 XI1575_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1575_MP22_1 (XI1575_ap4 cm149_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1575_MP23_1 (XI1575_ap5 fa150_1 XI1575_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1575_MP24_1 (XI1575_asn cm151_0 XI1575_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1575_MP17 (XI1575_acon cm151_0 XI1575_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1575_MP14 (XI1575_ap1 fa150_1 XI1575_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1575_MP13 (VDD cm149_1 XI1575_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1575_MP15 (XI1575_ap2 cm149_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1575_MP16 (VDD fa150_1 XI1575_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1575_MP28 (cm214_2 XI1575_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1575_MP19 (XI1575_ap3 fa150_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1575_MP20 (VDD cm151_0 XI1575_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1388_MP50 (VDD XI1388_s1 XI1388_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1388_MP47 (XI1388_bp3 pp7_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1388_MP49 (XI1388_bsn XI1388_bcon XI1388_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1388_MP52 (XI1388_bp5 cm24_2 XI1388_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1388_MP51 (XI1388_bp4 pp7_5 XI1388_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1388_MP51_1 (XI1388_bp5 pp7_5 XI1388_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1388_MP52_1 (XI1388_bsn cm24_2 XI1388_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1388_MP54 (VDD XI1388_bsn cm27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1388_MP41 (XI1388_bp1 XI1388_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1388_MP42 (XI1388_bcon pp7_5 XI1388_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1388_MP45 (XI1388_bp2 cm24_2 XI1388_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1388_MP43 (VDD XI1388_s1 XI1388_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1388_MP44 (XI1388_bp2 pp7_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1388_MP56 (VDD XI1388_bcon cm27_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1388_MP46 (XI1388_bp3 XI1388_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1388_MP48 (VDD cm24_2 XI1388_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1388_MP50_1 (XI1388_bp4 XI1388_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1388_MP26 (VDD XI1388_asn XI1388_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1388_MP18 (XI1388_ap3 pp4_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1388_MP21 (XI1388_asn XI1388_acon XI1388_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1388_MP24 (XI1388_ap5 pp6_7 XI1388_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1388_MP23 (XI1388_ap4 pp5_9 XI1388_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1388_MP22 (VDD pp4_11 XI1388_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1388_MP22_1 (XI1388_ap4 pp4_11 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1388_MP23_1 (XI1388_ap5 pp5_9 XI1388_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1388_MP24_1 (XI1388_asn pp6_7 XI1388_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1388_MP17 (XI1388_acon pp6_7 XI1388_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1388_MP14 (XI1388_ap1 pp5_9 XI1388_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1388_MP13 (VDD pp4_11 XI1388_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1388_MP15 (XI1388_ap2 pp4_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1388_MP16 (VDD pp5_9 XI1388_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1388_MP28 (cm27_2 XI1388_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1388_MP19 (XI1388_ap3 pp5_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1388_MP20 (VDD pp6_7 XI1388_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1382_MP50 (VDD XI1382_s1 XI1382_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1382_MP47 (XI1382_bp3 pp3_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1382_MP49 (XI1382_bsn XI1382_bcon XI1382_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1382_MP52 (XI1382_bp5 cm19_2 XI1382_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1382_MP51 (XI1382_bp4 pp3_11 XI1382_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1382_MP51_1 (XI1382_bp5 pp3_11 XI1382_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1382_MP52_1 (XI1382_bsn cm19_2 XI1382_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1382_MP54 (VDD XI1382_bsn cm21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1382_MP41 (XI1382_bp1 XI1382_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1382_MP42 (XI1382_bcon pp3_11 XI1382_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1382_MP45 (XI1382_bp2 cm19_2 XI1382_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1382_MP43 (VDD XI1382_s1 XI1382_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1382_MP44 (XI1382_bp2 pp3_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1382_MP56 (VDD XI1382_bcon cm21_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1382_MP46 (XI1382_bp3 XI1382_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1382_MP48 (VDD cm19_2 XI1382_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1382_MP50_1 (XI1382_bp4 XI1382_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1382_MP26 (VDD XI1382_asn XI1382_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1382_MP18 (XI1382_ap3 pp0_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1382_MP21 (XI1382_asn XI1382_acon XI1382_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1382_MP24 (XI1382_ap5 pp2_13 XI1382_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1382_MP23 (XI1382_ap4 pp1_15 XI1382_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1382_MP22 (VDD pp0_17 XI1382_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1382_MP22_1 (XI1382_ap4 pp0_17 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1382_MP23_1 (XI1382_ap5 pp1_15 XI1382_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1382_MP24_1 (XI1382_asn pp2_13 XI1382_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1382_MP17 (XI1382_acon pp2_13 XI1382_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1382_MP14 (XI1382_ap1 pp1_15 XI1382_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1382_MP13 (VDD pp0_17 XI1382_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1382_MP15 (XI1382_ap2 pp0_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1382_MP16 (VDD pp1_15 XI1382_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1382_MP28 (cm21_2 XI1382_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1382_MP19 (XI1382_ap3 pp1_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1382_MP20 (VDD pp2_13 XI1382_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1510_MP50 (VDD XI1510_s1 XI1510_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1510_MP47 (XI1510_bp3 cm26_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1510_MP49 (XI1510_bsn XI1510_bcon XI1510_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1510_MP52 (XI1510_bp5 cm148_2 XI1510_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1510_MP51 (XI1510_bp4 cm26_0 XI1510_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1510_MP51_1 (XI1510_bp5 cm26_0 XI1510_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1510_MP52_1 (XI1510_bsn cm148_2 XI1510_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1510_MP54 (VDD XI1510_bsn cm149_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1510_MP41 (XI1510_bp1 XI1510_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1510_MP42 (XI1510_bcon cm26_0 XI1510_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1510_MP45 (XI1510_bp2 cm148_2 XI1510_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1510_MP43 (VDD XI1510_s1 XI1510_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1510_MP44 (XI1510_bp2 cm26_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1510_MP56 (VDD XI1510_bcon cm149_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1510_MP46 (XI1510_bp3 XI1510_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1510_MP48 (VDD cm148_2 XI1510_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1510_MP50_1 (XI1510_bp4 XI1510_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1510_MP26 (VDD XI1510_asn XI1510_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1510_MP18 (XI1510_ap3 cm23_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1510_MP21 (XI1510_asn XI1510_acon XI1510_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1510_MP24 (XI1510_ap5 fa25_1 XI1510_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1510_MP23 (XI1510_ap4 cm24_1 XI1510_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1510_MP22 (VDD cm23_1 XI1510_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1510_MP22_1 (XI1510_ap4 cm23_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1510_MP23_1 (XI1510_ap5 cm24_1 XI1510_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1510_MP24_1 (XI1510_asn fa25_1 XI1510_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1510_MP17 (XI1510_acon fa25_1 XI1510_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1510_MP14 (XI1510_ap1 cm24_1 XI1510_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1510_MP13 (VDD cm23_1 XI1510_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1510_MP15 (XI1510_ap2 cm23_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1510_MP16 (VDD cm24_1 XI1510_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1510_MP28 (cm149_2 XI1510_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1510_MP19 (XI1510_ap3 cm24_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1510_MP20 (VDD fa25_1 XI1510_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1385_MP50 (VDD XI1385_s1 XI1385_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1385_MP47 (XI1385_bp3 pp7_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1385_MP49 (XI1385_bsn XI1385_bcon XI1385_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1385_MP52 (XI1385_bp5 cm22_2 XI1385_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1385_MP51 (XI1385_bp4 pp7_4 XI1385_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1385_MP51_1 (XI1385_bp5 pp7_4 XI1385_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1385_MP52_1 (XI1385_bsn cm22_2 XI1385_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1385_MP54 (VDD XI1385_bsn cm24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1385_MP41 (XI1385_bp1 XI1385_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1385_MP42 (XI1385_bcon pp7_4 XI1385_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1385_MP45 (XI1385_bp2 cm22_2 XI1385_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1385_MP43 (VDD XI1385_s1 XI1385_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1385_MP44 (XI1385_bp2 pp7_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1385_MP56 (VDD XI1385_bcon cm24_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1385_MP46 (XI1385_bp3 XI1385_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1385_MP48 (VDD cm22_2 XI1385_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1385_MP50_1 (XI1385_bp4 XI1385_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1385_MP26 (VDD XI1385_asn XI1385_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1385_MP18 (XI1385_ap3 pp4_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1385_MP21 (XI1385_asn XI1385_acon XI1385_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1385_MP24 (XI1385_ap5 pp6_6 XI1385_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1385_MP23 (XI1385_ap4 pp5_8 XI1385_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1385_MP22 (VDD pp4_10 XI1385_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1385_MP22_1 (XI1385_ap4 pp4_10 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1385_MP23_1 (XI1385_ap5 pp5_8 XI1385_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1385_MP24_1 (XI1385_asn pp6_6 XI1385_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1385_MP17 (XI1385_acon pp6_6 XI1385_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1385_MP14 (XI1385_ap1 pp5_8 XI1385_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1385_MP13 (VDD pp4_10 XI1385_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1385_MP15 (XI1385_ap2 pp4_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1385_MP16 (VDD pp5_8 XI1385_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1385_MP28 (cm24_2 XI1385_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1385_MP19 (XI1385_ap3 pp5_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1385_MP20 (VDD pp6_6 XI1385_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1509_MP50 (VDD XI1509_s1 XI1509_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1509_MP47 (XI1509_bp3 cm24_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1509_MP49 (XI1509_bsn XI1509_bcon XI1509_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1509_MP52 (XI1509_bp5 cm147_2 XI1509_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1509_MP51 (XI1509_bp4 cm24_0 XI1509_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1509_MP51_1 (XI1509_bp5 cm24_0 XI1509_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1509_MP52_1 (XI1509_bsn cm147_2 XI1509_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1509_MP54 (VDD XI1509_bsn cm148_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1509_MP41 (XI1509_bp1 XI1509_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1509_MP42 (XI1509_bcon cm24_0 XI1509_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1509_MP45 (XI1509_bp2 cm147_2 XI1509_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1509_MP43 (VDD XI1509_s1 XI1509_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1509_MP44 (XI1509_bp2 cm24_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1509_MP56 (VDD XI1509_bcon cm148_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1509_MP46 (XI1509_bp3 XI1509_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1509_MP48 (VDD cm147_2 XI1509_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1509_MP50_1 (XI1509_bp4 XI1509_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1509_MP26 (VDD XI1509_asn XI1509_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1509_MP18 (XI1509_ap3 cm21_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1509_MP21 (XI1509_asn XI1509_acon XI1509_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1509_MP24 (XI1509_ap5 cm23_0 XI1509_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1509_MP23 (XI1509_ap4 cm22_1 XI1509_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1509_MP22 (VDD cm21_1 XI1509_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1509_MP22_1 (XI1509_ap4 cm21_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1509_MP23_1 (XI1509_ap5 cm22_1 XI1509_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1509_MP24_1 (XI1509_asn cm23_0 XI1509_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1509_MP17 (XI1509_acon cm23_0 XI1509_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1509_MP14 (XI1509_ap1 cm22_1 XI1509_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1509_MP13 (VDD cm21_1 XI1509_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1509_MP15 (XI1509_ap2 cm21_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1509_MP16 (VDD cm22_1 XI1509_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1509_MP28 (cm148_2 XI1509_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1509_MP19 (XI1509_ap3 cm22_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1509_MP20 (VDD cm23_0 XI1509_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1383_MP50 (VDD XI1383_s1 XI1383_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1383_MP47 (XI1383_bp3 pp7_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1383_MP49 (XI1383_bsn XI1383_bcon XI1383_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1383_MP52 (XI1383_bp5 cm20_2 XI1383_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1383_MP51 (XI1383_bp4 pp7_3 XI1383_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1383_MP51_1 (XI1383_bp5 pp7_3 XI1383_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1383_MP52_1 (XI1383_bsn cm20_2 XI1383_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1383_MP54 (VDD XI1383_bsn cm22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1383_MP41 (XI1383_bp1 XI1383_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1383_MP42 (XI1383_bcon pp7_3 XI1383_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1383_MP45 (XI1383_bp2 cm20_2 XI1383_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1383_MP43 (VDD XI1383_s1 XI1383_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1383_MP44 (XI1383_bp2 pp7_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1383_MP56 (VDD XI1383_bcon cm22_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1383_MP46 (XI1383_bp3 XI1383_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1383_MP48 (VDD cm20_2 XI1383_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1383_MP50_1 (XI1383_bp4 XI1383_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1383_MP26 (VDD XI1383_asn XI1383_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1383_MP18 (XI1383_ap3 pp4_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1383_MP21 (XI1383_asn XI1383_acon XI1383_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1383_MP24 (XI1383_ap5 pp6_5 XI1383_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1383_MP23 (XI1383_ap4 pp5_7 XI1383_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1383_MP22 (VDD pp4_9 XI1383_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1383_MP22_1 (XI1383_ap4 pp4_9 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1383_MP23_1 (XI1383_ap5 pp5_7 XI1383_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1383_MP24_1 (XI1383_asn pp6_5 XI1383_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1383_MP17 (XI1383_acon pp6_5 XI1383_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1383_MP14 (XI1383_ap1 pp5_7 XI1383_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1383_MP13 (VDD pp4_9 XI1383_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1383_MP15 (XI1383_ap2 pp4_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1383_MP16 (VDD pp5_7 XI1383_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1383_MP28 (cm22_2 XI1383_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1383_MP19 (XI1383_ap3 pp5_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1383_MP20 (VDD pp6_5 XI1383_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1508_MP50 (VDD XI1508_s1 XI1508_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1508_MP47 (XI1508_bp3 cm22_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1508_MP49 (XI1508_bsn XI1508_bcon XI1508_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1508_MP52 (XI1508_bp5 cm146_2 XI1508_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1508_MP51 (XI1508_bp4 cm22_0 XI1508_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1508_MP51_1 (XI1508_bp5 cm22_0 XI1508_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1508_MP52_1 (XI1508_bsn cm146_2 XI1508_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1508_MP54 (VDD XI1508_bsn cm147_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1508_MP41 (XI1508_bp1 XI1508_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1508_MP42 (XI1508_bcon cm22_0 XI1508_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1508_MP45 (XI1508_bp2 cm146_2 XI1508_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1508_MP43 (VDD XI1508_s1 XI1508_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1508_MP44 (XI1508_bp2 cm22_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1508_MP56 (VDD XI1508_bcon cm147_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1508_MP46 (XI1508_bp3 XI1508_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1508_MP48 (VDD cm146_2 XI1508_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1508_MP50_1 (XI1508_bp4 XI1508_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1508_MP26 (VDD XI1508_asn XI1508_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1508_MP18 (XI1508_ap3 cm19_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1508_MP21 (XI1508_asn XI1508_acon XI1508_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1508_MP24 (XI1508_ap5 cm21_0 XI1508_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1508_MP23 (XI1508_ap4 cm20_1 XI1508_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1508_MP22 (VDD cm19_1 XI1508_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1508_MP22_1 (XI1508_ap4 cm19_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1508_MP23_1 (XI1508_ap5 cm20_1 XI1508_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1508_MP24_1 (XI1508_asn cm21_0 XI1508_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1508_MP17 (XI1508_acon cm21_0 XI1508_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1508_MP14 (XI1508_ap1 cm20_1 XI1508_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1508_MP13 (VDD cm19_1 XI1508_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1508_MP15 (XI1508_ap2 cm19_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1508_MP16 (VDD cm20_1 XI1508_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1508_MP28 (cm147_2 XI1508_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1508_MP19 (XI1508_ap3 cm20_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1508_MP20 (VDD cm21_0 XI1508_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1380_MP50 (VDD XI1380_s1 XI1380_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1380_MP47 (XI1380_bp3 pp3_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1380_MP49 (XI1380_bsn XI1380_bcon XI1380_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1380_MP52 (XI1380_bp5 cm17_2 XI1380_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1380_MP51 (XI1380_bp4 pp3_10 XI1380_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1380_MP51_1 (XI1380_bp5 pp3_10 XI1380_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1380_MP52_1 (XI1380_bsn cm17_2 XI1380_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1380_MP54 (VDD XI1380_bsn cm19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1380_MP41 (XI1380_bp1 XI1380_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1380_MP42 (XI1380_bcon pp3_10 XI1380_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1380_MP45 (XI1380_bp2 cm17_2 XI1380_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1380_MP43 (VDD XI1380_s1 XI1380_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1380_MP44 (XI1380_bp2 pp3_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1380_MP56 (VDD XI1380_bcon cm19_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1380_MP46 (XI1380_bp3 XI1380_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1380_MP48 (VDD cm17_2 XI1380_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1380_MP50_1 (XI1380_bp4 XI1380_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1380_MP26 (VDD XI1380_asn XI1380_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1380_MP18 (XI1380_ap3 pp0_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1380_MP21 (XI1380_asn XI1380_acon XI1380_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1380_MP24 (XI1380_ap5 pp2_12 XI1380_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1380_MP23 (XI1380_ap4 pp1_14 XI1380_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1380_MP22 (VDD pp0_16 XI1380_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1380_MP22_1 (XI1380_ap4 pp0_16 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1380_MP23_1 (XI1380_ap5 pp1_14 XI1380_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1380_MP24_1 (XI1380_asn pp2_12 XI1380_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1380_MP17 (XI1380_acon pp2_12 XI1380_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1380_MP14 (XI1380_ap1 pp1_14 XI1380_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1380_MP13 (VDD pp0_16 XI1380_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1380_MP15 (XI1380_ap2 pp0_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1380_MP16 (VDD pp1_14 XI1380_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1380_MP28 (cm19_2 XI1380_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1380_MP19 (XI1380_ap3 pp1_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1380_MP20 (VDD pp2_12 XI1380_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1381_MP50 (VDD XI1381_s1 XI1381_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1381_MP47 (XI1381_bp3 pp7_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1381_MP49 (XI1381_bsn XI1381_bcon XI1381_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1381_MP52 (XI1381_bp5 cm18_2 XI1381_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1381_MP51 (XI1381_bp4 pp7_2 XI1381_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1381_MP51_1 (XI1381_bp5 pp7_2 XI1381_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1381_MP52_1 (XI1381_bsn cm18_2 XI1381_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1381_MP54 (VDD XI1381_bsn cm20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1381_MP41 (XI1381_bp1 XI1381_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1381_MP42 (XI1381_bcon pp7_2 XI1381_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1381_MP45 (XI1381_bp2 cm18_2 XI1381_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1381_MP43 (VDD XI1381_s1 XI1381_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1381_MP44 (XI1381_bp2 pp7_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1381_MP56 (VDD XI1381_bcon cm20_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1381_MP46 (XI1381_bp3 XI1381_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1381_MP48 (VDD cm18_2 XI1381_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1381_MP50_1 (XI1381_bp4 XI1381_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1381_MP26 (VDD XI1381_asn XI1381_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1381_MP18 (XI1381_ap3 pp4_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1381_MP21 (XI1381_asn XI1381_acon XI1381_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1381_MP24 (XI1381_ap5 pp6_4 XI1381_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1381_MP23 (XI1381_ap4 pp5_6 XI1381_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1381_MP22 (VDD pp4_8 XI1381_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1381_MP22_1 (XI1381_ap4 pp4_8 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1381_MP23_1 (XI1381_ap5 pp5_6 XI1381_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1381_MP24_1 (XI1381_asn pp6_4 XI1381_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1381_MP17 (XI1381_acon pp6_4 XI1381_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1381_MP14 (XI1381_ap1 pp5_6 XI1381_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1381_MP13 (VDD pp4_8 XI1381_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1381_MP15 (XI1381_ap2 pp4_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1381_MP16 (VDD pp5_6 XI1381_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1381_MP28 (cm20_2 XI1381_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1381_MP19 (XI1381_ap3 pp5_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1381_MP20 (VDD pp6_4 XI1381_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1507_MP50 (VDD XI1507_s1 XI1507_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1507_MP47 (XI1507_bp3 cm20_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1507_MP49 (XI1507_bsn XI1507_bcon XI1507_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1507_MP52 (XI1507_bp5 cm145_2 XI1507_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1507_MP51 (XI1507_bp4 cm20_0 XI1507_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1507_MP51_1 (XI1507_bp5 cm20_0 XI1507_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1507_MP52_1 (XI1507_bsn cm145_2 XI1507_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1507_MP54 (VDD XI1507_bsn cm146_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1507_MP41 (XI1507_bp1 XI1507_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1507_MP42 (XI1507_bcon cm20_0 XI1507_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1507_MP45 (XI1507_bp2 cm145_2 XI1507_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1507_MP43 (VDD XI1507_s1 XI1507_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1507_MP44 (XI1507_bp2 cm20_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1507_MP56 (VDD XI1507_bcon cm146_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1507_MP46 (XI1507_bp3 XI1507_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1507_MP48 (VDD cm145_2 XI1507_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1507_MP50_1 (XI1507_bp4 XI1507_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1507_MP26 (VDD XI1507_asn XI1507_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1507_MP18 (XI1507_ap3 cm17_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1507_MP21 (XI1507_asn XI1507_acon XI1507_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1507_MP24 (XI1507_ap5 cm19_0 XI1507_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1507_MP23 (XI1507_ap4 cm18_1 XI1507_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1507_MP22 (VDD cm17_1 XI1507_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1507_MP22_1 (XI1507_ap4 cm17_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1507_MP23_1 (XI1507_ap5 cm18_1 XI1507_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1507_MP24_1 (XI1507_asn cm19_0 XI1507_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1507_MP17 (XI1507_acon cm19_0 XI1507_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1507_MP14 (XI1507_ap1 cm18_1 XI1507_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1507_MP13 (VDD cm17_1 XI1507_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1507_MP15 (XI1507_ap2 cm17_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1507_MP16 (VDD cm18_1 XI1507_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1507_MP28 (cm146_2 XI1507_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1507_MP19 (XI1507_ap3 cm18_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1507_MP20 (VDD cm19_0 XI1507_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1378_MP50 (VDD XI1378_s1 XI1378_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1378_MP47 (XI1378_bp3 pp3_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1378_MP49 (XI1378_bsn XI1378_bcon XI1378_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1378_MP52 (XI1378_bp5 cm15_2 XI1378_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1378_MP51 (XI1378_bp4 pp3_9 XI1378_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1378_MP51_1 (XI1378_bp5 pp3_9 XI1378_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1378_MP52_1 (XI1378_bsn cm15_2 XI1378_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1378_MP54 (VDD XI1378_bsn cm17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1378_MP41 (XI1378_bp1 XI1378_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1378_MP42 (XI1378_bcon pp3_9 XI1378_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1378_MP45 (XI1378_bp2 cm15_2 XI1378_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1378_MP43 (VDD XI1378_s1 XI1378_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1378_MP44 (XI1378_bp2 pp3_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1378_MP56 (VDD XI1378_bcon cm17_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1378_MP46 (XI1378_bp3 XI1378_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1378_MP48 (VDD cm15_2 XI1378_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1378_MP50_1 (XI1378_bp4 XI1378_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1378_MP26 (VDD XI1378_asn XI1378_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1378_MP18 (XI1378_ap3 pp0_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1378_MP21 (XI1378_asn XI1378_acon XI1378_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1378_MP24 (XI1378_ap5 pp2_11 XI1378_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1378_MP23 (XI1378_ap4 pp1_13 XI1378_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1378_MP22 (VDD pp0_15 XI1378_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1378_MP22_1 (XI1378_ap4 pp0_15 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1378_MP23_1 (XI1378_ap5 pp1_13 XI1378_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1378_MP24_1 (XI1378_asn pp2_11 XI1378_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1378_MP17 (XI1378_acon pp2_11 XI1378_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1378_MP14 (XI1378_ap1 pp1_13 XI1378_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1378_MP13 (VDD pp0_15 XI1378_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1378_MP15 (XI1378_ap2 pp0_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1378_MP16 (VDD pp1_13 XI1378_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1378_MP28 (cm17_2 XI1378_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1378_MP19 (XI1378_ap3 pp1_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1378_MP20 (VDD pp2_11 XI1378_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1379_MP50 (VDD XI1379_s1 XI1379_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1379_MP47 (XI1379_bp3 pp7_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1379_MP49 (XI1379_bsn XI1379_bcon XI1379_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1379_MP52 (XI1379_bp5 cm16_2 XI1379_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1379_MP51 (XI1379_bp4 pp7_1 XI1379_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1379_MP51_1 (XI1379_bp5 pp7_1 XI1379_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1379_MP52_1 (XI1379_bsn cm16_2 XI1379_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1379_MP54 (VDD XI1379_bsn cm18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1379_MP41 (XI1379_bp1 XI1379_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1379_MP42 (XI1379_bcon pp7_1 XI1379_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1379_MP45 (XI1379_bp2 cm16_2 XI1379_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1379_MP43 (VDD XI1379_s1 XI1379_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1379_MP44 (XI1379_bp2 pp7_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1379_MP56 (VDD XI1379_bcon cm18_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1379_MP46 (XI1379_bp3 XI1379_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1379_MP48 (VDD cm16_2 XI1379_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1379_MP50_1 (XI1379_bp4 XI1379_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1379_MP26 (VDD XI1379_asn XI1379_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1379_MP18 (XI1379_ap3 pp4_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1379_MP21 (XI1379_asn XI1379_acon XI1379_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1379_MP24 (XI1379_ap5 pp6_3 XI1379_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1379_MP23 (XI1379_ap4 pp5_5 XI1379_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1379_MP22 (VDD pp4_7 XI1379_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1379_MP22_1 (XI1379_ap4 pp4_7 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1379_MP23_1 (XI1379_ap5 pp5_5 XI1379_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1379_MP24_1 (XI1379_asn pp6_3 XI1379_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1379_MP17 (XI1379_acon pp6_3 XI1379_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1379_MP14 (XI1379_ap1 pp5_5 XI1379_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1379_MP13 (VDD pp4_7 XI1379_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1379_MP15 (XI1379_ap2 pp4_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1379_MP16 (VDD pp5_5 XI1379_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1379_MP28 (cm18_2 XI1379_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1379_MP19 (XI1379_ap3 pp5_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1379_MP20 (VDD pp6_3 XI1379_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1506_MP50 (VDD XI1506_s1 XI1506_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1506_MP47 (XI1506_bp3 cm18_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1506_MP49 (XI1506_bsn XI1506_bcon XI1506_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1506_MP52 (XI1506_bp5 cm144_2 XI1506_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1506_MP51 (XI1506_bp4 cm18_0 XI1506_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1506_MP51_1 (XI1506_bp5 cm18_0 XI1506_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1506_MP52_1 (XI1506_bsn cm144_2 XI1506_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1506_MP54 (VDD XI1506_bsn cm145_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1506_MP41 (XI1506_bp1 XI1506_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1506_MP42 (XI1506_bcon cm18_0 XI1506_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1506_MP45 (XI1506_bp2 cm144_2 XI1506_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1506_MP43 (VDD XI1506_s1 XI1506_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1506_MP44 (XI1506_bp2 cm18_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1506_MP56 (VDD XI1506_bcon cm145_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1506_MP46 (XI1506_bp3 XI1506_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1506_MP48 (VDD cm144_2 XI1506_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1506_MP50_1 (XI1506_bp4 XI1506_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1506_MP26 (VDD XI1506_asn XI1506_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1506_MP18 (XI1506_ap3 cm15_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1506_MP21 (XI1506_asn XI1506_acon XI1506_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1506_MP24 (XI1506_ap5 cm17_0 XI1506_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1506_MP23 (XI1506_ap4 cm16_1 XI1506_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1506_MP22 (VDD cm15_1 XI1506_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1506_MP22_1 (XI1506_ap4 cm15_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1506_MP23_1 (XI1506_ap5 cm16_1 XI1506_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1506_MP24_1 (XI1506_asn cm17_0 XI1506_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1506_MP17 (XI1506_acon cm17_0 XI1506_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1506_MP14 (XI1506_ap1 cm16_1 XI1506_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1506_MP13 (VDD cm15_1 XI1506_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1506_MP15 (XI1506_ap2 cm15_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1506_MP16 (VDD cm16_1 XI1506_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1506_MP28 (cm145_2 XI1506_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1506_MP19 (XI1506_ap3 cm16_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1506_MP20 (VDD cm17_0 XI1506_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1376_MP50 (VDD XI1376_s1 XI1376_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1376_MP47 (XI1376_bp3 pp3_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1376_MP49 (XI1376_bsn XI1376_bcon XI1376_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1376_MP52 (XI1376_bp5 cm13_2 XI1376_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1376_MP51 (XI1376_bp4 pp3_8 XI1376_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1376_MP51_1 (XI1376_bp5 pp3_8 XI1376_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1376_MP52_1 (XI1376_bsn cm13_2 XI1376_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1376_MP54 (VDD XI1376_bsn cm15_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1376_MP41 (XI1376_bp1 XI1376_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1376_MP42 (XI1376_bcon pp3_8 XI1376_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1376_MP45 (XI1376_bp2 cm13_2 XI1376_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1376_MP43 (VDD XI1376_s1 XI1376_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1376_MP44 (XI1376_bp2 pp3_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1376_MP56 (VDD XI1376_bcon cm15_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1376_MP46 (XI1376_bp3 XI1376_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1376_MP48 (VDD cm13_2 XI1376_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1376_MP50_1 (XI1376_bp4 XI1376_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1376_MP26 (VDD XI1376_asn XI1376_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1376_MP18 (XI1376_ap3 pp0_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1376_MP21 (XI1376_asn XI1376_acon XI1376_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1376_MP24 (XI1376_ap5 pp2_10 XI1376_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1376_MP23 (XI1376_ap4 pp1_12 XI1376_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1376_MP22 (VDD pp0_14 XI1376_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1376_MP22_1 (XI1376_ap4 pp0_14 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1376_MP23_1 (XI1376_ap5 pp1_12 XI1376_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1376_MP24_1 (XI1376_asn pp2_10 XI1376_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1376_MP17 (XI1376_acon pp2_10 XI1376_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1376_MP14 (XI1376_ap1 pp1_12 XI1376_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1376_MP13 (VDD pp0_14 XI1376_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1376_MP15 (XI1376_ap2 pp0_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1376_MP16 (VDD pp1_12 XI1376_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1376_MP28 (cm15_2 XI1376_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1376_MP19 (XI1376_ap3 pp1_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1376_MP20 (VDD pp2_10 XI1376_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1377_MP50 (VDD XI1377_s1 XI1377_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1377_MP47 (XI1377_bp3 pp7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1377_MP49 (XI1377_bsn XI1377_bcon XI1377_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1377_MP52 (XI1377_bp5 B_15_b3_5 XI1377_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1377_MP51 (XI1377_bp4 pp7_0 XI1377_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1377_MP51_1 (XI1377_bp5 pp7_0 XI1377_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1377_MP52_1 (XI1377_bsn B_15_b3_5 XI1377_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1377_MP54 (VDD XI1377_bsn cm16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1377_MP41 (XI1377_bp1 XI1377_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1377_MP42 (XI1377_bcon pp7_0 XI1377_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1377_MP45 (XI1377_bp2 B_15_b3_5 XI1377_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1377_MP43 (VDD XI1377_s1 XI1377_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1377_MP44 (XI1377_bp2 pp7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1377_MP56 (VDD XI1377_bcon cm16_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1377_MP46 (XI1377_bp3 XI1377_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1377_MP48 (VDD B_15_b3_5 XI1377_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1377_MP50_1 (XI1377_bp4 XI1377_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1377_MP26 (VDD XI1377_asn XI1377_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1377_MP18 (XI1377_ap3 pp4_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1377_MP21 (XI1377_asn XI1377_acon XI1377_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1377_MP24 (XI1377_ap5 pp6_2 XI1377_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1377_MP23 (XI1377_ap4 pp5_4 XI1377_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1377_MP22 (VDD pp4_6 XI1377_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1377_MP22_1 (XI1377_ap4 pp4_6 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1377_MP23_1 (XI1377_ap5 pp5_4 XI1377_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1377_MP24_1 (XI1377_asn pp6_2 XI1377_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1377_MP17 (XI1377_acon pp6_2 XI1377_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1377_MP14 (XI1377_ap1 pp5_4 XI1377_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1377_MP13 (VDD pp4_6 XI1377_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1377_MP15 (XI1377_ap2 pp4_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1377_MP16 (VDD pp5_4 XI1377_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1377_MP28 (cm16_2 XI1377_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1377_MP19 (XI1377_ap3 pp5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1377_MP20 (VDD pp6_2 XI1377_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1505_MP50 (VDD XI1505_s1 XI1505_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1505_MP47 (XI1505_bp3 cm16_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1505_MP49 (XI1505_bsn XI1505_bcon XI1505_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1505_MP52 (XI1505_bp5 cm143_2 XI1505_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1505_MP51 (XI1505_bp4 cm16_0 XI1505_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1505_MP51_1 (XI1505_bp5 cm16_0 XI1505_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1505_MP52_1 (XI1505_bsn cm143_2 XI1505_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1505_MP54 (VDD XI1505_bsn cm144_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1505_MP41 (XI1505_bp1 XI1505_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1505_MP42 (XI1505_bcon cm16_0 XI1505_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1505_MP45 (XI1505_bp2 cm143_2 XI1505_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1505_MP43 (VDD XI1505_s1 XI1505_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1505_MP44 (XI1505_bp2 cm16_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1505_MP56 (VDD XI1505_bcon cm144_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1505_MP46 (XI1505_bp3 XI1505_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1505_MP48 (VDD cm143_2 XI1505_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1505_MP50_1 (XI1505_bp4 XI1505_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1505_MP26 (VDD XI1505_asn XI1505_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1505_MP18 (XI1505_ap3 cm13_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1505_MP21 (XI1505_asn XI1505_acon XI1505_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1505_MP24 (XI1505_ap5 cm15_0 XI1505_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1505_MP23 (XI1505_ap4 fa14_1 XI1505_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1505_MP22 (VDD cm13_1 XI1505_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1505_MP22_1 (XI1505_ap4 cm13_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1505_MP23_1 (XI1505_ap5 fa14_1 XI1505_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1505_MP24_1 (XI1505_asn cm15_0 XI1505_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1505_MP17 (XI1505_acon cm15_0 XI1505_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1505_MP14 (XI1505_ap1 fa14_1 XI1505_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1505_MP13 (VDD cm13_1 XI1505_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1505_MP15 (XI1505_ap2 cm13_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1505_MP16 (VDD fa14_1 XI1505_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1505_MP28 (cm144_2 XI1505_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1505_MP19 (XI1505_ap3 fa14_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1505_MP20 (VDD cm15_0 XI1505_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1374_MP50 (VDD XI1374_s1 XI1374_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1374_MP47 (XI1374_bp3 pp3_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1374_MP49 (XI1374_bsn XI1374_bcon XI1374_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1374_MP52 (XI1374_bp5 cm11_2 XI1374_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1374_MP51 (XI1374_bp4 pp3_7 XI1374_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1374_MP51_1 (XI1374_bp5 pp3_7 XI1374_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1374_MP52_1 (XI1374_bsn cm11_2 XI1374_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1374_MP54 (VDD XI1374_bsn cm13_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1374_MP41 (XI1374_bp1 XI1374_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1374_MP42 (XI1374_bcon pp3_7 XI1374_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1374_MP45 (XI1374_bp2 cm11_2 XI1374_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1374_MP43 (VDD XI1374_s1 XI1374_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1374_MP44 (XI1374_bp2 pp3_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1374_MP56 (VDD XI1374_bcon cm13_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1374_MP46 (XI1374_bp3 XI1374_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1374_MP48 (VDD cm11_2 XI1374_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1374_MP50_1 (XI1374_bp4 XI1374_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1374_MP26 (VDD XI1374_asn XI1374_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1374_MP18 (XI1374_ap3 pp0_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1374_MP21 (XI1374_asn XI1374_acon XI1374_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1374_MP24 (XI1374_ap5 pp2_9 XI1374_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1374_MP23 (XI1374_ap4 pp1_11 XI1374_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1374_MP22 (VDD pp0_13 XI1374_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1374_MP22_1 (XI1374_ap4 pp0_13 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1374_MP23_1 (XI1374_ap5 pp1_11 XI1374_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1374_MP24_1 (XI1374_asn pp2_9 XI1374_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1374_MP17 (XI1374_acon pp2_9 XI1374_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1374_MP14 (XI1374_ap1 pp1_11 XI1374_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1374_MP13 (VDD pp0_13 XI1374_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1374_MP15 (XI1374_ap2 pp0_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1374_MP16 (VDD pp1_11 XI1374_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1374_MP28 (cm13_2 XI1374_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1374_MP19 (XI1374_ap3 pp1_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1374_MP20 (VDD pp2_9 XI1374_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1504_MP50 (VDD XI1504_s1 XI1504_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1504_MP47 (XI1504_bp3 fa14_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1504_MP49 (XI1504_bsn XI1504_bcon XI1504_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1504_MP52 (XI1504_bp5 cm142_2 XI1504_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1504_MP51 (XI1504_bp4 fa14_0 XI1504_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1504_MP51_1 (XI1504_bp5 fa14_0 XI1504_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1504_MP52_1 (XI1504_bsn cm142_2 XI1504_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1504_MP54 (VDD XI1504_bsn cm143_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1504_MP41 (XI1504_bp1 XI1504_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1504_MP42 (XI1504_bcon fa14_0 XI1504_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1504_MP45 (XI1504_bp2 cm142_2 XI1504_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1504_MP43 (VDD XI1504_s1 XI1504_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1504_MP44 (XI1504_bp2 fa14_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1504_MP56 (VDD XI1504_bcon cm143_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1504_MP46 (XI1504_bp3 XI1504_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1504_MP48 (VDD cm142_2 XI1504_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1504_MP50_1 (XI1504_bp4 XI1504_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1504_MP26 (VDD XI1504_asn XI1504_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1504_MP18 (XI1504_ap3 cm11_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1504_MP21 (XI1504_asn XI1504_acon XI1504_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1504_MP24 (XI1504_ap5 cm13_0 XI1504_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1504_MP23 (XI1504_ap4 fa12_1 XI1504_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1504_MP22 (VDD cm11_1 XI1504_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1504_MP22_1 (XI1504_ap4 cm11_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1504_MP23_1 (XI1504_ap5 fa12_1 XI1504_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1504_MP24_1 (XI1504_asn cm13_0 XI1504_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1504_MP17 (XI1504_acon cm13_0 XI1504_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1504_MP14 (XI1504_ap1 fa12_1 XI1504_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1504_MP13 (VDD cm11_1 XI1504_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1504_MP15 (XI1504_ap2 cm11_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1504_MP16 (VDD fa12_1 XI1504_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1504_MP28 (cm143_2 XI1504_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1504_MP19 (XI1504_ap3 fa12_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1504_MP20 (VDD cm13_0 XI1504_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1372_MP50 (VDD XI1372_s1 XI1372_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1372_MP47 (XI1372_bp3 pp3_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1372_MP49 (XI1372_bsn XI1372_bcon XI1372_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1372_MP52 (XI1372_bp5 cm10_2 XI1372_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1372_MP51 (XI1372_bp4 pp3_6 XI1372_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1372_MP51_1 (XI1372_bp5 pp3_6 XI1372_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1372_MP52_1 (XI1372_bsn cm10_2 XI1372_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1372_MP54 (VDD XI1372_bsn cm11_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1372_MP41 (XI1372_bp1 XI1372_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1372_MP42 (XI1372_bcon pp3_6 XI1372_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1372_MP45 (XI1372_bp2 cm10_2 XI1372_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1372_MP43 (VDD XI1372_s1 XI1372_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1372_MP44 (XI1372_bp2 pp3_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1372_MP56 (VDD XI1372_bcon cm11_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1372_MP46 (XI1372_bp3 XI1372_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1372_MP48 (VDD cm10_2 XI1372_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1372_MP50_1 (XI1372_bp4 XI1372_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1372_MP26 (VDD XI1372_asn XI1372_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1372_MP18 (XI1372_ap3 pp0_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1372_MP21 (XI1372_asn XI1372_acon XI1372_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1372_MP24 (XI1372_ap5 pp2_8 XI1372_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1372_MP23 (XI1372_ap4 pp1_10 XI1372_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1372_MP22 (VDD pp0_12 XI1372_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1372_MP22_1 (XI1372_ap4 pp0_12 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1372_MP23_1 (XI1372_ap5 pp1_10 XI1372_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1372_MP24_1 (XI1372_asn pp2_8 XI1372_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1372_MP17 (XI1372_acon pp2_8 XI1372_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1372_MP14 (XI1372_ap1 pp1_10 XI1372_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1372_MP13 (VDD pp0_12 XI1372_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1372_MP15 (XI1372_ap2 pp0_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1372_MP16 (VDD pp1_10 XI1372_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1372_MP28 (cm11_2 XI1372_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1372_MP19 (XI1372_ap3 pp1_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1372_MP20 (VDD pp2_8 XI1372_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1503_MP50 (VDD XI1503_s1 XI1503_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1503_MP47 (XI1503_bp3 B_13_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1503_MP49 (XI1503_bsn XI1503_bcon XI1503_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1503_MP52 (XI1503_bp5 cm141_2 XI1503_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1503_MP51 (XI1503_bp4 B_13_b3_5 XI1503_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1503_MP51_1 (XI1503_bp5 B_13_b3_5 XI1503_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1503_MP52_1 (XI1503_bsn cm141_2 XI1503_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1503_MP54 (VDD XI1503_bsn cm142_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1503_MP41 (XI1503_bp1 XI1503_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1503_MP42 (XI1503_bcon B_13_b3_5 XI1503_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1503_MP45 (XI1503_bp2 cm141_2 XI1503_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1503_MP43 (VDD XI1503_s1 XI1503_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1503_MP44 (XI1503_bp2 B_13_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1503_MP56 (VDD XI1503_bcon cm142_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1503_MP46 (XI1503_bp3 XI1503_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1503_MP48 (VDD cm141_2 XI1503_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1503_MP50_1 (XI1503_bp4 XI1503_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1503_MP26 (VDD XI1503_asn XI1503_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1503_MP18 (XI1503_ap3 cm10_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1503_MP21 (XI1503_asn XI1503_acon XI1503_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1503_MP24 (XI1503_ap5 fa12_0 XI1503_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1503_MP23 (XI1503_ap4 cm11_0 XI1503_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1503_MP22 (VDD cm10_1 XI1503_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1503_MP22_1 (XI1503_ap4 cm10_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1503_MP23_1 (XI1503_ap5 cm11_0 XI1503_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1503_MP24_1 (XI1503_asn fa12_0 XI1503_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1503_MP17 (XI1503_acon fa12_0 XI1503_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1503_MP14 (XI1503_ap1 cm11_0 XI1503_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1503_MP13 (VDD cm10_1 XI1503_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1503_MP15 (XI1503_ap2 cm10_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1503_MP16 (VDD cm11_0 XI1503_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1503_MP28 (cm142_2 XI1503_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1503_MP19 (XI1503_ap3 cm11_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1503_MP20 (VDD fa12_0 XI1503_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1371_MP50 (VDD XI1371_s1 XI1371_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1371_MP47 (XI1371_bp3 pp3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1371_MP49 (XI1371_bsn XI1371_bcon XI1371_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1371_MP52 (XI1371_bp5 cm8_2 XI1371_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1371_MP51 (XI1371_bp4 pp3_5 XI1371_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1371_MP51_1 (XI1371_bp5 pp3_5 XI1371_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1371_MP52_1 (XI1371_bsn cm8_2 XI1371_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1371_MP54 (VDD XI1371_bsn cm10_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1371_MP41 (XI1371_bp1 XI1371_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1371_MP42 (XI1371_bcon pp3_5 XI1371_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1371_MP45 (XI1371_bp2 cm8_2 XI1371_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1371_MP43 (VDD XI1371_s1 XI1371_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1371_MP44 (XI1371_bp2 pp3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1371_MP56 (VDD XI1371_bcon cm10_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1371_MP46 (XI1371_bp3 XI1371_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1371_MP48 (VDD cm8_2 XI1371_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1371_MP50_1 (XI1371_bp4 XI1371_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1371_MP26 (VDD XI1371_asn XI1371_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1371_MP18 (XI1371_ap3 pp0_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1371_MP21 (XI1371_asn XI1371_acon XI1371_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1371_MP24 (XI1371_ap5 pp2_7 XI1371_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1371_MP23 (XI1371_ap4 pp1_9 XI1371_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1371_MP22 (VDD pp0_11 XI1371_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1371_MP22_1 (XI1371_ap4 pp0_11 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1371_MP23_1 (XI1371_ap5 pp1_9 XI1371_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1371_MP24_1 (XI1371_asn pp2_7 XI1371_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1371_MP17 (XI1371_acon pp2_7 XI1371_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1371_MP14 (XI1371_ap1 pp1_9 XI1371_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1371_MP13 (VDD pp0_11 XI1371_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1371_MP15 (XI1371_ap2 pp0_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1371_MP16 (VDD pp1_9 XI1371_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1371_MP28 (cm10_2 XI1371_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1371_MP19 (XI1371_ap3 pp1_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1371_MP20 (VDD pp2_7 XI1371_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1365_MP50 (VDD XI1365_s1 XI1365_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1365_MP47 (XI1365_bp3 pp3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1365_MP49 (XI1365_bsn XI1365_bcon XI1365_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1365_MP52 (XI1365_bp5 B_7_b3_5 XI1365_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1365_MP51 (XI1365_bp4 pp3_0 XI1365_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1365_MP51_1 (XI1365_bp5 pp3_0 XI1365_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1365_MP52_1 (XI1365_bsn B_7_b3_5 XI1365_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1365_MP54 (VDD XI1365_bsn cm4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1365_MP41 (XI1365_bp1 XI1365_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1365_MP42 (XI1365_bcon pp3_0 XI1365_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1365_MP45 (XI1365_bp2 B_7_b3_5 XI1365_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1365_MP43 (VDD XI1365_s1 XI1365_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1365_MP44 (XI1365_bp2 pp3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1365_MP56 (VDD XI1365_bcon cm4_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1365_MP46 (XI1365_bp3 XI1365_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1365_MP48 (VDD B_7_b3_5 XI1365_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1365_MP50_1 (XI1365_bp4 XI1365_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1365_MP26 (VDD XI1365_asn XI1365_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1365_MP18 (XI1365_ap3 pp0_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1365_MP21 (XI1365_asn XI1365_acon XI1365_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1365_MP24 (XI1365_ap5 pp2_2 XI1365_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1365_MP23 (XI1365_ap4 pp1_4 XI1365_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1365_MP22 (VDD pp0_6 XI1365_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1365_MP22_1 (XI1365_ap4 pp0_6 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1365_MP23_1 (XI1365_ap5 pp1_4 XI1365_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1365_MP24_1 (XI1365_asn pp2_2 XI1365_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1365_MP17 (XI1365_acon pp2_2 XI1365_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1365_MP14 (XI1365_ap1 pp1_4 XI1365_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1365_MP13 (VDD pp0_6 XI1365_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1365_MP15 (XI1365_ap2 pp0_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1365_MP16 (VDD pp1_4 XI1365_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1365_MP28 (cm4_2 XI1365_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1365_MP19 (XI1365_ap3 pp1_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1365_MP20 (VDD pp2_2 XI1365_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1366_MP50 (VDD XI1366_s1 XI1366_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1366_MP47 (XI1366_bp3 pp3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1366_MP49 (XI1366_bsn XI1366_bcon XI1366_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1366_MP52 (XI1366_bp5 cm4_2 XI1366_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1366_MP51 (XI1366_bp4 pp3_1 XI1366_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1366_MP51_1 (XI1366_bp5 pp3_1 XI1366_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1366_MP52_1 (XI1366_bsn cm4_2 XI1366_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1366_MP54 (VDD XI1366_bsn cm5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1366_MP41 (XI1366_bp1 XI1366_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1366_MP42 (XI1366_bcon pp3_1 XI1366_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1366_MP45 (XI1366_bp2 cm4_2 XI1366_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1366_MP43 (VDD XI1366_s1 XI1366_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1366_MP44 (XI1366_bp2 pp3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1366_MP56 (VDD XI1366_bcon cm5_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1366_MP46 (XI1366_bp3 XI1366_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1366_MP48 (VDD cm4_2 XI1366_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1366_MP50_1 (XI1366_bp4 XI1366_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1366_MP26 (VDD XI1366_asn XI1366_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1366_MP18 (XI1366_ap3 pp0_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1366_MP21 (XI1366_asn XI1366_acon XI1366_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1366_MP24 (XI1366_ap5 pp2_3 XI1366_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1366_MP23 (XI1366_ap4 pp1_5 XI1366_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1366_MP22 (VDD pp0_7 XI1366_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1366_MP22_1 (XI1366_ap4 pp0_7 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1366_MP23_1 (XI1366_ap5 pp1_5 XI1366_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1366_MP24_1 (XI1366_asn pp2_3 XI1366_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1366_MP17 (XI1366_acon pp2_3 XI1366_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1366_MP14 (XI1366_ap1 pp1_5 XI1366_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1366_MP13 (VDD pp0_7 XI1366_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1366_MP15 (XI1366_ap2 pp0_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1366_MP16 (VDD pp1_5 XI1366_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1366_MP28 (cm5_2 XI1366_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1366_MP19 (XI1366_ap3 pp1_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1366_MP20 (VDD pp2_3 XI1366_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1502_MP50 (VDD XI1502_s1 XI1502_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1502_MP47 (XI1502_bp3 pp4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1502_MP49 (XI1502_bsn XI1502_bcon XI1502_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1502_MP52 (XI1502_bp5 pp5_1 XI1502_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1502_MP51 (XI1502_bp4 pp4_3 XI1502_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1502_MP51_1 (XI1502_bp5 pp4_3 XI1502_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1502_MP52_1 (XI1502_bsn pp5_1 XI1502_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1502_MP54 (VDD XI1502_bsn cm141_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1502_MP41 (XI1502_bp1 XI1502_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1502_MP42 (XI1502_bcon pp4_3 XI1502_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1502_MP45 (XI1502_bp2 pp5_1 XI1502_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1502_MP43 (VDD XI1502_s1 XI1502_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1502_MP44 (XI1502_bp2 pp4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1502_MP56 (VDD XI1502_bcon cm141_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1502_MP46 (XI1502_bp3 XI1502_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1502_MP48 (VDD pp5_1 XI1502_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1502_MP50_1 (XI1502_bp4 XI1502_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1502_MP26 (VDD XI1502_asn XI1502_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1502_MP18 (XI1502_ap3 cm8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1502_MP21 (XI1502_asn XI1502_acon XI1502_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1502_MP24 (XI1502_ap5 cm10_0 XI1502_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1502_MP23 (XI1502_ap4 fa9_1 XI1502_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1502_MP22 (VDD cm8_1 XI1502_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1502_MP22_1 (XI1502_ap4 cm8_1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1502_MP23_1 (XI1502_ap5 fa9_1 XI1502_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1502_MP24_1 (XI1502_asn cm10_0 XI1502_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1502_MP17 (XI1502_acon cm10_0 XI1502_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1502_MP14 (XI1502_ap1 fa9_1 XI1502_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1502_MP13 (VDD cm8_1 XI1502_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1502_MP15 (XI1502_ap2 cm8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1502_MP16 (VDD fa9_1 XI1502_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1502_MP28 (cm141_2 XI1502_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1502_MP19 (XI1502_ap3 fa9_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1502_MP20 (VDD cm10_0 XI1502_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1369_MP50 (VDD XI1369_s1 XI1369_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1369_MP47 (XI1369_bp3 pp3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1369_MP49 (XI1369_bsn XI1369_bcon XI1369_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1369_MP52 (XI1369_bp5 cm7_2 XI1369_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1369_MP51 (XI1369_bp4 pp3_4 XI1369_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1369_MP51_1 (XI1369_bp5 pp3_4 XI1369_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1369_MP52_1 (XI1369_bsn cm7_2 XI1369_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1369_MP54 (VDD XI1369_bsn cm8_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1369_MP41 (XI1369_bp1 XI1369_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1369_MP42 (XI1369_bcon pp3_4 XI1369_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1369_MP45 (XI1369_bp2 cm7_2 XI1369_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1369_MP43 (VDD XI1369_s1 XI1369_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1369_MP44 (XI1369_bp2 pp3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1369_MP56 (VDD XI1369_bcon cm8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1369_MP46 (XI1369_bp3 XI1369_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1369_MP48 (VDD cm7_2 XI1369_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1369_MP50_1 (XI1369_bp4 XI1369_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1369_MP26 (VDD XI1369_asn XI1369_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1369_MP18 (XI1369_ap3 pp0_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1369_MP21 (XI1369_asn XI1369_acon XI1369_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1369_MP24 (XI1369_ap5 pp2_6 XI1369_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1369_MP23 (XI1369_ap4 pp1_8 XI1369_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1369_MP22 (VDD pp0_10 XI1369_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1369_MP22_1 (XI1369_ap4 pp0_10 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1369_MP23_1 (XI1369_ap5 pp1_8 XI1369_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1369_MP24_1 (XI1369_asn pp2_6 XI1369_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1369_MP17 (XI1369_acon pp2_6 XI1369_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1369_MP14 (XI1369_ap1 pp1_8 XI1369_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1369_MP13 (VDD pp0_10 XI1369_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1369_MP15 (XI1369_ap2 pp0_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1369_MP16 (VDD pp1_8 XI1369_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1369_MP28 (cm8_2 XI1369_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1369_MP19 (XI1369_ap3 pp1_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1369_MP20 (VDD pp2_6 XI1369_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1367_MP50 (VDD XI1367_s1 XI1367_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1367_MP47 (XI1367_bp3 pp3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1367_MP49 (XI1367_bsn XI1367_bcon XI1367_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1367_MP52 (XI1367_bp5 cm5_2 XI1367_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1367_MP51 (XI1367_bp4 pp3_2 XI1367_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1367_MP51_1 (XI1367_bp5 pp3_2 XI1367_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1367_MP52_1 (XI1367_bsn cm5_2 XI1367_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1367_MP54 (VDD XI1367_bsn cm6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1367_MP41 (XI1367_bp1 XI1367_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1367_MP42 (XI1367_bcon pp3_2 XI1367_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1367_MP45 (XI1367_bp2 cm5_2 XI1367_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1367_MP43 (VDD XI1367_s1 XI1367_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1367_MP44 (XI1367_bp2 pp3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1367_MP56 (VDD XI1367_bcon cm6_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1367_MP46 (XI1367_bp3 XI1367_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1367_MP48 (VDD cm5_2 XI1367_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1367_MP50_1 (XI1367_bp4 XI1367_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1367_MP26 (VDD XI1367_asn XI1367_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1367_MP18 (XI1367_ap3 pp0_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1367_MP21 (XI1367_asn XI1367_acon XI1367_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1367_MP24 (XI1367_ap5 pp2_4 XI1367_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1367_MP23 (XI1367_ap4 pp1_6 XI1367_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1367_MP22 (VDD pp0_8 XI1367_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1367_MP22_1 (XI1367_ap4 pp0_8 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1367_MP23_1 (XI1367_ap5 pp1_6 XI1367_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1367_MP24_1 (XI1367_asn pp2_4 XI1367_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1367_MP17 (XI1367_acon pp2_4 XI1367_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1367_MP14 (XI1367_ap1 pp1_6 XI1367_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1367_MP13 (VDD pp0_8 XI1367_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1367_MP15 (XI1367_ap2 pp0_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1367_MP16 (VDD pp1_6 XI1367_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1367_MP28 (cm6_2 XI1367_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1367_MP19 (XI1367_ap3 pp1_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1367_MP20 (VDD pp2_4 XI1367_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI1368_MP50 (VDD XI1368_s1 XI1368_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0996p as=0.0792p pd=0.91999u ps=0.79999u
    I_MXI1368_MP47 (XI1368_bp3 pp3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.2352p as=0.0996p pd=1.45999u ps=0.91999u
    I_MXI1368_MP49 (XI1368_bsn XI1368_bcon XI1368_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.2352p pd=0.91999u ps=1.45999u
    I_MXI1368_MP52 (XI1368_bp5 cm6_2 XI1368_bsn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1368_MP51 (XI1368_bp4 pp3_3 XI1368_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1368_MP51_1 (XI1368_bp5 pp3_3 XI1368_bp4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1368_MP52_1 (XI1368_bsn cm6_2 XI1368_bp5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1368_MP54 (VDD XI1368_bsn cm7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1368_MP41 (XI1368_bp1 XI1368_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1368_MP42 (XI1368_bcon pp3_3 XI1368_bp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1368_MP45 (XI1368_bp2 cm6_2 XI1368_bcon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1368_MP43 (VDD XI1368_s1 XI1368_bp2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1368_MP44 (XI1368_bp2 pp3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.63999u ps=0.91999u
    I_MXI1368_MP56 (VDD XI1368_bcon cm7_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1368_MP46 (XI1368_bp3 XI1368_s1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.91999u ps=0.91999u
    I_MXI1368_MP48 (VDD cm6_2 XI1368_bp3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1368_MP50_1 (XI1368_bp4 XI1368_s1 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1368_MP26 (VDD XI1368_asn XI1368_s1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.91999u ps=1.15999u
    I_MXI1368_MP18 (XI1368_ap3 pp0_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.264p pd=0.91999u ps=2.23999u
    I_MXI1368_MP21 (XI1368_asn XI1368_acon XI1368_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0996p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1368_MP24 (XI1368_ap5 pp2_5 XI1368_asn VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0996p pd=0.79999u ps=0.91999u
    I_MXI1368_MP23 (XI1368_ap4 pp1_7 XI1368_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1368_MP22 (VDD pp0_9 XI1368_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1368_MP22_1 (XI1368_ap4 pp0_9 VDD VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1368_MP23_1 (XI1368_ap5 pp1_7 XI1368_ap4 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.0792p as=0.0792p pd=0.79999u ps=0.79999u
    I_MXI1368_MP24_1 (XI1368_asn pp2_5 XI1368_ap5 VDD) gpdk090_pmos1v w=0.36u l=0.1u ad=0.1224p as=0.0792p pd=1.39999u ps=0.79999u
    I_MXI1368_MP17 (XI1368_acon pp2_5 XI1368_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1368_MP14 (XI1368_ap1 pp1_7 XI1368_acon VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1368_MP13 (VDD pp0_9 XI1368_ap1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1368_MP15 (XI1368_ap2 pp0_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1368_MP16 (VDD pp1_7 XI1368_ap2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.0936p as=0.1056p pd=0.91999u ps=0.91999u
    I_MXI1368_MP28 (cm7_2 XI1368_acon VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0936p pd=1.15999u ps=0.91999u
    I_MXI1368_MP19 (XI1368_ap3 pp1_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
    I_MXI1368_MP20 (VDD pp2_5 XI1368_ap3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.264p as=0.1056p pd=2.23999u ps=0.91999u
    I_MXI190_MP0 (A_18_b0 A_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI240_MP0 (A_23_b0 A_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI260_MP0 (A_25_b0 A_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI250_MP0 (A_24_b0 A_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI811_MP0 (sn5 pp5_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI402_MP0 (B_17_b0 B_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI412_MP0 (B_19_b0 B_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI422_MP0 (B_21_b0 B_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI976_MP0 (sn8 pp8_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI230_MP0 (A_22_b0 A_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI921_MP0 (sn7 pp7_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1031_MP0 (sn9 pp9_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI756_MP0 (sn4 pp4_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI866_MP0 (sn6 pp6_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI270_MP0 (A_26_b0 A_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI220_MP0 (A_21_b0 A_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI701_MP0 (sn3 pp3_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI280_MP0 (A_27_b0 A_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI392_MP0 (B_15_b0 B_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI290_MP0 (A_28_b0 A_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI382_MP0 (B_13_b0 B_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI646_MP0 (sn2 pp2_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI310_MP0 (A_30_b0 A_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI210_MP0 (A_20_b0 A_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI200_MP0 (A_19_b0 A_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI180_MP0 (A_17_b0 A_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI300_MP0 (A_29_b0 A_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1086_MP0 (sn10 pp10_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI591_MP0 (sn1 pp1_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI432_MP0 (B_23_b0 B_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI170_MP0 (A_16_b0 A_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI536_MP0 (sn0 pp0_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1088_MP0 (one11_b0 one11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1098_MP0 (two11_b0 two11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1141_MP0 (sn11 pp11_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1143_MP0 (one12_b0 one12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1153_MP0 (two12_b0 two12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI442_MP0 (B_25_b0 B_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI452_MP0 (B_27_b0 B_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI320_MP0 (A_31_b0 A_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI160_MP0 (A_15_b0 A_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI150_MP0 (A_14_b0 A_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1263_MP0 (two14_b0 two14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1253_MP0 (one14_b0 one14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1308_MP0 (one15_b0 one15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI372_MP0 (B_11_b0 B_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1198_MP0 (one13_b0 one13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1208_MP0 (two13_b0 two13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1318_MP0 (two15_b0 two15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI462_MP0 (B_29_b0 B_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI472_MP0 (B_31_b0 B_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1196_MP0 (sn12 pp12_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI140_MP0 (A_13_b0 A_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI130_MP0 (A_12_b0 A_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1033_MP0 (one10_b0 one10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1043_MP0 (two10_b0 two10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1251_MP0 (sn13 pp13_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI868_MP0 (one7_b0 one7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI362_MP0 (B_9_b0 B_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI878_MP0 (two7_b0 two7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1306_MP0 (sn14 pp14_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI120_MP0 (A_11_b0 A_11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI923_MP0 (one8_b0 one8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI933_MP0 (two8_b0 two8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI978_MP0 (one9_b0 one9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI988_MP0 (two9_b0 two9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI352_MP0 (B_7_b0 B_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1361_MP0 (sn15 pp15_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI813_MP0 (one6_b0 one6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI823_MP0 (two6_b0 two6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I443_MP0 (I1660_G12_0np I1660_G12_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I531_MP0 (kcm I1660_G62_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I447_MP0 (I1660_G14_0np I1660_G14_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI768_MP0 (two5_b0 two5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI758_MP0 (one5_b0 one5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I439_MP0 (I1660_G10_0np I1660_G10_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I435_MP0 (I1660_G8_0np I1660_G8_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I383_MP0 (I1660_G6_0n I1660_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I445_MP0 (I1660_G13_0np I1660_G13_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI658_MP0 (two3_b0 two3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI648_MP0 (one3_b0 one3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I532_MP0 (kco I1660_G63_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI713_MP0 (two4_b0 two4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI703_MP0 (one4_b0 one4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI110_MP0 (A_10_b0 A_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI603_MP0 (two2_b0 two2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI100_MP0 (A_9_b0 A_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI90_MP0 (A_8_b0 A_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I379_MP0 (I1660_G4_0n I1660_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI342_MP0 (B_5_b0 B_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI593_MP0 (one2_b0 one2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI548_MP0 (two1_b0 two1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI538_MP0 (one1_b0 one1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI80_MP0 (A_7_b0 A_7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I437_MP0 (I1660_G9_0np I1660_G9_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I449_MP0 (I1660_G15_0np I1660_G15_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI70_MP0 (A_6_b0 A_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI30_MP0 (A_2_b0 A_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I319_MP0 (I1660_G2_0np I1660_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI0_MP0 (B_1_b0 B_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI332_MP0 (B_3_b0 B_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI483_MP0 (one0_b0 one0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI493_MP0 (two0_b0 two0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI60_MP0 (A_5_b0 A_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI40_MP0 (A_3_b0 A_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI10_MP0 (A_0_b0 A_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI20_MP0 (A_1_b0 A_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I128_MP0 (I1660_cinn VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I130_MP0 (I1660_G0_0n I1660_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I441_MP0 (I1660_G11_0np I1660_G11_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI50_MP0 (A_4_b0 A_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I381_MP0 (I1660_G5_0n I1660_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I385_MP0 (I1660_G7_0n I1660_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I257_MP0 (I1660_G1_0n I1660_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1660_I321_MP0 (I1660_G3_0np I1660_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.15999u ps=1.15999u
    I_MXI1087_MP9 (XI1087_ap1 B_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.91999u ps=1.63999u
