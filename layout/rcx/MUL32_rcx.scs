    I_MXI1119_MN2 (VSS A_11_b3_4 XI1119_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1119_MN4 (XI1119_n2 A_10_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1119_MN3 (XI1119_xn two11_b3_2 XI1119_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1119_MN1 (XI1119_n1 one11_b3_2 XI1119_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1119_MN9 (VSS XI1119_xn XI1119_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1067_MN11 (VSS B_21_b3_2 XI1067_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1067_MN14 (VSS XI1067_xbn XI1067_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1067_MN16 (XI1067_xn2 B_21_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1067_MN15 (pp10_14 XI1067_xan XI1067_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1067_MN13 (XI1067_xn1 XI1067_xn pp10_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1067_MN2 (VSS A_14_b3_3 XI1067_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1067_MN4 (XI1067_n2 A_13_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1067_MN3 (XI1067_xn two10_b3_2 XI1067_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1067_MN1 (XI1067_n1 one10_b3_2 XI1067_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1067_MN9 (VSS XI1067_xn XI1067_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1282_MN11 (VSS B_29_b3_1 XI1282_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1282_MN14 (VSS XI1282_xbn XI1282_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1282_MN16 (XI1282_xn2 B_29_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1282_MN15 (pp14_9 XI1282_xan XI1282_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1282_MN13 (XI1282_xn1 XI1282_xn pp14_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1282_MN2 (VSS A_9_b3_5 XI1282_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1282_MN4 (XI1282_n2 A_8_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1282_MN3 (XI1282_xn two14_b3_1 XI1282_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1282_MN1 (XI1282_n1 one14_b3_1 XI1282_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1282_MN9 (VSS XI1282_xn XI1282_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1174_MN11 (VSS B_25_b3_2 XI1174_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1174_MN14 (VSS XI1174_xbn XI1174_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1174_MN16 (XI1174_xn2 B_25_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1174_MN15 (pp12_11 XI1174_xan XI1174_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1174_MN13 (XI1174_xn1 XI1174_xn pp12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1174_MN2 (VSS A_11_b3_4 XI1174_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1174_MN4 (XI1174_n2 A_10_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1174_MN3 (XI1174_xn two12_b3_2 XI1174_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1174_MN1 (XI1174_n1 one12_b3_2 XI1174_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1174_MN9 (VSS XI1174_xn XI1174_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1280_MN11 (VSS B_29_b3_1 XI1280_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1280_MN14 (VSS XI1280_xbn XI1280_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1280_MN16 (XI1280_xn2 B_29_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1280_MN15 (pp14_7 XI1280_xan XI1280_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1280_MN13 (XI1280_xn1 XI1280_xn pp14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1280_MN2 (VSS A_7_b3_5 XI1280_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1280_MN4 (XI1280_n2 A_6_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1280_MN3 (XI1280_xn two14_b3_1 XI1280_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1280_MN1 (XI1280_n1 one14_b3_1 XI1280_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1280_MN9 (VSS XI1280_xn XI1280_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1279_MN11 (VSS B_29_b3_1 XI1279_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1279_MN14 (VSS XI1279_xbn XI1279_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1279_MN16 (XI1279_xn2 B_29_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1279_MN15 (pp14_6 XI1279_xan XI1279_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1279_MN13 (XI1279_xn1 XI1279_xn pp14_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1279_MN2 (VSS A_6_b3_5 XI1279_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1279_MN4 (XI1279_n2 A_5_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1279_MN3 (XI1279_xn two14_b3_1 XI1279_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1279_MN1 (XI1279_n1 one14_b3_1 XI1279_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1279_MN9 (VSS XI1279_xn XI1279_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1247_MN11 (VSS B_27_b3_5 XI1247_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1247_MN14 (VSS XI1247_xbn XI1247_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1247_MN16 (XI1247_xn2 B_27_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1247_MN15 (pp13_29 XI1247_xan XI1247_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1247_MN13 (XI1247_xn1 XI1247_xn pp13_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1247_MN2 (VSS A_29_b3_4 XI1247_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1247_MN4 (XI1247_n2 A_28_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1247_MN3 (XI1247_xn two13_b3_5 XI1247_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1247_MN1 (XI1247_n1 one13_b3_5 XI1247_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1247_MN9 (VSS XI1247_xn XI1247_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1246_MN11 (VSS B_27_b3_4 XI1246_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1246_MN14 (VSS XI1246_xbn XI1246_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1246_MN16 (XI1246_xn2 B_27_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1246_MN15 (pp13_28 XI1246_xan XI1246_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1246_MN13 (XI1246_xn1 XI1246_xn pp13_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1246_MN2 (VSS A_28_b3_4 XI1246_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1246_MN4 (XI1246_n2 A_27_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1246_MN3 (XI1246_xn two13_b3_5 XI1246_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1246_MN1 (XI1246_n1 one13_b3_5 XI1246_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1246_MN9 (VSS XI1246_xn XI1246_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1355_MN11 (VSS B_31_b3_4 XI1355_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1355_MN14 (VSS XI1355_xbn XI1355_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1355_MN16 (XI1355_xn2 B_31_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1355_MN15 (pp15_27 XI1355_xan XI1355_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1355_MN13 (XI1355_xn1 XI1355_xn pp15_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1355_MN2 (VSS A_27_b3_5 XI1355_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1355_MN4 (XI1355_n2 A_26_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1355_MN3 (XI1355_xn two15_b3_4 XI1355_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1355_MN1 (XI1355_n1 one15_b3_4 XI1355_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1355_MN9 (VSS XI1355_xn XI1355_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1353_MN11 (VSS B_31_b3_4 XI1353_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1353_MN14 (VSS XI1353_xbn XI1353_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1353_MN16 (XI1353_xn2 B_31_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1353_MN15 (pp15_25 XI1353_xan XI1353_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1353_MN13 (XI1353_xn1 XI1353_xn pp15_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1353_MN2 (VSS A_25_b3_5 XI1353_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1353_MN4 (XI1353_n2 A_24_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1353_MN3 (XI1353_xn two15_b3_4 XI1353_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1353_MN1 (XI1353_n1 one15_b3_4 XI1353_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1353_MN9 (VSS XI1353_xn XI1353_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1354_MN11 (VSS B_31_b3_4 XI1354_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1354_MN14 (VSS XI1354_xbn XI1354_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1354_MN16 (XI1354_xn2 B_31_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1354_MN15 (pp15_26 XI1354_xan XI1354_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1354_MN13 (XI1354_xn1 XI1354_xn pp15_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1354_MN2 (VSS A_26_b3_5 XI1354_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1354_MN4 (XI1354_n2 A_25_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1354_MN3 (XI1354_xn two15_b3_4 XI1354_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1354_MN1 (XI1354_n1 one15_b3_4 XI1354_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1354_MN9 (VSS XI1354_xn XI1354_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI853_MN11 (VSS B_13_b3_3 XI853_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI853_MN14 (VSS XI853_xbn XI853_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI853_MN16 (XI853_xn2 B_13_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI853_MN15 (pp6_20 XI853_xan XI853_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI853_MN13 (XI853_xn1 XI853_xn pp6_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI853_MN2 (VSS A_20_b3_2 XI853_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI853_MN4 (XI853_n2 A_19_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI853_MN3 (XI853_xn two6_b3_3 XI853_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI853_MN1 (XI853_n1 one6_b3_3 XI853_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI853_MN9 (VSS XI853_xn XI853_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI747_MN11 (VSS B_9_b3_4 XI747_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI747_MN14 (VSS XI747_xbn XI747_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI747_MN16 (XI747_xn2 B_9_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI747_MN15 (pp4_24 XI747_xan XI747_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI747_MN13 (XI747_xn1 XI747_xn pp4_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI747_MN2 (VSS A_24_b3_1 XI747_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI747_MN4 (XI747_n2 A_23_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI747_MN3 (XI747_xn two4_b3_4 XI747_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI747_MN1 (XI747_n1 one4_b3_4 XI747_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI747_MN9 (VSS XI747_xn XI747_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI693_MN11 (VSS B_7_b3_4 XI693_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI693_MN14 (VSS XI693_xbn XI693_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI693_MN16 (XI693_xn2 B_7_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI693_MN15 (pp3_25 XI693_xan XI693_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI693_MN13 (XI693_xn1 XI693_xn pp3_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI693_MN2 (VSS A_25_b3_1 XI693_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI693_MN4 (XI693_n2 A_24_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI693_MN3 (XI693_xn two3_b3_4 XI693_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI693_MN1 (XI693_n1 one3_b3_4 XI693_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI693_MN9 (VSS XI693_xn XI693_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI590_MN11 (VSS B_3_b3_5 XI590_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI590_MN14 (VSS XI590_xbn XI590_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI590_MN16 (XI590_xn2 B_3_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI590_MN15 (pp1_32 XI590_xan XI590_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI590_MN13 (XI590_xn1 XI590_xn pp1_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI590_MN2 (VSS A_31_b3_0 XI590_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI590_MN4 (XI590_n2 A_31_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI590_MN3 (XI590_xn two1_b3_5 XI590_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI590_MN1 (XI590_n1 one1_b3_5 XI590_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI590_MN9 (VSS XI590_xn XI590_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI642_MN11 (VSS B_5_b3_5 XI642_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI642_MN14 (VSS XI642_xbn XI642_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI642_MN16 (XI642_xn2 B_5_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI642_MN15 (pp2_29 XI642_xan XI642_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI642_MN13 (XI642_xn1 XI642_xn pp2_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI642_MN2 (VSS A_29_b3_0 XI642_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI642_MN4 (XI642_n2 A_28_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI642_MN3 (XI642_xn two2_b3_5 XI642_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI642_MN1 (XI642_n1 one2_b3_5 XI642_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI642_MN9 (VSS XI642_xn XI642_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI589_MN11 (VSS B_3_b3_5 XI589_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI589_MN14 (VSS XI589_xbn XI589_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI589_MN16 (XI589_xn2 B_3_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI589_MN15 (pp1_31 XI589_xan XI589_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI589_MN13 (XI589_xn1 XI589_xn pp1_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI589_MN2 (VSS A_31_b3_0 XI589_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI589_MN4 (XI589_n2 A_30_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI589_MN3 (XI589_xn two1_b3_5 XI589_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI589_MN1 (XI589_n1 one1_b3_5 XI589_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI589_MN9 (VSS XI589_xn XI589_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1014_MN11 (VSS B_19_b3_2 XI1014_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1014_MN14 (VSS XI1014_xbn XI1014_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1014_MN16 (XI1014_xn2 B_19_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1014_MN15 (pp9_16 XI1014_xan XI1014_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1014_MN13 (XI1014_xn1 XI1014_xn pp9_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1014_MN2 (VSS A_16_b3_3 XI1014_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1014_MN4 (XI1014_n2 A_15_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1014_MN3 (XI1014_xn two9_b3_2 XI1014_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1014_MN1 (XI1014_n1 one9_b3_2 XI1014_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1014_MN9 (VSS XI1014_xn XI1014_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1013_MN11 (VSS B_19_b3_2 XI1013_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1013_MN14 (VSS XI1013_xbn XI1013_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1013_MN16 (XI1013_xn2 B_19_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1013_MN15 (pp9_15 XI1013_xan XI1013_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1013_MN13 (XI1013_xn1 XI1013_xn pp9_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1013_MN2 (VSS A_15_b3_3 XI1013_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1013_MN4 (XI1013_n2 A_14_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1013_MN3 (XI1013_xn two9_b3_2 XI1013_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1013_MN1 (XI1013_n1 one9_b3_2 XI1013_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1013_MN9 (VSS XI1013_xn XI1013_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1066_MN11 (VSS B_21_b3_2 XI1066_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1066_MN14 (VSS XI1066_xbn XI1066_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1066_MN16 (XI1066_xn2 B_21_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1066_MN15 (pp10_13 XI1066_xan XI1066_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1066_MN13 (XI1066_xn1 XI1066_xn pp10_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1066_MN2 (VSS A_13_b3_3 XI1066_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1066_MN4 (XI1066_n2 A_12_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1066_MN3 (XI1066_xn two10_b3_2 XI1066_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1066_MN1 (XI1066_n1 one10_b3_2 XI1066_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1066_MN9 (VSS XI1066_xn XI1066_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1333_MN11 (VSS B_31_b3_1 XI1333_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1333_MN14 (VSS XI1333_xbn XI1333_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1333_MN16 (XI1333_xn2 B_31_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1333_MN15 (pp15_5 XI1333_xan XI1333_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1333_MN13 (XI1333_xn1 XI1333_xn pp15_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1333_MN2 (VSS A_5_b3_5 XI1333_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1333_MN4 (XI1333_n2 A_4_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1333_MN3 (XI1333_xn two15_b3_0 XI1333_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1333_MN1 (XI1333_n1 one15_b3_0 XI1333_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1333_MN9 (VSS XI1333_xn XI1333_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1301_MN11 (VSS B_29_b3_4 XI1301_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1301_MN14 (VSS XI1301_xbn XI1301_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1301_MN16 (XI1301_xn2 B_29_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1301_MN15 (pp14_28 XI1301_xan XI1301_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1301_MN13 (XI1301_xn1 XI1301_xn pp14_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1301_MN2 (VSS A_28_b3_5 XI1301_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1301_MN4 (XI1301_n2 A_27_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1301_MN3 (XI1301_xn two14_b3_5 XI1301_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1301_MN1 (XI1301_n1 one14_b3_5 XI1301_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1301_MN9 (VSS XI1301_xn XI1301_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1194_MN11 (VSS B_25_b3_5 XI1194_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1194_MN14 (VSS XI1194_xbn XI1194_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1194_MN16 (XI1194_xn2 B_25_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1194_MN15 (pp12_31 XI1194_xan XI1194_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1194_MN13 (XI1194_xn1 XI1194_xn pp12_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1194_MN2 (VSS A_31_b3_6 XI1194_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1194_MN4 (XI1194_n2 A_30_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1194_MN3 (XI1194_xn two12_b3_5 XI1194_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1194_MN1 (XI1194_n1 one12_b3_5 XI1194_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1194_MN9 (VSS XI1194_xn XI1194_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1195_MN11 (VSS B_25_b3_5 XI1195_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1195_MN14 (VSS XI1195_xbn XI1195_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1195_MN16 (XI1195_xn2 B_25_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1195_MN15 (pp12_32 XI1195_xan XI1195_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1195_MN13 (XI1195_xn1 XI1195_xn pp12_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1195_MN2 (VSS A_31_b3_6 XI1195_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1195_MN4 (XI1195_n2 A_31_b3_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1195_MN3 (XI1195_xn two12_b3_5 XI1195_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1195_MN1 (XI1195_n1 one12_b3_5 XI1195_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1195_MN9 (VSS XI1195_xn XI1195_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI905_MN11 (VSS B_15_b3_3 XI905_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI905_MN14 (VSS XI905_xbn XI905_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI905_MN16 (XI905_xn2 B_15_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI905_MN15 (pp7_17 XI905_xan XI905_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI905_MN13 (XI905_xn1 XI905_xn pp7_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI905_MN2 (VSS A_17_b3_2 XI905_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI905_MN4 (XI905_n2 A_16_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI905_MN3 (XI905_xn two7_b3_3 XI905_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI905_MN1 (XI905_n1 one7_b3_3 XI905_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI905_MN9 (VSS XI905_xn XI905_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI906_MN11 (VSS B_15_b3_3 XI906_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI906_MN14 (VSS XI906_xbn XI906_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI906_MN16 (XI906_xn2 B_15_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI906_MN15 (pp7_18 XI906_xan XI906_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI906_MN13 (XI906_xn1 XI906_xn pp7_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI906_MN2 (VSS A_18_b3_2 XI906_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI906_MN4 (XI906_n2 A_17_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI906_MN3 (XI906_xn two7_b3_3 XI906_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI906_MN1 (XI906_n1 one7_b3_3 XI906_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI906_MN9 (VSS XI906_xn XI906_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI746_MN11 (VSS B_9_b3_4 XI746_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI746_MN14 (VSS XI746_xbn XI746_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI746_MN16 (XI746_xn2 B_9_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI746_MN15 (pp4_23 XI746_xan XI746_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI746_MN13 (XI746_xn1 XI746_xn pp4_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI746_MN2 (VSS A_23_b3_1 XI746_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI746_MN4 (XI746_n2 A_22_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI746_MN3 (XI746_xn two4_b3_4 XI746_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI746_MN1 (XI746_n1 one4_b3_4 XI746_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI746_MN9 (VSS XI746_xn XI746_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI692_MN11 (VSS B_7_b3_4 XI692_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI692_MN14 (VSS XI692_xbn XI692_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI692_MN16 (XI692_xn2 B_7_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI692_MN15 (pp3_24 XI692_xan XI692_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI692_MN13 (XI692_xn1 XI692_xn pp3_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI692_MN2 (VSS A_24_b3_1 XI692_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI692_MN4 (XI692_n2 A_23_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI692_MN3 (XI692_xn two3_b3_4 XI692_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI692_MN1 (XI692_n1 one3_b3_4 XI692_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI692_MN9 (VSS XI692_xn XI692_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI691_MN11 (VSS B_7_b3_4 XI691_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI691_MN14 (VSS XI691_xbn XI691_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI691_MN16 (XI691_xn2 B_7_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI691_MN15 (pp3_23 XI691_xan XI691_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI691_MN13 (XI691_xn1 XI691_xn pp3_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI691_MN2 (VSS A_23_b3_1 XI691_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI691_MN4 (XI691_n2 A_22_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI691_MN3 (XI691_xn two3_b3_4 XI691_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI691_MN1 (XI691_n1 one3_b3_4 XI691_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI691_MN9 (VSS XI691_xn XI691_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI588_MN11 (VSS B_3_b3_5 XI588_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI588_MN14 (VSS XI588_xbn XI588_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI588_MN16 (XI588_xn2 B_3_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI588_MN15 (pp1_30 XI588_xan XI588_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI588_MN13 (XI588_xn1 XI588_xn pp1_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI588_MN2 (VSS A_30_b3_0 XI588_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI588_MN4 (XI588_n2 A_29_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI588_MN3 (XI588_xn two1_b3_5 XI588_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI588_MN1 (XI588_n1 one1_b3_5 XI588_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI588_MN9 (VSS XI588_xn XI588_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI535_MN11 (VSS B_1_b3_5 XI535_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI535_MN14 (VSS XI535_xbn XI535_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI535_MN16 (XI535_xn2 B_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI535_MN15 (pp0_32 XI535_xan XI535_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI535_MN13 (XI535_xn1 XI535_xn pp0_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI535_MN2 (VSS A_31_b3_0 XI535_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI535_MN4 (XI535_n2 A_31_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI535_MN3 (XI535_xn two0_b3_5 XI535_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI535_MN1 (XI535_n1 one0_b3_5 XI535_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI535_MN9 (VSS XI535_xn XI535_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1012_MN11 (VSS B_19_b3_2 XI1012_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1012_MN14 (VSS XI1012_xbn XI1012_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1012_MN16 (XI1012_xn2 B_19_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1012_MN15 (pp9_14 XI1012_xan XI1012_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1012_MN13 (XI1012_xn1 XI1012_xn pp9_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1012_MN2 (VSS A_14_b3_3 XI1012_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1012_MN4 (XI1012_n2 A_13_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1012_MN3 (XI1012_xn two9_b3_2 XI1012_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1012_MN1 (XI1012_n1 one9_b3_2 XI1012_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1012_MN9 (VSS XI1012_xn XI1012_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1228_MN11 (VSS B_27_b3_1 XI1228_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1228_MN14 (VSS XI1228_xbn XI1228_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1228_MN16 (XI1228_xn2 B_27_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1228_MN15 (pp13_10 XI1228_xan XI1228_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1228_MN13 (XI1228_xn1 XI1228_xn pp13_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1228_MN2 (VSS A_10_b3_4 XI1228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1228_MN4 (XI1228_n2 A_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1228_MN3 (XI1228_xn two13_b3_1 XI1228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1228_MN1 (XI1228_n1 one13_b3_1 XI1228_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1228_MN9 (VSS XI1228_xn XI1228_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1227_MN11 (VSS B_27_b3_1 XI1227_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1227_MN14 (VSS XI1227_xbn XI1227_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1227_MN16 (XI1227_xn2 B_27_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1227_MN15 (pp13_9 XI1227_xan XI1227_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1227_MN13 (XI1227_xn1 XI1227_xn pp13_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1227_MN2 (VSS A_9_b3_4 XI1227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1227_MN4 (XI1227_n2 A_8_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1227_MN3 (XI1227_xn two13_b3_1 XI1227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1227_MN1 (XI1227_n1 one13_b3_1 XI1227_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1227_MN9 (VSS XI1227_xn XI1227_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1226_MN11 (VSS B_27_b3_1 XI1226_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1226_MN14 (VSS XI1226_xbn XI1226_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1226_MN16 (XI1226_xn2 B_27_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1226_MN15 (pp13_8 XI1226_xan XI1226_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1226_MN13 (XI1226_xn1 XI1226_xn pp13_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1226_MN2 (VSS A_8_b3_4 XI1226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1226_MN4 (XI1226_n2 A_7_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1226_MN3 (XI1226_xn two13_b3_1 XI1226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1226_MN1 (XI1226_n1 one13_b3_1 XI1226_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1226_MN9 (VSS XI1226_xn XI1226_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1225_MN11 (VSS B_27_b3_1 XI1225_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1225_MN14 (VSS XI1225_xbn XI1225_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1225_MN16 (XI1225_xn2 B_27_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1225_MN15 (pp13_7 XI1225_xan XI1225_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1225_MN13 (XI1225_xn1 XI1225_xn pp13_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1225_MN2 (VSS A_7_b3_4 XI1225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1225_MN4 (XI1225_n2 A_6_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1225_MN3 (XI1225_xn two13_b3_1 XI1225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1225_MN1 (XI1225_n1 one13_b3_1 XI1225_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1225_MN9 (VSS XI1225_xn XI1225_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1278_MN11 (VSS B_29_b3_1 XI1278_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1278_MN14 (VSS XI1278_xbn XI1278_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1278_MN16 (XI1278_xn2 B_29_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1278_MN15 (pp14_5 XI1278_xan XI1278_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1278_MN13 (XI1278_xn1 XI1278_xn pp14_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1278_MN2 (VSS A_5_b3_5 XI1278_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1278_MN4 (XI1278_n2 A_4_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1278_MN3 (XI1278_xn two14_b3_0 XI1278_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1278_MN1 (XI1278_n1 one14_b3_0 XI1278_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1278_MN9 (VSS XI1278_xn XI1278_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1332_MN11 (VSS B_31_b3_0 XI1332_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1332_MN14 (VSS XI1332_xbn XI1332_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1332_MN16 (XI1332_xn2 B_31_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1332_MN15 (pp15_4 XI1332_xan XI1332_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1332_MN13 (XI1332_xn1 XI1332_xn pp15_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1332_MN2 (VSS A_4_b3_5 XI1332_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1332_MN4 (XI1332_n2 A_3_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1332_MN3 (XI1332_xn two15_b3_0 XI1332_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1332_MN1 (XI1332_n1 one15_b3_0 XI1332_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1332_MN9 (VSS XI1332_xn XI1332_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1356_MN11 (VSS B_31_b3_4 XI1356_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1356_MN14 (VSS XI1356_xbn XI1356_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1356_MN16 (XI1356_xn2 B_31_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1356_MN15 (pp15_28 XI1356_xan XI1356_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1356_MN13 (XI1356_xn1 XI1356_xn pp15_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1356_MN2 (VSS A_28_b3_5 XI1356_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1356_MN4 (XI1356_n2 A_27_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1356_MN3 (XI1356_xn two15_b3_5 XI1356_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1356_MN1 (XI1356_n1 one15_b3_5 XI1356_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1356_MN9 (VSS XI1356_xn XI1356_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1248_MN11 (VSS B_27_b3_5 XI1248_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1248_MN14 (VSS XI1248_xbn XI1248_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1248_MN16 (XI1248_xn2 B_27_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1248_MN15 (pp13_30 XI1248_xan XI1248_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1248_MN13 (XI1248_xn1 XI1248_xn pp13_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1248_MN2 (VSS A_30_b3_4 XI1248_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1248_MN4 (XI1248_n2 A_29_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1248_MN3 (XI1248_xn two13_b3_5 XI1248_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1248_MN1 (XI1248_n1 one13_b3_5 XI1248_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1248_MN9 (VSS XI1248_xn XI1248_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI852_MN11 (VSS B_13_b3_3 XI852_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI852_MN14 (VSS XI852_xbn XI852_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI852_MN16 (XI852_xn2 B_13_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI852_MN15 (pp6_19 XI852_xan XI852_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI852_MN13 (XI852_xn1 XI852_xn pp6_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI852_MN2 (VSS A_19_b3_2 XI852_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI852_MN4 (XI852_n2 A_18_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI852_MN3 (XI852_xn two6_b3_3 XI852_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI852_MN1 (XI852_n1 one6_b3_3 XI852_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI852_MN9 (VSS XI852_xn XI852_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI745_MN11 (VSS B_9_b3_3 XI745_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI745_MN14 (VSS XI745_xbn XI745_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI745_MN16 (XI745_xn2 B_9_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI745_MN15 (pp4_22 XI745_xan XI745_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI745_MN13 (XI745_xn1 XI745_xn pp4_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI745_MN2 (VSS A_22_b3_1 XI745_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI745_MN4 (XI745_n2 A_21_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI745_MN3 (XI745_xn two4_b3_4 XI745_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI745_MN1 (XI745_n1 one4_b3_4 XI745_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI745_MN9 (VSS XI745_xn XI745_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI690_MN11 (VSS B_7_b3_3 XI690_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI690_MN14 (VSS XI690_xbn XI690_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI690_MN16 (XI690_xn2 B_7_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI690_MN15 (pp3_22 XI690_xan XI690_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI690_MN13 (XI690_xn1 XI690_xn pp3_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI690_MN2 (VSS A_22_b3_1 XI690_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI690_MN4 (XI690_n2 A_21_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI690_MN3 (XI690_xn two3_b3_4 XI690_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI690_MN1 (XI690_n1 one3_b3_4 XI690_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI690_MN9 (VSS XI690_xn XI690_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI587_MN11 (VSS B_3_b3_5 XI587_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI587_MN14 (VSS XI587_xbn XI587_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI587_MN16 (XI587_xn2 B_3_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI587_MN15 (pp1_29 XI587_xan XI587_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI587_MN13 (XI587_xn1 XI587_xn pp1_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI587_MN2 (VSS A_29_b3_0 XI587_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI587_MN4 (XI587_n2 A_28_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI587_MN3 (XI587_xn two1_b3_5 XI587_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI587_MN1 (XI587_n1 one1_b3_5 XI587_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI587_MN9 (VSS XI587_xn XI587_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI641_MN11 (VSS B_5_b3_4 XI641_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI641_MN14 (VSS XI641_xbn XI641_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI641_MN16 (XI641_xn2 B_5_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI641_MN15 (pp2_28 XI641_xan XI641_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI641_MN13 (XI641_xn1 XI641_xn pp2_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI641_MN2 (VSS A_28_b3_0 XI641_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI641_MN4 (XI641_n2 A_27_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI641_MN3 (XI641_xn two2_b3_5 XI641_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI641_MN1 (XI641_n1 one2_b3_5 XI641_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI641_MN9 (VSS XI641_xn XI641_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI534_MN11 (VSS B_1_b3_5 XI534_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI534_MN14 (VSS XI534_xbn XI534_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI534_MN16 (XI534_xn2 B_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI534_MN15 (pp0_31 XI534_xan XI534_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI534_MN13 (XI534_xn1 XI534_xn pp0_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI534_MN2 (VSS A_31_b3_0 XI534_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI534_MN4 (XI534_n2 A_30_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI534_MN3 (XI534_xn two0_b3_5 XI534_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI534_MN1 (XI534_n1 one0_b3_5 XI534_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI534_MN9 (VSS XI534_xn XI534_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI958_MN11 (VSS B_17_b3_2 XI958_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI958_MN14 (VSS XI958_xbn XI958_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI958_MN16 (XI958_xn2 B_17_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI958_MN15 (pp8_15 XI958_xan XI958_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI958_MN13 (XI958_xn1 XI958_xn pp8_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI958_MN2 (VSS A_15_b3_3 XI958_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI958_MN4 (XI958_n2 A_14_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI958_MN3 (XI958_xn two8_b3_2 XI958_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI958_MN1 (XI958_n1 one8_b3_2 XI958_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI958_MN9 (VSS XI958_xn XI958_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI959_MN11 (VSS B_17_b3_2 XI959_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI959_MN14 (VSS XI959_xbn XI959_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI959_MN16 (XI959_xn2 B_17_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI959_MN15 (pp8_16 XI959_xan XI959_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI959_MN13 (XI959_xn1 XI959_xn pp8_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI959_MN2 (VSS A_16_b3_3 XI959_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI959_MN4 (XI959_n2 A_15_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI959_MN3 (XI959_xn two8_b3_2 XI959_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI959_MN1 (XI959_n1 one8_b3_2 XI959_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI959_MN9 (VSS XI959_xn XI959_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1064_MN11 (VSS B_21_b3_2 XI1064_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1064_MN14 (VSS XI1064_xbn XI1064_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1064_MN16 (XI1064_xn2 B_21_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1064_MN15 (pp10_11 XI1064_xan XI1064_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1064_MN13 (XI1064_xn1 XI1064_xn pp10_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1064_MN2 (VSS A_11_b3_3 XI1064_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1064_MN4 (XI1064_n2 A_10_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1064_MN3 (XI1064_xn two10_b3_2 XI1064_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1064_MN1 (XI1064_n1 one10_b3_2 XI1064_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1064_MN9 (VSS XI1064_xn XI1064_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1117_MN11 (VSS B_23_b3_1 XI1117_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1117_MN14 (VSS XI1117_xbn XI1117_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1117_MN16 (XI1117_xn2 B_23_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1117_MN15 (pp11_9 XI1117_xan XI1117_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1117_MN13 (XI1117_xn1 XI1117_xn pp11_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1117_MN2 (VSS A_9_b3_4 XI1117_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1117_MN4 (XI1117_n2 A_8_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1117_MN3 (XI1117_xn two11_b3_1 XI1117_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1117_MN1 (XI1117_n1 one11_b3_1 XI1117_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1117_MN9 (VSS XI1117_xn XI1117_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1065_MN11 (VSS B_21_b3_2 XI1065_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1065_MN14 (VSS XI1065_xbn XI1065_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1065_MN16 (XI1065_xn2 B_21_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1065_MN15 (pp10_12 XI1065_xan XI1065_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1065_MN13 (XI1065_xn1 XI1065_xn pp10_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1065_MN2 (VSS A_12_b3_3 XI1065_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1065_MN4 (XI1065_n2 A_11_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1065_MN3 (XI1065_xn two10_b3_2 XI1065_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1065_MN1 (XI1065_n1 one10_b3_2 XI1065_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1065_MN9 (VSS XI1065_xn XI1065_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1118_MN11 (VSS B_23_b3_1 XI1118_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1118_MN14 (VSS XI1118_xbn XI1118_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1118_MN16 (XI1118_xn2 B_23_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1118_MN15 (pp11_10 XI1118_xan XI1118_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1118_MN13 (XI1118_xn1 XI1118_xn pp11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1118_MN2 (VSS A_10_b3_4 XI1118_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1118_MN4 (XI1118_n2 A_9_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1118_MN3 (XI1118_xn two11_b3_1 XI1118_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1118_MN1 (XI1118_n1 one11_b3_1 XI1118_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1118_MN9 (VSS XI1118_xn XI1118_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1172_MN11 (VSS B_25_b3_1 XI1172_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1172_MN14 (VSS XI1172_xbn XI1172_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1172_MN16 (XI1172_xn2 B_25_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1172_MN15 (pp12_9 XI1172_xan XI1172_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1172_MN13 (XI1172_xn1 XI1172_xn pp12_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1172_MN2 (VSS A_9_b3_4 XI1172_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1172_MN4 (XI1172_n2 A_8_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1172_MN3 (XI1172_xn two12_b3_1 XI1172_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1172_MN1 (XI1172_n1 one12_b3_1 XI1172_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1172_MN9 (VSS XI1172_xn XI1172_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1173_MN11 (VSS B_25_b3_1 XI1173_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1173_MN14 (VSS XI1173_xbn XI1173_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1173_MN16 (XI1173_xn2 B_25_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1173_MN15 (pp12_10 XI1173_xan XI1173_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1173_MN13 (XI1173_xn1 XI1173_xn pp12_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1173_MN2 (VSS A_10_b3_4 XI1173_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1173_MN4 (XI1173_n2 A_9_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1173_MN3 (XI1173_xn two12_b3_1 XI1173_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1173_MN1 (XI1173_n1 one12_b3_1 XI1173_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1173_MN9 (VSS XI1173_xn XI1173_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1224_MN11 (VSS B_27_b3_1 XI1224_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1224_MN14 (VSS XI1224_xbn XI1224_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1224_MN16 (XI1224_xn2 B_27_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1224_MN15 (pp13_6 XI1224_xan XI1224_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1224_MN13 (XI1224_xn1 XI1224_xn pp13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1224_MN2 (VSS A_6_b3_4 XI1224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1224_MN4 (XI1224_n2 A_5_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1224_MN3 (XI1224_xn two13_b3_1 XI1224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1224_MN1 (XI1224_n1 one13_b3_1 XI1224_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1224_MN9 (VSS XI1224_xn XI1224_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1277_MN11 (VSS B_29_b3_0 XI1277_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1277_MN14 (VSS XI1277_xbn XI1277_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1277_MN16 (XI1277_xn2 B_29_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1277_MN15 (pp14_4 XI1277_xan XI1277_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1277_MN13 (XI1277_xn1 XI1277_xn pp14_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1277_MN2 (VSS A_4_b3_5 XI1277_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1277_MN4 (XI1277_n2 A_3_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1277_MN3 (XI1277_xn two14_b3_0 XI1277_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1277_MN1 (XI1277_n1 one14_b3_0 XI1277_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1277_MN9 (VSS XI1277_xn XI1277_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1331_MN11 (VSS B_31_b3_0 XI1331_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1331_MN14 (VSS XI1331_xbn XI1331_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1331_MN16 (XI1331_xn2 B_31_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1331_MN15 (pp15_3 XI1331_xan XI1331_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1331_MN13 (XI1331_xn1 XI1331_xn pp15_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1331_MN2 (VSS A_3_b3_5 XI1331_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1331_MN4 (XI1331_n2 A_2_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1331_MN3 (XI1331_xn two15_b3_0 XI1331_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1331_MN1 (XI1331_n1 one15_b3_0 XI1331_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1331_MN9 (VSS XI1331_xn XI1331_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1303_MN11 (VSS B_29_b3_5 XI1303_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1303_MN14 (VSS XI1303_xbn XI1303_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1303_MN16 (XI1303_xn2 B_29_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1303_MN15 (pp14_30 XI1303_xan XI1303_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1303_MN13 (XI1303_xn1 XI1303_xn pp14_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1303_MN2 (VSS A_30_b3_5 XI1303_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1303_MN4 (XI1303_n2 A_29_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1303_MN3 (XI1303_xn two14_b3_5 XI1303_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1303_MN1 (XI1303_n1 one14_b3_5 XI1303_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1303_MN9 (VSS XI1303_xn XI1303_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1302_MN11 (VSS B_29_b3_5 XI1302_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1302_MN14 (VSS XI1302_xbn XI1302_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1302_MN16 (XI1302_xn2 B_29_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1302_MN15 (pp14_29 XI1302_xan XI1302_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1302_MN13 (XI1302_xn1 XI1302_xn pp14_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1302_MN2 (VSS A_29_b3_5 XI1302_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1302_MN4 (XI1302_n2 A_28_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1302_MN3 (XI1302_xn two14_b3_5 XI1302_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1302_MN1 (XI1302_n1 one14_b3_5 XI1302_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1302_MN9 (VSS XI1302_xn XI1302_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1249_MN11 (VSS B_27_b3_5 XI1249_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1249_MN14 (VSS XI1249_xbn XI1249_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1249_MN16 (XI1249_xn2 B_27_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1249_MN15 (pp13_31 XI1249_xan XI1249_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1249_MN13 (XI1249_xn1 XI1249_xn pp13_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1249_MN2 (VSS A_31_b3_6 XI1249_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1249_MN4 (XI1249_n2 A_30_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1249_MN3 (XI1249_xn two13_b3_5 XI1249_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1249_MN1 (XI1249_n1 one13_b3_5 XI1249_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1249_MN9 (VSS XI1249_xn XI1249_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1250_MN11 (VSS B_27_b3_5 XI1250_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1250_MN14 (VSS XI1250_xbn XI1250_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1250_MN16 (XI1250_xn2 B_27_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1250_MN15 (pp13_32 XI1250_xan XI1250_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1250_MN13 (XI1250_xn1 XI1250_xn pp13_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1250_MN2 (VSS A_31_b3_6 XI1250_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1250_MN4 (XI1250_n2 A_31_b3_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1250_MN3 (XI1250_xn two13_b3_5 XI1250_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1250_MN1 (XI1250_n1 one13_b3_5 XI1250_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1250_MN9 (VSS XI1250_xn XI1250_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI850_MN11 (VSS B_13_b3_3 XI850_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI850_MN14 (VSS XI850_xbn XI850_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI850_MN16 (XI850_xn2 B_13_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI850_MN15 (pp6_17 XI850_xan XI850_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI850_MN13 (XI850_xn1 XI850_xn pp6_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI850_MN2 (VSS A_17_b3_2 XI850_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI850_MN4 (XI850_n2 A_16_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI850_MN3 (XI850_xn two6_b3_3 XI850_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI850_MN1 (XI850_n1 one6_b3_3 XI850_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI850_MN9 (VSS XI850_xn XI850_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI851_MN11 (VSS B_13_b3_3 XI851_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI851_MN14 (VSS XI851_xbn XI851_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI851_MN16 (XI851_xn2 B_13_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI851_MN15 (pp6_18 XI851_xan XI851_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI851_MN13 (XI851_xn1 XI851_xn pp6_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI851_MN2 (VSS A_18_b3_2 XI851_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI851_MN4 (XI851_n2 A_17_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI851_MN3 (XI851_xn two6_b3_3 XI851_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI851_MN1 (XI851_n1 one6_b3_3 XI851_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI851_MN9 (VSS XI851_xn XI851_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI799_MN11 (VSS B_11_b3_3 XI799_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI799_MN14 (VSS XI799_xbn XI799_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI799_MN16 (XI799_xn2 B_11_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI799_MN15 (pp5_21 XI799_xan XI799_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI799_MN13 (XI799_xn1 XI799_xn pp5_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI799_MN2 (VSS A_21_b3_1 XI799_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI799_MN4 (XI799_n2 A_20_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI799_MN3 (XI799_xn two5_b3_3 XI799_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI799_MN1 (XI799_n1 one5_b3_3 XI799_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI799_MN9 (VSS XI799_xn XI799_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI640_MN11 (VSS B_5_b3_4 XI640_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI640_MN14 (VSS XI640_xbn XI640_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI640_MN16 (XI640_xn2 B_5_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI640_MN15 (pp2_27 XI640_xan XI640_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI640_MN13 (XI640_xn1 XI640_xn pp2_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI640_MN2 (VSS A_27_b3_0 XI640_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI640_MN4 (XI640_n2 A_26_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI640_MN3 (XI640_xn two2_b3_4 XI640_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI640_MN1 (XI640_n1 one2_b3_4 XI640_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI640_MN9 (VSS XI640_xn XI640_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI533_MN11 (VSS B_1_b3_5 XI533_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI533_MN14 (VSS XI533_xbn XI533_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI533_MN16 (XI533_xn2 B_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI533_MN15 (pp0_30 XI533_xan XI533_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI533_MN13 (XI533_xn1 XI533_xn pp0_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI533_MN2 (VSS A_30_b3_0 XI533_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI533_MN4 (XI533_n2 A_29_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI533_MN3 (XI533_xn two0_b3_5 XI533_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI533_MN1 (XI533_n1 one0_b3_5 XI533_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI533_MN9 (VSS XI533_xn XI533_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1011_MN11 (VSS B_19_b3_2 XI1011_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1011_MN14 (VSS XI1011_xbn XI1011_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1011_MN16 (XI1011_xn2 B_19_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1011_MN15 (pp9_13 XI1011_xan XI1011_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1011_MN13 (XI1011_xn1 XI1011_xn pp9_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1011_MN2 (VSS A_13_b3_3 XI1011_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1011_MN4 (XI1011_n2 A_12_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1011_MN3 (XI1011_xn two9_b3_2 XI1011_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1011_MN1 (XI1011_n1 one9_b3_2 XI1011_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1011_MN9 (VSS XI1011_xn XI1011_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1009_MN11 (VSS B_19_b3_2 XI1009_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1009_MN14 (VSS XI1009_xbn XI1009_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1009_MN16 (XI1009_xn2 B_19_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1009_MN15 (pp9_11 XI1009_xan XI1009_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1009_MN13 (XI1009_xn1 XI1009_xn pp9_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1009_MN2 (VSS A_11_b3_3 XI1009_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1009_MN4 (XI1009_n2 A_10_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1009_MN3 (XI1009_xn two9_b3_2 XI1009_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1009_MN1 (XI1009_n1 one9_b3_2 XI1009_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1009_MN9 (VSS XI1009_xn XI1009_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1171_MN11 (VSS B_25_b3_1 XI1171_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1171_MN14 (VSS XI1171_xbn XI1171_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1171_MN16 (XI1171_xn2 B_25_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1171_MN15 (pp12_8 XI1171_xan XI1171_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1171_MN13 (XI1171_xn1 XI1171_xn pp12_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1171_MN2 (VSS A_8_b3_4 XI1171_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1171_MN4 (XI1171_n2 A_7_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1171_MN3 (XI1171_xn two12_b3_1 XI1171_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1171_MN1 (XI1171_n1 one12_b3_1 XI1171_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1171_MN9 (VSS XI1171_xn XI1171_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1330_MN11 (VSS B_31_b3_0 XI1330_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1330_MN14 (VSS XI1330_xbn XI1330_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1330_MN16 (XI1330_xn2 B_31_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1330_MN15 (pp15_2 XI1330_xan XI1330_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1330_MN13 (XI1330_xn1 XI1330_xn pp15_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1330_MN2 (VSS A_2_b3_5 XI1330_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1330_MN4 (XI1330_n2 A_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1330_MN3 (XI1330_xn two15_b3_0 XI1330_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1330_MN1 (XI1330_n1 one15_b3_0 XI1330_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1330_MN9 (VSS XI1330_xn XI1330_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1329_MN11 (VSS B_31_b3_0 XI1329_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1329_MN14 (VSS XI1329_xbn XI1329_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1329_MN16 (XI1329_xn2 B_31_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1329_MN15 (pp15_1 XI1329_xan XI1329_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1329_MN13 (XI1329_xn1 XI1329_xn pp15_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1329_MN2 (VSS A_1_b3_5 XI1329_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1329_MN4 (XI1329_n2 A_0_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1329_MN3 (XI1329_xn two15_b3_0 XI1329_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1329_MN1 (XI1329_n1 one15_b3_0 XI1329_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1329_MN9 (VSS XI1329_xn XI1329_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1305_MN11 (VSS B_29_b3_5 XI1305_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1305_MN14 (VSS XI1305_xbn XI1305_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1305_MN16 (XI1305_xn2 B_29_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1305_MN15 (pp14_32 XI1305_xan XI1305_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1305_MN13 (XI1305_xn1 XI1305_xn pp14_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1305_MN2 (VSS A_31_b3_7 XI1305_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1305_MN4 (XI1305_n2 A_31_b3_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1305_MN3 (XI1305_xn two14_b3_5 XI1305_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1305_MN1 (XI1305_n1 one14_b3_5 XI1305_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1305_MN9 (VSS XI1305_xn XI1305_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1304_MN11 (VSS B_29_b3_5 XI1304_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1304_MN14 (VSS XI1304_xbn XI1304_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1304_MN16 (XI1304_xn2 B_29_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1304_MN15 (pp14_31 XI1304_xan XI1304_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1304_MN13 (XI1304_xn1 XI1304_xn pp14_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1304_MN2 (VSS A_31_b3_7 XI1304_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1304_MN4 (XI1304_n2 A_30_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1304_MN3 (XI1304_xn two14_b3_5 XI1304_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1304_MN1 (XI1304_n1 one14_b3_5 XI1304_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1304_MN9 (VSS XI1304_xn XI1304_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI796_MN11 (VSS B_11_b3_3 XI796_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI796_MN14 (VSS XI796_xbn XI796_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI796_MN16 (XI796_xn2 B_11_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI796_MN15 (pp5_18 XI796_xan XI796_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI796_MN13 (XI796_xn1 XI796_xn pp5_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI796_MN2 (VSS A_18_b3_1 XI796_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI796_MN4 (XI796_n2 A_17_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI796_MN3 (XI796_xn two5_b3_3 XI796_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI796_MN1 (XI796_n1 one5_b3_3 XI796_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI796_MN9 (VSS XI796_xn XI796_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI798_MN11 (VSS B_11_b3_3 XI798_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI798_MN14 (VSS XI798_xbn XI798_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI798_MN16 (XI798_xn2 B_11_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI798_MN15 (pp5_20 XI798_xan XI798_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI798_MN13 (XI798_xn1 XI798_xn pp5_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI798_MN2 (VSS A_20_b3_1 XI798_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI798_MN4 (XI798_n2 A_19_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI798_MN3 (XI798_xn two5_b3_3 XI798_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI798_MN1 (XI798_n1 one5_b3_3 XI798_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI798_MN9 (VSS XI798_xn XI798_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI639_MN11 (VSS B_5_b3_4 XI639_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI639_MN14 (VSS XI639_xbn XI639_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI639_MN16 (XI639_xn2 B_5_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI639_MN15 (pp2_26 XI639_xan XI639_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI639_MN13 (XI639_xn1 XI639_xn pp2_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI639_MN2 (VSS A_26_b3_0 XI639_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI639_MN4 (XI639_n2 A_25_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI639_MN3 (XI639_xn two2_b3_4 XI639_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI639_MN1 (XI639_n1 one2_b3_4 XI639_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI639_MN9 (VSS XI639_xn XI639_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI532_MN11 (VSS B_1_b3_5 XI532_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI532_MN14 (VSS XI532_xbn XI532_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI532_MN16 (XI532_xn2 B_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI532_MN15 (pp0_29 XI532_xan XI532_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI532_MN13 (XI532_xn1 XI532_xn pp0_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI532_MN2 (VSS A_29_b3_0 XI532_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI532_MN4 (XI532_n2 A_28_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI532_MN3 (XI532_xn two0_b3_5 XI532_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI532_MN1 (XI532_n1 one0_b3_5 XI532_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI532_MN9 (VSS XI532_xn XI532_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI957_MN11 (VSS B_17_b3_2 XI957_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI957_MN14 (VSS XI957_xbn XI957_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI957_MN16 (XI957_xn2 B_17_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI957_MN15 (pp8_14 XI957_xan XI957_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI957_MN13 (XI957_xn1 XI957_xn pp8_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI957_MN2 (VSS A_14_b3_3 XI957_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI957_MN4 (XI957_n2 A_13_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI957_MN3 (XI957_xn two8_b3_2 XI957_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI957_MN1 (XI957_n1 one8_b3_2 XI957_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI957_MN9 (VSS XI957_xn XI957_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1116_MN11 (VSS B_23_b3_1 XI1116_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1116_MN14 (VSS XI1116_xbn XI1116_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1116_MN16 (XI1116_xn2 B_23_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1116_MN15 (pp11_8 XI1116_xan XI1116_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1116_MN13 (XI1116_xn1 XI1116_xn pp11_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1116_MN2 (VSS A_8_b3_4 XI1116_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1116_MN4 (XI1116_n2 A_7_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1116_MN3 (XI1116_xn two11_b3_1 XI1116_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1116_MN1 (XI1116_n1 one11_b3_1 XI1116_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1116_MN9 (VSS XI1116_xn XI1116_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1010_MN11 (VSS B_19_b3_2 XI1010_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1010_MN14 (VSS XI1010_xbn XI1010_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1010_MN16 (XI1010_xn2 B_19_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1010_MN15 (pp9_12 XI1010_xan XI1010_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1010_MN13 (XI1010_xn1 XI1010_xn pp9_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1010_MN2 (VSS A_12_b3_3 XI1010_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1010_MN4 (XI1010_n2 A_11_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1010_MN3 (XI1010_xn two9_b3_2 XI1010_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1010_MN1 (XI1010_n1 one9_b3_2 XI1010_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1010_MN9 (VSS XI1010_xn XI1010_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1170_MN11 (VSS B_25_b3_1 XI1170_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1170_MN14 (VSS XI1170_xbn XI1170_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1170_MN16 (XI1170_xn2 B_25_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1170_MN15 (pp12_7 XI1170_xan XI1170_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1170_MN13 (XI1170_xn1 XI1170_xn pp12_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1170_MN2 (VSS A_7_b3_4 XI1170_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1170_MN4 (XI1170_n2 A_6_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1170_MN3 (XI1170_xn two12_b3_1 XI1170_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1170_MN1 (XI1170_n1 one12_b3_1 XI1170_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1170_MN9 (VSS XI1170_xn XI1170_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1223_MN11 (VSS B_27_b3_1 XI1223_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1223_MN14 (VSS XI1223_xbn XI1223_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1223_MN16 (XI1223_xn2 B_27_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1223_MN15 (pp13_5 XI1223_xan XI1223_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1223_MN13 (XI1223_xn1 XI1223_xn pp13_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1223_MN2 (VSS A_5_b3_4 XI1223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1223_MN4 (XI1223_n2 A_4_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1223_MN3 (XI1223_xn two13_b3_0 XI1223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1223_MN1 (XI1223_n1 one13_b3_0 XI1223_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1223_MN9 (VSS XI1223_xn XI1223_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1328_MN11 (VSS B_31_b3_0 XI1328_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1328_MN14 (VSS XI1328_xbn XI1328_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1328_MN16 (XI1328_xn2 B_31_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1328_MN15 (pp15_0 XI1328_xan XI1328_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1328_MN13 (XI1328_xn1 XI1328_xn pp15_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1328_MN2 (VSS A_0_b3_5 XI1328_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1328_MN4 (XI1328_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1328_MN3 (XI1328_xn two15_b3_0 XI1328_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1328_MN1 (XI1328_n1 one15_b3_0 XI1328_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1328_MN9 (VSS XI1328_xn XI1328_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1358_MN11 (VSS B_31_b3_5 XI1358_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1358_MN14 (VSS XI1358_xbn XI1358_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1358_MN16 (XI1358_xn2 B_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1358_MN15 (pp15_30 XI1358_xan XI1358_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1358_MN13 (XI1358_xn1 XI1358_xn pp15_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1358_MN2 (VSS A_30_b3_5 XI1358_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1358_MN4 (XI1358_n2 A_29_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1358_MN3 (XI1358_xn two15_b3_5 XI1358_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1358_MN1 (XI1358_n1 one15_b3_5 XI1358_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1358_MN9 (VSS XI1358_xn XI1358_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1357_MN11 (VSS B_31_b3_5 XI1357_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1357_MN14 (VSS XI1357_xbn XI1357_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1357_MN16 (XI1357_xn2 B_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1357_MN15 (pp15_29 XI1357_xan XI1357_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1357_MN13 (XI1357_xn1 XI1357_xn pp15_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1357_MN2 (VSS A_29_b3_5 XI1357_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1357_MN4 (XI1357_n2 A_28_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1357_MN3 (XI1357_xn two15_b3_5 XI1357_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1357_MN1 (XI1357_n1 one15_b3_5 XI1357_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1357_MN9 (VSS XI1357_xn XI1357_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI795_MN11 (VSS B_11_b3_3 XI795_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI795_MN14 (VSS XI795_xbn XI795_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI795_MN16 (XI795_xn2 B_11_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI795_MN15 (pp5_17 XI795_xan XI795_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI795_MN13 (XI795_xn1 XI795_xn pp5_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI795_MN2 (VSS A_17_b3_1 XI795_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI795_MN4 (XI795_n2 A_16_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI795_MN3 (XI795_xn two5_b3_3 XI795_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI795_MN1 (XI795_n1 one5_b3_3 XI795_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI795_MN9 (VSS XI795_xn XI795_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI797_MN11 (VSS B_11_b3_3 XI797_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI797_MN14 (VSS XI797_xbn XI797_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI797_MN16 (XI797_xn2 B_11_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI797_MN15 (pp5_19 XI797_xan XI797_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI797_MN13 (XI797_xn1 XI797_xn pp5_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI797_MN2 (VSS A_19_b3_1 XI797_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI797_MN4 (XI797_n2 A_18_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI797_MN3 (XI797_xn two5_b3_3 XI797_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI797_MN1 (XI797_n1 one5_b3_3 XI797_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI797_MN9 (VSS XI797_xn XI797_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI586_MN11 (VSS B_3_b3_4 XI586_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI586_MN14 (VSS XI586_xbn XI586_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI586_MN16 (XI586_xn2 B_3_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI586_MN15 (pp1_28 XI586_xan XI586_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI586_MN13 (XI586_xn1 XI586_xn pp1_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI586_MN2 (VSS A_28_b3_0 XI586_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI586_MN4 (XI586_n2 A_27_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI586_MN3 (XI586_xn two1_b3_5 XI586_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI586_MN1 (XI586_n1 one1_b3_5 XI586_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI586_MN9 (VSS XI586_xn XI586_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI638_MN11 (VSS B_5_b3_4 XI638_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI638_MN14 (VSS XI638_xbn XI638_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI638_MN16 (XI638_xn2 B_5_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI638_MN15 (pp2_25 XI638_xan XI638_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI638_MN13 (XI638_xn1 XI638_xn pp2_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI638_MN2 (VSS A_25_b3_0 XI638_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI638_MN4 (XI638_n2 A_24_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI638_MN3 (XI638_xn two2_b3_4 XI638_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI638_MN1 (XI638_n1 one2_b3_4 XI638_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI638_MN9 (VSS XI638_xn XI638_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI956_MN11 (VSS B_17_b3_2 XI956_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI956_MN14 (VSS XI956_xbn XI956_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI956_MN16 (XI956_xn2 B_17_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI956_MN15 (pp8_13 XI956_xan XI956_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI956_MN13 (XI956_xn1 XI956_xn pp8_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI956_MN2 (VSS A_13_b3_3 XI956_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI956_MN4 (XI956_n2 A_12_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI956_MN3 (XI956_xn two8_b3_2 XI956_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI956_MN1 (XI956_n1 one8_b3_2 XI956_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI956_MN9 (VSS XI956_xn XI956_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI955_MN11 (VSS B_17_b3_2 XI955_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI955_MN14 (VSS XI955_xbn XI955_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI955_MN16 (XI955_xn2 B_17_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI955_MN15 (pp8_12 XI955_xan XI955_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI955_MN13 (XI955_xn1 XI955_xn pp8_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI955_MN2 (VSS A_12_b3_3 XI955_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI955_MN4 (XI955_n2 A_11_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI955_MN3 (XI955_xn two8_b3_2 XI955_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI955_MN1 (XI955_n1 one8_b3_2 XI955_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI955_MN9 (VSS XI955_xn XI955_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1115_MN11 (VSS B_23_b3_1 XI1115_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1115_MN14 (VSS XI1115_xbn XI1115_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1115_MN16 (XI1115_xn2 B_23_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1115_MN15 (pp11_7 XI1115_xan XI1115_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1115_MN13 (XI1115_xn1 XI1115_xn pp11_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1115_MN2 (VSS A_7_b3_4 XI1115_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1115_MN4 (XI1115_n2 A_6_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1115_MN3 (XI1115_xn two11_b3_1 XI1115_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1115_MN1 (XI1115_n1 one11_b3_1 XI1115_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1115_MN9 (VSS XI1115_xn XI1115_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1114_MN11 (VSS B_23_b3_1 XI1114_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1114_MN14 (VSS XI1114_xbn XI1114_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1114_MN16 (XI1114_xn2 B_23_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1114_MN15 (pp11_6 XI1114_xan XI1114_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1114_MN13 (XI1114_xn1 XI1114_xn pp11_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1114_MN2 (VSS A_6_b3_4 XI1114_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1114_MN4 (XI1114_n2 A_5_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1114_MN3 (XI1114_xn two11_b3_1 XI1114_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1114_MN1 (XI1114_n1 one11_b3_1 XI1114_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1114_MN9 (VSS XI1114_xn XI1114_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1169_MN11 (VSS B_25_b3_1 XI1169_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1169_MN14 (VSS XI1169_xbn XI1169_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1169_MN16 (XI1169_xn2 B_25_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1169_MN15 (pp12_6 XI1169_xan XI1169_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1169_MN13 (XI1169_xn1 XI1169_xn pp12_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1169_MN2 (VSS A_6_b3_4 XI1169_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1169_MN4 (XI1169_n2 A_5_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1169_MN3 (XI1169_xn two12_b3_1 XI1169_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1169_MN1 (XI1169_n1 one12_b3_1 XI1169_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1169_MN9 (VSS XI1169_xn XI1169_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1276_MN11 (VSS B_29_b3_0 XI1276_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1276_MN14 (VSS XI1276_xbn XI1276_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1276_MN16 (XI1276_xn2 B_29_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1276_MN15 (pp14_3 XI1276_xan XI1276_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1276_MN13 (XI1276_xn1 XI1276_xn pp14_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1276_MN2 (VSS A_3_b3_5 XI1276_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1276_MN4 (XI1276_n2 A_2_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1276_MN3 (XI1276_xn two14_b3_0 XI1276_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1276_MN1 (XI1276_n1 one14_b3_0 XI1276_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1276_MN9 (VSS XI1276_xn XI1276_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1275_MN11 (VSS B_29_b3_0 XI1275_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1275_MN14 (VSS XI1275_xbn XI1275_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1275_MN16 (XI1275_xn2 B_29_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1275_MN15 (pp14_2 XI1275_xan XI1275_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1275_MN13 (XI1275_xn1 XI1275_xn pp14_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1275_MN2 (VSS A_2_b3_5 XI1275_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1275_MN4 (XI1275_n2 A_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1275_MN3 (XI1275_xn two14_b3_0 XI1275_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1275_MN1 (XI1275_n1 one14_b3_0 XI1275_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1275_MN9 (VSS XI1275_xn XI1275_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1360_MN11 (VSS B_31_b3_5 XI1360_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1360_MN14 (VSS XI1360_xbn XI1360_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1360_MN16 (XI1360_xn2 B_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1360_MN15 (pp15_32 XI1360_xan XI1360_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1360_MN13 (XI1360_xn1 XI1360_xn pp15_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1360_MN2 (VSS A_31_b3_7 XI1360_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1360_MN4 (XI1360_n2 A_31_b3_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1360_MN3 (XI1360_xn two15_b3_5 XI1360_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1360_MN1 (XI1360_n1 one15_b3_5 XI1360_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1360_MN9 (VSS XI1360_xn XI1360_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1359_MN11 (VSS B_31_b3_5 XI1359_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1359_MN14 (VSS XI1359_xbn XI1359_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1359_MN16 (XI1359_xn2 B_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1359_MN15 (pp15_31 XI1359_xan XI1359_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1359_MN13 (XI1359_xn1 XI1359_xn pp15_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1359_MN2 (VSS A_31_b3_7 XI1359_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1359_MN4 (XI1359_n2 A_30_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1359_MN3 (XI1359_xn two15_b3_5 XI1359_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1359_MN1 (XI1359_n1 one15_b3_5 XI1359_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1359_MN9 (VSS XI1359_xn XI1359_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI744_MN11 (VSS B_9_b3_3 XI744_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI744_MN14 (VSS XI744_xbn XI744_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI744_MN16 (XI744_xn2 B_9_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI744_MN15 (pp4_21 XI744_xan XI744_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI744_MN13 (XI744_xn1 XI744_xn pp4_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI744_MN2 (VSS A_21_b3_1 XI744_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI744_MN4 (XI744_n2 A_20_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI744_MN3 (XI744_xn two4_b3_3 XI744_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI744_MN1 (XI744_n1 one4_b3_3 XI744_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI744_MN9 (VSS XI744_xn XI744_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI688_MN11 (VSS B_7_b3_3 XI688_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI688_MN14 (VSS XI688_xbn XI688_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI688_MN16 (XI688_xn2 B_7_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI688_MN15 (pp3_20 XI688_xan XI688_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI688_MN13 (XI688_xn1 XI688_xn pp3_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI688_MN2 (VSS A_20_b3_1 XI688_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI688_MN4 (XI688_n2 A_19_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI688_MN3 (XI688_xn two3_b3_3 XI688_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI688_MN1 (XI688_n1 one3_b3_3 XI688_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI688_MN9 (VSS XI688_xn XI688_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI689_MN11 (VSS B_7_b3_3 XI689_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI689_MN14 (VSS XI689_xbn XI689_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI689_MN16 (XI689_xn2 B_7_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI689_MN15 (pp3_21 XI689_xan XI689_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI689_MN13 (XI689_xn1 XI689_xn pp3_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI689_MN2 (VSS A_21_b3_1 XI689_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI689_MN4 (XI689_n2 A_20_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI689_MN3 (XI689_xn two3_b3_3 XI689_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI689_MN1 (XI689_n1 one3_b3_3 XI689_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI689_MN9 (VSS XI689_xn XI689_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI637_MN11 (VSS B_5_b3_4 XI637_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI637_MN14 (VSS XI637_xbn XI637_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI637_MN16 (XI637_xn2 B_5_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI637_MN15 (pp2_24 XI637_xan XI637_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI637_MN13 (XI637_xn1 XI637_xn pp2_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI637_MN2 (VSS A_24_b3_0 XI637_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI637_MN4 (XI637_n2 A_23_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI637_MN3 (XI637_xn two2_b3_4 XI637_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI637_MN1 (XI637_n1 one2_b3_4 XI637_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI637_MN9 (VSS XI637_xn XI637_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI636_MN11 (VSS B_5_b3_4 XI636_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI636_MN14 (VSS XI636_xbn XI636_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI636_MN16 (XI636_xn2 B_5_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI636_MN15 (pp2_23 XI636_xan XI636_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI636_MN13 (XI636_xn1 XI636_xn pp2_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI636_MN2 (VSS A_23_b3_0 XI636_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI636_MN4 (XI636_n2 A_22_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI636_MN3 (XI636_xn two2_b3_4 XI636_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI636_MN1 (XI636_n1 one2_b3_4 XI636_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI636_MN9 (VSS XI636_xn XI636_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI531_MN11 (VSS B_1_b3_4 XI531_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI531_MN14 (VSS XI531_xbn XI531_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI531_MN16 (XI531_xn2 B_1_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI531_MN15 (pp0_28 XI531_xan XI531_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI531_MN13 (XI531_xn1 XI531_xn pp0_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI531_MN2 (VSS A_28_b3_0 XI531_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI531_MN4 (XI531_n2 A_27_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI531_MN3 (XI531_xn two0_b3_5 XI531_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI531_MN1 (XI531_n1 one0_b3_5 XI531_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI531_MN9 (VSS XI531_xn XI531_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI954_MN11 (VSS B_17_b3_2 XI954_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI954_MN14 (VSS XI954_xbn XI954_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI954_MN16 (XI954_xn2 B_17_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI954_MN15 (pp8_11 XI954_xan XI954_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI954_MN13 (XI954_xn1 XI954_xn pp8_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI954_MN2 (VSS A_11_b3_3 XI954_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI954_MN4 (XI954_n2 A_10_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI954_MN3 (XI954_xn two8_b3_2 XI954_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI954_MN1 (XI954_n1 one8_b3_2 XI954_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI954_MN9 (VSS XI954_xn XI954_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1063_MN11 (VSS B_21_b3_1 XI1063_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1063_MN14 (VSS XI1063_xbn XI1063_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1063_MN16 (XI1063_xn2 B_21_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1063_MN15 (pp10_10 XI1063_xan XI1063_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1063_MN13 (XI1063_xn1 XI1063_xn pp10_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1063_MN2 (VSS A_10_b3_3 XI1063_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1063_MN4 (XI1063_n2 A_9_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1063_MN3 (XI1063_xn two10_b3_1 XI1063_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1063_MN1 (XI1063_n1 one10_b3_1 XI1063_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1063_MN9 (VSS XI1063_xn XI1063_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1113_MN11 (VSS B_23_b3_1 XI1113_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1113_MN14 (VSS XI1113_xbn XI1113_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1113_MN16 (XI1113_xn2 B_23_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1113_MN15 (pp11_5 XI1113_xan XI1113_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1113_MN13 (XI1113_xn1 XI1113_xn pp11_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1113_MN2 (VSS A_5_b3_4 XI1113_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1113_MN4 (XI1113_n2 A_4_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1113_MN3 (XI1113_xn two11_b3_0 XI1113_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1113_MN1 (XI1113_n1 one11_b3_0 XI1113_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1113_MN9 (VSS XI1113_xn XI1113_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1222_MN11 (VSS B_27_b3_0 XI1222_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1222_MN14 (VSS XI1222_xbn XI1222_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1222_MN16 (XI1222_xn2 B_27_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1222_MN15 (pp13_4 XI1222_xan XI1222_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1222_MN13 (XI1222_xn1 XI1222_xn pp13_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1222_MN2 (VSS A_4_b3_4 XI1222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1222_MN4 (XI1222_n2 A_3_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1222_MN3 (XI1222_xn two13_b3_0 XI1222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1222_MN1 (XI1222_n1 one13_b3_0 XI1222_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1222_MN9 (VSS XI1222_xn XI1222_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1168_MN11 (VSS B_25_b3_1 XI1168_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1168_MN14 (VSS XI1168_xbn XI1168_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1168_MN16 (XI1168_xn2 B_25_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1168_MN15 (pp12_5 XI1168_xan XI1168_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1168_MN13 (XI1168_xn1 XI1168_xn pp12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1168_MN2 (VSS A_5_b3_4 XI1168_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1168_MN4 (XI1168_n2 A_4_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1168_MN3 (XI1168_xn two12_b3_0 XI1168_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1168_MN1 (XI1168_n1 one12_b3_0 XI1168_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1168_MN9 (VSS XI1168_xn XI1168_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1273_MN11 (VSS B_29_b3_0 XI1273_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1273_MN14 (VSS XI1273_xbn XI1273_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1273_MN16 (XI1273_xn2 B_29_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1273_MN15 (pp14_0 XI1273_xan XI1273_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1273_MN13 (XI1273_xn1 XI1273_xn pp14_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1273_MN2 (VSS A_0_b3_5 XI1273_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1273_MN4 (XI1273_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1273_MN3 (XI1273_xn two14_b3_0 XI1273_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1273_MN1 (XI1273_n1 one14_b3_0 XI1273_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1273_MN9 (VSS XI1273_xn XI1273_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1274_MN11 (VSS B_29_b3_0 XI1274_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1274_MN14 (VSS XI1274_xbn XI1274_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1274_MN16 (XI1274_xn2 B_29_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1274_MN15 (pp14_1 XI1274_xan XI1274_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1274_MN13 (XI1274_xn1 XI1274_xn pp14_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1274_MN2 (VSS A_1_b3_5 XI1274_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1274_MN4 (XI1274_n2 A_0_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1274_MN3 (XI1274_xn two14_b3_0 XI1274_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1274_MN1 (XI1274_n1 one14_b3_0 XI1274_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1274_MN9 (VSS XI1274_xn XI1274_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI742_MN11 (VSS B_9_b3_3 XI742_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI742_MN14 (VSS XI742_xbn XI742_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI742_MN16 (XI742_xn2 B_9_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI742_MN15 (pp4_19 XI742_xan XI742_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI742_MN13 (XI742_xn1 XI742_xn pp4_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI742_MN2 (VSS A_19_b3_1 XI742_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI742_MN4 (XI742_n2 A_18_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI742_MN3 (XI742_xn two4_b3_3 XI742_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI742_MN1 (XI742_n1 one4_b3_3 XI742_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI742_MN9 (VSS XI742_xn XI742_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI743_MN11 (VSS B_9_b3_3 XI743_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI743_MN14 (VSS XI743_xbn XI743_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI743_MN16 (XI743_xn2 B_9_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI743_MN15 (pp4_20 XI743_xan XI743_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI743_MN13 (XI743_xn1 XI743_xn pp4_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI743_MN2 (VSS A_20_b3_1 XI743_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI743_MN4 (XI743_n2 A_19_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI743_MN3 (XI743_xn two4_b3_3 XI743_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI743_MN1 (XI743_n1 one4_b3_3 XI743_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI743_MN9 (VSS XI743_xn XI743_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI687_MN11 (VSS B_7_b3_3 XI687_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI687_MN14 (VSS XI687_xbn XI687_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI687_MN16 (XI687_xn2 B_7_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI687_MN15 (pp3_19 XI687_xan XI687_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI687_MN13 (XI687_xn1 XI687_xn pp3_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI687_MN2 (VSS A_19_b3_1 XI687_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI687_MN4 (XI687_n2 A_18_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI687_MN3 (XI687_xn two3_b3_3 XI687_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI687_MN1 (XI687_n1 one3_b3_3 XI687_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI687_MN9 (VSS XI687_xn XI687_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI635_MN11 (VSS B_5_b3_3 XI635_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI635_MN14 (VSS XI635_xbn XI635_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI635_MN16 (XI635_xn2 B_5_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI635_MN15 (pp2_22 XI635_xan XI635_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI635_MN13 (XI635_xn1 XI635_xn pp2_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI635_MN2 (VSS A_22_b3_0 XI635_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI635_MN4 (XI635_n2 A_21_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI635_MN3 (XI635_xn two2_b3_4 XI635_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI635_MN1 (XI635_n1 one2_b3_4 XI635_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI635_MN9 (VSS XI635_xn XI635_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI584_MN11 (VSS B_3_b3_4 XI584_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI584_MN14 (VSS XI584_xbn XI584_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI584_MN16 (XI584_xn2 B_3_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI584_MN15 (pp1_26 XI584_xan XI584_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI584_MN13 (XI584_xn1 XI584_xn pp1_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI584_MN2 (VSS A_26_b3_0 XI584_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI584_MN4 (XI584_n2 A_25_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI584_MN3 (XI584_xn two1_b3_4 XI584_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI584_MN1 (XI584_n1 one1_b3_4 XI584_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI584_MN9 (VSS XI584_xn XI584_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI585_MN11 (VSS B_3_b3_4 XI585_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI585_MN14 (VSS XI585_xbn XI585_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI585_MN16 (XI585_xn2 B_3_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI585_MN15 (pp1_27 XI585_xan XI585_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI585_MN13 (XI585_xn1 XI585_xn pp1_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI585_MN2 (VSS A_27_b3_0 XI585_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI585_MN4 (XI585_n2 A_26_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI585_MN3 (XI585_xn two1_b3_4 XI585_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI585_MN1 (XI585_n1 one1_b3_4 XI585_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI585_MN9 (VSS XI585_xn XI585_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1062_MN11 (VSS B_21_b3_1 XI1062_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1062_MN14 (VSS XI1062_xbn XI1062_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1062_MN16 (XI1062_xn2 B_21_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1062_MN15 (pp10_9 XI1062_xan XI1062_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1062_MN13 (XI1062_xn1 XI1062_xn pp10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1062_MN2 (VSS A_9_b3_3 XI1062_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1062_MN4 (XI1062_n2 A_8_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1062_MN3 (XI1062_xn two10_b3_1 XI1062_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1062_MN1 (XI1062_n1 one10_b3_1 XI1062_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1062_MN9 (VSS XI1062_xn XI1062_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1061_MN11 (VSS B_21_b3_1 XI1061_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1061_MN14 (VSS XI1061_xbn XI1061_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1061_MN16 (XI1061_xn2 B_21_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1061_MN15 (pp10_8 XI1061_xan XI1061_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1061_MN13 (XI1061_xn1 XI1061_xn pp10_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1061_MN2 (VSS A_8_b3_3 XI1061_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1061_MN4 (XI1061_n2 A_7_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1061_MN3 (XI1061_xn two10_b3_1 XI1061_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1061_MN1 (XI1061_n1 one10_b3_1 XI1061_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1061_MN9 (VSS XI1061_xn XI1061_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1221_MN11 (VSS B_27_b3_0 XI1221_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1221_MN14 (VSS XI1221_xbn XI1221_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1221_MN16 (XI1221_xn2 B_27_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1221_MN15 (pp13_3 XI1221_xan XI1221_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1221_MN13 (XI1221_xn1 XI1221_xn pp13_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1221_MN2 (VSS A_3_b3_4 XI1221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1221_MN4 (XI1221_n2 A_2_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1221_MN3 (XI1221_xn two13_b3_0 XI1221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1221_MN1 (XI1221_n1 one13_b3_0 XI1221_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1221_MN9 (VSS XI1221_xn XI1221_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI904_MN11 (VSS B_15_b3_2 XI904_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI904_MN14 (VSS XI904_xbn XI904_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI904_MN16 (XI904_xn2 B_15_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI904_MN15 (pp7_16 XI904_xan XI904_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI904_MN13 (XI904_xn1 XI904_xn pp7_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI904_MN2 (VSS A_16_b3_2 XI904_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI904_MN4 (XI904_n2 A_15_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI904_MN3 (XI904_xn two7_b3_2 XI904_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI904_MN1 (XI904_n1 one7_b3_2 XI904_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI904_MN9 (VSS XI904_xn XI904_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI849_MN11 (VSS B_13_b3_2 XI849_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI849_MN14 (VSS XI849_xbn XI849_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI849_MN16 (XI849_xn2 B_13_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI849_MN15 (pp6_16 XI849_xan XI849_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI849_MN13 (XI849_xn1 XI849_xn pp6_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI849_MN2 (VSS A_16_b3_2 XI849_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI849_MN4 (XI849_n2 A_15_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI849_MN3 (XI849_xn two6_b3_2 XI849_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI849_MN1 (XI849_n1 one6_b3_2 XI849_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI849_MN9 (VSS XI849_xn XI849_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI741_MN11 (VSS B_9_b3_3 XI741_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI741_MN14 (VSS XI741_xbn XI741_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI741_MN16 (XI741_xn2 B_9_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI741_MN15 (pp4_18 XI741_xan XI741_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI741_MN13 (XI741_xn1 XI741_xn pp4_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI741_MN2 (VSS A_18_b3_1 XI741_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI741_MN4 (XI741_n2 A_17_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI741_MN3 (XI741_xn two4_b3_3 XI741_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI741_MN1 (XI741_n1 one4_b3_3 XI741_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI741_MN9 (VSS XI741_xn XI741_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI685_MN11 (VSS B_7_b3_3 XI685_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI685_MN14 (VSS XI685_xbn XI685_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI685_MN16 (XI685_xn2 B_7_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI685_MN15 (pp3_17 XI685_xan XI685_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI685_MN13 (XI685_xn1 XI685_xn pp3_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI685_MN2 (VSS A_17_b3_1 XI685_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI685_MN4 (XI685_n2 A_16_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI685_MN3 (XI685_xn two3_b3_3 XI685_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI685_MN1 (XI685_n1 one3_b3_3 XI685_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI685_MN9 (VSS XI685_xn XI685_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI686_MN11 (VSS B_7_b3_3 XI686_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI686_MN14 (VSS XI686_xbn XI686_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI686_MN16 (XI686_xn2 B_7_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI686_MN15 (pp3_18 XI686_xan XI686_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI686_MN13 (XI686_xn1 XI686_xn pp3_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI686_MN2 (VSS A_18_b3_1 XI686_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI686_MN4 (XI686_n2 A_17_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI686_MN3 (XI686_xn two3_b3_3 XI686_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI686_MN1 (XI686_n1 one3_b3_3 XI686_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI686_MN9 (VSS XI686_xn XI686_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI583_MN11 (VSS B_3_b3_4 XI583_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI583_MN14 (VSS XI583_xbn XI583_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI583_MN16 (XI583_xn2 B_3_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI583_MN15 (pp1_25 XI583_xan XI583_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI583_MN13 (XI583_xn1 XI583_xn pp1_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI583_MN2 (VSS A_25_b3_0 XI583_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI583_MN4 (XI583_n2 A_24_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI583_MN3 (XI583_xn two1_b3_4 XI583_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI583_MN1 (XI583_n1 one1_b3_4 XI583_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI583_MN9 (VSS XI583_xn XI583_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI530_MN11 (VSS B_1_b3_4 XI530_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI530_MN14 (VSS XI530_xbn XI530_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI530_MN16 (XI530_xn2 B_1_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI530_MN15 (pp0_27 XI530_xan XI530_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI530_MN13 (XI530_xn1 XI530_xn pp0_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI530_MN2 (VSS A_27_b3_0 XI530_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI530_MN4 (XI530_n2 A_26_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI530_MN3 (XI530_xn two0_b3_4 XI530_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI530_MN1 (XI530_n1 one0_b3_4 XI530_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI530_MN9 (VSS XI530_xn XI530_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1007_MN11 (VSS B_19_b3_1 XI1007_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1007_MN14 (VSS XI1007_xbn XI1007_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1007_MN16 (XI1007_xn2 B_19_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1007_MN15 (pp9_9 XI1007_xan XI1007_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1007_MN13 (XI1007_xn1 XI1007_xn pp9_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1007_MN2 (VSS A_9_b3_3 XI1007_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1007_MN4 (XI1007_n2 A_8_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1007_MN3 (XI1007_xn two9_b3_1 XI1007_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1007_MN1 (XI1007_n1 one9_b3_1 XI1007_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1007_MN9 (VSS XI1007_xn XI1007_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1008_MN11 (VSS B_19_b3_1 XI1008_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1008_MN14 (VSS XI1008_xbn XI1008_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1008_MN16 (XI1008_xn2 B_19_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1008_MN15 (pp9_10 XI1008_xan XI1008_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1008_MN13 (XI1008_xn1 XI1008_xn pp9_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1008_MN2 (VSS A_10_b3_3 XI1008_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1008_MN4 (XI1008_n2 A_9_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1008_MN3 (XI1008_xn two9_b3_1 XI1008_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1008_MN1 (XI1008_n1 one9_b3_1 XI1008_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1008_MN9 (VSS XI1008_xn XI1008_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1060_MN11 (VSS B_21_b3_1 XI1060_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1060_MN14 (VSS XI1060_xbn XI1060_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1060_MN16 (XI1060_xn2 B_21_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1060_MN15 (pp10_7 XI1060_xan XI1060_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1060_MN13 (XI1060_xn1 XI1060_xn pp10_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1060_MN2 (VSS A_7_b3_3 XI1060_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1060_MN4 (XI1060_n2 A_6_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1060_MN3 (XI1060_xn two10_b3_1 XI1060_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1060_MN1 (XI1060_n1 one10_b3_1 XI1060_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1060_MN9 (VSS XI1060_xn XI1060_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1219_MN11 (VSS B_27_b3_0 XI1219_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1219_MN14 (VSS XI1219_xbn XI1219_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1219_MN16 (XI1219_xn2 B_27_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1219_MN15 (pp13_1 XI1219_xan XI1219_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1219_MN13 (XI1219_xn1 XI1219_xn pp13_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1219_MN2 (VSS A_1_b3_4 XI1219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1219_MN4 (XI1219_n2 A_0_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1219_MN3 (XI1219_xn two13_b3_0 XI1219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1219_MN1 (XI1219_n1 one13_b3_0 XI1219_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1219_MN9 (VSS XI1219_xn XI1219_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1112_MN11 (VSS B_23_b3_0 XI1112_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1112_MN14 (VSS XI1112_xbn XI1112_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1112_MN16 (XI1112_xn2 B_23_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1112_MN15 (pp11_4 XI1112_xan XI1112_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1112_MN13 (XI1112_xn1 XI1112_xn pp11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1112_MN2 (VSS A_4_b3_4 XI1112_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1112_MN4 (XI1112_n2 A_3_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1112_MN3 (XI1112_xn two11_b3_0 XI1112_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1112_MN1 (XI1112_n1 one11_b3_0 XI1112_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1112_MN9 (VSS XI1112_xn XI1112_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1167_MN11 (VSS B_25_b3_0 XI1167_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1167_MN14 (VSS XI1167_xbn XI1167_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1167_MN16 (XI1167_xn2 B_25_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1167_MN15 (pp12_4 XI1167_xan XI1167_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1167_MN13 (XI1167_xn1 XI1167_xn pp12_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1167_MN2 (VSS A_4_b3_4 XI1167_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1167_MN4 (XI1167_n2 A_3_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1167_MN3 (XI1167_xn two12_b3_0 XI1167_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1167_MN1 (XI1167_n1 one12_b3_0 XI1167_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1167_MN9 (VSS XI1167_xn XI1167_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1220_MN11 (VSS B_27_b3_0 XI1220_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1220_MN14 (VSS XI1220_xbn XI1220_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1220_MN16 (XI1220_xn2 B_27_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1220_MN15 (pp13_2 XI1220_xan XI1220_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1220_MN13 (XI1220_xn1 XI1220_xn pp13_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1220_MN2 (VSS A_2_b3_4 XI1220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1220_MN4 (XI1220_n2 A_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1220_MN3 (XI1220_xn two13_b3_0 XI1220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1220_MN1 (XI1220_n1 one13_b3_0 XI1220_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1220_MN9 (VSS XI1220_xn XI1220_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI903_MN11 (VSS B_15_b3_2 XI903_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI903_MN14 (VSS XI903_xbn XI903_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI903_MN16 (XI903_xn2 B_15_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI903_MN15 (pp7_15 XI903_xan XI903_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI903_MN13 (XI903_xn1 XI903_xn pp7_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI903_MN2 (VSS A_15_b3_2 XI903_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI903_MN4 (XI903_n2 A_14_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI903_MN3 (XI903_xn two7_b3_2 XI903_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI903_MN1 (XI903_n1 one7_b3_2 XI903_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI903_MN9 (VSS XI903_xn XI903_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI902_MN11 (VSS B_15_b3_2 XI902_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI902_MN14 (VSS XI902_xbn XI902_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI902_MN16 (XI902_xn2 B_15_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI902_MN15 (pp7_14 XI902_xan XI902_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI902_MN13 (XI902_xn1 XI902_xn pp7_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI902_MN2 (VSS A_14_b3_2 XI902_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI902_MN4 (XI902_n2 A_13_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI902_MN3 (XI902_xn two7_b3_2 XI902_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI902_MN1 (XI902_n1 one7_b3_2 XI902_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI902_MN9 (VSS XI902_xn XI902_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI847_MN11 (VSS B_13_b3_2 XI847_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI847_MN14 (VSS XI847_xbn XI847_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI847_MN16 (XI847_xn2 B_13_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI847_MN15 (pp6_14 XI847_xan XI847_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI847_MN13 (XI847_xn1 XI847_xn pp6_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI847_MN2 (VSS A_14_b3_2 XI847_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI847_MN4 (XI847_n2 A_13_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI847_MN3 (XI847_xn two6_b3_2 XI847_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI847_MN1 (XI847_n1 one6_b3_2 XI847_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI847_MN9 (VSS XI847_xn XI847_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI848_MN11 (VSS B_13_b3_2 XI848_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI848_MN14 (VSS XI848_xbn XI848_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI848_MN16 (XI848_xn2 B_13_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI848_MN15 (pp6_15 XI848_xan XI848_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI848_MN13 (XI848_xn1 XI848_xn pp6_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI848_MN2 (VSS A_15_b3_2 XI848_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI848_MN4 (XI848_n2 A_14_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI848_MN3 (XI848_xn two6_b3_2 XI848_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI848_MN1 (XI848_n1 one6_b3_2 XI848_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI848_MN9 (VSS XI848_xn XI848_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI740_MN11 (VSS B_9_b3_3 XI740_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI740_MN14 (VSS XI740_xbn XI740_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI740_MN16 (XI740_xn2 B_9_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI740_MN15 (pp4_17 XI740_xan XI740_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI740_MN13 (XI740_xn1 XI740_xn pp4_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI740_MN2 (VSS A_17_b3_1 XI740_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI740_MN4 (XI740_n2 A_16_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI740_MN3 (XI740_xn two4_b3_3 XI740_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI740_MN1 (XI740_n1 one4_b3_3 XI740_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI740_MN9 (VSS XI740_xn XI740_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI529_MN11 (VSS B_1_b3_4 XI529_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI529_MN14 (VSS XI529_xbn XI529_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI529_MN16 (XI529_xn2 B_1_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI529_MN15 (pp0_26 XI529_xan XI529_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI529_MN13 (XI529_xn1 XI529_xn pp0_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI529_MN2 (VSS A_26_b3_0 XI529_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI529_MN4 (XI529_n2 A_25_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI529_MN3 (XI529_xn two0_b3_4 XI529_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI529_MN1 (XI529_n1 one0_b3_4 XI529_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI529_MN9 (VSS XI529_xn XI529_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI582_MN11 (VSS B_3_b3_4 XI582_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI582_MN14 (VSS XI582_xbn XI582_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI582_MN16 (XI582_xn2 B_3_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI582_MN15 (pp1_24 XI582_xan XI582_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI582_MN13 (XI582_xn1 XI582_xn pp1_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI582_MN2 (VSS A_24_b3_0 XI582_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI582_MN4 (XI582_n2 A_23_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI582_MN3 (XI582_xn two1_b3_4 XI582_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI582_MN1 (XI582_n1 one1_b3_4 XI582_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI582_MN9 (VSS XI582_xn XI582_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1005_MN11 (VSS B_19_b3_1 XI1005_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1005_MN14 (VSS XI1005_xbn XI1005_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1005_MN16 (XI1005_xn2 B_19_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1005_MN15 (pp9_7 XI1005_xan XI1005_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1005_MN13 (XI1005_xn1 XI1005_xn pp9_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1005_MN2 (VSS A_7_b3_3 XI1005_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1005_MN4 (XI1005_n2 A_6_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1005_MN3 (XI1005_xn two9_b3_1 XI1005_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1005_MN1 (XI1005_n1 one9_b3_1 XI1005_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1005_MN9 (VSS XI1005_xn XI1005_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1006_MN11 (VSS B_19_b3_1 XI1006_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1006_MN14 (VSS XI1006_xbn XI1006_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1006_MN16 (XI1006_xn2 B_19_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1006_MN15 (pp9_8 XI1006_xan XI1006_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1006_MN13 (XI1006_xn1 XI1006_xn pp9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1006_MN2 (VSS A_8_b3_3 XI1006_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1006_MN4 (XI1006_n2 A_7_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1006_MN3 (XI1006_xn two9_b3_1 XI1006_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1006_MN1 (XI1006_n1 one9_b3_1 XI1006_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1006_MN9 (VSS XI1006_xn XI1006_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1059_MN11 (VSS B_21_b3_1 XI1059_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1059_MN14 (VSS XI1059_xbn XI1059_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1059_MN16 (XI1059_xn2 B_21_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1059_MN15 (pp10_6 XI1059_xan XI1059_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1059_MN13 (XI1059_xn1 XI1059_xn pp10_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1059_MN2 (VSS A_6_b3_3 XI1059_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1059_MN4 (XI1059_n2 A_5_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1059_MN3 (XI1059_xn two10_b3_1 XI1059_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1059_MN1 (XI1059_n1 one10_b3_1 XI1059_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1059_MN9 (VSS XI1059_xn XI1059_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1166_MN11 (VSS B_25_b3_0 XI1166_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1166_MN14 (VSS XI1166_xbn XI1166_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1166_MN16 (XI1166_xn2 B_25_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1166_MN15 (pp12_3 XI1166_xan XI1166_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1166_MN13 (XI1166_xn1 XI1166_xn pp12_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1166_MN2 (VSS A_3_b3_4 XI1166_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1166_MN4 (XI1166_n2 A_2_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1166_MN3 (XI1166_xn two12_b3_0 XI1166_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1166_MN1 (XI1166_n1 one12_b3_0 XI1166_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1166_MN9 (VSS XI1166_xn XI1166_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1164_MN11 (VSS B_25_b3_0 XI1164_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1164_MN14 (VSS XI1164_xbn XI1164_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1164_MN16 (XI1164_xn2 B_25_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1164_MN15 (pp12_1 XI1164_xan XI1164_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1164_MN13 (XI1164_xn1 XI1164_xn pp12_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1164_MN2 (VSS A_1_b3_4 XI1164_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1164_MN4 (XI1164_n2 A_0_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1164_MN3 (XI1164_xn two12_b3_0 XI1164_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1164_MN1 (XI1164_n1 one12_b3_0 XI1164_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1164_MN9 (VSS XI1164_xn XI1164_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1218_MN11 (VSS B_27_b3_0 XI1218_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1218_MN14 (VSS XI1218_xbn XI1218_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1218_MN16 (XI1218_xn2 B_27_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1218_MN15 (pp13_0 XI1218_xan XI1218_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1218_MN13 (XI1218_xn1 XI1218_xn pp13_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1218_MN2 (VSS A_0_b3_4 XI1218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1218_MN4 (XI1218_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1218_MN3 (XI1218_xn two13_b3_0 XI1218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1218_MN1 (XI1218_n1 one13_b3_0 XI1218_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1218_MN9 (VSS XI1218_xn XI1218_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1165_MN11 (VSS B_25_b3_0 XI1165_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1165_MN14 (VSS XI1165_xbn XI1165_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1165_MN16 (XI1165_xn2 B_25_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1165_MN15 (pp12_2 XI1165_xan XI1165_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1165_MN13 (XI1165_xn1 XI1165_xn pp12_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1165_MN2 (VSS A_2_b3_4 XI1165_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1165_MN4 (XI1165_n2 A_1_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1165_MN3 (XI1165_xn two12_b3_0 XI1165_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1165_MN1 (XI1165_n1 one12_b3_0 XI1165_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1165_MN9 (VSS XI1165_xn XI1165_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI900_MN11 (VSS B_15_b3_2 XI900_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI900_MN14 (VSS XI900_xbn XI900_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI900_MN16 (XI900_xn2 B_15_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI900_MN15 (pp7_12 XI900_xan XI900_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI900_MN13 (XI900_xn1 XI900_xn pp7_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI900_MN2 (VSS A_12_b3_2 XI900_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI900_MN4 (XI900_n2 A_11_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI900_MN3 (XI900_xn two7_b3_2 XI900_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI900_MN1 (XI900_n1 one7_b3_2 XI900_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI900_MN9 (VSS XI900_xn XI900_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI901_MN11 (VSS B_15_b3_2 XI901_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI901_MN14 (VSS XI901_xbn XI901_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI901_MN16 (XI901_xn2 B_15_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI901_MN15 (pp7_13 XI901_xan XI901_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI901_MN13 (XI901_xn1 XI901_xn pp7_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI901_MN2 (VSS A_13_b3_2 XI901_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI901_MN4 (XI901_n2 A_12_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI901_MN3 (XI901_xn two7_b3_2 XI901_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI901_MN1 (XI901_n1 one7_b3_2 XI901_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI901_MN9 (VSS XI901_xn XI901_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI581_MN11 (VSS B_3_b3_4 XI581_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI581_MN14 (VSS XI581_xbn XI581_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI581_MN16 (XI581_xn2 B_3_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI581_MN15 (pp1_23 XI581_xan XI581_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI581_MN13 (XI581_xn1 XI581_xn pp1_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI581_MN2 (VSS A_23_b3_0 XI581_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI581_MN4 (XI581_n2 A_22_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI581_MN3 (XI581_xn two1_b3_4 XI581_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI581_MN1 (XI581_n1 one1_b3_4 XI581_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI581_MN9 (VSS XI581_xn XI581_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI528_MN11 (VSS B_1_b3_4 XI528_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI528_MN14 (VSS XI528_xbn XI528_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI528_MN16 (XI528_xn2 B_1_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI528_MN15 (pp0_25 XI528_xan XI528_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI528_MN13 (XI528_xn1 XI528_xn pp0_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI528_MN2 (VSS A_25_b3_0 XI528_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI528_MN4 (XI528_n2 A_24_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI528_MN3 (XI528_xn two0_b3_4 XI528_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI528_MN1 (XI528_n1 one0_b3_4 XI528_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI528_MN9 (VSS XI528_xn XI528_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI526_MN11 (VSS B_1_b3_4 XI526_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI526_MN14 (VSS XI526_xbn XI526_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI526_MN16 (XI526_xn2 B_1_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI526_MN15 (pp0_23 XI526_xan XI526_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI526_MN13 (XI526_xn1 XI526_xn pp0_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI526_MN2 (VSS A_23_b3_0 XI526_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI526_MN4 (XI526_n2 A_22_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI526_MN3 (XI526_xn two0_b3_4 XI526_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI526_MN1 (XI526_n1 one0_b3_4 XI526_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI526_MN9 (VSS XI526_xn XI526_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI527_MN11 (VSS B_1_b3_4 XI527_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI527_MN14 (VSS XI527_xbn XI527_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI527_MN16 (XI527_xn2 B_1_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI527_MN15 (pp0_24 XI527_xan XI527_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI527_MN13 (XI527_xn1 XI527_xn pp0_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI527_MN2 (VSS A_24_b3_0 XI527_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI527_MN4 (XI527_n2 A_23_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI527_MN3 (XI527_xn two0_b3_4 XI527_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI527_MN1 (XI527_n1 one0_b3_4 XI527_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI527_MN9 (VSS XI527_xn XI527_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI952_MN11 (VSS B_17_b3_1 XI952_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI952_MN14 (VSS XI952_xbn XI952_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI952_MN16 (XI952_xn2 B_17_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI952_MN15 (pp8_9 XI952_xan XI952_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI952_MN13 (XI952_xn1 XI952_xn pp8_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI952_MN2 (VSS A_9_b3_3 XI952_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI952_MN4 (XI952_n2 A_8_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI952_MN3 (XI952_xn two8_b3_1 XI952_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI952_MN1 (XI952_n1 one8_b3_1 XI952_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI952_MN9 (VSS XI952_xn XI952_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI953_MN11 (VSS B_17_b3_1 XI953_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI953_MN14 (VSS XI953_xbn XI953_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI953_MN16 (XI953_xn2 B_17_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI953_MN15 (pp8_10 XI953_xan XI953_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI953_MN13 (XI953_xn1 XI953_xn pp8_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI953_MN2 (VSS A_10_b3_3 XI953_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI953_MN4 (XI953_n2 A_9_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI953_MN3 (XI953_xn two8_b3_1 XI953_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI953_MN1 (XI953_n1 one8_b3_1 XI953_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI953_MN9 (VSS XI953_xn XI953_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1058_MN11 (VSS B_21_b3_1 XI1058_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1058_MN14 (VSS XI1058_xbn XI1058_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1058_MN16 (XI1058_xn2 B_21_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1058_MN15 (pp10_5 XI1058_xan XI1058_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1058_MN13 (XI1058_xn1 XI1058_xn pp10_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1058_MN2 (VSS A_5_b3_3 XI1058_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1058_MN4 (XI1058_n2 A_4_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1058_MN3 (XI1058_xn two10_b3_0 XI1058_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1058_MN1 (XI1058_n1 one10_b3_0 XI1058_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1058_MN9 (VSS XI1058_xn XI1058_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1004_MN11 (VSS B_19_b3_1 XI1004_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1004_MN14 (VSS XI1004_xbn XI1004_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1004_MN16 (XI1004_xn2 B_19_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1004_MN15 (pp9_6 XI1004_xan XI1004_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1004_MN13 (XI1004_xn1 XI1004_xn pp9_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1004_MN2 (VSS A_6_b3_3 XI1004_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1004_MN4 (XI1004_n2 A_5_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1004_MN3 (XI1004_xn two9_b3_1 XI1004_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1004_MN1 (XI1004_n1 one9_b3_1 XI1004_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1004_MN9 (VSS XI1004_xn XI1004_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1111_MN11 (VSS B_23_b3_0 XI1111_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1111_MN14 (VSS XI1111_xbn XI1111_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1111_MN16 (XI1111_xn2 B_23_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1111_MN15 (pp11_3 XI1111_xan XI1111_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1111_MN13 (XI1111_xn1 XI1111_xn pp11_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1111_MN2 (VSS A_3_b3_4 XI1111_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1111_MN4 (XI1111_n2 A_2_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1111_MN3 (XI1111_xn two11_b3_0 XI1111_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1111_MN1 (XI1111_n1 one11_b3_0 XI1111_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1111_MN9 (VSS XI1111_xn XI1111_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1163_MN11 (VSS B_25_b3_0 XI1163_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1163_MN14 (VSS XI1163_xbn XI1163_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1163_MN16 (XI1163_xn2 B_25_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1163_MN15 (pp12_0 XI1163_xan XI1163_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1163_MN13 (XI1163_xn1 XI1163_xn pp12_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1163_MN2 (VSS A_0_b3_4 XI1163_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1163_MN4 (XI1163_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1163_MN3 (XI1163_xn two12_b3_0 XI1163_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1163_MN1 (XI1163_n1 one12_b3_0 XI1163_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1163_MN9 (VSS XI1163_xn XI1163_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI899_MN11 (VSS B_15_b3_2 XI899_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI899_MN14 (VSS XI899_xbn XI899_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI899_MN16 (XI899_xn2 B_15_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI899_MN15 (pp7_11 XI899_xan XI899_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI899_MN13 (XI899_xn1 XI899_xn pp7_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI899_MN2 (VSS A_11_b3_2 XI899_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI899_MN4 (XI899_n2 A_10_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI899_MN3 (XI899_xn two7_b3_2 XI899_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI899_MN1 (XI899_n1 one7_b3_2 XI899_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI899_MN9 (VSS XI899_xn XI899_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI846_MN11 (VSS B_13_b3_2 XI846_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI846_MN14 (VSS XI846_xbn XI846_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI846_MN16 (XI846_xn2 B_13_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI846_MN15 (pp6_13 XI846_xan XI846_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI846_MN13 (XI846_xn1 XI846_xn pp6_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI846_MN2 (VSS A_13_b3_2 XI846_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI846_MN4 (XI846_n2 A_12_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI846_MN3 (XI846_xn two6_b3_2 XI846_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI846_MN1 (XI846_n1 one6_b3_2 XI846_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI846_MN9 (VSS XI846_xn XI846_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI845_MN11 (VSS B_13_b3_2 XI845_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI845_MN14 (VSS XI845_xbn XI845_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI845_MN16 (XI845_xn2 B_13_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI845_MN15 (pp6_12 XI845_xan XI845_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI845_MN13 (XI845_xn1 XI845_xn pp6_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI845_MN2 (VSS A_12_b3_2 XI845_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI845_MN4 (XI845_n2 A_11_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI845_MN3 (XI845_xn two6_b3_2 XI845_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI845_MN1 (XI845_n1 one6_b3_2 XI845_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI845_MN9 (VSS XI845_xn XI845_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI793_MN11 (VSS B_11_b3_2 XI793_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI793_MN14 (VSS XI793_xbn XI793_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI793_MN16 (XI793_xn2 B_11_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI793_MN15 (pp5_15 XI793_xan XI793_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI793_MN13 (XI793_xn1 XI793_xn pp5_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI793_MN2 (VSS A_15_b3_1 XI793_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI793_MN4 (XI793_n2 A_14_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI793_MN3 (XI793_xn two5_b3_2 XI793_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI793_MN1 (XI793_n1 one5_b3_2 XI793_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI793_MN9 (VSS XI793_xn XI793_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI794_MN11 (VSS B_11_b3_2 XI794_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI794_MN14 (VSS XI794_xbn XI794_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI794_MN16 (XI794_xn2 B_11_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI794_MN15 (pp5_16 XI794_xan XI794_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI794_MN13 (XI794_xn1 XI794_xn pp5_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI794_MN2 (VSS A_16_b3_1 XI794_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI794_MN4 (XI794_n2 A_15_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI794_MN3 (XI794_xn two5_b3_2 XI794_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI794_MN1 (XI794_n1 one5_b3_2 XI794_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI794_MN9 (VSS XI794_xn XI794_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI525_MN11 (VSS B_1_b3_3 XI525_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI525_MN14 (VSS XI525_xbn XI525_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI525_MN16 (XI525_xn2 B_1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI525_MN15 (pp0_22 XI525_xan XI525_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI525_MN13 (XI525_xn1 XI525_xn pp0_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI525_MN2 (VSS A_22_b3_0 XI525_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI525_MN4 (XI525_n2 A_21_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI525_MN3 (XI525_xn two0_b3_4 XI525_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI525_MN1 (XI525_n1 one0_b3_4 XI525_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI525_MN9 (VSS XI525_xn XI525_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI580_MN11 (VSS B_3_b3_3 XI580_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI580_MN14 (VSS XI580_xbn XI580_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI580_MN16 (XI580_xn2 B_3_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI580_MN15 (pp1_22 XI580_xan XI580_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI580_MN13 (XI580_xn1 XI580_xn pp1_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI580_MN2 (VSS A_22_b3_0 XI580_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI580_MN4 (XI580_n2 A_21_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI580_MN3 (XI580_xn two1_b3_4 XI580_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI580_MN1 (XI580_n1 one1_b3_4 XI580_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI580_MN9 (VSS XI580_xn XI580_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI951_MN11 (VSS B_17_b3_1 XI951_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI951_MN14 (VSS XI951_xbn XI951_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI951_MN16 (XI951_xn2 B_17_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI951_MN15 (pp8_8 XI951_xan XI951_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI951_MN13 (XI951_xn1 XI951_xn pp8_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI951_MN2 (VSS A_8_b3_3 XI951_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI951_MN4 (XI951_n2 A_7_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI951_MN3 (XI951_xn two8_b3_1 XI951_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI951_MN1 (XI951_n1 one8_b3_1 XI951_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI951_MN9 (VSS XI951_xn XI951_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI950_MN11 (VSS B_17_b3_1 XI950_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI950_MN14 (VSS XI950_xbn XI950_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI950_MN16 (XI950_xn2 B_17_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI950_MN15 (pp8_7 XI950_xan XI950_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI950_MN13 (XI950_xn1 XI950_xn pp8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI950_MN2 (VSS A_7_b3_3 XI950_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI950_MN4 (XI950_n2 A_6_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI950_MN3 (XI950_xn two8_b3_1 XI950_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI950_MN1 (XI950_n1 one8_b3_1 XI950_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI950_MN9 (VSS XI950_xn XI950_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1109_MN11 (VSS B_23_b3_0 XI1109_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1109_MN14 (VSS XI1109_xbn XI1109_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1109_MN16 (XI1109_xn2 B_23_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1109_MN15 (pp11_1 XI1109_xan XI1109_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1109_MN13 (XI1109_xn1 XI1109_xn pp11_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1109_MN2 (VSS A_1_b3_4 XI1109_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1109_MN4 (XI1109_n2 A_0_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1109_MN3 (XI1109_xn two11_b3_0 XI1109_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1109_MN1 (XI1109_n1 one11_b3_0 XI1109_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1109_MN9 (VSS XI1109_xn XI1109_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1110_MN11 (VSS B_23_b3_0 XI1110_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1110_MN14 (VSS XI1110_xbn XI1110_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1110_MN16 (XI1110_xn2 B_23_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1110_MN15 (pp11_2 XI1110_xan XI1110_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1110_MN13 (XI1110_xn1 XI1110_xn pp11_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1110_MN2 (VSS A_2_b3_4 XI1110_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1110_MN4 (XI1110_n2 A_1_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1110_MN3 (XI1110_xn two11_b3_0 XI1110_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1110_MN1 (XI1110_n1 one11_b3_0 XI1110_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1110_MN9 (VSS XI1110_xn XI1110_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI844_MN11 (VSS B_13_b3_2 XI844_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI844_MN14 (VSS XI844_xbn XI844_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI844_MN16 (XI844_xn2 B_13_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI844_MN15 (pp6_11 XI844_xan XI844_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI844_MN13 (XI844_xn1 XI844_xn pp6_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI844_MN2 (VSS A_11_b3_2 XI844_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI844_MN4 (XI844_n2 A_10_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI844_MN3 (XI844_xn two6_b3_2 XI844_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI844_MN1 (XI844_n1 one6_b3_2 XI844_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI844_MN9 (VSS XI844_xn XI844_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI792_MN11 (VSS B_11_b3_2 XI792_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI792_MN14 (VSS XI792_xbn XI792_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI792_MN16 (XI792_xn2 B_11_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI792_MN15 (pp5_14 XI792_xan XI792_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI792_MN13 (XI792_xn1 XI792_xn pp5_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI792_MN2 (VSS A_14_b3_1 XI792_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI792_MN4 (XI792_n2 A_13_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI792_MN3 (XI792_xn two5_b3_2 XI792_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI792_MN1 (XI792_n1 one5_b3_2 XI792_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI792_MN9 (VSS XI792_xn XI792_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI634_MN11 (VSS B_5_b3_3 XI634_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI634_MN14 (VSS XI634_xbn XI634_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI634_MN16 (XI634_xn2 B_5_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI634_MN15 (pp2_21 XI634_xan XI634_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI634_MN13 (XI634_xn1 XI634_xn pp2_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI634_MN2 (VSS A_21_b3_0 XI634_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI634_MN4 (XI634_n2 A_20_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI634_MN3 (XI634_xn two2_b3_3 XI634_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI634_MN1 (XI634_n1 one2_b3_3 XI634_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI634_MN9 (VSS XI634_xn XI634_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI633_MN11 (VSS B_5_b3_3 XI633_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI633_MN14 (VSS XI633_xbn XI633_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI633_MN16 (XI633_xn2 B_5_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI633_MN15 (pp2_20 XI633_xan XI633_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI633_MN13 (XI633_xn1 XI633_xn pp2_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI633_MN2 (VSS A_20_b3_0 XI633_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI633_MN4 (XI633_n2 A_19_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI633_MN3 (XI633_xn two2_b3_3 XI633_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI633_MN1 (XI633_n1 one2_b3_3 XI633_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI633_MN9 (VSS XI633_xn XI633_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI949_MN11 (VSS B_17_b3_1 XI949_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI949_MN14 (VSS XI949_xbn XI949_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI949_MN16 (XI949_xn2 B_17_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI949_MN15 (pp8_6 XI949_xan XI949_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI949_MN13 (XI949_xn1 XI949_xn pp8_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI949_MN2 (VSS A_6_b3_3 XI949_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI949_MN4 (XI949_n2 A_5_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI949_MN3 (XI949_xn two8_b3_1 XI949_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI949_MN1 (XI949_n1 one8_b3_1 XI949_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI949_MN9 (VSS XI949_xn XI949_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1003_MN11 (VSS B_19_b3_1 XI1003_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1003_MN14 (VSS XI1003_xbn XI1003_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1003_MN16 (XI1003_xn2 B_19_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1003_MN15 (pp9_5 XI1003_xan XI1003_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1003_MN13 (XI1003_xn1 XI1003_xn pp9_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1003_MN2 (VSS A_5_b3_3 XI1003_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1003_MN4 (XI1003_n2 A_4_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1003_MN3 (XI1003_xn two9_b3_0 XI1003_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1003_MN1 (XI1003_n1 one9_b3_0 XI1003_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1003_MN9 (VSS XI1003_xn XI1003_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1108_MN11 (VSS B_23_b3_0 XI1108_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1108_MN14 (VSS XI1108_xbn XI1108_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1108_MN16 (XI1108_xn2 B_23_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1108_MN15 (pp11_0 XI1108_xan XI1108_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1108_MN13 (XI1108_xn1 XI1108_xn pp11_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1108_MN2 (VSS A_0_b3_4 XI1108_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1108_MN4 (XI1108_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1108_MN3 (XI1108_xn two11_b3_0 XI1108_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1108_MN1 (XI1108_n1 one11_b3_0 XI1108_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1108_MN9 (VSS XI1108_xn XI1108_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI791_MN11 (VSS B_11_b3_2 XI791_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI791_MN14 (VSS XI791_xbn XI791_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI791_MN16 (XI791_xn2 B_11_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI791_MN15 (pp5_13 XI791_xan XI791_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI791_MN13 (XI791_xn1 XI791_xn pp5_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI791_MN2 (VSS A_13_b3_1 XI791_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI791_MN4 (XI791_n2 A_12_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI791_MN3 (XI791_xn two5_b3_2 XI791_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI791_MN1 (XI791_n1 one5_b3_2 XI791_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI791_MN9 (VSS XI791_xn XI791_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI631_MN11 (VSS B_5_b3_3 XI631_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI631_MN14 (VSS XI631_xbn XI631_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI631_MN16 (XI631_xn2 B_5_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI631_MN15 (pp2_18 XI631_xan XI631_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI631_MN13 (XI631_xn1 XI631_xn pp2_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI631_MN2 (VSS A_18_b3_0 XI631_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI631_MN4 (XI631_n2 A_17_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI631_MN3 (XI631_xn two2_b3_3 XI631_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI631_MN1 (XI631_n1 one2_b3_3 XI631_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI631_MN9 (VSS XI631_xn XI631_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI632_MN11 (VSS B_5_b3_3 XI632_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI632_MN14 (VSS XI632_xbn XI632_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI632_MN16 (XI632_xn2 B_5_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI632_MN15 (pp2_19 XI632_xan XI632_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI632_MN13 (XI632_xn1 XI632_xn pp2_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI632_MN2 (VSS A_19_b3_0 XI632_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI632_MN4 (XI632_n2 A_18_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI632_MN3 (XI632_xn two2_b3_3 XI632_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI632_MN1 (XI632_n1 one2_b3_3 XI632_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI632_MN9 (VSS XI632_xn XI632_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI579_MN11 (VSS B_3_b3_3 XI579_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI579_MN14 (VSS XI579_xbn XI579_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI579_MN16 (XI579_xn2 B_3_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI579_MN15 (pp1_21 XI579_xan XI579_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI579_MN13 (XI579_xn1 XI579_xn pp1_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI579_MN2 (VSS A_21_b3_0 XI579_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI579_MN4 (XI579_n2 A_20_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI579_MN3 (XI579_xn two1_b3_3 XI579_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI579_MN1 (XI579_n1 one1_b3_3 XI579_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI579_MN9 (VSS XI579_xn XI579_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI578_MN11 (VSS B_3_b3_3 XI578_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI578_MN14 (VSS XI578_xbn XI578_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI578_MN16 (XI578_xn2 B_3_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI578_MN15 (pp1_20 XI578_xan XI578_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI578_MN13 (XI578_xn1 XI578_xn pp1_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI578_MN2 (VSS A_20_b3_0 XI578_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI578_MN4 (XI578_n2 A_19_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI578_MN3 (XI578_xn two1_b3_3 XI578_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI578_MN1 (XI578_n1 one1_b3_3 XI578_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI578_MN9 (VSS XI578_xn XI578_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI898_MN11 (VSS B_15_b3_1 XI898_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI898_MN14 (VSS XI898_xbn XI898_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI898_MN16 (XI898_xn2 B_15_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI898_MN15 (pp7_10 XI898_xan XI898_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI898_MN13 (XI898_xn1 XI898_xn pp7_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI898_MN2 (VSS A_10_b3_2 XI898_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI898_MN4 (XI898_n2 A_9_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI898_MN3 (XI898_xn two7_b3_1 XI898_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI898_MN1 (XI898_n1 one7_b3_1 XI898_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI898_MN9 (VSS XI898_xn XI898_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI897_MN11 (VSS B_15_b3_1 XI897_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI897_MN14 (VSS XI897_xbn XI897_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI897_MN16 (XI897_xn2 B_15_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI897_MN15 (pp7_9 XI897_xan XI897_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI897_MN13 (XI897_xn1 XI897_xn pp7_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI897_MN2 (VSS A_9_b3_2 XI897_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI897_MN4 (XI897_n2 A_8_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI897_MN3 (XI897_xn two7_b3_1 XI897_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI897_MN1 (XI897_n1 one7_b3_1 XI897_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI897_MN9 (VSS XI897_xn XI897_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI789_MN11 (VSS B_11_b3_2 XI789_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI789_MN14 (VSS XI789_xbn XI789_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI789_MN16 (XI789_xn2 B_11_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI789_MN15 (pp5_11 XI789_xan XI789_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI789_MN13 (XI789_xn1 XI789_xn pp5_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI789_MN2 (VSS A_11_b3_1 XI789_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI789_MN4 (XI789_n2 A_10_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI789_MN3 (XI789_xn two5_b3_2 XI789_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI789_MN1 (XI789_n1 one5_b3_2 XI789_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI789_MN9 (VSS XI789_xn XI789_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI790_MN11 (VSS B_11_b3_2 XI790_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI790_MN14 (VSS XI790_xbn XI790_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI790_MN16 (XI790_xn2 B_11_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI790_MN15 (pp5_12 XI790_xan XI790_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI790_MN13 (XI790_xn1 XI790_xn pp5_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI790_MN2 (VSS A_12_b3_1 XI790_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI790_MN4 (XI790_n2 A_11_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI790_MN3 (XI790_xn two5_b3_2 XI790_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI790_MN1 (XI790_n1 one5_b3_2 XI790_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI790_MN9 (VSS XI790_xn XI790_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI737_MN11 (VSS B_9_b3_2 XI737_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI737_MN14 (VSS XI737_xbn XI737_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI737_MN16 (XI737_xn2 B_9_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI737_MN15 (pp4_14 XI737_xan XI737_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI737_MN13 (XI737_xn1 XI737_xn pp4_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI737_MN2 (VSS A_14_b3_1 XI737_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI737_MN4 (XI737_n2 A_13_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI737_MN3 (XI737_xn two4_b3_2 XI737_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI737_MN1 (XI737_n1 one4_b3_2 XI737_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI737_MN9 (VSS XI737_xn XI737_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI739_MN11 (VSS B_9_b3_2 XI739_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI739_MN14 (VSS XI739_xbn XI739_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI739_MN16 (XI739_xn2 B_9_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI739_MN15 (pp4_16 XI739_xan XI739_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI739_MN13 (XI739_xn1 XI739_xn pp4_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI739_MN2 (VSS A_16_b3_1 XI739_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI739_MN4 (XI739_n2 A_15_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI739_MN3 (XI739_xn two4_b3_2 XI739_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI739_MN1 (XI739_n1 one4_b3_2 XI739_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI739_MN9 (VSS XI739_xn XI739_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI684_MN11 (VSS B_7_b3_2 XI684_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI684_MN14 (VSS XI684_xbn XI684_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI684_MN16 (XI684_xn2 B_7_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI684_MN15 (pp3_16 XI684_xan XI684_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI684_MN13 (XI684_xn1 XI684_xn pp3_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI684_MN2 (VSS A_16_b3_1 XI684_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI684_MN4 (XI684_n2 A_15_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI684_MN3 (XI684_xn two3_b3_2 XI684_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI684_MN1 (XI684_n1 one3_b3_2 XI684_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI684_MN9 (VSS XI684_xn XI684_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI683_MN11 (VSS B_7_b3_2 XI683_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI683_MN14 (VSS XI683_xbn XI683_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI683_MN16 (XI683_xn2 B_7_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI683_MN15 (pp3_15 XI683_xan XI683_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI683_MN13 (XI683_xn1 XI683_xn pp3_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI683_MN2 (VSS A_15_b3_1 XI683_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI683_MN4 (XI683_n2 A_14_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI683_MN3 (XI683_xn two3_b3_2 XI683_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI683_MN1 (XI683_n1 one3_b3_2 XI683_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI683_MN9 (VSS XI683_xn XI683_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI630_MN11 (VSS B_5_b3_3 XI630_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI630_MN14 (VSS XI630_xbn XI630_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI630_MN16 (XI630_xn2 B_5_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI630_MN15 (pp2_17 XI630_xan XI630_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI630_MN13 (XI630_xn1 XI630_xn pp2_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI630_MN2 (VSS A_17_b3_0 XI630_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI630_MN4 (XI630_n2 A_16_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI630_MN3 (XI630_xn two2_b3_3 XI630_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI630_MN1 (XI630_n1 one2_b3_3 XI630_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI630_MN9 (VSS XI630_xn XI630_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI524_MN11 (VSS B_1_b3_3 XI524_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI524_MN14 (VSS XI524_xbn XI524_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI524_MN16 (XI524_xn2 B_1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI524_MN15 (pp0_21 XI524_xan XI524_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI524_MN13 (XI524_xn1 XI524_xn pp0_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI524_MN2 (VSS A_21_b3_0 XI524_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI524_MN4 (XI524_n2 A_20_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI524_MN3 (XI524_xn two0_b3_3 XI524_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI524_MN1 (XI524_n1 one0_b3_3 XI524_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI524_MN9 (VSS XI524_xn XI524_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI577_MN11 (VSS B_3_b3_3 XI577_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI577_MN14 (VSS XI577_xbn XI577_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI577_MN16 (XI577_xn2 B_3_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI577_MN15 (pp1_19 XI577_xan XI577_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI577_MN13 (XI577_xn1 XI577_xn pp1_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI577_MN2 (VSS A_19_b3_0 XI577_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI577_MN4 (XI577_n2 A_18_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI577_MN3 (XI577_xn two1_b3_3 XI577_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI577_MN1 (XI577_n1 one1_b3_3 XI577_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI577_MN9 (VSS XI577_xn XI577_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI947_MN11 (VSS B_17_b3_0 XI947_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI947_MN14 (VSS XI947_xbn XI947_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI947_MN16 (XI947_xn2 B_17_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI947_MN15 (pp8_4 XI947_xan XI947_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI947_MN13 (XI947_xn1 XI947_xn pp8_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI947_MN2 (VSS A_4_b3_3 XI947_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI947_MN4 (XI947_n2 A_3_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI947_MN3 (XI947_xn two8_b3_0 XI947_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI947_MN1 (XI947_n1 one8_b3_0 XI947_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI947_MN9 (VSS XI947_xn XI947_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI948_MN11 (VSS B_17_b3_1 XI948_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI948_MN14 (VSS XI948_xbn XI948_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI948_MN16 (XI948_xn2 B_17_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI948_MN15 (pp8_5 XI948_xan XI948_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI948_MN13 (XI948_xn1 XI948_xn pp8_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI948_MN2 (VSS A_5_b3_3 XI948_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI948_MN4 (XI948_n2 A_4_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI948_MN3 (XI948_xn two8_b3_0 XI948_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI948_MN1 (XI948_n1 one8_b3_0 XI948_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI948_MN9 (VSS XI948_xn XI948_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1057_MN11 (VSS B_21_b3_0 XI1057_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1057_MN14 (VSS XI1057_xbn XI1057_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1057_MN16 (XI1057_xn2 B_21_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1057_MN15 (pp10_4 XI1057_xan XI1057_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1057_MN13 (XI1057_xn1 XI1057_xn pp10_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1057_MN2 (VSS A_4_b3_3 XI1057_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1057_MN4 (XI1057_n2 A_3_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1057_MN3 (XI1057_xn two10_b3_0 XI1057_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1057_MN1 (XI1057_n1 one10_b3_0 XI1057_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1057_MN9 (VSS XI1057_xn XI1057_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1002_MN11 (VSS B_19_b3_0 XI1002_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1002_MN14 (VSS XI1002_xbn XI1002_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1002_MN16 (XI1002_xn2 B_19_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1002_MN15 (pp9_4 XI1002_xan XI1002_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1002_MN13 (XI1002_xn1 XI1002_xn pp9_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1002_MN2 (VSS A_4_b3_3 XI1002_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1002_MN4 (XI1002_n2 A_3_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1002_MN3 (XI1002_xn two9_b3_0 XI1002_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1002_MN1 (XI1002_n1 one9_b3_0 XI1002_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1002_MN9 (VSS XI1002_xn XI1002_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI896_MN11 (VSS B_15_b3_1 XI896_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI896_MN14 (VSS XI896_xbn XI896_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI896_MN16 (XI896_xn2 B_15_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI896_MN15 (pp7_8 XI896_xan XI896_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI896_MN13 (XI896_xn1 XI896_xn pp7_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI896_MN2 (VSS A_8_b3_2 XI896_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI896_MN4 (XI896_n2 A_7_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI896_MN3 (XI896_xn two7_b3_1 XI896_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI896_MN1 (XI896_n1 one7_b3_1 XI896_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI896_MN9 (VSS XI896_xn XI896_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI843_MN11 (VSS B_13_b3_1 XI843_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI843_MN14 (VSS XI843_xbn XI843_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI843_MN16 (XI843_xn2 B_13_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI843_MN15 (pp6_10 XI843_xan XI843_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI843_MN13 (XI843_xn1 XI843_xn pp6_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI843_MN2 (VSS A_10_b3_2 XI843_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI843_MN4 (XI843_n2 A_9_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI843_MN3 (XI843_xn two6_b3_1 XI843_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI843_MN1 (XI843_n1 one6_b3_1 XI843_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI843_MN9 (VSS XI843_xn XI843_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI736_MN11 (VSS B_9_b3_2 XI736_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI736_MN14 (VSS XI736_xbn XI736_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI736_MN16 (XI736_xn2 B_9_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI736_MN15 (pp4_13 XI736_xan XI736_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI736_MN13 (XI736_xn1 XI736_xn pp4_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI736_MN2 (VSS A_13_b3_1 XI736_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI736_MN4 (XI736_n2 A_12_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI736_MN3 (XI736_xn two4_b3_2 XI736_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI736_MN1 (XI736_n1 one4_b3_2 XI736_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI736_MN9 (VSS XI736_xn XI736_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI738_MN11 (VSS B_9_b3_2 XI738_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI738_MN14 (VSS XI738_xbn XI738_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI738_MN16 (XI738_xn2 B_9_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI738_MN15 (pp4_15 XI738_xan XI738_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI738_MN13 (XI738_xn1 XI738_xn pp4_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI738_MN2 (VSS A_15_b3_1 XI738_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI738_MN4 (XI738_n2 A_14_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI738_MN3 (XI738_xn two4_b3_2 XI738_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI738_MN1 (XI738_n1 one4_b3_2 XI738_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI738_MN9 (VSS XI738_xn XI738_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI681_MN11 (VSS B_7_b3_2 XI681_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI681_MN14 (VSS XI681_xbn XI681_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI681_MN16 (XI681_xn2 B_7_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI681_MN15 (pp3_13 XI681_xan XI681_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI681_MN13 (XI681_xn1 XI681_xn pp3_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI681_MN2 (VSS A_13_b3_1 XI681_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI681_MN4 (XI681_n2 A_12_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI681_MN3 (XI681_xn two3_b3_2 XI681_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI681_MN1 (XI681_n1 one3_b3_2 XI681_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI681_MN9 (VSS XI681_xn XI681_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI682_MN11 (VSS B_7_b3_2 XI682_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI682_MN14 (VSS XI682_xbn XI682_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI682_MN16 (XI682_xn2 B_7_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI682_MN15 (pp3_14 XI682_xan XI682_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI682_MN13 (XI682_xn1 XI682_xn pp3_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI682_MN2 (VSS A_14_b3_1 XI682_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI682_MN4 (XI682_n2 A_13_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI682_MN3 (XI682_xn two3_b3_2 XI682_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI682_MN1 (XI682_n1 one3_b3_2 XI682_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI682_MN9 (VSS XI682_xn XI682_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI521_MN11 (VSS B_1_b3_3 XI521_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI521_MN14 (VSS XI521_xbn XI521_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI521_MN16 (XI521_xn2 B_1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI521_MN15 (pp0_18 XI521_xan XI521_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI521_MN13 (XI521_xn1 XI521_xn pp0_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI521_MN2 (VSS A_18_b3_0 XI521_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI521_MN4 (XI521_n2 A_17_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI521_MN3 (XI521_xn two0_b3_3 XI521_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI521_MN1 (XI521_n1 one0_b3_3 XI521_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI521_MN9 (VSS XI521_xn XI521_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI523_MN11 (VSS B_1_b3_3 XI523_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI523_MN14 (VSS XI523_xbn XI523_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI523_MN16 (XI523_xn2 B_1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI523_MN15 (pp0_20 XI523_xan XI523_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI523_MN13 (XI523_xn1 XI523_xn pp0_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI523_MN2 (VSS A_20_b3_0 XI523_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI523_MN4 (XI523_n2 A_19_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI523_MN3 (XI523_xn two0_b3_3 XI523_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI523_MN1 (XI523_n1 one0_b3_3 XI523_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI523_MN9 (VSS XI523_xn XI523_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI576_MN11 (VSS B_3_b3_3 XI576_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI576_MN14 (VSS XI576_xbn XI576_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI576_MN16 (XI576_xn2 B_3_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI576_MN15 (pp1_18 XI576_xan XI576_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI576_MN13 (XI576_xn1 XI576_xn pp1_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI576_MN2 (VSS A_18_b3_0 XI576_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI576_MN4 (XI576_n2 A_17_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI576_MN3 (XI576_xn two1_b3_3 XI576_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI576_MN1 (XI576_n1 one1_b3_3 XI576_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI576_MN9 (VSS XI576_xn XI576_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1054_MN11 (VSS B_21_b3_0 XI1054_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1054_MN14 (VSS XI1054_xbn XI1054_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1054_MN16 (XI1054_xn2 B_21_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1054_MN15 (pp10_1 XI1054_xan XI1054_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1054_MN13 (XI1054_xn1 XI1054_xn pp10_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1054_MN2 (VSS A_1_b3_3 XI1054_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1054_MN4 (XI1054_n2 A_0_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1054_MN3 (XI1054_xn two10_b3_0 XI1054_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1054_MN1 (XI1054_n1 one10_b3_0 XI1054_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1054_MN9 (VSS XI1054_xn XI1054_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1053_MN11 (VSS B_21_b3_0 XI1053_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1053_MN14 (VSS XI1053_xbn XI1053_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1053_MN16 (XI1053_xn2 B_21_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1053_MN15 (pp10_0 XI1053_xan XI1053_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1053_MN13 (XI1053_xn1 XI1053_xn pp10_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1053_MN2 (VSS A_0_b3_3 XI1053_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1053_MN4 (XI1053_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1053_MN3 (XI1053_xn two10_b3_0 XI1053_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1053_MN1 (XI1053_n1 one10_b3_0 XI1053_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1053_MN9 (VSS XI1053_xn XI1053_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1055_MN11 (VSS B_21_b3_0 XI1055_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1055_MN14 (VSS XI1055_xbn XI1055_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1055_MN16 (XI1055_xn2 B_21_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1055_MN15 (pp10_2 XI1055_xan XI1055_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1055_MN13 (XI1055_xn1 XI1055_xn pp10_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1055_MN2 (VSS A_2_b3_3 XI1055_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1055_MN4 (XI1055_n2 A_1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1055_MN3 (XI1055_xn two10_b3_0 XI1055_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1055_MN1 (XI1055_n1 one10_b3_0 XI1055_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1055_MN9 (VSS XI1055_xn XI1055_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1056_MN11 (VSS B_21_b3_0 XI1056_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1056_MN14 (VSS XI1056_xbn XI1056_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1056_MN16 (XI1056_xn2 B_21_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1056_MN15 (pp10_3 XI1056_xan XI1056_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1056_MN13 (XI1056_xn1 XI1056_xn pp10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1056_MN2 (VSS A_3_b3_3 XI1056_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1056_MN4 (XI1056_n2 A_2_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1056_MN3 (XI1056_xn two10_b3_0 XI1056_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1056_MN1 (XI1056_n1 one10_b3_0 XI1056_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1056_MN9 (VSS XI1056_xn XI1056_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI894_MN11 (VSS B_15_b3_1 XI894_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI894_MN14 (VSS XI894_xbn XI894_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI894_MN16 (XI894_xn2 B_15_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI894_MN15 (pp7_6 XI894_xan XI894_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI894_MN13 (XI894_xn1 XI894_xn pp7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI894_MN2 (VSS A_6_b3_2 XI894_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI894_MN4 (XI894_n2 A_5_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI894_MN3 (XI894_xn two7_b3_1 XI894_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI894_MN1 (XI894_n1 one7_b3_1 XI894_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI894_MN9 (VSS XI894_xn XI894_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI895_MN11 (VSS B_15_b3_1 XI895_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI895_MN14 (VSS XI895_xbn XI895_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI895_MN16 (XI895_xn2 B_15_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI895_MN15 (pp7_7 XI895_xan XI895_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI895_MN13 (XI895_xn1 XI895_xn pp7_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI895_MN2 (VSS A_7_b3_2 XI895_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI895_MN4 (XI895_n2 A_6_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI895_MN3 (XI895_xn two7_b3_1 XI895_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI895_MN1 (XI895_n1 one7_b3_1 XI895_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI895_MN9 (VSS XI895_xn XI895_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI842_MN11 (VSS B_13_b3_1 XI842_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI842_MN14 (VSS XI842_xbn XI842_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI842_MN16 (XI842_xn2 B_13_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI842_MN15 (pp6_9 XI842_xan XI842_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI842_MN13 (XI842_xn1 XI842_xn pp6_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI842_MN2 (VSS A_9_b3_2 XI842_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI842_MN4 (XI842_n2 A_8_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI842_MN3 (XI842_xn two6_b3_1 XI842_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI842_MN1 (XI842_n1 one6_b3_1 XI842_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI842_MN9 (VSS XI842_xn XI842_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI735_MN11 (VSS B_9_b3_2 XI735_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI735_MN14 (VSS XI735_xbn XI735_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI735_MN16 (XI735_xn2 B_9_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI735_MN15 (pp4_12 XI735_xan XI735_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI735_MN13 (XI735_xn1 XI735_xn pp4_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI735_MN2 (VSS A_12_b3_1 XI735_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI735_MN4 (XI735_n2 A_11_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI735_MN3 (XI735_xn two4_b3_2 XI735_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI735_MN1 (XI735_n1 one4_b3_2 XI735_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI735_MN9 (VSS XI735_xn XI735_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI679_MN11 (VSS B_7_b3_2 XI679_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI679_MN14 (VSS XI679_xbn XI679_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI679_MN16 (XI679_xn2 B_7_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI679_MN15 (pp3_11 XI679_xan XI679_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI679_MN13 (XI679_xn1 XI679_xn pp3_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI679_MN2 (VSS A_11_b3_1 XI679_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI679_MN4 (XI679_n2 A_10_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI679_MN3 (XI679_xn two3_b3_2 XI679_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI679_MN1 (XI679_n1 one3_b3_2 XI679_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI679_MN9 (VSS XI679_xn XI679_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI680_MN11 (VSS B_7_b3_2 XI680_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI680_MN14 (VSS XI680_xbn XI680_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI680_MN16 (XI680_xn2 B_7_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI680_MN15 (pp3_12 XI680_xan XI680_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI680_MN13 (XI680_xn1 XI680_xn pp3_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI680_MN2 (VSS A_12_b3_1 XI680_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI680_MN4 (XI680_n2 A_11_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI680_MN3 (XI680_xn two3_b3_2 XI680_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI680_MN1 (XI680_n1 one3_b3_2 XI680_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI680_MN9 (VSS XI680_xn XI680_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI520_MN11 (VSS B_1_b3_3 XI520_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI520_MN14 (VSS XI520_xbn XI520_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI520_MN16 (XI520_xn2 B_1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI520_MN15 (pp0_17 XI520_xan XI520_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI520_MN13 (XI520_xn1 XI520_xn pp0_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI520_MN2 (VSS A_17_b3_0 XI520_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI520_MN4 (XI520_n2 A_16_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI520_MN3 (XI520_xn two0_b3_3 XI520_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI520_MN1 (XI520_n1 one0_b3_3 XI520_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI520_MN9 (VSS XI520_xn XI520_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI522_MN11 (VSS B_1_b3_3 XI522_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI522_MN14 (VSS XI522_xbn XI522_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI522_MN16 (XI522_xn2 B_1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI522_MN15 (pp0_19 XI522_xan XI522_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI522_MN13 (XI522_xn1 XI522_xn pp0_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI522_MN2 (VSS A_19_b3_0 XI522_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI522_MN4 (XI522_n2 A_18_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI522_MN3 (XI522_xn two0_b3_3 XI522_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI522_MN1 (XI522_n1 one0_b3_3 XI522_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI522_MN9 (VSS XI522_xn XI522_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI575_MN11 (VSS B_3_b3_3 XI575_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI575_MN14 (VSS XI575_xbn XI575_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI575_MN16 (XI575_xn2 B_3_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI575_MN15 (pp1_17 XI575_xan XI575_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI575_MN13 (XI575_xn1 XI575_xn pp1_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI575_MN2 (VSS A_17_b3_0 XI575_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI575_MN4 (XI575_n2 A_16_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI575_MN3 (XI575_xn two1_b3_3 XI575_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI575_MN1 (XI575_n1 one1_b3_3 XI575_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI575_MN9 (VSS XI575_xn XI575_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1001_MN11 (VSS B_19_b3_0 XI1001_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1001_MN14 (VSS XI1001_xbn XI1001_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1001_MN16 (XI1001_xn2 B_19_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1001_MN15 (pp9_3 XI1001_xan XI1001_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1001_MN13 (XI1001_xn1 XI1001_xn pp9_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1001_MN2 (VSS A_3_b3_3 XI1001_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1001_MN4 (XI1001_n2 A_2_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1001_MN3 (XI1001_xn two9_b3_0 XI1001_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1001_MN1 (XI1001_n1 one9_b3_0 XI1001_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1001_MN9 (VSS XI1001_xn XI1001_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1000_MN11 (VSS B_19_b3_0 XI1000_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI1000_MN14 (VSS XI1000_xbn XI1000_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1000_MN16 (XI1000_xn2 B_19_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1000_MN15 (pp9_2 XI1000_xan XI1000_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1000_MN13 (XI1000_xn1 XI1000_xn pp9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1000_MN2 (VSS A_2_b3_3 XI1000_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI1000_MN4 (XI1000_n2 A_1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1000_MN3 (XI1000_xn two9_b3_0 XI1000_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI1000_MN1 (XI1000_n1 one9_b3_0 XI1000_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI1000_MN9 (VSS XI1000_xn XI1000_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI841_MN11 (VSS B_13_b3_1 XI841_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI841_MN14 (VSS XI841_xbn XI841_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI841_MN16 (XI841_xn2 B_13_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI841_MN15 (pp6_8 XI841_xan XI841_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI841_MN13 (XI841_xn1 XI841_xn pp6_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI841_MN2 (VSS A_8_b3_2 XI841_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI841_MN4 (XI841_n2 A_7_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI841_MN3 (XI841_xn two6_b3_1 XI841_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI841_MN1 (XI841_n1 one6_b3_1 XI841_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI841_MN9 (VSS XI841_xn XI841_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI734_MN11 (VSS B_9_b3_2 XI734_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI734_MN14 (VSS XI734_xbn XI734_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI734_MN16 (XI734_xn2 B_9_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI734_MN15 (pp4_11 XI734_xan XI734_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI734_MN13 (XI734_xn1 XI734_xn pp4_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI734_MN2 (VSS A_11_b3_1 XI734_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI734_MN4 (XI734_n2 A_10_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI734_MN3 (XI734_xn two4_b3_2 XI734_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI734_MN1 (XI734_n1 one4_b3_2 XI734_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI734_MN9 (VSS XI734_xn XI734_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI946_MN11 (VSS B_17_b3_0 XI946_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI946_MN14 (VSS XI946_xbn XI946_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI946_MN16 (XI946_xn2 B_17_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI946_MN15 (pp8_3 XI946_xan XI946_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI946_MN13 (XI946_xn1 XI946_xn pp8_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI946_MN2 (VSS A_3_b3_3 XI946_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI946_MN4 (XI946_n2 A_2_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI946_MN3 (XI946_xn two8_b3_0 XI946_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI946_MN1 (XI946_n1 one8_b3_0 XI946_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI946_MN9 (VSS XI946_xn XI946_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI998_MN11 (VSS B_19_b3_0 XI998_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI998_MN14 (VSS XI998_xbn XI998_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI998_MN16 (XI998_xn2 B_19_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI998_MN15 (pp9_0 XI998_xan XI998_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI998_MN13 (XI998_xn1 XI998_xn pp9_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI998_MN2 (VSS A_0_b3_3 XI998_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI998_MN4 (XI998_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI998_MN3 (XI998_xn two9_b3_0 XI998_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI998_MN1 (XI998_n1 one9_b3_0 XI998_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI998_MN9 (VSS XI998_xn XI998_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI999_MN11 (VSS B_19_b3_0 XI999_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI999_MN14 (VSS XI999_xbn XI999_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI999_MN16 (XI999_xn2 B_19_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI999_MN15 (pp9_1 XI999_xan XI999_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI999_MN13 (XI999_xn1 XI999_xn pp9_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI999_MN2 (VSS A_1_b3_3 XI999_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI999_MN4 (XI999_n2 A_0_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI999_MN3 (XI999_xn two9_b3_0 XI999_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI999_MN1 (XI999_n1 one9_b3_0 XI999_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI999_MN9 (VSS XI999_xn XI999_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI893_MN11 (VSS B_15_b3_1 XI893_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI893_MN14 (VSS XI893_xbn XI893_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI893_MN16 (XI893_xn2 B_15_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI893_MN15 (pp7_5 XI893_xan XI893_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI893_MN13 (XI893_xn1 XI893_xn pp7_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI893_MN2 (VSS A_5_b3_2 XI893_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI893_MN4 (XI893_n2 A_4_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI893_MN3 (XI893_xn two7_b3_0 XI893_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI893_MN1 (XI893_n1 one7_b3_0 XI893_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI893_MN9 (VSS XI893_xn XI893_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI840_MN11 (VSS B_13_b3_1 XI840_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI840_MN14 (VSS XI840_xbn XI840_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI840_MN16 (XI840_xn2 B_13_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI840_MN15 (pp6_7 XI840_xan XI840_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI840_MN13 (XI840_xn1 XI840_xn pp6_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI840_MN2 (VSS A_7_b3_2 XI840_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI840_MN4 (XI840_n2 A_6_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI840_MN3 (XI840_xn two6_b3_1 XI840_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI840_MN1 (XI840_n1 one6_b3_1 XI840_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI840_MN9 (VSS XI840_xn XI840_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI839_MN11 (VSS B_13_b3_1 XI839_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI839_MN14 (VSS XI839_xbn XI839_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI839_MN16 (XI839_xn2 B_13_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI839_MN15 (pp6_6 XI839_xan XI839_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI839_MN13 (XI839_xn1 XI839_xn pp6_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI839_MN2 (VSS A_6_b3_2 XI839_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI839_MN4 (XI839_n2 A_5_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI839_MN3 (XI839_xn two6_b3_1 XI839_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI839_MN1 (XI839_n1 one6_b3_1 XI839_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI839_MN9 (VSS XI839_xn XI839_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI788_MN11 (VSS B_11_b3_1 XI788_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI788_MN14 (VSS XI788_xbn XI788_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI788_MN16 (XI788_xn2 B_11_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI788_MN15 (pp5_10 XI788_xan XI788_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI788_MN13 (XI788_xn1 XI788_xn pp5_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI788_MN2 (VSS A_10_b3_1 XI788_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI788_MN4 (XI788_n2 A_9_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI788_MN3 (XI788_xn two5_b3_1 XI788_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI788_MN1 (XI788_n1 one5_b3_1 XI788_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI788_MN9 (VSS XI788_xn XI788_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI574_MN11 (VSS B_3_b3_2 XI574_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI574_MN14 (VSS XI574_xbn XI574_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI574_MN16 (XI574_xn2 B_3_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI574_MN15 (pp1_16 XI574_xan XI574_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI574_MN13 (XI574_xn1 XI574_xn pp1_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI574_MN2 (VSS A_16_b3_0 XI574_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI574_MN4 (XI574_n2 A_15_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI574_MN3 (XI574_xn two1_b3_2 XI574_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI574_MN1 (XI574_n1 one1_b3_2 XI574_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI574_MN9 (VSS XI574_xn XI574_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI628_MN11 (VSS B_5_b3_2 XI628_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI628_MN14 (VSS XI628_xbn XI628_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI628_MN16 (XI628_xn2 B_5_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI628_MN15 (pp2_15 XI628_xan XI628_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI628_MN13 (XI628_xn1 XI628_xn pp2_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI628_MN2 (VSS A_15_b3_0 XI628_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI628_MN4 (XI628_n2 A_14_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI628_MN3 (XI628_xn two2_b3_2 XI628_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI628_MN1 (XI628_n1 one2_b3_2 XI628_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI628_MN9 (VSS XI628_xn XI628_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI626_MN11 (VSS B_5_b3_2 XI626_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI626_MN14 (VSS XI626_xbn XI626_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI626_MN16 (XI626_xn2 B_5_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI626_MN15 (pp2_13 XI626_xan XI626_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI626_MN13 (XI626_xn1 XI626_xn pp2_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI626_MN2 (VSS A_13_b3_0 XI626_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI626_MN4 (XI626_n2 A_12_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI626_MN3 (XI626_xn two2_b3_2 XI626_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI626_MN1 (XI626_n1 one2_b3_2 XI626_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI626_MN9 (VSS XI626_xn XI626_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI629_MN11 (VSS B_5_b3_2 XI629_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI629_MN14 (VSS XI629_xbn XI629_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI629_MN16 (XI629_xn2 B_5_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI629_MN15 (pp2_16 XI629_xan XI629_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI629_MN13 (XI629_xn1 XI629_xn pp2_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI629_MN2 (VSS A_16_b3_0 XI629_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI629_MN4 (XI629_n2 A_15_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI629_MN3 (XI629_xn two2_b3_2 XI629_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI629_MN1 (XI629_n1 one2_b3_2 XI629_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI629_MN9 (VSS XI629_xn XI629_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI944_MN11 (VSS B_17_b3_0 XI944_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI944_MN14 (VSS XI944_xbn XI944_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI944_MN16 (XI944_xn2 B_17_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI944_MN15 (pp8_1 XI944_xan XI944_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI944_MN13 (XI944_xn1 XI944_xn pp8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI944_MN2 (VSS A_1_b3_3 XI944_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI944_MN4 (XI944_n2 A_0_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI944_MN3 (XI944_xn two8_b3_0 XI944_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI944_MN1 (XI944_n1 one8_b3_0 XI944_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI944_MN9 (VSS XI944_xn XI944_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI945_MN11 (VSS B_17_b3_0 XI945_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI945_MN14 (VSS XI945_xbn XI945_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI945_MN16 (XI945_xn2 B_17_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI945_MN15 (pp8_2 XI945_xan XI945_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI945_MN13 (XI945_xn1 XI945_xn pp8_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI945_MN2 (VSS A_2_b3_3 XI945_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI945_MN4 (XI945_n2 A_1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI945_MN3 (XI945_xn two8_b3_0 XI945_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI945_MN1 (XI945_n1 one8_b3_0 XI945_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI945_MN9 (VSS XI945_xn XI945_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI787_MN11 (VSS B_11_b3_1 XI787_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI787_MN14 (VSS XI787_xbn XI787_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI787_MN16 (XI787_xn2 B_11_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI787_MN15 (pp5_9 XI787_xan XI787_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI787_MN13 (XI787_xn1 XI787_xn pp5_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI787_MN2 (VSS A_9_b3_1 XI787_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI787_MN4 (XI787_n2 A_8_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI787_MN3 (XI787_xn two5_b3_1 XI787_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI787_MN1 (XI787_n1 one5_b3_1 XI787_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI787_MN9 (VSS XI787_xn XI787_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI573_MN11 (VSS B_3_b3_2 XI573_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI573_MN14 (VSS XI573_xbn XI573_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI573_MN16 (XI573_xn2 B_3_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI573_MN15 (pp1_15 XI573_xan XI573_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI573_MN13 (XI573_xn1 XI573_xn pp1_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI573_MN2 (VSS A_15_b3_0 XI573_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI573_MN4 (XI573_n2 A_14_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI573_MN3 (XI573_xn two1_b3_2 XI573_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI573_MN1 (XI573_n1 one1_b3_2 XI573_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI573_MN9 (VSS XI573_xn XI573_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI625_MN11 (VSS B_5_b3_2 XI625_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI625_MN14 (VSS XI625_xbn XI625_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI625_MN16 (XI625_xn2 B_5_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI625_MN15 (pp2_12 XI625_xan XI625_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI625_MN13 (XI625_xn1 XI625_xn pp2_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI625_MN2 (VSS A_12_b3_0 XI625_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI625_MN4 (XI625_n2 A_11_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI625_MN3 (XI625_xn two2_b3_2 XI625_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI625_MN1 (XI625_n1 one2_b3_2 XI625_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI625_MN9 (VSS XI625_xn XI625_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI627_MN11 (VSS B_5_b3_2 XI627_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI627_MN14 (VSS XI627_xbn XI627_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI627_MN16 (XI627_xn2 B_5_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI627_MN15 (pp2_14 XI627_xan XI627_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI627_MN13 (XI627_xn1 XI627_xn pp2_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI627_MN2 (VSS A_14_b3_0 XI627_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI627_MN4 (XI627_n2 A_13_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI627_MN3 (XI627_xn two2_b3_2 XI627_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI627_MN1 (XI627_n1 one2_b3_2 XI627_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI627_MN9 (VSS XI627_xn XI627_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI624_MN11 (VSS B_5_b3_2 XI624_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI624_MN14 (VSS XI624_xbn XI624_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI624_MN16 (XI624_xn2 B_5_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI624_MN15 (pp2_11 XI624_xan XI624_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI624_MN13 (XI624_xn1 XI624_xn pp2_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI624_MN2 (VSS A_11_b3_0 XI624_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI624_MN4 (XI624_n2 A_10_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI624_MN3 (XI624_xn two2_b3_2 XI624_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI624_MN1 (XI624_n1 one2_b3_2 XI624_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI624_MN9 (VSS XI624_xn XI624_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI943_MN11 (VSS B_17_b3_0 XI943_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI943_MN14 (VSS XI943_xbn XI943_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI943_MN16 (XI943_xn2 B_17_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI943_MN15 (pp8_0 XI943_xan XI943_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI943_MN13 (XI943_xn1 XI943_xn pp8_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI943_MN2 (VSS A_0_b3_3 XI943_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI943_MN4 (XI943_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI943_MN3 (XI943_xn two8_b3_0 XI943_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI943_MN1 (XI943_n1 one8_b3_0 XI943_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI943_MN9 (VSS XI943_xn XI943_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI838_MN11 (VSS B_13_b3_1 XI838_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI838_MN14 (VSS XI838_xbn XI838_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI838_MN16 (XI838_xn2 B_13_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI838_MN15 (pp6_5 XI838_xan XI838_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI838_MN13 (XI838_xn1 XI838_xn pp6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI838_MN2 (VSS A_5_b3_2 XI838_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI838_MN4 (XI838_n2 A_4_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI838_MN3 (XI838_xn two6_b3_0 XI838_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI838_MN1 (XI838_n1 one6_b3_0 XI838_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI838_MN9 (VSS XI838_xn XI838_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI786_MN11 (VSS B_11_b3_1 XI786_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI786_MN14 (VSS XI786_xbn XI786_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI786_MN16 (XI786_xn2 B_11_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI786_MN15 (pp5_8 XI786_xan XI786_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI786_MN13 (XI786_xn1 XI786_xn pp5_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI786_MN2 (VSS A_8_b3_1 XI786_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI786_MN4 (XI786_n2 A_7_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI786_MN3 (XI786_xn two5_b3_1 XI786_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI786_MN1 (XI786_n1 one5_b3_1 XI786_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI786_MN9 (VSS XI786_xn XI786_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI518_MN11 (VSS B_1_b3_2 XI518_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI518_MN14 (VSS XI518_xbn XI518_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI518_MN16 (XI518_xn2 B_1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI518_MN15 (pp0_15 XI518_xan XI518_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI518_MN13 (XI518_xn1 XI518_xn pp0_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI518_MN2 (VSS A_15_b3_0 XI518_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI518_MN4 (XI518_n2 A_14_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI518_MN3 (XI518_xn two0_b3_2 XI518_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI518_MN1 (XI518_n1 one0_b3_2 XI518_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI518_MN9 (VSS XI518_xn XI518_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI519_MN11 (VSS B_1_b3_2 XI519_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI519_MN14 (VSS XI519_xbn XI519_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI519_MN16 (XI519_xn2 B_1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI519_MN15 (pp0_16 XI519_xan XI519_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI519_MN13 (XI519_xn1 XI519_xn pp0_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI519_MN2 (VSS A_16_b3_0 XI519_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI519_MN4 (XI519_n2 A_15_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI519_MN3 (XI519_xn two0_b3_2 XI519_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI519_MN1 (XI519_n1 one0_b3_2 XI519_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI519_MN9 (VSS XI519_xn XI519_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI892_MN11 (VSS B_15_b3_0 XI892_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI892_MN14 (VSS XI892_xbn XI892_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI892_MN16 (XI892_xn2 B_15_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI892_MN15 (pp7_4 XI892_xan XI892_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI892_MN13 (XI892_xn1 XI892_xn pp7_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI892_MN2 (VSS A_4_b3_2 XI892_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI892_MN4 (XI892_n2 A_3_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI892_MN3 (XI892_xn two7_b3_0 XI892_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI892_MN1 (XI892_n1 one7_b3_0 XI892_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI892_MN9 (VSS XI892_xn XI892_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI837_MN11 (VSS B_13_b3_0 XI837_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI837_MN14 (VSS XI837_xbn XI837_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI837_MN16 (XI837_xn2 B_13_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI837_MN15 (pp6_4 XI837_xan XI837_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI837_MN13 (XI837_xn1 XI837_xn pp6_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI837_MN2 (VSS A_4_b3_2 XI837_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI837_MN4 (XI837_n2 A_3_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI837_MN3 (XI837_xn two6_b3_0 XI837_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI837_MN1 (XI837_n1 one6_b3_0 XI837_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI837_MN9 (VSS XI837_xn XI837_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI784_MN11 (VSS B_11_b3_1 XI784_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI784_MN14 (VSS XI784_xbn XI784_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI784_MN16 (XI784_xn2 B_11_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI784_MN15 (pp5_6 XI784_xan XI784_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI784_MN13 (XI784_xn1 XI784_xn pp5_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI784_MN2 (VSS A_6_b3_1 XI784_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI784_MN4 (XI784_n2 A_5_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI784_MN3 (XI784_xn two5_b3_1 XI784_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI784_MN1 (XI784_n1 one5_b3_1 XI784_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI784_MN9 (VSS XI784_xn XI784_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI785_MN11 (VSS B_11_b3_1 XI785_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI785_MN14 (VSS XI785_xbn XI785_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI785_MN16 (XI785_xn2 B_11_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI785_MN15 (pp5_7 XI785_xan XI785_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI785_MN13 (XI785_xn1 XI785_xn pp5_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI785_MN2 (VSS A_7_b3_1 XI785_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI785_MN4 (XI785_n2 A_6_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI785_MN3 (XI785_xn two5_b3_1 XI785_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI785_MN1 (XI785_n1 one5_b3_1 XI785_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI785_MN9 (VSS XI785_xn XI785_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI732_MN11 (VSS B_9_b3_1 XI732_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI732_MN14 (VSS XI732_xbn XI732_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI732_MN16 (XI732_xn2 B_9_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI732_MN15 (pp4_9 XI732_xan XI732_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI732_MN13 (XI732_xn1 XI732_xn pp4_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI732_MN2 (VSS A_9_b3_1 XI732_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI732_MN4 (XI732_n2 A_8_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI732_MN3 (XI732_xn two4_b3_1 XI732_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI732_MN1 (XI732_n1 one4_b3_1 XI732_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI732_MN9 (VSS XI732_xn XI732_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI733_MN11 (VSS B_9_b3_1 XI733_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI733_MN14 (VSS XI733_xbn XI733_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI733_MN16 (XI733_xn2 B_9_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI733_MN15 (pp4_10 XI733_xan XI733_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI733_MN13 (XI733_xn1 XI733_xn pp4_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI733_MN2 (VSS A_10_b3_1 XI733_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI733_MN4 (XI733_n2 A_9_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI733_MN3 (XI733_xn two4_b3_1 XI733_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI733_MN1 (XI733_n1 one4_b3_1 XI733_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI733_MN9 (VSS XI733_xn XI733_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI677_MN11 (VSS B_7_b3_1 XI677_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI677_MN14 (VSS XI677_xbn XI677_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI677_MN16 (XI677_xn2 B_7_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI677_MN15 (pp3_9 XI677_xan XI677_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI677_MN13 (XI677_xn1 XI677_xn pp3_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI677_MN2 (VSS A_9_b3_1 XI677_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI677_MN4 (XI677_n2 A_8_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI677_MN3 (XI677_xn two3_b3_1 XI677_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI677_MN1 (XI677_n1 one3_b3_1 XI677_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI677_MN9 (VSS XI677_xn XI677_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI678_MN11 (VSS B_7_b3_1 XI678_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI678_MN14 (VSS XI678_xbn XI678_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI678_MN16 (XI678_xn2 B_7_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI678_MN15 (pp3_10 XI678_xan XI678_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI678_MN13 (XI678_xn1 XI678_xn pp3_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI678_MN2 (VSS A_10_b3_1 XI678_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI678_MN4 (XI678_n2 A_9_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI678_MN3 (XI678_xn two3_b3_1 XI678_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI678_MN1 (XI678_n1 one3_b3_1 XI678_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI678_MN9 (VSS XI678_xn XI678_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI572_MN11 (VSS B_3_b3_2 XI572_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI572_MN14 (VSS XI572_xbn XI572_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI572_MN16 (XI572_xn2 B_3_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI572_MN15 (pp1_14 XI572_xan XI572_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI572_MN13 (XI572_xn1 XI572_xn pp1_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI572_MN2 (VSS A_14_b3_0 XI572_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI572_MN4 (XI572_n2 A_13_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI572_MN3 (XI572_xn two1_b3_2 XI572_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI572_MN1 (XI572_n1 one1_b3_2 XI572_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI572_MN9 (VSS XI572_xn XI572_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI571_MN11 (VSS B_3_b3_2 XI571_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI571_MN14 (VSS XI571_xbn XI571_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI571_MN16 (XI571_xn2 B_3_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI571_MN15 (pp1_13 XI571_xan XI571_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI571_MN13 (XI571_xn1 XI571_xn pp1_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI571_MN2 (VSS A_13_b3_0 XI571_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI571_MN4 (XI571_n2 A_12_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI571_MN3 (XI571_xn two1_b3_2 XI571_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI571_MN1 (XI571_n1 one1_b3_2 XI571_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI571_MN9 (VSS XI571_xn XI571_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI517_MN11 (VSS B_1_b3_2 XI517_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI517_MN14 (VSS XI517_xbn XI517_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI517_MN16 (XI517_xn2 B_1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI517_MN15 (pp0_14 XI517_xan XI517_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI517_MN13 (XI517_xn1 XI517_xn pp0_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI517_MN2 (VSS A_14_b3_0 XI517_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI517_MN4 (XI517_n2 A_13_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI517_MN3 (XI517_xn two0_b3_2 XI517_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI517_MN1 (XI517_n1 one0_b3_2 XI517_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI517_MN9 (VSS XI517_xn XI517_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI516_MN11 (VSS B_1_b3_2 XI516_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI516_MN14 (VSS XI516_xbn XI516_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI516_MN16 (XI516_xn2 B_1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI516_MN15 (pp0_13 XI516_xan XI516_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI516_MN13 (XI516_xn1 XI516_xn pp0_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI516_MN2 (VSS A_13_b3_0 XI516_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI516_MN4 (XI516_n2 A_12_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI516_MN3 (XI516_xn two0_b3_2 XI516_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI516_MN1 (XI516_n1 one0_b3_2 XI516_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI516_MN9 (VSS XI516_xn XI516_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI570_MN11 (VSS B_3_b3_2 XI570_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI570_MN14 (VSS XI570_xbn XI570_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI570_MN16 (XI570_xn2 B_3_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI570_MN15 (pp1_12 XI570_xan XI570_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI570_MN13 (XI570_xn1 XI570_xn pp1_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI570_MN2 (VSS A_12_b3_0 XI570_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI570_MN4 (XI570_n2 A_11_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI570_MN3 (XI570_xn two1_b3_2 XI570_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI570_MN1 (XI570_n1 one1_b3_2 XI570_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI570_MN9 (VSS XI570_xn XI570_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI514_MN11 (VSS B_1_b3_2 XI514_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI514_MN14 (VSS XI514_xbn XI514_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI514_MN16 (XI514_xn2 B_1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI514_MN15 (pp0_11 XI514_xan XI514_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI514_MN13 (XI514_xn1 XI514_xn pp0_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI514_MN2 (VSS A_11_b3_0 XI514_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI514_MN4 (XI514_n2 A_10_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI514_MN3 (XI514_xn two0_b3_2 XI514_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI514_MN1 (XI514_n1 one0_b3_2 XI514_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI514_MN9 (VSS XI514_xn XI514_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI891_MN11 (VSS B_15_b3_0 XI891_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI891_MN14 (VSS XI891_xbn XI891_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI891_MN16 (XI891_xn2 B_15_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI891_MN15 (pp7_3 XI891_xan XI891_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI891_MN13 (XI891_xn1 XI891_xn pp7_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI891_MN2 (VSS A_3_b3_2 XI891_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI891_MN4 (XI891_n2 A_2_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI891_MN3 (XI891_xn two7_b3_0 XI891_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI891_MN1 (XI891_n1 one7_b3_0 XI891_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI891_MN9 (VSS XI891_xn XI891_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI890_MN11 (VSS B_15_b3_0 XI890_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI890_MN14 (VSS XI890_xbn XI890_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI890_MN16 (XI890_xn2 B_15_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI890_MN15 (pp7_2 XI890_xan XI890_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI890_MN13 (XI890_xn1 XI890_xn pp7_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI890_MN2 (VSS A_2_b3_2 XI890_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI890_MN4 (XI890_n2 A_1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI890_MN3 (XI890_xn two7_b3_0 XI890_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI890_MN1 (XI890_n1 one7_b3_0 XI890_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI890_MN9 (VSS XI890_xn XI890_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI731_MN11 (VSS B_9_b3_1 XI731_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI731_MN14 (VSS XI731_xbn XI731_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI731_MN16 (XI731_xn2 B_9_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI731_MN15 (pp4_8 XI731_xan XI731_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI731_MN13 (XI731_xn1 XI731_xn pp4_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI731_MN2 (VSS A_8_b3_1 XI731_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI731_MN4 (XI731_n2 A_7_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI731_MN3 (XI731_xn two4_b3_1 XI731_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI731_MN1 (XI731_n1 one4_b3_1 XI731_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI731_MN9 (VSS XI731_xn XI731_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI676_MN11 (VSS B_7_b3_1 XI676_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI676_MN14 (VSS XI676_xbn XI676_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI676_MN16 (XI676_xn2 B_7_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI676_MN15 (pp3_8 XI676_xan XI676_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI676_MN13 (XI676_xn1 XI676_xn pp3_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI676_MN2 (VSS A_8_b3_1 XI676_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI676_MN4 (XI676_n2 A_7_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI676_MN3 (XI676_xn two3_b3_1 XI676_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI676_MN1 (XI676_n1 one3_b3_1 XI676_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI676_MN9 (VSS XI676_xn XI676_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI515_MN11 (VSS B_1_b3_2 XI515_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI515_MN14 (VSS XI515_xbn XI515_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI515_MN16 (XI515_xn2 B_1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI515_MN15 (pp0_12 XI515_xan XI515_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI515_MN13 (XI515_xn1 XI515_xn pp0_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI515_MN2 (VSS A_12_b3_0 XI515_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI515_MN4 (XI515_n2 A_11_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI515_MN3 (XI515_xn two0_b3_2 XI515_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI515_MN1 (XI515_n1 one0_b3_2 XI515_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI515_MN9 (VSS XI515_xn XI515_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI569_MN11 (VSS B_3_b3_2 XI569_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI569_MN14 (VSS XI569_xbn XI569_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI569_MN16 (XI569_xn2 B_3_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI569_MN15 (pp1_11 XI569_xan XI569_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI569_MN13 (XI569_xn1 XI569_xn pp1_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI569_MN2 (VSS A_11_b3_0 XI569_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI569_MN4 (XI569_n2 A_10_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI569_MN3 (XI569_xn two1_b3_2 XI569_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI569_MN1 (XI569_n1 one1_b3_2 XI569_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI569_MN9 (VSS XI569_xn XI569_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI503_MN11 (VSS B_1_b3_0 XI503_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI503_MN14 (VSS XI503_xbn XI503_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI503_MN16 (XI503_xn2 B_1_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI503_MN15 (pp0_0 XI503_xan XI503_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI503_MN13 (XI503_xn1 XI503_xn pp0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI503_MN2 (VSS A_0_b3_0 XI503_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI503_MN4 (XI503_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI503_MN3 (XI503_xn two0_b3_0 XI503_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI503_MN1 (XI503_n1 one0_b3_0 XI503_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI503_MN9 (VSS XI503_xn XI503_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI889_MN11 (VSS B_15_b3_0 XI889_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI889_MN14 (VSS XI889_xbn XI889_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI889_MN16 (XI889_xn2 B_15_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI889_MN15 (pp7_1 XI889_xan XI889_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI889_MN13 (XI889_xn1 XI889_xn pp7_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI889_MN2 (VSS A_1_b3_2 XI889_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI889_MN4 (XI889_n2 A_0_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI889_MN3 (XI889_xn two7_b3_0 XI889_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI889_MN1 (XI889_n1 one7_b3_0 XI889_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI889_MN9 (VSS XI889_xn XI889_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI783_MN11 (VSS B_11_b3_1 XI783_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI783_MN14 (VSS XI783_xbn XI783_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI783_MN16 (XI783_xn2 B_11_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI783_MN15 (pp5_5 XI783_xan XI783_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI783_MN13 (XI783_xn1 XI783_xn pp5_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI783_MN2 (VSS A_5_b3_1 XI783_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI783_MN4 (XI783_n2 A_4_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI783_MN3 (XI783_xn two5_b3_0 XI783_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI783_MN1 (XI783_n1 one5_b3_0 XI783_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI783_MN9 (VSS XI783_xn XI783_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI729_MN11 (VSS B_9_b3_1 XI729_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI729_MN14 (VSS XI729_xbn XI729_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI729_MN16 (XI729_xn2 B_9_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI729_MN15 (pp4_6 XI729_xan XI729_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI729_MN13 (XI729_xn1 XI729_xn pp4_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI729_MN2 (VSS A_6_b3_1 XI729_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI729_MN4 (XI729_n2 A_5_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI729_MN3 (XI729_xn two4_b3_1 XI729_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI729_MN1 (XI729_n1 one4_b3_1 XI729_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI729_MN9 (VSS XI729_xn XI729_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI730_MN11 (VSS B_9_b3_1 XI730_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI730_MN14 (VSS XI730_xbn XI730_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI730_MN16 (XI730_xn2 B_9_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI730_MN15 (pp4_7 XI730_xan XI730_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI730_MN13 (XI730_xn1 XI730_xn pp4_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI730_MN2 (VSS A_7_b3_1 XI730_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI730_MN4 (XI730_n2 A_6_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI730_MN3 (XI730_xn two4_b3_1 XI730_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI730_MN1 (XI730_n1 one4_b3_1 XI730_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI730_MN9 (VSS XI730_xn XI730_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI675_MN11 (VSS B_7_b3_1 XI675_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI675_MN14 (VSS XI675_xbn XI675_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI675_MN16 (XI675_xn2 B_7_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI675_MN15 (pp3_7 XI675_xan XI675_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI675_MN13 (XI675_xn1 XI675_xn pp3_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI675_MN2 (VSS A_7_b3_1 XI675_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI675_MN4 (XI675_n2 A_6_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI675_MN3 (XI675_xn two3_b3_1 XI675_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI675_MN1 (XI675_n1 one3_b3_1 XI675_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI675_MN9 (VSS XI675_xn XI675_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI622_MN11 (VSS B_5_b3_1 XI622_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI622_MN14 (VSS XI622_xbn XI622_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI622_MN16 (XI622_xn2 B_5_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI622_MN15 (pp2_9 XI622_xan XI622_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI622_MN13 (XI622_xn1 XI622_xn pp2_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI622_MN2 (VSS A_9_b3_0 XI622_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI622_MN4 (XI622_n2 A_8_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI622_MN3 (XI622_xn two2_b3_1 XI622_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI622_MN1 (XI622_n1 one2_b3_1 XI622_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI622_MN9 (VSS XI622_xn XI622_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI623_MN11 (VSS B_5_b3_1 XI623_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI623_MN14 (VSS XI623_xbn XI623_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI623_MN16 (XI623_xn2 B_5_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI623_MN15 (pp2_10 XI623_xan XI623_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI623_MN13 (XI623_xn1 XI623_xn pp2_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI623_MN2 (VSS A_10_b3_0 XI623_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI623_MN4 (XI623_n2 A_9_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI623_MN3 (XI623_xn two2_b3_1 XI623_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI623_MN1 (XI623_n1 one2_b3_1 XI623_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI623_MN9 (VSS XI623_xn XI623_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI505_MN11 (VSS B_1_b3_0 XI505_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI505_MN14 (VSS XI505_xbn XI505_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI505_MN16 (XI505_xn2 B_1_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI505_MN15 (pp0_2 XI505_xan XI505_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI505_MN13 (XI505_xn1 XI505_xn pp0_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI505_MN2 (VSS A_2_b3_0 XI505_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI505_MN4 (XI505_n2 A_1_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI505_MN3 (XI505_xn two0_b3_0 XI505_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI505_MN1 (XI505_n1 one0_b3_0 XI505_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI505_MN9 (VSS XI505_xn XI505_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI504_MN11 (VSS B_1_b3_0 XI504_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI504_MN14 (VSS XI504_xbn XI504_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI504_MN16 (XI504_xn2 B_1_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI504_MN15 (pp0_1 XI504_xan XI504_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI504_MN13 (XI504_xn1 XI504_xn pp0_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI504_MN2 (VSS A_1_b3_0 XI504_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI504_MN4 (XI504_n2 A_0_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI504_MN3 (XI504_xn two0_b3_0 XI504_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI504_MN1 (XI504_n1 one0_b3_0 XI504_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI504_MN9 (VSS XI504_xn XI504_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI558_MN11 (VSS B_3_b3_0 XI558_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI558_MN14 (VSS XI558_xbn XI558_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI558_MN16 (XI558_xn2 B_3_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI558_MN15 (pp1_0 XI558_xan XI558_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI558_MN13 (XI558_xn1 XI558_xn pp1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI558_MN2 (VSS A_0_b3_0 XI558_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI558_MN4 (XI558_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI558_MN3 (XI558_xn two1_b3_0 XI558_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI558_MN1 (XI558_n1 one1_b3_0 XI558_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI558_MN9 (VSS XI558_xn XI558_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI559_MN11 (VSS B_3_b3_0 XI559_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI559_MN14 (VSS XI559_xbn XI559_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI559_MN16 (XI559_xn2 B_3_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI559_MN15 (pp1_1 XI559_xan XI559_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI559_MN13 (XI559_xn1 XI559_xn pp1_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI559_MN2 (VSS A_1_b3_0 XI559_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI559_MN4 (XI559_n2 A_0_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI559_MN3 (XI559_xn two1_b3_0 XI559_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI559_MN1 (XI559_n1 one1_b3_0 XI559_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI559_MN9 (VSS XI559_xn XI559_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI888_MN11 (VSS B_15_b3_0 XI888_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI888_MN14 (VSS XI888_xbn XI888_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI888_MN16 (XI888_xn2 B_15_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI888_MN15 (pp7_0 XI888_xan XI888_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI888_MN13 (XI888_xn1 XI888_xn pp7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI888_MN2 (VSS A_0_b3_2 XI888_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI888_MN4 (XI888_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI888_MN3 (XI888_xn two7_b3_0 XI888_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI888_MN1 (XI888_n1 one7_b3_0 XI888_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI888_MN9 (VSS XI888_xn XI888_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI836_MN11 (VSS B_13_b3_0 XI836_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI836_MN14 (VSS XI836_xbn XI836_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI836_MN16 (XI836_xn2 B_13_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI836_MN15 (pp6_3 XI836_xan XI836_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI836_MN13 (XI836_xn1 XI836_xn pp6_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI836_MN2 (VSS A_3_b3_2 XI836_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI836_MN4 (XI836_n2 A_2_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI836_MN3 (XI836_xn two6_b3_0 XI836_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI836_MN1 (XI836_n1 one6_b3_0 XI836_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI836_MN9 (VSS XI836_xn XI836_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI674_MN11 (VSS B_7_b3_1 XI674_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI674_MN14 (VSS XI674_xbn XI674_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI674_MN16 (XI674_xn2 B_7_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI674_MN15 (pp3_6 XI674_xan XI674_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI674_MN13 (XI674_xn1 XI674_xn pp3_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI674_MN2 (VSS A_6_b3_1 XI674_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI674_MN4 (XI674_n2 A_5_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI674_MN3 (XI674_xn two3_b3_1 XI674_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI674_MN1 (XI674_n1 one3_b3_1 XI674_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI674_MN9 (VSS XI674_xn XI674_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI621_MN11 (VSS B_5_b3_1 XI621_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI621_MN14 (VSS XI621_xbn XI621_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI621_MN16 (XI621_xn2 B_5_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI621_MN15 (pp2_8 XI621_xan XI621_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI621_MN13 (XI621_xn1 XI621_xn pp2_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI621_MN2 (VSS A_8_b3_0 XI621_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI621_MN4 (XI621_n2 A_7_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI621_MN3 (XI621_xn two2_b3_1 XI621_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI621_MN1 (XI621_n1 one2_b3_1 XI621_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI621_MN9 (VSS XI621_xn XI621_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI619_MN11 (VSS B_5_b3_1 XI619_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI619_MN14 (VSS XI619_xbn XI619_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI619_MN16 (XI619_xn2 B_5_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI619_MN15 (pp2_6 XI619_xan XI619_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI619_MN13 (XI619_xn1 XI619_xn pp2_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI619_MN2 (VSS A_6_b3_0 XI619_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI619_MN4 (XI619_n2 A_5_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI619_MN3 (XI619_xn two2_b3_1 XI619_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI619_MN1 (XI619_n1 one2_b3_1 XI619_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI619_MN9 (VSS XI619_xn XI619_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI620_MN11 (VSS B_5_b3_1 XI620_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI620_MN14 (VSS XI620_xbn XI620_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI620_MN16 (XI620_xn2 B_5_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI620_MN15 (pp2_7 XI620_xan XI620_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI620_MN13 (XI620_xn1 XI620_xn pp2_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI620_MN2 (VSS A_7_b3_0 XI620_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI620_MN4 (XI620_n2 A_6_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI620_MN3 (XI620_xn two2_b3_1 XI620_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI620_MN1 (XI620_n1 one2_b3_1 XI620_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI620_MN9 (VSS XI620_xn XI620_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI618_MN11 (VSS B_5_b3_1 XI618_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI618_MN14 (VSS XI618_xbn XI618_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI618_MN16 (XI618_xn2 B_5_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI618_MN15 (pp2_5 XI618_xan XI618_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI618_MN13 (XI618_xn1 XI618_xn pp2_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI618_MN2 (VSS A_5_b3_0 XI618_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI618_MN4 (XI618_n2 A_4_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI618_MN3 (XI618_xn two2_b3_0 XI618_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI618_MN1 (XI618_n1 one2_b3_0 XI618_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI618_MN9 (VSS XI618_xn XI618_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI508_MN11 (VSS B_1_b3_1 XI508_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI508_MN14 (VSS XI508_xbn XI508_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI508_MN16 (XI508_xn2 B_1_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI508_MN15 (pp0_5 XI508_xan XI508_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI508_MN13 (XI508_xn1 XI508_xn pp0_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI508_MN2 (VSS A_5_b3_0 XI508_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI508_MN4 (XI508_n2 A_4_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI508_MN3 (XI508_xn two0_b3_0 XI508_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI508_MN1 (XI508_n1 one0_b3_0 XI508_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI508_MN9 (VSS XI508_xn XI508_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI562_MN11 (VSS B_3_b3_0 XI562_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI562_MN14 (VSS XI562_xbn XI562_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI562_MN16 (XI562_xn2 B_3_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI562_MN15 (pp1_4 XI562_xan XI562_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI562_MN13 (XI562_xn1 XI562_xn pp1_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI562_MN2 (VSS A_4_b3_0 XI562_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI562_MN4 (XI562_n2 A_3_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI562_MN3 (XI562_xn two1_b3_0 XI562_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI562_MN1 (XI562_n1 one1_b3_0 XI562_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI562_MN9 (VSS XI562_xn XI562_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI507_MN11 (VSS B_1_b3_0 XI507_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI507_MN14 (VSS XI507_xbn XI507_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI507_MN16 (XI507_xn2 B_1_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI507_MN15 (pp0_4 XI507_xan XI507_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI507_MN13 (XI507_xn1 XI507_xn pp0_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI507_MN2 (VSS A_4_b3_0 XI507_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI507_MN4 (XI507_n2 A_3_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI507_MN3 (XI507_xn two0_b3_0 XI507_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI507_MN1 (XI507_n1 one0_b3_0 XI507_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI507_MN9 (VSS XI507_xn XI507_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI506_MN11 (VSS B_1_b3_0 XI506_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI506_MN14 (VSS XI506_xbn XI506_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI506_MN16 (XI506_xn2 B_1_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI506_MN15 (pp0_3 XI506_xan XI506_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI506_MN13 (XI506_xn1 XI506_xn pp0_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI506_MN2 (VSS A_3_b3_0 XI506_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI506_MN4 (XI506_n2 A_2_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI506_MN3 (XI506_xn two0_b3_0 XI506_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI506_MN1 (XI506_n1 one0_b3_0 XI506_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI506_MN9 (VSS XI506_xn XI506_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI561_MN11 (VSS B_3_b3_0 XI561_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI561_MN14 (VSS XI561_xbn XI561_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI561_MN16 (XI561_xn2 B_3_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI561_MN15 (pp1_3 XI561_xan XI561_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI561_MN13 (XI561_xn1 XI561_xn pp1_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI561_MN2 (VSS A_3_b3_0 XI561_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI561_MN4 (XI561_n2 A_2_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI561_MN3 (XI561_xn two1_b3_0 XI561_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI561_MN1 (XI561_n1 one1_b3_0 XI561_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI561_MN9 (VSS XI561_xn XI561_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI834_MN11 (VSS B_13_b3_0 XI834_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI834_MN14 (VSS XI834_xbn XI834_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI834_MN16 (XI834_xn2 B_13_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI834_MN15 (pp6_1 XI834_xan XI834_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI834_MN13 (XI834_xn1 XI834_xn pp6_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI834_MN2 (VSS A_1_b3_2 XI834_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI834_MN4 (XI834_n2 A_0_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI834_MN3 (XI834_xn two6_b3_0 XI834_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI834_MN1 (XI834_n1 one6_b3_0 XI834_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI834_MN9 (VSS XI834_xn XI834_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI835_MN11 (VSS B_13_b3_0 XI835_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI835_MN14 (VSS XI835_xbn XI835_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI835_MN16 (XI835_xn2 B_13_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI835_MN15 (pp6_2 XI835_xan XI835_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI835_MN13 (XI835_xn1 XI835_xn pp6_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI835_MN2 (VSS A_2_b3_2 XI835_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI835_MN4 (XI835_n2 A_1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI835_MN3 (XI835_xn two6_b3_0 XI835_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI835_MN1 (XI835_n1 one6_b3_0 XI835_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI835_MN9 (VSS XI835_xn XI835_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI781_MN11 (VSS B_11_b3_0 XI781_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI781_MN14 (VSS XI781_xbn XI781_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI781_MN16 (XI781_xn2 B_11_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI781_MN15 (pp5_3 XI781_xan XI781_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI781_MN13 (XI781_xn1 XI781_xn pp5_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI781_MN2 (VSS A_3_b3_1 XI781_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI781_MN4 (XI781_n2 A_2_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI781_MN3 (XI781_xn two5_b3_0 XI781_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI781_MN1 (XI781_n1 one5_b3_0 XI781_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI781_MN9 (VSS XI781_xn XI781_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI782_MN11 (VSS B_11_b3_0 XI782_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI782_MN14 (VSS XI782_xbn XI782_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI782_MN16 (XI782_xn2 B_11_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI782_MN15 (pp5_4 XI782_xan XI782_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI782_MN13 (XI782_xn1 XI782_xn pp5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI782_MN2 (VSS A_4_b3_1 XI782_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI782_MN4 (XI782_n2 A_3_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI782_MN3 (XI782_xn two5_b3_0 XI782_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI782_MN1 (XI782_n1 one5_b3_0 XI782_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI782_MN9 (VSS XI782_xn XI782_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI728_MN11 (VSS B_9_b3_1 XI728_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI728_MN14 (VSS XI728_xbn XI728_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI728_MN16 (XI728_xn2 B_9_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI728_MN15 (pp4_5 XI728_xan XI728_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI728_MN13 (XI728_xn1 XI728_xn pp4_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI728_MN2 (VSS A_5_b3_1 XI728_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI728_MN4 (XI728_n2 A_4_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI728_MN3 (XI728_xn two4_b3_0 XI728_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI728_MN1 (XI728_n1 one4_b3_0 XI728_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI728_MN9 (VSS XI728_xn XI728_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI672_MN11 (VSS B_7_b3_0 XI672_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI672_MN14 (VSS XI672_xbn XI672_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI672_MN16 (XI672_xn2 B_7_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI672_MN15 (pp3_4 XI672_xan XI672_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI672_MN13 (XI672_xn1 XI672_xn pp3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI672_MN2 (VSS A_4_b3_1 XI672_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI672_MN4 (XI672_n2 A_3_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI672_MN3 (XI672_xn two3_b3_0 XI672_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI672_MN1 (XI672_n1 one3_b3_0 XI672_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI672_MN9 (VSS XI672_xn XI672_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI673_MN11 (VSS B_7_b3_1 XI673_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI673_MN14 (VSS XI673_xbn XI673_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI673_MN16 (XI673_xn2 B_7_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI673_MN15 (pp3_5 XI673_xan XI673_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI673_MN13 (XI673_xn1 XI673_xn pp3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI673_MN2 (VSS A_5_b3_1 XI673_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI673_MN4 (XI673_n2 A_4_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI673_MN3 (XI673_xn two3_b3_0 XI673_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI673_MN1 (XI673_n1 one3_b3_0 XI673_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI673_MN9 (VSS XI673_xn XI673_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI567_MN11 (VSS B_3_b3_1 XI567_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI567_MN14 (VSS XI567_xbn XI567_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI567_MN16 (XI567_xn2 B_3_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI567_MN15 (pp1_9 XI567_xan XI567_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI567_MN13 (XI567_xn1 XI567_xn pp1_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI567_MN2 (VSS A_9_b3_0 XI567_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI567_MN4 (XI567_n2 A_8_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI567_MN3 (XI567_xn two1_b3_1 XI567_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI567_MN1 (XI567_n1 one1_b3_1 XI567_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI567_MN9 (VSS XI567_xn XI567_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI568_MN11 (VSS B_3_b3_1 XI568_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI568_MN14 (VSS XI568_xbn XI568_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI568_MN16 (XI568_xn2 B_3_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI568_MN15 (pp1_10 XI568_xan XI568_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI568_MN13 (XI568_xn1 XI568_xn pp1_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI568_MN2 (VSS A_10_b3_0 XI568_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI568_MN4 (XI568_n2 A_9_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI568_MN3 (XI568_xn two1_b3_1 XI568_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI568_MN1 (XI568_n1 one1_b3_1 XI568_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI568_MN9 (VSS XI568_xn XI568_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI513_MN11 (VSS B_1_b3_1 XI513_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI513_MN14 (VSS XI513_xbn XI513_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI513_MN16 (XI513_xn2 B_1_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI513_MN15 (pp0_10 XI513_xan XI513_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI513_MN13 (XI513_xn1 XI513_xn pp0_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI513_MN2 (VSS A_10_b3_0 XI513_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI513_MN4 (XI513_n2 A_9_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI513_MN3 (XI513_xn two0_b3_1 XI513_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI513_MN1 (XI513_n1 one0_b3_1 XI513_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI513_MN9 (VSS XI513_xn XI513_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI564_MN11 (VSS B_3_b3_1 XI564_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI564_MN14 (VSS XI564_xbn XI564_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI564_MN16 (XI564_xn2 B_3_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI564_MN15 (pp1_6 XI564_xan XI564_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI564_MN13 (XI564_xn1 XI564_xn pp1_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI564_MN2 (VSS A_6_b3_0 XI564_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI564_MN4 (XI564_n2 A_5_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI564_MN3 (XI564_xn two1_b3_1 XI564_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI564_MN1 (XI564_n1 one1_b3_1 XI564_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI564_MN9 (VSS XI564_xn XI564_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI563_MN11 (VSS B_3_b3_1 XI563_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI563_MN14 (VSS XI563_xbn XI563_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI563_MN16 (XI563_xn2 B_3_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI563_MN15 (pp1_5 XI563_xan XI563_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI563_MN13 (XI563_xn1 XI563_xn pp1_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI563_MN2 (VSS A_5_b3_0 XI563_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI563_MN4 (XI563_n2 A_4_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI563_MN3 (XI563_xn two1_b3_0 XI563_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI563_MN1 (XI563_n1 one1_b3_0 XI563_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI563_MN9 (VSS XI563_xn XI563_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI509_MN11 (VSS B_1_b3_1 XI509_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI509_MN14 (VSS XI509_xbn XI509_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI509_MN16 (XI509_xn2 B_1_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI509_MN15 (pp0_6 XI509_xan XI509_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI509_MN13 (XI509_xn1 XI509_xn pp0_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI509_MN2 (VSS A_6_b3_0 XI509_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI509_MN4 (XI509_n2 A_5_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI509_MN3 (XI509_xn two0_b3_1 XI509_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI509_MN1 (XI509_n1 one0_b3_1 XI509_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI509_MN9 (VSS XI509_xn XI509_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI510_MN11 (VSS B_1_b3_1 XI510_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI510_MN14 (VSS XI510_xbn XI510_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI510_MN16 (XI510_xn2 B_1_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI510_MN15 (pp0_7 XI510_xan XI510_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI510_MN13 (XI510_xn1 XI510_xn pp0_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI510_MN2 (VSS A_7_b3_0 XI510_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI510_MN4 (XI510_n2 A_6_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI510_MN3 (XI510_xn two0_b3_1 XI510_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI510_MN1 (XI510_n1 one0_b3_1 XI510_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI510_MN9 (VSS XI510_xn XI510_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI617_MN11 (VSS B_5_b3_0 XI617_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI617_MN14 (VSS XI617_xbn XI617_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI617_MN16 (XI617_xn2 B_5_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI617_MN15 (pp2_4 XI617_xan XI617_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI617_MN13 (XI617_xn1 XI617_xn pp2_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI617_MN2 (VSS A_4_b3_0 XI617_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI617_MN4 (XI617_n2 A_3_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI617_MN3 (XI617_xn two2_b3_0 XI617_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI617_MN1 (XI617_n1 one2_b3_0 XI617_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI617_MN9 (VSS XI617_xn XI617_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI616_MN11 (VSS B_5_b3_0 XI616_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI616_MN14 (VSS XI616_xbn XI616_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI616_MN16 (XI616_xn2 B_5_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI616_MN15 (pp2_3 XI616_xan XI616_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI616_MN13 (XI616_xn1 XI616_xn pp2_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI616_MN2 (VSS A_3_b3_0 XI616_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI616_MN4 (XI616_n2 A_2_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI616_MN3 (XI616_xn two2_b3_0 XI616_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI616_MN1 (XI616_n1 one2_b3_0 XI616_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI616_MN9 (VSS XI616_xn XI616_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI615_MN11 (VSS B_5_b3_0 XI615_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI615_MN14 (VSS XI615_xbn XI615_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI615_MN16 (XI615_xn2 B_5_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI615_MN15 (pp2_2 XI615_xan XI615_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI615_MN13 (XI615_xn1 XI615_xn pp2_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI615_MN2 (VSS A_2_b3_0 XI615_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI615_MN4 (XI615_n2 A_1_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI615_MN3 (XI615_xn two2_b3_0 XI615_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI615_MN1 (XI615_n1 one2_b3_0 XI615_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI615_MN9 (VSS XI615_xn XI615_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI613_MN11 (VSS B_5_b3_0 XI613_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI613_MN14 (VSS XI613_xbn XI613_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI613_MN16 (XI613_xn2 B_5_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI613_MN15 (pp2_0 XI613_xan XI613_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI613_MN13 (XI613_xn1 XI613_xn pp2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI613_MN2 (VSS A_0_b3_0 XI613_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI613_MN4 (XI613_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI613_MN3 (XI613_xn two2_b3_0 XI613_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI613_MN1 (XI613_n1 one2_b3_0 XI613_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI613_MN9 (VSS XI613_xn XI613_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI614_MN11 (VSS B_5_b3_0 XI614_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI614_MN14 (VSS XI614_xbn XI614_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI614_MN16 (XI614_xn2 B_5_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI614_MN15 (pp2_1 XI614_xan XI614_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI614_MN13 (XI614_xn1 XI614_xn pp2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI614_MN2 (VSS A_1_b3_0 XI614_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI614_MN4 (XI614_n2 A_0_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI614_MN3 (XI614_xn two2_b3_0 XI614_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI614_MN1 (XI614_n1 one2_b3_0 XI614_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI614_MN9 (VSS XI614_xn XI614_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI560_MN11 (VSS B_3_b3_0 XI560_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI560_MN14 (VSS XI560_xbn XI560_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI560_MN16 (XI560_xn2 B_3_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI560_MN15 (pp1_2 XI560_xan XI560_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI560_MN13 (XI560_xn1 XI560_xn pp1_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI560_MN2 (VSS A_2_b3_0 XI560_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI560_MN4 (XI560_n2 A_1_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI560_MN3 (XI560_xn two1_b3_0 XI560_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI560_MN1 (XI560_n1 one1_b3_0 XI560_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI560_MN9 (VSS XI560_xn XI560_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI833_MN11 (VSS B_13_b3_0 XI833_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI833_MN14 (VSS XI833_xbn XI833_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI833_MN16 (XI833_xn2 B_13_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI833_MN15 (pp6_0 XI833_xan XI833_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI833_MN13 (XI833_xn1 XI833_xn pp6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI833_MN2 (VSS A_0_b3_2 XI833_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI833_MN4 (XI833_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI833_MN3 (XI833_xn two6_b3_0 XI833_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI833_MN1 (XI833_n1 one6_b3_0 XI833_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI833_MN9 (VSS XI833_xn XI833_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI780_MN11 (VSS B_11_b3_0 XI780_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI780_MN14 (VSS XI780_xbn XI780_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI780_MN16 (XI780_xn2 B_11_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI780_MN15 (pp5_2 XI780_xan XI780_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI780_MN13 (XI780_xn1 XI780_xn pp5_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI780_MN2 (VSS A_2_b3_1 XI780_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI780_MN4 (XI780_n2 A_1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI780_MN3 (XI780_xn two5_b3_0 XI780_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI780_MN1 (XI780_n1 one5_b3_0 XI780_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI780_MN9 (VSS XI780_xn XI780_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI727_MN11 (VSS B_9_b3_0 XI727_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI727_MN14 (VSS XI727_xbn XI727_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI727_MN16 (XI727_xn2 B_9_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI727_MN15 (pp4_4 XI727_xan XI727_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI727_MN13 (XI727_xn1 XI727_xn pp4_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI727_MN2 (VSS A_4_b3_1 XI727_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI727_MN4 (XI727_n2 A_3_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI727_MN3 (XI727_xn two4_b3_0 XI727_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI727_MN1 (XI727_n1 one4_b3_0 XI727_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI727_MN9 (VSS XI727_xn XI727_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI726_MN11 (VSS B_9_b3_0 XI726_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI726_MN14 (VSS XI726_xbn XI726_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI726_MN16 (XI726_xn2 B_9_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI726_MN15 (pp4_3 XI726_xan XI726_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI726_MN13 (XI726_xn1 XI726_xn pp4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI726_MN2 (VSS A_3_b3_1 XI726_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI726_MN4 (XI726_n2 A_2_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI726_MN3 (XI726_xn two4_b3_0 XI726_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI726_MN1 (XI726_n1 one4_b3_0 XI726_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI726_MN9 (VSS XI726_xn XI726_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI669_MN11 (VSS B_7_b3_0 XI669_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI669_MN14 (VSS XI669_xbn XI669_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI669_MN16 (XI669_xn2 B_7_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI669_MN15 (pp3_1 XI669_xan XI669_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI669_MN13 (XI669_xn1 XI669_xn pp3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI669_MN2 (VSS A_1_b3_1 XI669_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI669_MN4 (XI669_n2 A_0_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI669_MN3 (XI669_xn two3_b3_0 XI669_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI669_MN1 (XI669_n1 one3_b3_0 XI669_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI669_MN9 (VSS XI669_xn XI669_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI668_MN11 (VSS B_7_b3_0 XI668_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI668_MN14 (VSS XI668_xbn XI668_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI668_MN16 (XI668_xn2 B_7_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI668_MN15 (pp3_0 XI668_xan XI668_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI668_MN13 (XI668_xn1 XI668_xn pp3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI668_MN2 (VSS A_0_b3_1 XI668_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI668_MN4 (XI668_n2 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI668_MN3 (XI668_xn two3_b3_0 XI668_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI668_MN1 (XI668_n1 one3_b3_0 XI668_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI668_MN9 (VSS XI668_xn XI668_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI566_MN11 (VSS B_3_b3_1 XI566_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI566_MN14 (VSS XI566_xbn XI566_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI566_MN16 (XI566_xn2 B_3_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI566_MN15 (pp1_8 XI566_xan XI566_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI566_MN13 (XI566_xn1 XI566_xn pp1_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI566_MN2 (VSS A_8_b3_0 XI566_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI566_MN4 (XI566_n2 A_7_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI566_MN3 (XI566_xn two1_b3_1 XI566_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI566_MN1 (XI566_n1 one1_b3_1 XI566_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI566_MN9 (VSS XI566_xn XI566_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI512_MN11 (VSS B_1_b3_1 XI512_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI512_MN14 (VSS XI512_xbn XI512_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI512_MN16 (XI512_xn2 B_1_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI512_MN15 (pp0_9 XI512_xan XI512_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI512_MN13 (XI512_xn1 XI512_xn pp0_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI512_MN2 (VSS A_9_b3_0 XI512_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI512_MN4 (XI512_n2 A_8_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI512_MN3 (XI512_xn two0_b3_1 XI512_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI512_MN1 (XI512_n1 one0_b3_1 XI512_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI512_MN9 (VSS XI512_xn XI512_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI565_MN11 (VSS B_3_b3_1 XI565_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI565_MN14 (VSS XI565_xbn XI565_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI565_MN16 (XI565_xn2 B_3_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI565_MN15 (pp1_7 XI565_xan XI565_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI565_MN13 (XI565_xn1 XI565_xn pp1_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI565_MN2 (VSS A_7_b3_0 XI565_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
    I_MXI565_MN4 (XI565_n2 A_6_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI565_MN3 (XI565_xn two1_b3_1 XI565_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67999u ps=0.67999u
    I_MXI565_MN1 (XI565_n1 one1_b3_1 XI565_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15999u ps=0.67999u
    I_MXI565_MN9 (VSS XI565_xn XI565_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI511_MN11 (VSS B_1_b3_1 XI511_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15999u ps=1.15999u
    I_MXI511_MN14 (VSS XI511_xbn XI511_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67999u ps=1.15999u
