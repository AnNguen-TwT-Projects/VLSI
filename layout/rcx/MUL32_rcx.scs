    I_MXI1393_MN27 (cm32_2 XI1393_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1393_MN7 (XI1393_an3 pp5_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1393_MN8 (VSS pp6_9 XI1393_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1389_MN34 (XI1389_bn3 XI1389_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1389_MN35 (VSS pp3_14 XI1389_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1389_MN36 (XI1389_bn3 cm26_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1389_MN37 (XI1389_bsn XI1389_bcon XI1389_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1389_MN40 (XI1389_bn5 cm26_2 XI1389_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1389_MN39 (XI1389_bn4 pp3_14 XI1389_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1389_MN39_1 (XI1389_bn5 pp3_14 XI1389_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1389_MN40_1 (XI1389_bsn cm26_2 XI1389_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1389_MN53 (VSS XI1389_bsn cm28_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1389_MN29 (XI1389_bn1 XI1389_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1389_MN30 (XI1389_bcon pp3_14 XI1389_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1389_MN33 (XI1389_bn2 cm26_2 XI1389_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1389_MN31 (VSS XI1389_s1 XI1389_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1389_MN32 (XI1389_bn2 pp3_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1389_MN55 (VSS XI1389_bcon cm28_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1389_MN38 (XI1389_bn4 XI1389_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1389_MN38_1 (VSS XI1389_s1 XI1389_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1389_MN25 (VSS XI1389_asn XI1389_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1389_MN10 (VSS pp0_20 XI1389_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1389_MN6 (XI1389_an3 pp0_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1389_MN9 (XI1389_asn XI1389_acon XI1389_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1389_MN12 (XI1389_an5 pp2_16 XI1389_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1389_MN11 (XI1389_an4 pp1_18 XI1389_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1389_MN11_1 (XI1389_an5 pp1_18 XI1389_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1389_MN12_1 (XI1389_asn pp2_16 XI1389_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1389_MN10_1 (XI1389_an4 pp0_20 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1389_MN5 (XI1389_acon pp2_16 XI1389_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1389_MN2 (XI1389_an1 pp1_18 XI1389_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1389_MN1 (VSS pp0_20 XI1389_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1389_MN3 (XI1389_an2 pp0_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1389_MN4 (VSS pp1_18 XI1389_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1389_MN27 (cm28_2 XI1389_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1389_MN7 (XI1389_an3 pp1_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1389_MN8 (VSS pp2_16 XI1389_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1577_MN34 (XI1577_bn3 XI1577_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1577_MN35 (VSS cm36_0 XI1577_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1577_MN36 (XI1577_bn3 cm215_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1577_MN37 (XI1577_bsn XI1577_bcon XI1577_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1577_MN40 (XI1577_bn5 cm215_2 XI1577_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1577_MN39 (XI1577_bn4 cm36_0 XI1577_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1577_MN39_1 (XI1577_bn5 cm36_0 XI1577_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1577_MN40_1 (XI1577_bsn cm215_2 XI1577_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1577_MN53 (VSS XI1577_bsn cm216_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1577_MN29 (XI1577_bn1 XI1577_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1577_MN30 (XI1577_bcon cm36_0 XI1577_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1577_MN33 (XI1577_bn2 cm215_2 XI1577_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1577_MN31 (VSS XI1577_s1 XI1577_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1577_MN32 (XI1577_bn2 cm36_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1577_MN55 (VSS XI1577_bcon cm216_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1577_MN38 (XI1577_bn4 XI1577_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1577_MN38_1 (VSS XI1577_s1 XI1577_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1577_MN25 (VSS XI1577_asn XI1577_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1577_MN10 (VSS cm152_1 XI1577_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1577_MN6 (XI1577_an3 cm152_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1577_MN9 (XI1577_asn XI1577_acon XI1577_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1577_MN12 (XI1577_an5 cm35_0 XI1577_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1577_MN11 (XI1577_an4 cm153_0 XI1577_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1577_MN11_1 (XI1577_an5 cm153_0 XI1577_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1577_MN12_1 (XI1577_asn cm35_0 XI1577_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1577_MN10_1 (XI1577_an4 cm152_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1577_MN5 (XI1577_acon cm35_0 XI1577_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1577_MN2 (XI1577_an1 cm153_0 XI1577_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1577_MN1 (VSS cm152_1 XI1577_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1577_MN3 (XI1577_an2 cm152_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1577_MN4 (VSS cm153_0 XI1577_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1577_MN27 (cm216_2 XI1577_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1577_MN7 (XI1577_an3 cm153_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1577_MN8 (VSS cm35_0 XI1577_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1513_MN34 (XI1513_bn3 XI1513_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1513_MN35 (VSS cm31_0 XI1513_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1513_MN36 (XI1513_bn3 cm151_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1513_MN37 (XI1513_bsn XI1513_bcon XI1513_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1513_MN40 (XI1513_bn5 cm151_2 XI1513_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1513_MN39 (XI1513_bn4 cm31_0 XI1513_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1513_MN39_1 (XI1513_bn5 cm31_0 XI1513_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1513_MN40_1 (XI1513_bsn cm151_2 XI1513_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1513_MN53 (VSS XI1513_bsn cm152_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1513_MN29 (XI1513_bn1 XI1513_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1513_MN30 (XI1513_bcon cm31_0 XI1513_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1513_MN33 (XI1513_bn2 cm151_2 XI1513_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1513_MN31 (VSS XI1513_s1 XI1513_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1513_MN32 (XI1513_bn2 cm31_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1513_MN55 (VSS XI1513_bcon cm152_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1513_MN38 (XI1513_bn4 XI1513_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1513_MN38_1 (VSS XI1513_s1 XI1513_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1513_MN25 (VSS XI1513_asn XI1513_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1513_MN10 (VSS cm28_1 XI1513_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1513_MN6 (XI1513_an3 cm28_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1513_MN9 (XI1513_asn XI1513_acon XI1513_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1513_MN12 (XI1513_an5 fa30_1 XI1513_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1513_MN11 (XI1513_an4 cm29_1 XI1513_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1513_MN11_1 (XI1513_an5 cm29_1 XI1513_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1513_MN12_1 (XI1513_asn fa30_1 XI1513_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1513_MN10_1 (XI1513_an4 cm28_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1513_MN5 (XI1513_acon fa30_1 XI1513_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1513_MN2 (XI1513_an1 cm29_1 XI1513_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1513_MN1 (VSS cm28_1 XI1513_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1513_MN3 (XI1513_an2 cm28_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1513_MN4 (VSS cm29_1 XI1513_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1513_MN27 (cm152_2 XI1513_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1513_MN7 (XI1513_an3 cm29_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1513_MN8 (VSS fa30_1 XI1513_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1390_MN34 (XI1390_bn3 XI1390_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1390_MN35 (VSS pp7_6 XI1390_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1390_MN36 (XI1390_bn3 cm27_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1390_MN37 (XI1390_bsn XI1390_bcon XI1390_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1390_MN40 (XI1390_bn5 cm27_2 XI1390_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1390_MN39 (XI1390_bn4 pp7_6 XI1390_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1390_MN39_1 (XI1390_bn5 pp7_6 XI1390_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1390_MN40_1 (XI1390_bsn cm27_2 XI1390_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1390_MN53 (VSS XI1390_bsn cm29_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1390_MN29 (XI1390_bn1 XI1390_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1390_MN30 (XI1390_bcon pp7_6 XI1390_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1390_MN33 (XI1390_bn2 cm27_2 XI1390_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1390_MN31 (VSS XI1390_s1 XI1390_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1390_MN32 (XI1390_bn2 pp7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1390_MN55 (VSS XI1390_bcon cm29_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1390_MN38 (XI1390_bn4 XI1390_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1390_MN38_1 (VSS XI1390_s1 XI1390_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1390_MN25 (VSS XI1390_asn XI1390_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1390_MN10 (VSS pp4_12 XI1390_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1390_MN6 (XI1390_an3 pp4_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1390_MN9 (XI1390_asn XI1390_acon XI1390_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1390_MN12 (XI1390_an5 pp6_8 XI1390_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1390_MN11 (XI1390_an4 pp5_10 XI1390_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1390_MN11_1 (XI1390_an5 pp5_10 XI1390_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1390_MN12_1 (XI1390_asn pp6_8 XI1390_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1390_MN10_1 (XI1390_an4 pp4_12 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1390_MN5 (XI1390_acon pp6_8 XI1390_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1390_MN2 (XI1390_an1 pp5_10 XI1390_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1390_MN1 (VSS pp4_12 XI1390_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1390_MN3 (XI1390_an2 pp4_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1390_MN4 (VSS pp5_10 XI1390_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1390_MN27 (cm29_2 XI1390_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1390_MN7 (XI1390_an3 pp5_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1390_MN8 (VSS pp6_8 XI1390_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1387_MN34 (XI1387_bn3 XI1387_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1387_MN35 (VSS pp3_13 XI1387_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1387_MN36 (XI1387_bn3 cm23_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1387_MN37 (XI1387_bsn XI1387_bcon XI1387_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1387_MN40 (XI1387_bn5 cm23_2 XI1387_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1387_MN39 (XI1387_bn4 pp3_13 XI1387_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1387_MN39_1 (XI1387_bn5 pp3_13 XI1387_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1387_MN40_1 (XI1387_bsn cm23_2 XI1387_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1387_MN53 (VSS XI1387_bsn cm26_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1387_MN29 (XI1387_bn1 XI1387_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1387_MN30 (XI1387_bcon pp3_13 XI1387_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1387_MN33 (XI1387_bn2 cm23_2 XI1387_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1387_MN31 (VSS XI1387_s1 XI1387_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1387_MN32 (XI1387_bn2 pp3_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1387_MN55 (VSS XI1387_bcon cm26_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1387_MN38 (XI1387_bn4 XI1387_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1387_MN38_1 (VSS XI1387_s1 XI1387_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1387_MN25 (VSS XI1387_asn XI1387_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1387_MN10 (VSS pp0_19 XI1387_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1387_MN6 (XI1387_an3 pp0_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1387_MN9 (XI1387_asn XI1387_acon XI1387_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1387_MN12 (XI1387_an5 pp2_15 XI1387_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1387_MN11 (XI1387_an4 pp1_17 XI1387_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1387_MN11_1 (XI1387_an5 pp1_17 XI1387_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1387_MN12_1 (XI1387_asn pp2_15 XI1387_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1387_MN10_1 (XI1387_an4 pp0_19 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1387_MN5 (XI1387_acon pp2_15 XI1387_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1387_MN2 (XI1387_an1 pp1_17 XI1387_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1387_MN1 (VSS pp0_19 XI1387_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1387_MN3 (XI1387_an2 pp0_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1387_MN4 (VSS pp1_17 XI1387_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1387_MN27 (cm26_2 XI1387_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1387_MN7 (XI1387_an3 pp1_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1387_MN8 (VSS pp2_15 XI1387_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1384_MN34 (XI1384_bn3 XI1384_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1384_MN35 (VSS pp3_12 XI1384_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1384_MN36 (XI1384_bn3 cm21_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1384_MN37 (XI1384_bsn XI1384_bcon XI1384_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1384_MN40 (XI1384_bn5 cm21_2 XI1384_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1384_MN39 (XI1384_bn4 pp3_12 XI1384_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1384_MN39_1 (XI1384_bn5 pp3_12 XI1384_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1384_MN40_1 (XI1384_bsn cm21_2 XI1384_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1384_MN53 (VSS XI1384_bsn cm23_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1384_MN29 (XI1384_bn1 XI1384_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1384_MN30 (XI1384_bcon pp3_12 XI1384_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1384_MN33 (XI1384_bn2 cm21_2 XI1384_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1384_MN31 (VSS XI1384_s1 XI1384_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1384_MN32 (XI1384_bn2 pp3_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1384_MN55 (VSS XI1384_bcon cm23_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1384_MN38 (XI1384_bn4 XI1384_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1384_MN38_1 (VSS XI1384_s1 XI1384_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1384_MN25 (VSS XI1384_asn XI1384_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1384_MN10 (VSS pp0_18 XI1384_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1384_MN6 (XI1384_an3 pp0_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1384_MN9 (XI1384_asn XI1384_acon XI1384_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1384_MN12 (XI1384_an5 pp2_14 XI1384_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1384_MN11 (XI1384_an4 pp1_16 XI1384_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1384_MN11_1 (XI1384_an5 pp1_16 XI1384_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1384_MN12_1 (XI1384_asn pp2_14 XI1384_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1384_MN10_1 (XI1384_an4 pp0_18 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1384_MN5 (XI1384_acon pp2_14 XI1384_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1384_MN2 (XI1384_an1 pp1_16 XI1384_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1384_MN1 (VSS pp0_18 XI1384_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1384_MN3 (XI1384_an2 pp0_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1384_MN4 (VSS pp1_16 XI1384_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1384_MN27 (cm23_2 XI1384_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1384_MN7 (XI1384_an3 pp1_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1384_MN8 (VSS pp2_14 XI1384_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1512_MN34 (XI1512_bn3 XI1512_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1512_MN35 (VSS cm29_0 XI1512_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1512_MN36 (XI1512_bn3 cm149_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1512_MN37 (XI1512_bsn XI1512_bcon XI1512_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1512_MN40 (XI1512_bn5 cm149_2 XI1512_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1512_MN39 (XI1512_bn4 cm29_0 XI1512_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1512_MN39_1 (XI1512_bn5 cm29_0 XI1512_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1512_MN40_1 (XI1512_bsn cm149_2 XI1512_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1512_MN53 (VSS XI1512_bsn cm151_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1512_MN29 (XI1512_bn1 XI1512_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1512_MN30 (XI1512_bcon cm29_0 XI1512_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1512_MN33 (XI1512_bn2 cm149_2 XI1512_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1512_MN31 (VSS XI1512_s1 XI1512_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1512_MN32 (XI1512_bn2 cm29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1512_MN55 (VSS XI1512_bcon cm151_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1512_MN38 (XI1512_bn4 XI1512_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1512_MN38_1 (VSS XI1512_s1 XI1512_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1512_MN25 (VSS XI1512_asn XI1512_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1512_MN10 (VSS cm26_1 XI1512_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1512_MN6 (XI1512_an3 cm26_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1512_MN9 (XI1512_asn XI1512_acon XI1512_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1512_MN12 (XI1512_an5 cm28_0 XI1512_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1512_MN11 (XI1512_an4 cm27_1 XI1512_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1512_MN11_1 (XI1512_an5 cm27_1 XI1512_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1512_MN12_1 (XI1512_asn cm28_0 XI1512_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1512_MN10_1 (XI1512_an4 cm26_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1512_MN5 (XI1512_acon cm28_0 XI1512_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1512_MN2 (XI1512_an1 cm27_1 XI1512_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1512_MN1 (VSS cm26_1 XI1512_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1512_MN3 (XI1512_an2 cm26_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1512_MN4 (VSS cm27_1 XI1512_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1512_MN27 (cm151_2 XI1512_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1512_MN7 (XI1512_an3 cm27_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1512_MN8 (VSS cm28_0 XI1512_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1576_MN34 (XI1576_bn3 XI1576_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1576_MN35 (VSS fa33_0 XI1576_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1576_MN36 (XI1576_bn3 cm214_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1576_MN37 (XI1576_bsn XI1576_bcon XI1576_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1576_MN40 (XI1576_bn5 cm214_2 XI1576_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1576_MN39 (XI1576_bn4 fa33_0 XI1576_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1576_MN39_1 (XI1576_bn5 fa33_0 XI1576_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1576_MN40_1 (XI1576_bsn cm214_2 XI1576_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1576_MN53 (VSS XI1576_bsn cm215_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1576_MN29 (XI1576_bn1 XI1576_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1576_MN30 (XI1576_bcon fa33_0 XI1576_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1576_MN33 (XI1576_bn2 cm214_2 XI1576_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1576_MN31 (VSS XI1576_s1 XI1576_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1576_MN32 (XI1576_bn2 fa33_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1576_MN55 (VSS XI1576_bcon cm215_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1576_MN38 (XI1576_bn4 XI1576_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1576_MN38_1 (VSS XI1576_s1 XI1576_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1576_MN25 (VSS XI1576_asn XI1576_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1576_MN10 (VSS cm151_1 XI1576_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1576_MN6 (XI1576_an3 cm151_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1576_MN9 (XI1576_asn XI1576_acon XI1576_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1576_MN12 (XI1576_an5 cm32_0 XI1576_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1576_MN11 (XI1576_an4 cm152_0 XI1576_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1576_MN11_1 (XI1576_an5 cm152_0 XI1576_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1576_MN12_1 (XI1576_asn cm32_0 XI1576_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1576_MN10_1 (XI1576_an4 cm151_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1576_MN5 (XI1576_acon cm32_0 XI1576_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1576_MN2 (XI1576_an1 cm152_0 XI1576_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1576_MN1 (VSS cm151_1 XI1576_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1576_MN3 (XI1576_an2 cm151_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1576_MN4 (VSS cm152_0 XI1576_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1576_MN27 (cm215_2 XI1576_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1576_MN7 (XI1576_an3 cm152_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1576_MN8 (VSS cm32_0 XI1576_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1575_MN34 (XI1575_bn3 XI1575_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1575_MN35 (VSS fa30_0 XI1575_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1575_MN36 (XI1575_bn3 B_21_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1575_MN37 (XI1575_bsn XI1575_bcon XI1575_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1575_MN40 (XI1575_bn5 B_21_b3_5 XI1575_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1575_MN39 (XI1575_bn4 fa30_0 XI1575_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1575_MN39_1 (XI1575_bn5 fa30_0 XI1575_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1575_MN40_1 (XI1575_bsn B_21_b3_5 XI1575_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1575_MN53 (VSS XI1575_bsn cm214_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1575_MN29 (XI1575_bn1 XI1575_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1575_MN30 (XI1575_bcon fa30_0 XI1575_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1575_MN33 (XI1575_bn2 B_21_b3_5 XI1575_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1575_MN31 (VSS XI1575_s1 XI1575_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1575_MN32 (XI1575_bn2 fa30_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1575_MN55 (VSS XI1575_bcon cm214_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1575_MN38 (XI1575_bn4 XI1575_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1575_MN38_1 (VSS XI1575_s1 XI1575_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1575_MN25 (VSS XI1575_asn XI1575_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1575_MN10 (VSS cm149_1 XI1575_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1575_MN6 (XI1575_an3 cm149_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1575_MN9 (XI1575_asn XI1575_acon XI1575_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1575_MN12 (XI1575_an5 cm151_0 XI1575_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1575_MN11 (XI1575_an4 fa150_1 XI1575_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1575_MN11_1 (XI1575_an5 fa150_1 XI1575_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1575_MN12_1 (XI1575_asn cm151_0 XI1575_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1575_MN10_1 (XI1575_an4 cm149_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1575_MN5 (XI1575_acon cm151_0 XI1575_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1575_MN2 (XI1575_an1 fa150_1 XI1575_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1575_MN1 (VSS cm149_1 XI1575_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1575_MN3 (XI1575_an2 cm149_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1575_MN4 (VSS fa150_1 XI1575_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1575_MN27 (cm214_2 XI1575_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1575_MN7 (XI1575_an3 fa150_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1575_MN8 (VSS cm151_0 XI1575_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1388_MN34 (XI1388_bn3 XI1388_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1388_MN35 (VSS pp7_5 XI1388_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1388_MN36 (XI1388_bn3 cm24_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1388_MN37 (XI1388_bsn XI1388_bcon XI1388_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1388_MN40 (XI1388_bn5 cm24_2 XI1388_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1388_MN39 (XI1388_bn4 pp7_5 XI1388_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1388_MN39_1 (XI1388_bn5 pp7_5 XI1388_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1388_MN40_1 (XI1388_bsn cm24_2 XI1388_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1388_MN53 (VSS XI1388_bsn cm27_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1388_MN29 (XI1388_bn1 XI1388_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1388_MN30 (XI1388_bcon pp7_5 XI1388_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1388_MN33 (XI1388_bn2 cm24_2 XI1388_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1388_MN31 (VSS XI1388_s1 XI1388_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1388_MN32 (XI1388_bn2 pp7_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1388_MN55 (VSS XI1388_bcon cm27_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1388_MN38 (XI1388_bn4 XI1388_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1388_MN38_1 (VSS XI1388_s1 XI1388_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1388_MN25 (VSS XI1388_asn XI1388_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1388_MN10 (VSS pp4_11 XI1388_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1388_MN6 (XI1388_an3 pp4_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1388_MN9 (XI1388_asn XI1388_acon XI1388_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1388_MN12 (XI1388_an5 pp6_7 XI1388_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1388_MN11 (XI1388_an4 pp5_9 XI1388_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1388_MN11_1 (XI1388_an5 pp5_9 XI1388_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1388_MN12_1 (XI1388_asn pp6_7 XI1388_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1388_MN10_1 (XI1388_an4 pp4_11 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1388_MN5 (XI1388_acon pp6_7 XI1388_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1388_MN2 (XI1388_an1 pp5_9 XI1388_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1388_MN1 (VSS pp4_11 XI1388_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1388_MN3 (XI1388_an2 pp4_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1388_MN4 (VSS pp5_9 XI1388_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1388_MN27 (cm27_2 XI1388_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1388_MN7 (XI1388_an3 pp5_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1388_MN8 (VSS pp6_7 XI1388_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1382_MN34 (XI1382_bn3 XI1382_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1382_MN35 (VSS pp3_11 XI1382_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1382_MN36 (XI1382_bn3 cm19_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1382_MN37 (XI1382_bsn XI1382_bcon XI1382_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1382_MN40 (XI1382_bn5 cm19_2 XI1382_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1382_MN39 (XI1382_bn4 pp3_11 XI1382_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1382_MN39_1 (XI1382_bn5 pp3_11 XI1382_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1382_MN40_1 (XI1382_bsn cm19_2 XI1382_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1382_MN53 (VSS XI1382_bsn cm21_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1382_MN29 (XI1382_bn1 XI1382_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1382_MN30 (XI1382_bcon pp3_11 XI1382_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1382_MN33 (XI1382_bn2 cm19_2 XI1382_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1382_MN31 (VSS XI1382_s1 XI1382_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1382_MN32 (XI1382_bn2 pp3_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1382_MN55 (VSS XI1382_bcon cm21_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1382_MN38 (XI1382_bn4 XI1382_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1382_MN38_1 (VSS XI1382_s1 XI1382_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1382_MN25 (VSS XI1382_asn XI1382_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1382_MN10 (VSS pp0_17 XI1382_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1382_MN6 (XI1382_an3 pp0_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1382_MN9 (XI1382_asn XI1382_acon XI1382_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1382_MN12 (XI1382_an5 pp2_13 XI1382_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1382_MN11 (XI1382_an4 pp1_15 XI1382_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1382_MN11_1 (XI1382_an5 pp1_15 XI1382_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1382_MN12_1 (XI1382_asn pp2_13 XI1382_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1382_MN10_1 (XI1382_an4 pp0_17 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1382_MN5 (XI1382_acon pp2_13 XI1382_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1382_MN2 (XI1382_an1 pp1_15 XI1382_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1382_MN1 (VSS pp0_17 XI1382_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1382_MN3 (XI1382_an2 pp0_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1382_MN4 (VSS pp1_15 XI1382_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1382_MN27 (cm21_2 XI1382_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1382_MN7 (XI1382_an3 pp1_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1382_MN8 (VSS pp2_13 XI1382_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1510_MN34 (XI1510_bn3 XI1510_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1510_MN35 (VSS cm26_0 XI1510_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1510_MN36 (XI1510_bn3 cm148_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1510_MN37 (XI1510_bsn XI1510_bcon XI1510_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1510_MN40 (XI1510_bn5 cm148_2 XI1510_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1510_MN39 (XI1510_bn4 cm26_0 XI1510_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1510_MN39_1 (XI1510_bn5 cm26_0 XI1510_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1510_MN40_1 (XI1510_bsn cm148_2 XI1510_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1510_MN53 (VSS XI1510_bsn cm149_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1510_MN29 (XI1510_bn1 XI1510_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1510_MN30 (XI1510_bcon cm26_0 XI1510_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1510_MN33 (XI1510_bn2 cm148_2 XI1510_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1510_MN31 (VSS XI1510_s1 XI1510_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1510_MN32 (XI1510_bn2 cm26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1510_MN55 (VSS XI1510_bcon cm149_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1510_MN38 (XI1510_bn4 XI1510_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1510_MN38_1 (VSS XI1510_s1 XI1510_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1510_MN25 (VSS XI1510_asn XI1510_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1510_MN10 (VSS cm23_1 XI1510_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1510_MN6 (XI1510_an3 cm23_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1510_MN9 (XI1510_asn XI1510_acon XI1510_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1510_MN12 (XI1510_an5 fa25_1 XI1510_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1510_MN11 (XI1510_an4 cm24_1 XI1510_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1510_MN11_1 (XI1510_an5 cm24_1 XI1510_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1510_MN12_1 (XI1510_asn fa25_1 XI1510_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1510_MN10_1 (XI1510_an4 cm23_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1510_MN5 (XI1510_acon fa25_1 XI1510_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1510_MN2 (XI1510_an1 cm24_1 XI1510_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1510_MN1 (VSS cm23_1 XI1510_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1510_MN3 (XI1510_an2 cm23_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1510_MN4 (VSS cm24_1 XI1510_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1510_MN27 (cm149_2 XI1510_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1510_MN7 (XI1510_an3 cm24_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1510_MN8 (VSS fa25_1 XI1510_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1385_MN34 (XI1385_bn3 XI1385_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1385_MN35 (VSS pp7_4 XI1385_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1385_MN36 (XI1385_bn3 cm22_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1385_MN37 (XI1385_bsn XI1385_bcon XI1385_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1385_MN40 (XI1385_bn5 cm22_2 XI1385_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1385_MN39 (XI1385_bn4 pp7_4 XI1385_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1385_MN39_1 (XI1385_bn5 pp7_4 XI1385_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1385_MN40_1 (XI1385_bsn cm22_2 XI1385_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1385_MN53 (VSS XI1385_bsn cm24_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1385_MN29 (XI1385_bn1 XI1385_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1385_MN30 (XI1385_bcon pp7_4 XI1385_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1385_MN33 (XI1385_bn2 cm22_2 XI1385_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1385_MN31 (VSS XI1385_s1 XI1385_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1385_MN32 (XI1385_bn2 pp7_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1385_MN55 (VSS XI1385_bcon cm24_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1385_MN38 (XI1385_bn4 XI1385_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1385_MN38_1 (VSS XI1385_s1 XI1385_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1385_MN25 (VSS XI1385_asn XI1385_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1385_MN10 (VSS pp4_10 XI1385_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1385_MN6 (XI1385_an3 pp4_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1385_MN9 (XI1385_asn XI1385_acon XI1385_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1385_MN12 (XI1385_an5 pp6_6 XI1385_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1385_MN11 (XI1385_an4 pp5_8 XI1385_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1385_MN11_1 (XI1385_an5 pp5_8 XI1385_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1385_MN12_1 (XI1385_asn pp6_6 XI1385_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1385_MN10_1 (XI1385_an4 pp4_10 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1385_MN5 (XI1385_acon pp6_6 XI1385_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1385_MN2 (XI1385_an1 pp5_8 XI1385_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1385_MN1 (VSS pp4_10 XI1385_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1385_MN3 (XI1385_an2 pp4_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1385_MN4 (VSS pp5_8 XI1385_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1385_MN27 (cm24_2 XI1385_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1385_MN7 (XI1385_an3 pp5_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1385_MN8 (VSS pp6_6 XI1385_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1509_MN34 (XI1509_bn3 XI1509_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1509_MN35 (VSS cm24_0 XI1509_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1509_MN36 (XI1509_bn3 cm147_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1509_MN37 (XI1509_bsn XI1509_bcon XI1509_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1509_MN40 (XI1509_bn5 cm147_2 XI1509_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1509_MN39 (XI1509_bn4 cm24_0 XI1509_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1509_MN39_1 (XI1509_bn5 cm24_0 XI1509_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1509_MN40_1 (XI1509_bsn cm147_2 XI1509_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1509_MN53 (VSS XI1509_bsn cm148_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1509_MN29 (XI1509_bn1 XI1509_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1509_MN30 (XI1509_bcon cm24_0 XI1509_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1509_MN33 (XI1509_bn2 cm147_2 XI1509_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1509_MN31 (VSS XI1509_s1 XI1509_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1509_MN32 (XI1509_bn2 cm24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1509_MN55 (VSS XI1509_bcon cm148_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1509_MN38 (XI1509_bn4 XI1509_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1509_MN38_1 (VSS XI1509_s1 XI1509_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1509_MN25 (VSS XI1509_asn XI1509_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1509_MN10 (VSS cm21_1 XI1509_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1509_MN6 (XI1509_an3 cm21_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1509_MN9 (XI1509_asn XI1509_acon XI1509_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1509_MN12 (XI1509_an5 cm23_0 XI1509_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1509_MN11 (XI1509_an4 cm22_1 XI1509_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1509_MN11_1 (XI1509_an5 cm22_1 XI1509_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1509_MN12_1 (XI1509_asn cm23_0 XI1509_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1509_MN10_1 (XI1509_an4 cm21_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1509_MN5 (XI1509_acon cm23_0 XI1509_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1509_MN2 (XI1509_an1 cm22_1 XI1509_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1509_MN1 (VSS cm21_1 XI1509_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1509_MN3 (XI1509_an2 cm21_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1509_MN4 (VSS cm22_1 XI1509_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1509_MN27 (cm148_2 XI1509_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1509_MN7 (XI1509_an3 cm22_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1509_MN8 (VSS cm23_0 XI1509_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1383_MN34 (XI1383_bn3 XI1383_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1383_MN35 (VSS pp7_3 XI1383_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1383_MN36 (XI1383_bn3 cm20_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1383_MN37 (XI1383_bsn XI1383_bcon XI1383_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1383_MN40 (XI1383_bn5 cm20_2 XI1383_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1383_MN39 (XI1383_bn4 pp7_3 XI1383_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1383_MN39_1 (XI1383_bn5 pp7_3 XI1383_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1383_MN40_1 (XI1383_bsn cm20_2 XI1383_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1383_MN53 (VSS XI1383_bsn cm22_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1383_MN29 (XI1383_bn1 XI1383_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1383_MN30 (XI1383_bcon pp7_3 XI1383_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1383_MN33 (XI1383_bn2 cm20_2 XI1383_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1383_MN31 (VSS XI1383_s1 XI1383_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1383_MN32 (XI1383_bn2 pp7_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1383_MN55 (VSS XI1383_bcon cm22_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1383_MN38 (XI1383_bn4 XI1383_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1383_MN38_1 (VSS XI1383_s1 XI1383_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1383_MN25 (VSS XI1383_asn XI1383_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1383_MN10 (VSS pp4_9 XI1383_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1383_MN6 (XI1383_an3 pp4_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1383_MN9 (XI1383_asn XI1383_acon XI1383_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1383_MN12 (XI1383_an5 pp6_5 XI1383_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1383_MN11 (XI1383_an4 pp5_7 XI1383_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1383_MN11_1 (XI1383_an5 pp5_7 XI1383_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1383_MN12_1 (XI1383_asn pp6_5 XI1383_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1383_MN10_1 (XI1383_an4 pp4_9 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1383_MN5 (XI1383_acon pp6_5 XI1383_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1383_MN2 (XI1383_an1 pp5_7 XI1383_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1383_MN1 (VSS pp4_9 XI1383_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1383_MN3 (XI1383_an2 pp4_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1383_MN4 (VSS pp5_7 XI1383_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1383_MN27 (cm22_2 XI1383_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1383_MN7 (XI1383_an3 pp5_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1383_MN8 (VSS pp6_5 XI1383_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1508_MN34 (XI1508_bn3 XI1508_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1508_MN35 (VSS cm22_0 XI1508_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1508_MN36 (XI1508_bn3 cm146_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1508_MN37 (XI1508_bsn XI1508_bcon XI1508_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1508_MN40 (XI1508_bn5 cm146_2 XI1508_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1508_MN39 (XI1508_bn4 cm22_0 XI1508_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1508_MN39_1 (XI1508_bn5 cm22_0 XI1508_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1508_MN40_1 (XI1508_bsn cm146_2 XI1508_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1508_MN53 (VSS XI1508_bsn cm147_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1508_MN29 (XI1508_bn1 XI1508_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1508_MN30 (XI1508_bcon cm22_0 XI1508_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1508_MN33 (XI1508_bn2 cm146_2 XI1508_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1508_MN31 (VSS XI1508_s1 XI1508_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1508_MN32 (XI1508_bn2 cm22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1508_MN55 (VSS XI1508_bcon cm147_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1508_MN38 (XI1508_bn4 XI1508_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1508_MN38_1 (VSS XI1508_s1 XI1508_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1508_MN25 (VSS XI1508_asn XI1508_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1508_MN10 (VSS cm19_1 XI1508_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1508_MN6 (XI1508_an3 cm19_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1508_MN9 (XI1508_asn XI1508_acon XI1508_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1508_MN12 (XI1508_an5 cm21_0 XI1508_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1508_MN11 (XI1508_an4 cm20_1 XI1508_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1508_MN11_1 (XI1508_an5 cm20_1 XI1508_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1508_MN12_1 (XI1508_asn cm21_0 XI1508_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1508_MN10_1 (XI1508_an4 cm19_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1508_MN5 (XI1508_acon cm21_0 XI1508_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1508_MN2 (XI1508_an1 cm20_1 XI1508_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1508_MN1 (VSS cm19_1 XI1508_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1508_MN3 (XI1508_an2 cm19_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1508_MN4 (VSS cm20_1 XI1508_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1508_MN27 (cm147_2 XI1508_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1508_MN7 (XI1508_an3 cm20_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1508_MN8 (VSS cm21_0 XI1508_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1380_MN34 (XI1380_bn3 XI1380_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1380_MN35 (VSS pp3_10 XI1380_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1380_MN36 (XI1380_bn3 cm17_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1380_MN37 (XI1380_bsn XI1380_bcon XI1380_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1380_MN40 (XI1380_bn5 cm17_2 XI1380_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1380_MN39 (XI1380_bn4 pp3_10 XI1380_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1380_MN39_1 (XI1380_bn5 pp3_10 XI1380_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1380_MN40_1 (XI1380_bsn cm17_2 XI1380_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1380_MN53 (VSS XI1380_bsn cm19_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1380_MN29 (XI1380_bn1 XI1380_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1380_MN30 (XI1380_bcon pp3_10 XI1380_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1380_MN33 (XI1380_bn2 cm17_2 XI1380_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1380_MN31 (VSS XI1380_s1 XI1380_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1380_MN32 (XI1380_bn2 pp3_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1380_MN55 (VSS XI1380_bcon cm19_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1380_MN38 (XI1380_bn4 XI1380_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1380_MN38_1 (VSS XI1380_s1 XI1380_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1380_MN25 (VSS XI1380_asn XI1380_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1380_MN10 (VSS pp0_16 XI1380_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1380_MN6 (XI1380_an3 pp0_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1380_MN9 (XI1380_asn XI1380_acon XI1380_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1380_MN12 (XI1380_an5 pp2_12 XI1380_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1380_MN11 (XI1380_an4 pp1_14 XI1380_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1380_MN11_1 (XI1380_an5 pp1_14 XI1380_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1380_MN12_1 (XI1380_asn pp2_12 XI1380_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1380_MN10_1 (XI1380_an4 pp0_16 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1380_MN5 (XI1380_acon pp2_12 XI1380_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1380_MN2 (XI1380_an1 pp1_14 XI1380_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1380_MN1 (VSS pp0_16 XI1380_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1380_MN3 (XI1380_an2 pp0_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1380_MN4 (VSS pp1_14 XI1380_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1380_MN27 (cm19_2 XI1380_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1380_MN7 (XI1380_an3 pp1_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1380_MN8 (VSS pp2_12 XI1380_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1381_MN34 (XI1381_bn3 XI1381_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1381_MN35 (VSS pp7_2 XI1381_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1381_MN36 (XI1381_bn3 cm18_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1381_MN37 (XI1381_bsn XI1381_bcon XI1381_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1381_MN40 (XI1381_bn5 cm18_2 XI1381_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1381_MN39 (XI1381_bn4 pp7_2 XI1381_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1381_MN39_1 (XI1381_bn5 pp7_2 XI1381_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1381_MN40_1 (XI1381_bsn cm18_2 XI1381_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1381_MN53 (VSS XI1381_bsn cm20_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1381_MN29 (XI1381_bn1 XI1381_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1381_MN30 (XI1381_bcon pp7_2 XI1381_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1381_MN33 (XI1381_bn2 cm18_2 XI1381_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1381_MN31 (VSS XI1381_s1 XI1381_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1381_MN32 (XI1381_bn2 pp7_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1381_MN55 (VSS XI1381_bcon cm20_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1381_MN38 (XI1381_bn4 XI1381_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1381_MN38_1 (VSS XI1381_s1 XI1381_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1381_MN25 (VSS XI1381_asn XI1381_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1381_MN10 (VSS pp4_8 XI1381_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1381_MN6 (XI1381_an3 pp4_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1381_MN9 (XI1381_asn XI1381_acon XI1381_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1381_MN12 (XI1381_an5 pp6_4 XI1381_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1381_MN11 (XI1381_an4 pp5_6 XI1381_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1381_MN11_1 (XI1381_an5 pp5_6 XI1381_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1381_MN12_1 (XI1381_asn pp6_4 XI1381_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1381_MN10_1 (XI1381_an4 pp4_8 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1381_MN5 (XI1381_acon pp6_4 XI1381_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1381_MN2 (XI1381_an1 pp5_6 XI1381_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1381_MN1 (VSS pp4_8 XI1381_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1381_MN3 (XI1381_an2 pp4_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1381_MN4 (VSS pp5_6 XI1381_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1381_MN27 (cm20_2 XI1381_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1381_MN7 (XI1381_an3 pp5_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1381_MN8 (VSS pp6_4 XI1381_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1507_MN34 (XI1507_bn3 XI1507_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1507_MN35 (VSS cm20_0 XI1507_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1507_MN36 (XI1507_bn3 cm145_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1507_MN37 (XI1507_bsn XI1507_bcon XI1507_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1507_MN40 (XI1507_bn5 cm145_2 XI1507_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1507_MN39 (XI1507_bn4 cm20_0 XI1507_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1507_MN39_1 (XI1507_bn5 cm20_0 XI1507_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1507_MN40_1 (XI1507_bsn cm145_2 XI1507_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1507_MN53 (VSS XI1507_bsn cm146_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1507_MN29 (XI1507_bn1 XI1507_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1507_MN30 (XI1507_bcon cm20_0 XI1507_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1507_MN33 (XI1507_bn2 cm145_2 XI1507_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1507_MN31 (VSS XI1507_s1 XI1507_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1507_MN32 (XI1507_bn2 cm20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1507_MN55 (VSS XI1507_bcon cm146_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1507_MN38 (XI1507_bn4 XI1507_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1507_MN38_1 (VSS XI1507_s1 XI1507_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1507_MN25 (VSS XI1507_asn XI1507_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1507_MN10 (VSS cm17_1 XI1507_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1507_MN6 (XI1507_an3 cm17_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1507_MN9 (XI1507_asn XI1507_acon XI1507_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1507_MN12 (XI1507_an5 cm19_0 XI1507_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1507_MN11 (XI1507_an4 cm18_1 XI1507_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1507_MN11_1 (XI1507_an5 cm18_1 XI1507_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1507_MN12_1 (XI1507_asn cm19_0 XI1507_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1507_MN10_1 (XI1507_an4 cm17_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1507_MN5 (XI1507_acon cm19_0 XI1507_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1507_MN2 (XI1507_an1 cm18_1 XI1507_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1507_MN1 (VSS cm17_1 XI1507_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1507_MN3 (XI1507_an2 cm17_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1507_MN4 (VSS cm18_1 XI1507_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1507_MN27 (cm146_2 XI1507_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1507_MN7 (XI1507_an3 cm18_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1507_MN8 (VSS cm19_0 XI1507_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1378_MN34 (XI1378_bn3 XI1378_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1378_MN35 (VSS pp3_9 XI1378_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1378_MN36 (XI1378_bn3 cm15_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1378_MN37 (XI1378_bsn XI1378_bcon XI1378_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1378_MN40 (XI1378_bn5 cm15_2 XI1378_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1378_MN39 (XI1378_bn4 pp3_9 XI1378_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1378_MN39_1 (XI1378_bn5 pp3_9 XI1378_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1378_MN40_1 (XI1378_bsn cm15_2 XI1378_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1378_MN53 (VSS XI1378_bsn cm17_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1378_MN29 (XI1378_bn1 XI1378_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1378_MN30 (XI1378_bcon pp3_9 XI1378_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1378_MN33 (XI1378_bn2 cm15_2 XI1378_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1378_MN31 (VSS XI1378_s1 XI1378_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1378_MN32 (XI1378_bn2 pp3_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1378_MN55 (VSS XI1378_bcon cm17_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1378_MN38 (XI1378_bn4 XI1378_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1378_MN38_1 (VSS XI1378_s1 XI1378_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1378_MN25 (VSS XI1378_asn XI1378_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1378_MN10 (VSS pp0_15 XI1378_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1378_MN6 (XI1378_an3 pp0_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1378_MN9 (XI1378_asn XI1378_acon XI1378_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1378_MN12 (XI1378_an5 pp2_11 XI1378_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1378_MN11 (XI1378_an4 pp1_13 XI1378_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1378_MN11_1 (XI1378_an5 pp1_13 XI1378_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1378_MN12_1 (XI1378_asn pp2_11 XI1378_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1378_MN10_1 (XI1378_an4 pp0_15 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1378_MN5 (XI1378_acon pp2_11 XI1378_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1378_MN2 (XI1378_an1 pp1_13 XI1378_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1378_MN1 (VSS pp0_15 XI1378_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1378_MN3 (XI1378_an2 pp0_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1378_MN4 (VSS pp1_13 XI1378_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1378_MN27 (cm17_2 XI1378_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1378_MN7 (XI1378_an3 pp1_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1378_MN8 (VSS pp2_11 XI1378_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1379_MN34 (XI1379_bn3 XI1379_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1379_MN35 (VSS pp7_1 XI1379_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1379_MN36 (XI1379_bn3 cm16_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1379_MN37 (XI1379_bsn XI1379_bcon XI1379_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1379_MN40 (XI1379_bn5 cm16_2 XI1379_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1379_MN39 (XI1379_bn4 pp7_1 XI1379_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1379_MN39_1 (XI1379_bn5 pp7_1 XI1379_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1379_MN40_1 (XI1379_bsn cm16_2 XI1379_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1379_MN53 (VSS XI1379_bsn cm18_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1379_MN29 (XI1379_bn1 XI1379_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1379_MN30 (XI1379_bcon pp7_1 XI1379_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1379_MN33 (XI1379_bn2 cm16_2 XI1379_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1379_MN31 (VSS XI1379_s1 XI1379_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1379_MN32 (XI1379_bn2 pp7_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1379_MN55 (VSS XI1379_bcon cm18_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1379_MN38 (XI1379_bn4 XI1379_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1379_MN38_1 (VSS XI1379_s1 XI1379_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1379_MN25 (VSS XI1379_asn XI1379_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1379_MN10 (VSS pp4_7 XI1379_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1379_MN6 (XI1379_an3 pp4_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1379_MN9 (XI1379_asn XI1379_acon XI1379_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1379_MN12 (XI1379_an5 pp6_3 XI1379_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1379_MN11 (XI1379_an4 pp5_5 XI1379_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1379_MN11_1 (XI1379_an5 pp5_5 XI1379_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1379_MN12_1 (XI1379_asn pp6_3 XI1379_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1379_MN10_1 (XI1379_an4 pp4_7 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1379_MN5 (XI1379_acon pp6_3 XI1379_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1379_MN2 (XI1379_an1 pp5_5 XI1379_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1379_MN1 (VSS pp4_7 XI1379_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1379_MN3 (XI1379_an2 pp4_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1379_MN4 (VSS pp5_5 XI1379_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1379_MN27 (cm18_2 XI1379_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1379_MN7 (XI1379_an3 pp5_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1379_MN8 (VSS pp6_3 XI1379_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1506_MN34 (XI1506_bn3 XI1506_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1506_MN35 (VSS cm18_0 XI1506_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1506_MN36 (XI1506_bn3 cm144_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1506_MN37 (XI1506_bsn XI1506_bcon XI1506_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1506_MN40 (XI1506_bn5 cm144_2 XI1506_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1506_MN39 (XI1506_bn4 cm18_0 XI1506_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1506_MN39_1 (XI1506_bn5 cm18_0 XI1506_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1506_MN40_1 (XI1506_bsn cm144_2 XI1506_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1506_MN53 (VSS XI1506_bsn cm145_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1506_MN29 (XI1506_bn1 XI1506_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1506_MN30 (XI1506_bcon cm18_0 XI1506_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1506_MN33 (XI1506_bn2 cm144_2 XI1506_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1506_MN31 (VSS XI1506_s1 XI1506_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1506_MN32 (XI1506_bn2 cm18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1506_MN55 (VSS XI1506_bcon cm145_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1506_MN38 (XI1506_bn4 XI1506_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1506_MN38_1 (VSS XI1506_s1 XI1506_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1506_MN25 (VSS XI1506_asn XI1506_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1506_MN10 (VSS cm15_1 XI1506_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1506_MN6 (XI1506_an3 cm15_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1506_MN9 (XI1506_asn XI1506_acon XI1506_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1506_MN12 (XI1506_an5 cm17_0 XI1506_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1506_MN11 (XI1506_an4 cm16_1 XI1506_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1506_MN11_1 (XI1506_an5 cm16_1 XI1506_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1506_MN12_1 (XI1506_asn cm17_0 XI1506_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1506_MN10_1 (XI1506_an4 cm15_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1506_MN5 (XI1506_acon cm17_0 XI1506_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1506_MN2 (XI1506_an1 cm16_1 XI1506_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1506_MN1 (VSS cm15_1 XI1506_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1506_MN3 (XI1506_an2 cm15_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1506_MN4 (VSS cm16_1 XI1506_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1506_MN27 (cm145_2 XI1506_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1506_MN7 (XI1506_an3 cm16_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1506_MN8 (VSS cm17_0 XI1506_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1376_MN34 (XI1376_bn3 XI1376_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1376_MN35 (VSS pp3_8 XI1376_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1376_MN36 (XI1376_bn3 cm13_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1376_MN37 (XI1376_bsn XI1376_bcon XI1376_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1376_MN40 (XI1376_bn5 cm13_2 XI1376_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1376_MN39 (XI1376_bn4 pp3_8 XI1376_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1376_MN39_1 (XI1376_bn5 pp3_8 XI1376_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1376_MN40_1 (XI1376_bsn cm13_2 XI1376_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1376_MN53 (VSS XI1376_bsn cm15_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1376_MN29 (XI1376_bn1 XI1376_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1376_MN30 (XI1376_bcon pp3_8 XI1376_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1376_MN33 (XI1376_bn2 cm13_2 XI1376_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1376_MN31 (VSS XI1376_s1 XI1376_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1376_MN32 (XI1376_bn2 pp3_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1376_MN55 (VSS XI1376_bcon cm15_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1376_MN38 (XI1376_bn4 XI1376_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1376_MN38_1 (VSS XI1376_s1 XI1376_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1376_MN25 (VSS XI1376_asn XI1376_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1376_MN10 (VSS pp0_14 XI1376_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1376_MN6 (XI1376_an3 pp0_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1376_MN9 (XI1376_asn XI1376_acon XI1376_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1376_MN12 (XI1376_an5 pp2_10 XI1376_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1376_MN11 (XI1376_an4 pp1_12 XI1376_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1376_MN11_1 (XI1376_an5 pp1_12 XI1376_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1376_MN12_1 (XI1376_asn pp2_10 XI1376_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1376_MN10_1 (XI1376_an4 pp0_14 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1376_MN5 (XI1376_acon pp2_10 XI1376_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1376_MN2 (XI1376_an1 pp1_12 XI1376_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1376_MN1 (VSS pp0_14 XI1376_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1376_MN3 (XI1376_an2 pp0_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1376_MN4 (VSS pp1_12 XI1376_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1376_MN27 (cm15_2 XI1376_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1376_MN7 (XI1376_an3 pp1_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1376_MN8 (VSS pp2_10 XI1376_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1377_MN34 (XI1377_bn3 XI1377_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1377_MN35 (VSS pp7_0 XI1377_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1377_MN36 (XI1377_bn3 B_15_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1377_MN37 (XI1377_bsn XI1377_bcon XI1377_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1377_MN40 (XI1377_bn5 B_15_b3_5 XI1377_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1377_MN39 (XI1377_bn4 pp7_0 XI1377_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1377_MN39_1 (XI1377_bn5 pp7_0 XI1377_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1377_MN40_1 (XI1377_bsn B_15_b3_5 XI1377_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1377_MN53 (VSS XI1377_bsn cm16_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1377_MN29 (XI1377_bn1 XI1377_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1377_MN30 (XI1377_bcon pp7_0 XI1377_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1377_MN33 (XI1377_bn2 B_15_b3_5 XI1377_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1377_MN31 (VSS XI1377_s1 XI1377_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1377_MN32 (XI1377_bn2 pp7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1377_MN55 (VSS XI1377_bcon cm16_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1377_MN38 (XI1377_bn4 XI1377_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1377_MN38_1 (VSS XI1377_s1 XI1377_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1377_MN25 (VSS XI1377_asn XI1377_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1377_MN10 (VSS pp4_6 XI1377_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1377_MN6 (XI1377_an3 pp4_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1377_MN9 (XI1377_asn XI1377_acon XI1377_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1377_MN12 (XI1377_an5 pp6_2 XI1377_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1377_MN11 (XI1377_an4 pp5_4 XI1377_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1377_MN11_1 (XI1377_an5 pp5_4 XI1377_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1377_MN12_1 (XI1377_asn pp6_2 XI1377_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1377_MN10_1 (XI1377_an4 pp4_6 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1377_MN5 (XI1377_acon pp6_2 XI1377_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1377_MN2 (XI1377_an1 pp5_4 XI1377_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1377_MN1 (VSS pp4_6 XI1377_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1377_MN3 (XI1377_an2 pp4_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1377_MN4 (VSS pp5_4 XI1377_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1377_MN27 (cm16_2 XI1377_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1377_MN7 (XI1377_an3 pp5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1377_MN8 (VSS pp6_2 XI1377_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1505_MN34 (XI1505_bn3 XI1505_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1505_MN35 (VSS cm16_0 XI1505_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1505_MN36 (XI1505_bn3 cm143_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1505_MN37 (XI1505_bsn XI1505_bcon XI1505_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1505_MN40 (XI1505_bn5 cm143_2 XI1505_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1505_MN39 (XI1505_bn4 cm16_0 XI1505_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1505_MN39_1 (XI1505_bn5 cm16_0 XI1505_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1505_MN40_1 (XI1505_bsn cm143_2 XI1505_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1505_MN53 (VSS XI1505_bsn cm144_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1505_MN29 (XI1505_bn1 XI1505_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1505_MN30 (XI1505_bcon cm16_0 XI1505_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1505_MN33 (XI1505_bn2 cm143_2 XI1505_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1505_MN31 (VSS XI1505_s1 XI1505_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1505_MN32 (XI1505_bn2 cm16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1505_MN55 (VSS XI1505_bcon cm144_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1505_MN38 (XI1505_bn4 XI1505_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1505_MN38_1 (VSS XI1505_s1 XI1505_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1505_MN25 (VSS XI1505_asn XI1505_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1505_MN10 (VSS cm13_1 XI1505_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1505_MN6 (XI1505_an3 cm13_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1505_MN9 (XI1505_asn XI1505_acon XI1505_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1505_MN12 (XI1505_an5 cm15_0 XI1505_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1505_MN11 (XI1505_an4 fa14_1 XI1505_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1505_MN11_1 (XI1505_an5 fa14_1 XI1505_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1505_MN12_1 (XI1505_asn cm15_0 XI1505_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1505_MN10_1 (XI1505_an4 cm13_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1505_MN5 (XI1505_acon cm15_0 XI1505_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1505_MN2 (XI1505_an1 fa14_1 XI1505_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1505_MN1 (VSS cm13_1 XI1505_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1505_MN3 (XI1505_an2 cm13_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1505_MN4 (VSS fa14_1 XI1505_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1505_MN27 (cm144_2 XI1505_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1505_MN7 (XI1505_an3 fa14_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1505_MN8 (VSS cm15_0 XI1505_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1374_MN34 (XI1374_bn3 XI1374_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1374_MN35 (VSS pp3_7 XI1374_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1374_MN36 (XI1374_bn3 cm11_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1374_MN37 (XI1374_bsn XI1374_bcon XI1374_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1374_MN40 (XI1374_bn5 cm11_2 XI1374_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1374_MN39 (XI1374_bn4 pp3_7 XI1374_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1374_MN39_1 (XI1374_bn5 pp3_7 XI1374_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1374_MN40_1 (XI1374_bsn cm11_2 XI1374_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1374_MN53 (VSS XI1374_bsn cm13_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1374_MN29 (XI1374_bn1 XI1374_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1374_MN30 (XI1374_bcon pp3_7 XI1374_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1374_MN33 (XI1374_bn2 cm11_2 XI1374_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1374_MN31 (VSS XI1374_s1 XI1374_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1374_MN32 (XI1374_bn2 pp3_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1374_MN55 (VSS XI1374_bcon cm13_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1374_MN38 (XI1374_bn4 XI1374_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1374_MN38_1 (VSS XI1374_s1 XI1374_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1374_MN25 (VSS XI1374_asn XI1374_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1374_MN10 (VSS pp0_13 XI1374_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1374_MN6 (XI1374_an3 pp0_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1374_MN9 (XI1374_asn XI1374_acon XI1374_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1374_MN12 (XI1374_an5 pp2_9 XI1374_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1374_MN11 (XI1374_an4 pp1_11 XI1374_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1374_MN11_1 (XI1374_an5 pp1_11 XI1374_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1374_MN12_1 (XI1374_asn pp2_9 XI1374_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1374_MN10_1 (XI1374_an4 pp0_13 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1374_MN5 (XI1374_acon pp2_9 XI1374_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1374_MN2 (XI1374_an1 pp1_11 XI1374_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1374_MN1 (VSS pp0_13 XI1374_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1374_MN3 (XI1374_an2 pp0_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1374_MN4 (VSS pp1_11 XI1374_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1374_MN27 (cm13_2 XI1374_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1374_MN7 (XI1374_an3 pp1_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1374_MN8 (VSS pp2_9 XI1374_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1504_MN34 (XI1504_bn3 XI1504_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1504_MN35 (VSS fa14_0 XI1504_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1504_MN36 (XI1504_bn3 cm142_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1504_MN37 (XI1504_bsn XI1504_bcon XI1504_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1504_MN40 (XI1504_bn5 cm142_2 XI1504_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1504_MN39 (XI1504_bn4 fa14_0 XI1504_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1504_MN39_1 (XI1504_bn5 fa14_0 XI1504_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1504_MN40_1 (XI1504_bsn cm142_2 XI1504_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1504_MN53 (VSS XI1504_bsn cm143_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1504_MN29 (XI1504_bn1 XI1504_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1504_MN30 (XI1504_bcon fa14_0 XI1504_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1504_MN33 (XI1504_bn2 cm142_2 XI1504_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1504_MN31 (VSS XI1504_s1 XI1504_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1504_MN32 (XI1504_bn2 fa14_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1504_MN55 (VSS XI1504_bcon cm143_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1504_MN38 (XI1504_bn4 XI1504_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1504_MN38_1 (VSS XI1504_s1 XI1504_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1504_MN25 (VSS XI1504_asn XI1504_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1504_MN10 (VSS cm11_1 XI1504_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1504_MN6 (XI1504_an3 cm11_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1504_MN9 (XI1504_asn XI1504_acon XI1504_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1504_MN12 (XI1504_an5 cm13_0 XI1504_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1504_MN11 (XI1504_an4 fa12_1 XI1504_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1504_MN11_1 (XI1504_an5 fa12_1 XI1504_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1504_MN12_1 (XI1504_asn cm13_0 XI1504_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1504_MN10_1 (XI1504_an4 cm11_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1504_MN5 (XI1504_acon cm13_0 XI1504_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1504_MN2 (XI1504_an1 fa12_1 XI1504_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1504_MN1 (VSS cm11_1 XI1504_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1504_MN3 (XI1504_an2 cm11_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1504_MN4 (VSS fa12_1 XI1504_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1504_MN27 (cm143_2 XI1504_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1504_MN7 (XI1504_an3 fa12_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1504_MN8 (VSS cm13_0 XI1504_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1372_MN34 (XI1372_bn3 XI1372_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1372_MN35 (VSS pp3_6 XI1372_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1372_MN36 (XI1372_bn3 cm10_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1372_MN37 (XI1372_bsn XI1372_bcon XI1372_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1372_MN40 (XI1372_bn5 cm10_2 XI1372_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1372_MN39 (XI1372_bn4 pp3_6 XI1372_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1372_MN39_1 (XI1372_bn5 pp3_6 XI1372_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1372_MN40_1 (XI1372_bsn cm10_2 XI1372_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1372_MN53 (VSS XI1372_bsn cm11_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1372_MN29 (XI1372_bn1 XI1372_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1372_MN30 (XI1372_bcon pp3_6 XI1372_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1372_MN33 (XI1372_bn2 cm10_2 XI1372_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1372_MN31 (VSS XI1372_s1 XI1372_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1372_MN32 (XI1372_bn2 pp3_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1372_MN55 (VSS XI1372_bcon cm11_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1372_MN38 (XI1372_bn4 XI1372_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1372_MN38_1 (VSS XI1372_s1 XI1372_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1372_MN25 (VSS XI1372_asn XI1372_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1372_MN10 (VSS pp0_12 XI1372_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1372_MN6 (XI1372_an3 pp0_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1372_MN9 (XI1372_asn XI1372_acon XI1372_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1372_MN12 (XI1372_an5 pp2_8 XI1372_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1372_MN11 (XI1372_an4 pp1_10 XI1372_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1372_MN11_1 (XI1372_an5 pp1_10 XI1372_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1372_MN12_1 (XI1372_asn pp2_8 XI1372_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1372_MN10_1 (XI1372_an4 pp0_12 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1372_MN5 (XI1372_acon pp2_8 XI1372_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1372_MN2 (XI1372_an1 pp1_10 XI1372_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1372_MN1 (VSS pp0_12 XI1372_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1372_MN3 (XI1372_an2 pp0_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1372_MN4 (VSS pp1_10 XI1372_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1372_MN27 (cm11_2 XI1372_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1372_MN7 (XI1372_an3 pp1_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1372_MN8 (VSS pp2_8 XI1372_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1503_MN34 (XI1503_bn3 XI1503_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1503_MN35 (VSS B_13_b3_5 XI1503_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1503_MN36 (XI1503_bn3 cm141_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1503_MN37 (XI1503_bsn XI1503_bcon XI1503_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1503_MN40 (XI1503_bn5 cm141_2 XI1503_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1503_MN39 (XI1503_bn4 B_13_b3_5 XI1503_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1503_MN39_1 (XI1503_bn5 B_13_b3_5 XI1503_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1503_MN40_1 (XI1503_bsn cm141_2 XI1503_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1503_MN53 (VSS XI1503_bsn cm142_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1503_MN29 (XI1503_bn1 XI1503_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1503_MN30 (XI1503_bcon B_13_b3_5 XI1503_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1503_MN33 (XI1503_bn2 cm141_2 XI1503_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1503_MN31 (VSS XI1503_s1 XI1503_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1503_MN32 (XI1503_bn2 B_13_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1503_MN55 (VSS XI1503_bcon cm142_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1503_MN38 (XI1503_bn4 XI1503_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1503_MN38_1 (VSS XI1503_s1 XI1503_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1503_MN25 (VSS XI1503_asn XI1503_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1503_MN10 (VSS cm10_1 XI1503_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1503_MN6 (XI1503_an3 cm10_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1503_MN9 (XI1503_asn XI1503_acon XI1503_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1503_MN12 (XI1503_an5 fa12_0 XI1503_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1503_MN11 (XI1503_an4 cm11_0 XI1503_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1503_MN11_1 (XI1503_an5 cm11_0 XI1503_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1503_MN12_1 (XI1503_asn fa12_0 XI1503_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1503_MN10_1 (XI1503_an4 cm10_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1503_MN5 (XI1503_acon fa12_0 XI1503_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1503_MN2 (XI1503_an1 cm11_0 XI1503_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1503_MN1 (VSS cm10_1 XI1503_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1503_MN3 (XI1503_an2 cm10_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1503_MN4 (VSS cm11_0 XI1503_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1503_MN27 (cm142_2 XI1503_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1503_MN7 (XI1503_an3 cm11_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1503_MN8 (VSS fa12_0 XI1503_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1371_MN34 (XI1371_bn3 XI1371_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1371_MN35 (VSS pp3_5 XI1371_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1371_MN36 (XI1371_bn3 cm8_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1371_MN37 (XI1371_bsn XI1371_bcon XI1371_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1371_MN40 (XI1371_bn5 cm8_2 XI1371_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1371_MN39 (XI1371_bn4 pp3_5 XI1371_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1371_MN39_1 (XI1371_bn5 pp3_5 XI1371_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1371_MN40_1 (XI1371_bsn cm8_2 XI1371_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1371_MN53 (VSS XI1371_bsn cm10_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1371_MN29 (XI1371_bn1 XI1371_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1371_MN30 (XI1371_bcon pp3_5 XI1371_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1371_MN33 (XI1371_bn2 cm8_2 XI1371_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1371_MN31 (VSS XI1371_s1 XI1371_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1371_MN32 (XI1371_bn2 pp3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1371_MN55 (VSS XI1371_bcon cm10_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1371_MN38 (XI1371_bn4 XI1371_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1371_MN38_1 (VSS XI1371_s1 XI1371_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1371_MN25 (VSS XI1371_asn XI1371_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1371_MN10 (VSS pp0_11 XI1371_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1371_MN6 (XI1371_an3 pp0_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1371_MN9 (XI1371_asn XI1371_acon XI1371_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1371_MN12 (XI1371_an5 pp2_7 XI1371_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1371_MN11 (XI1371_an4 pp1_9 XI1371_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1371_MN11_1 (XI1371_an5 pp1_9 XI1371_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1371_MN12_1 (XI1371_asn pp2_7 XI1371_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1371_MN10_1 (XI1371_an4 pp0_11 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1371_MN5 (XI1371_acon pp2_7 XI1371_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1371_MN2 (XI1371_an1 pp1_9 XI1371_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1371_MN1 (VSS pp0_11 XI1371_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1371_MN3 (XI1371_an2 pp0_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1371_MN4 (VSS pp1_9 XI1371_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1371_MN27 (cm10_2 XI1371_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1371_MN7 (XI1371_an3 pp1_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1371_MN8 (VSS pp2_7 XI1371_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1365_MN34 (XI1365_bn3 XI1365_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1365_MN35 (VSS pp3_0 XI1365_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1365_MN36 (XI1365_bn3 B_7_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1365_MN37 (XI1365_bsn XI1365_bcon XI1365_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1365_MN40 (XI1365_bn5 B_7_b3_5 XI1365_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1365_MN39 (XI1365_bn4 pp3_0 XI1365_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1365_MN39_1 (XI1365_bn5 pp3_0 XI1365_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1365_MN40_1 (XI1365_bsn B_7_b3_5 XI1365_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1365_MN53 (VSS XI1365_bsn cm4_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1365_MN29 (XI1365_bn1 XI1365_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1365_MN30 (XI1365_bcon pp3_0 XI1365_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1365_MN33 (XI1365_bn2 B_7_b3_5 XI1365_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1365_MN31 (VSS XI1365_s1 XI1365_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1365_MN32 (XI1365_bn2 pp3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1365_MN55 (VSS XI1365_bcon cm4_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1365_MN38 (XI1365_bn4 XI1365_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1365_MN38_1 (VSS XI1365_s1 XI1365_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1365_MN25 (VSS XI1365_asn XI1365_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1365_MN10 (VSS pp0_6 XI1365_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1365_MN6 (XI1365_an3 pp0_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1365_MN9 (XI1365_asn XI1365_acon XI1365_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1365_MN12 (XI1365_an5 pp2_2 XI1365_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1365_MN11 (XI1365_an4 pp1_4 XI1365_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1365_MN11_1 (XI1365_an5 pp1_4 XI1365_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1365_MN12_1 (XI1365_asn pp2_2 XI1365_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1365_MN10_1 (XI1365_an4 pp0_6 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1365_MN5 (XI1365_acon pp2_2 XI1365_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1365_MN2 (XI1365_an1 pp1_4 XI1365_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1365_MN1 (VSS pp0_6 XI1365_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1365_MN3 (XI1365_an2 pp0_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1365_MN4 (VSS pp1_4 XI1365_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1365_MN27 (cm4_2 XI1365_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1365_MN7 (XI1365_an3 pp1_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1365_MN8 (VSS pp2_2 XI1365_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1366_MN34 (XI1366_bn3 XI1366_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1366_MN35 (VSS pp3_1 XI1366_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1366_MN36 (XI1366_bn3 cm4_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1366_MN37 (XI1366_bsn XI1366_bcon XI1366_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1366_MN40 (XI1366_bn5 cm4_2 XI1366_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1366_MN39 (XI1366_bn4 pp3_1 XI1366_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1366_MN39_1 (XI1366_bn5 pp3_1 XI1366_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1366_MN40_1 (XI1366_bsn cm4_2 XI1366_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1366_MN53 (VSS XI1366_bsn cm5_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1366_MN29 (XI1366_bn1 XI1366_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1366_MN30 (XI1366_bcon pp3_1 XI1366_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1366_MN33 (XI1366_bn2 cm4_2 XI1366_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1366_MN31 (VSS XI1366_s1 XI1366_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1366_MN32 (XI1366_bn2 pp3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1366_MN55 (VSS XI1366_bcon cm5_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1366_MN38 (XI1366_bn4 XI1366_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1366_MN38_1 (VSS XI1366_s1 XI1366_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1366_MN25 (VSS XI1366_asn XI1366_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1366_MN10 (VSS pp0_7 XI1366_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1366_MN6 (XI1366_an3 pp0_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1366_MN9 (XI1366_asn XI1366_acon XI1366_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1366_MN12 (XI1366_an5 pp2_3 XI1366_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1366_MN11 (XI1366_an4 pp1_5 XI1366_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1366_MN11_1 (XI1366_an5 pp1_5 XI1366_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1366_MN12_1 (XI1366_asn pp2_3 XI1366_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1366_MN10_1 (XI1366_an4 pp0_7 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1366_MN5 (XI1366_acon pp2_3 XI1366_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1366_MN2 (XI1366_an1 pp1_5 XI1366_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1366_MN1 (VSS pp0_7 XI1366_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1366_MN3 (XI1366_an2 pp0_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1366_MN4 (VSS pp1_5 XI1366_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1366_MN27 (cm5_2 XI1366_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1366_MN7 (XI1366_an3 pp1_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1366_MN8 (VSS pp2_3 XI1366_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1502_MN34 (XI1502_bn3 XI1502_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1502_MN35 (VSS pp4_3 XI1502_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1502_MN36 (XI1502_bn3 pp5_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1502_MN37 (XI1502_bsn XI1502_bcon XI1502_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1502_MN40 (XI1502_bn5 pp5_1 XI1502_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1502_MN39 (XI1502_bn4 pp4_3 XI1502_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1502_MN39_1 (XI1502_bn5 pp4_3 XI1502_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1502_MN40_1 (XI1502_bsn pp5_1 XI1502_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1502_MN53 (VSS XI1502_bsn cm141_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1502_MN29 (XI1502_bn1 XI1502_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1502_MN30 (XI1502_bcon pp4_3 XI1502_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1502_MN33 (XI1502_bn2 pp5_1 XI1502_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1502_MN31 (VSS XI1502_s1 XI1502_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1502_MN32 (XI1502_bn2 pp4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1502_MN55 (VSS XI1502_bcon cm141_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1502_MN38 (XI1502_bn4 XI1502_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1502_MN38_1 (VSS XI1502_s1 XI1502_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1502_MN25 (VSS XI1502_asn XI1502_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1502_MN10 (VSS cm8_1 XI1502_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1502_MN6 (XI1502_an3 cm8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1502_MN9 (XI1502_asn XI1502_acon XI1502_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1502_MN12 (XI1502_an5 cm10_0 XI1502_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1502_MN11 (XI1502_an4 fa9_1 XI1502_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1502_MN11_1 (XI1502_an5 fa9_1 XI1502_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1502_MN12_1 (XI1502_asn cm10_0 XI1502_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1502_MN10_1 (XI1502_an4 cm8_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1502_MN5 (XI1502_acon cm10_0 XI1502_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1502_MN2 (XI1502_an1 fa9_1 XI1502_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1502_MN1 (VSS cm8_1 XI1502_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1502_MN3 (XI1502_an2 cm8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1502_MN4 (VSS fa9_1 XI1502_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1502_MN27 (cm141_2 XI1502_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1502_MN7 (XI1502_an3 fa9_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1502_MN8 (VSS cm10_0 XI1502_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1369_MN34 (XI1369_bn3 XI1369_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1369_MN35 (VSS pp3_4 XI1369_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1369_MN36 (XI1369_bn3 cm7_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1369_MN37 (XI1369_bsn XI1369_bcon XI1369_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1369_MN40 (XI1369_bn5 cm7_2 XI1369_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1369_MN39 (XI1369_bn4 pp3_4 XI1369_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1369_MN39_1 (XI1369_bn5 pp3_4 XI1369_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1369_MN40_1 (XI1369_bsn cm7_2 XI1369_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1369_MN53 (VSS XI1369_bsn cm8_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1369_MN29 (XI1369_bn1 XI1369_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1369_MN30 (XI1369_bcon pp3_4 XI1369_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1369_MN33 (XI1369_bn2 cm7_2 XI1369_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1369_MN31 (VSS XI1369_s1 XI1369_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1369_MN32 (XI1369_bn2 pp3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1369_MN55 (VSS XI1369_bcon cm8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1369_MN38 (XI1369_bn4 XI1369_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1369_MN38_1 (VSS XI1369_s1 XI1369_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1369_MN25 (VSS XI1369_asn XI1369_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1369_MN10 (VSS pp0_10 XI1369_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1369_MN6 (XI1369_an3 pp0_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1369_MN9 (XI1369_asn XI1369_acon XI1369_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1369_MN12 (XI1369_an5 pp2_6 XI1369_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1369_MN11 (XI1369_an4 pp1_8 XI1369_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1369_MN11_1 (XI1369_an5 pp1_8 XI1369_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1369_MN12_1 (XI1369_asn pp2_6 XI1369_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1369_MN10_1 (XI1369_an4 pp0_10 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1369_MN5 (XI1369_acon pp2_6 XI1369_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1369_MN2 (XI1369_an1 pp1_8 XI1369_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1369_MN1 (VSS pp0_10 XI1369_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1369_MN3 (XI1369_an2 pp0_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1369_MN4 (VSS pp1_8 XI1369_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1369_MN27 (cm8_2 XI1369_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1369_MN7 (XI1369_an3 pp1_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1369_MN8 (VSS pp2_6 XI1369_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1367_MN34 (XI1367_bn3 XI1367_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1367_MN35 (VSS pp3_2 XI1367_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1367_MN36 (XI1367_bn3 cm5_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1367_MN37 (XI1367_bsn XI1367_bcon XI1367_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1367_MN40 (XI1367_bn5 cm5_2 XI1367_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1367_MN39 (XI1367_bn4 pp3_2 XI1367_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1367_MN39_1 (XI1367_bn5 pp3_2 XI1367_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1367_MN40_1 (XI1367_bsn cm5_2 XI1367_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1367_MN53 (VSS XI1367_bsn cm6_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1367_MN29 (XI1367_bn1 XI1367_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1367_MN30 (XI1367_bcon pp3_2 XI1367_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1367_MN33 (XI1367_bn2 cm5_2 XI1367_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1367_MN31 (VSS XI1367_s1 XI1367_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1367_MN32 (XI1367_bn2 pp3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1367_MN55 (VSS XI1367_bcon cm6_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1367_MN38 (XI1367_bn4 XI1367_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1367_MN38_1 (VSS XI1367_s1 XI1367_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1367_MN25 (VSS XI1367_asn XI1367_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1367_MN10 (VSS pp0_8 XI1367_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1367_MN6 (XI1367_an3 pp0_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1367_MN9 (XI1367_asn XI1367_acon XI1367_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1367_MN12 (XI1367_an5 pp2_4 XI1367_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1367_MN11 (XI1367_an4 pp1_6 XI1367_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1367_MN11_1 (XI1367_an5 pp1_6 XI1367_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1367_MN12_1 (XI1367_asn pp2_4 XI1367_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1367_MN10_1 (XI1367_an4 pp0_8 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1367_MN5 (XI1367_acon pp2_4 XI1367_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1367_MN2 (XI1367_an1 pp1_6 XI1367_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1367_MN1 (VSS pp0_8 XI1367_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1367_MN3 (XI1367_an2 pp0_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1367_MN4 (VSS pp1_6 XI1367_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1367_MN27 (cm6_2 XI1367_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1367_MN7 (XI1367_an3 pp1_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1367_MN8 (VSS pp2_4 XI1367_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1368_MN34 (XI1368_bn3 XI1368_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1368_MN35 (VSS pp3_3 XI1368_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1368_MN36 (XI1368_bn3 cm6_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1368_MN37 (XI1368_bsn XI1368_bcon XI1368_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1368_MN40 (XI1368_bn5 cm6_2 XI1368_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1368_MN39 (XI1368_bn4 pp3_3 XI1368_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1368_MN39_1 (XI1368_bn5 pp3_3 XI1368_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1368_MN40_1 (XI1368_bsn cm6_2 XI1368_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1368_MN53 (VSS XI1368_bsn cm7_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1368_MN29 (XI1368_bn1 XI1368_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1368_MN30 (XI1368_bcon pp3_3 XI1368_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1368_MN33 (XI1368_bn2 cm6_2 XI1368_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1368_MN31 (VSS XI1368_s1 XI1368_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1368_MN32 (XI1368_bn2 pp3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1368_MN55 (VSS XI1368_bcon cm7_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0438p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1368_MN38 (XI1368_bn4 XI1368_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0954p as=0.0438p pd=1.21997u ps=0.67997u
    I_MXI1368_MN38_1 (VSS XI1368_s1 XI1368_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0954p pd=0.67997u ps=1.21997u
    I_MXI1368_MN25 (VSS XI1368_asn XI1368_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1368_MN10 (VSS pp0_9 XI1368_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0498p as=0.0468p pd=0.67997u ps=0.67997u
    I_MXI1368_MN6 (XI1368_an3 pp0_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1368_MN9 (XI1368_asn XI1368_acon XI1368_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1368_MN12 (XI1368_an5 pp2_5 XI1368_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1368_MN11 (XI1368_an4 pp1_7 XI1368_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.144p as=0.0468p pd=1.75997u ps=0.67997u
    I_MXI1368_MN11_1 (XI1368_an5 pp1_7 XI1368_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.144p pd=0.67997u ps=1.75997u
    I_MXI1368_MN12_1 (XI1368_asn pp2_5 XI1368_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0756p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1368_MN10_1 (XI1368_an4 pp0_9 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.0468p as=0.0498p pd=0.67997u ps=0.67997u
    I_MXI1368_MN5 (XI1368_acon pp2_5 XI1368_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1368_MN2 (XI1368_an1 pp1_7 XI1368_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1368_MN1 (VSS pp0_9 XI1368_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1368_MN3 (XI1368_an2 pp0_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1368_MN4 (VSS pp1_7 XI1368_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0468p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1368_MN27 (cm7_2 XI1368_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0468p pd=1.15997u ps=0.67997u
    I_MXI1368_MN7 (XI1368_an3 pp1_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1368_MN8 (VSS pp2_5 XI1368_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0498p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI190_MN0 (A_18_b0 A_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI240_MN0 (A_23_b0 A_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI260_MN0 (A_25_b0 A_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI250_MN0 (A_24_b0 A_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI811_MN0 (sn5 pp5_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI402_MN0 (B_17_b0 B_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI412_MN0 (B_19_b0 B_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI422_MN0 (B_21_b0 B_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI976_MN0 (sn8 pp8_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI230_MN0 (A_22_b0 A_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI921_MN0 (sn7 pp7_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1031_MN0 (sn9 pp9_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI756_MN0 (sn4 pp4_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI866_MN0 (sn6 pp6_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI270_MN0 (A_26_b0 A_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI220_MN0 (A_21_b0 A_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI701_MN0 (sn3 pp3_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI280_MN0 (A_27_b0 A_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI392_MN0 (B_15_b0 B_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI290_MN0 (A_28_b0 A_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI382_MN0 (B_13_b0 B_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI646_MN0 (sn2 pp2_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI310_MN0 (A_30_b0 A_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI210_MN0 (A_20_b0 A_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI200_MN0 (A_19_b0 A_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI180_MN0 (A_17_b0 A_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI300_MN0 (A_29_b0 A_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1086_MN0 (sn10 pp10_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI591_MN0 (sn1 pp1_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI432_MN0 (B_23_b0 B_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI170_MN0 (A_16_b0 A_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI536_MN0 (sn0 pp0_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1088_MN0 (one11_b0 one11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1098_MN0 (two11_b0 two11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1141_MN0 (sn11 pp11_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1143_MN0 (one12_b0 one12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1153_MN0 (two12_b0 two12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI442_MN0 (B_25_b0 B_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI452_MN0 (B_27_b0 B_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI320_MN0 (A_31_b0 A_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI160_MN0 (A_15_b0 A_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI150_MN0 (A_14_b0 A_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1263_MN0 (two14_b0 two14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1253_MN0 (one14_b0 one14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1308_MN0 (one15_b0 one15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI372_MN0 (B_11_b0 B_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1198_MN0 (one13_b0 one13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1208_MN0 (two13_b0 two13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1318_MN0 (two15_b0 two15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI462_MN0 (B_29_b0 B_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI472_MN0 (B_31_b0 B_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1196_MN0 (sn12 pp12_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI140_MN0 (A_13_b0 A_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI130_MN0 (A_12_b0 A_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1033_MN0 (one10_b0 one10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1043_MN0 (two10_b0 two10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1251_MN0 (sn13 pp13_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI868_MN0 (one7_b0 one7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI362_MN0 (B_9_b0 B_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI878_MN0 (two7_b0 two7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1306_MN0 (sn14 pp14_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI120_MN0 (A_11_b0 A_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI923_MN0 (one8_b0 one8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI933_MN0 (two8_b0 two8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI978_MN0 (one9_b0 one9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI988_MN0 (two9_b0 two9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI352_MN0 (B_7_b0 B_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1361_MN0 (sn15 pp15_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI813_MN0 (one6_b0 one6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI823_MN0 (two6_b0 two6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I443_MN0 (I1660_G12_0np I1660_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I531_MN0 (kcm I1660_G62_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I447_MN0 (I1660_G14_0np I1660_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI768_MN0 (two5_b0 two5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI758_MN0 (one5_b0 one5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I439_MN0 (I1660_G10_0np I1660_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I435_MN0 (I1660_G8_0np I1660_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I383_MN0 (I1660_G6_0n I1660_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I445_MN0 (I1660_G13_0np I1660_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI658_MN0 (two3_b0 two3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI648_MN0 (one3_b0 one3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I532_MN0 (kco I1660_G63_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI713_MN0 (two4_b0 two4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI703_MN0 (one4_b0 one4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI110_MN0 (A_10_b0 A_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI603_MN0 (two2_b0 two2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI100_MN0 (A_9_b0 A_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI90_MN0 (A_8_b0 A_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I379_MN0 (I1660_G4_0n I1660_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI342_MN0 (B_5_b0 B_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI593_MN0 (one2_b0 one2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI548_MN0 (two1_b0 two1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI538_MN0 (one1_b0 one1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI80_MN0 (A_7_b0 A_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I437_MN0 (I1660_G9_0np I1660_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I449_MN0 (I1660_G15_0np I1660_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI70_MN0 (A_6_b0 A_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI30_MN0 (A_2_b0 A_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I319_MN0 (I1660_G2_0np I1660_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI0_MN0 (B_1_b0 B_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI332_MN0 (B_3_b0 B_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI483_MN0 (one0_b0 one0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI493_MN0 (two0_b0 two0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI60_MN0 (A_5_b0 A_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI40_MN0 (A_3_b0 A_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI10_MN0 (A_0_b0 A_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI20_MN0 (A_1_b0 A_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I128_MN0 (I1660_cinn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I130_MN0 (I1660_G0_0n I1660_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I441_MN0 (I1660_G11_0np I1660_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI50_MN0 (A_4_b0 A_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I381_MN0 (I1660_G5_0n I1660_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I385_MN0 (I1660_G7_0n I1660_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I257_MN0 (I1660_G1_0n I1660_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I321_MN0 (I1660_G3_0np I1660_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1087_MN5 (one11 B_22 XI1087_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1087_MN7 (XI1087_an2 XI1087_aan one11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1087_MN8 (VSS XI1087_abn XI1087_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1087_MN6 (XI1087_an1 B_21_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1087_MN1 (XI1087_aan B_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1087_MN3 (VSS B_21_b3_5 XI1087_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1087_MN15 (XI1087_bbn B_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15997u ps=0.67997u
    I_MXI1087_MN13 (XI1087_ban B_23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1087_MN19 (XI1087_bn2 XI1087_ban XI1087_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1087_MN20 (VSS B_22 XI1087_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1087_MN18 (XI1087_bn1 XI1087_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1087_MN17 (XI1087_e B_23_b3_0 XI1087_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1087_MN26 (two11 one11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1087_MN25 (VSS XI1087_e two11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0408p pd=0.67997u ps=0.67997u
    I_MXI1142_MN5 (one12 B_24 XI1142_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1142_MN7 (XI1142_an2 XI1142_aan one12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1142_MN8 (VSS XI1142_abn XI1142_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1142_MN6 (XI1142_an1 B_23_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1142_MN1 (XI1142_aan B_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1142_MN3 (VSS B_23_b3_5 XI1142_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1142_MN15 (XI1142_bbn B_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15997u ps=0.67997u
    I_MXI1142_MN13 (XI1142_ban B_25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1142_MN19 (XI1142_bn2 XI1142_ban XI1142_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1142_MN20 (VSS B_24 XI1142_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1142_MN18 (XI1142_bn1 XI1142_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1142_MN17 (XI1142_e B_25_b3_0 XI1142_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1142_MN26 (two12 one12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1142_MN25 (VSS XI1142_e two12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0408p pd=0.67997u ps=0.67997u
    I_MXI1197_MN5 (one13 B_26 XI1197_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1197_MN7 (XI1197_an2 XI1197_aan one13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1197_MN8 (VSS XI1197_abn XI1197_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1197_MN6 (XI1197_an1 B_25_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1197_MN1 (XI1197_aan B_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1197_MN3 (VSS B_25_b3_5 XI1197_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1197_MN15 (XI1197_bbn B_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15997u ps=0.67997u
    I_MXI1197_MN13 (XI1197_ban B_27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1197_MN19 (XI1197_bn2 XI1197_ban XI1197_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1197_MN20 (VSS B_26 XI1197_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1197_MN18 (XI1197_bn1 XI1197_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1197_MN17 (XI1197_e B_27_b3_0 XI1197_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1197_MN26 (two13 one13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1197_MN25 (VSS XI1197_e two13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0408p pd=0.67997u ps=0.67997u
    I_MXI1252_MN5 (one14 B_28 XI1252_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1252_MN7 (XI1252_an2 XI1252_aan one14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1252_MN8 (VSS XI1252_abn XI1252_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1252_MN6 (XI1252_an1 B_27_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1252_MN1 (XI1252_aan B_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1252_MN3 (VSS B_27_b3_5 XI1252_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1252_MN15 (XI1252_bbn B_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15997u ps=0.67997u
    I_MXI1252_MN13 (XI1252_ban B_29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1252_MN19 (XI1252_bn2 XI1252_ban XI1252_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1252_MN20 (VSS B_28 XI1252_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1252_MN18 (XI1252_bn1 XI1252_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1252_MN17 (XI1252_e B_29_b3_0 XI1252_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1252_MN26 (two14 one14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1252_MN25 (VSS XI1252_e two14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0408p pd=0.67997u ps=0.67997u
    I_MXI1307_MN5 (one15 B_30 XI1307_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1307_MN7 (XI1307_an2 XI1307_aan one15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1307_MN8 (VSS XI1307_abn XI1307_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1307_MN6 (XI1307_an1 B_29_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1307_MN1 (XI1307_aan B_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1307_MN3 (VSS B_29_b3_5 XI1307_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1307_MN15 (XI1307_bbn B_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15997u ps=0.67997u
    I_MXI1307_MN13 (XI1307_ban B_31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1307_MN19 (XI1307_bn2 XI1307_ban XI1307_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1307_MN20 (VSS B_30 XI1307_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1307_MN18 (XI1307_bn1 XI1307_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1307_MN17 (XI1307_e B_31_b3_0 XI1307_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1307_MN26 (two15 one15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1307_MN25 (VSS XI1307_e two15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0408p pd=0.67997u ps=0.67997u
    I_MXI1032_MN5 (one10 B_20 XI1032_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1032_MN7 (XI1032_an2 XI1032_aan one10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1032_MN8 (VSS XI1032_abn XI1032_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1032_MN6 (XI1032_an1 B_19_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1032_MN1 (XI1032_aan B_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1032_MN3 (VSS B_19_b3_5 XI1032_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1032_MN15 (XI1032_bbn B_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15997u ps=0.67997u
    I_MXI1032_MN13 (XI1032_ban B_21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1032_MN19 (XI1032_bn2 XI1032_ban XI1032_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1032_MN20 (VSS B_20 XI1032_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1032_MN18 (XI1032_bn1 XI1032_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1032_MN17 (XI1032_e B_21_b3_0 XI1032_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1032_MN26 (two10 one10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI1032_MN25 (VSS XI1032_e two10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0408p pd=0.67997u ps=0.67997u
    I_MXI867_MN5 (one7 B_14 XI867_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI867_MN7 (XI867_an2 XI867_aan one7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI867_MN8 (VSS XI867_abn XI867_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI867_MN6 (XI867_an1 B_13_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI867_MN1 (XI867_aan B_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI867_MN3 (VSS B_13_b3_5 XI867_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI867_MN15 (XI867_bbn B_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15997u ps=0.67997u
    I_MXI867_MN13 (XI867_ban B_15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI867_MN19 (XI867_bn2 XI867_ban XI867_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI867_MN20 (VSS B_14 XI867_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI867_MN18 (XI867_bn1 XI867_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI867_MN17 (XI867_e B_15_b3_0 XI867_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI867_MN26 (two7 one7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI867_MN25 (VSS XI867_e two7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0408p pd=0.67997u ps=0.67997u
    I_MXI922_MN5 (one8 B_16 XI922_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI922_MN7 (XI922_an2 XI922_aan one8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI922_MN8 (VSS XI922_abn XI922_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI922_MN6 (XI922_an1 B_15_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI922_MN1 (XI922_aan B_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI922_MN3 (VSS B_15_b3_5 XI922_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI922_MN15 (XI922_bbn B_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15997u ps=0.67997u
    I_MXI922_MN13 (XI922_ban B_17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI922_MN19 (XI922_bn2 XI922_ban XI922_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI922_MN20 (VSS B_16 XI922_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI922_MN18 (XI922_bn1 XI922_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI922_MN17 (XI922_e B_17_b3_0 XI922_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI922_MN26 (two8 one8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI922_MN25 (VSS XI922_e two8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0408p pd=0.67997u ps=0.67997u
    I_MXI977_MN5 (one9 B_18 XI977_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI977_MN7 (XI977_an2 XI977_aan one9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI977_MN8 (VSS XI977_abn XI977_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI977_MN6 (XI977_an1 B_17_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI977_MN1 (XI977_aan B_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI977_MN3 (VSS B_17_b3_5 XI977_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI977_MN15 (XI977_bbn B_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15997u ps=0.67997u
    I_MXI977_MN13 (XI977_ban B_19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI977_MN19 (XI977_bn2 XI977_ban XI977_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI977_MN20 (VSS B_18 XI977_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI977_MN18 (XI977_bn1 XI977_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI977_MN17 (XI977_e B_19_b3_0 XI977_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI977_MN26 (two9 one9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI977_MN25 (VSS XI977_e two9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0408p pd=0.67997u ps=0.67997u
    I_MXI812_MN5 (one6 B_12 XI812_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI812_MN7 (XI812_an2 XI812_aan one6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI812_MN8 (VSS XI812_abn XI812_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI812_MN6 (XI812_an1 B_11_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI812_MN1 (XI812_aan B_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI812_MN3 (VSS B_11_b3_5 XI812_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI812_MN15 (XI812_bbn B_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15997u ps=0.67997u
    I_MXI812_MN13 (XI812_ban B_13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI812_MN19 (XI812_bn2 XI812_ban XI812_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI812_MN20 (VSS B_12 XI812_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI812_MN18 (XI812_bn1 XI812_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI812_MN17 (XI812_e B_13_b3_0 XI812_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI812_MN26 (two6 one6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI812_MN25 (VSS XI812_e two6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0408p pd=0.67997u ps=0.67997u
    I_MXI757_MN5 (one5 B_10 XI757_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI757_MN7 (XI757_an2 XI757_aan one5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI757_MN8 (VSS XI757_abn XI757_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI757_MN6 (XI757_an1 B_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI757_MN1 (XI757_aan B_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI757_MN3 (VSS B_9_b3_5 XI757_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI757_MN15 (XI757_bbn B_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15997u ps=0.67997u
    I_MXI757_MN13 (XI757_ban B_11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI757_MN19 (XI757_bn2 XI757_ban XI757_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI757_MN20 (VSS B_10 XI757_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI757_MN18 (XI757_bn1 XI757_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI757_MN17 (XI757_e B_11_b3_0 XI757_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI757_MN26 (two5 one5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI757_MN25 (VSS XI757_e two5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0408p pd=0.67997u ps=0.67997u
    I_MXI647_MN5 (one3 B_6 XI647_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI647_MN7 (XI647_an2 XI647_aan one3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI647_MN8 (VSS XI647_abn XI647_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI647_MN6 (XI647_an1 B_5_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI647_MN1 (XI647_aan B_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI647_MN3 (VSS B_5_b3_5 XI647_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI647_MN15 (XI647_bbn B_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15997u ps=0.67997u
    I_MXI647_MN13 (XI647_ban B_7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI647_MN19 (XI647_bn2 XI647_ban XI647_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI647_MN20 (VSS B_6 XI647_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI647_MN18 (XI647_bn1 XI647_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI647_MN17 (XI647_e B_7_b3_0 XI647_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI647_MN26 (two3 one3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI647_MN25 (VSS XI647_e two3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0408p pd=0.67997u ps=0.67997u
    I_MXI702_MN5 (one4 B_8 XI702_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI702_MN7 (XI702_an2 XI702_aan one4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI702_MN8 (VSS XI702_abn XI702_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI702_MN6 (XI702_an1 B_7_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI702_MN1 (XI702_aan B_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI702_MN3 (VSS B_7_b3_5 XI702_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI702_MN15 (XI702_bbn B_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15997u ps=0.67997u
    I_MXI702_MN13 (XI702_ban B_9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI702_MN19 (XI702_bn2 XI702_ban XI702_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI702_MN20 (VSS B_8 XI702_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI702_MN18 (XI702_bn1 XI702_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI702_MN17 (XI702_e B_9_b3_0 XI702_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI702_MN26 (two4 one4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI702_MN25 (VSS XI702_e two4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0408p pd=0.67997u ps=0.67997u
    I_MXI592_MN5 (one2 B_4 XI592_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI592_MN7 (XI592_an2 XI592_aan one2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI592_MN8 (VSS XI592_abn XI592_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI592_MN6 (XI592_an1 B_3_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI592_MN1 (XI592_aan B_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI592_MN3 (VSS B_3_b3_5 XI592_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI592_MN15 (XI592_bbn B_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15997u ps=0.67997u
    I_MXI592_MN13 (XI592_ban B_5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI592_MN19 (XI592_bn2 XI592_ban XI592_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI592_MN20 (VSS B_4 XI592_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI592_MN18 (XI592_bn1 XI592_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI592_MN17 (XI592_e B_5_b3_0 XI592_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI592_MN26 (two2 one2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI592_MN25 (VSS XI592_e two2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0408p pd=0.67997u ps=0.67997u
    I_MXI537_MN5 (one1 B_2 XI537_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI537_MN7 (XI537_an2 XI537_aan one1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI537_MN8 (VSS XI537_abn XI537_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI537_MN6 (XI537_an1 B_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI537_MN1 (XI537_aan B_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI537_MN3 (VSS B_1_b3_5 XI537_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI537_MN15 (XI537_bbn B_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15997u ps=0.67997u
    I_MXI537_MN13 (XI537_ban B_3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI537_MN19 (XI537_bn2 XI537_ban XI537_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI537_MN20 (VSS B_2 XI537_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI537_MN18 (XI537_bn1 XI537_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI537_MN17 (XI537_e B_3_b3_0 XI537_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI537_MN26 (two1 one1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI537_MN25 (VSS XI537_e two1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0408p pd=0.67997u ps=0.67997u
    I_MXI482_MN5 (one0 B_0 XI482_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI482_MN7 (XI482_an2 XI482_aan one0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI482_MN8 (VSS XI482_abn XI482_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI482_MN6 (XI482_an1 VSS VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI482_MN1 (XI482_aan B_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI482_MN3 (VSS VSS XI482_abn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI482_MN15 (XI482_bbn B_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0408p pd=1.15997u ps=0.67997u
    I_MXI482_MN13 (XI482_ban B_1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI482_MN19 (XI482_bn2 XI482_ban XI482_e VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI482_MN20 (VSS B_0 XI482_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI482_MN18 (XI482_bn1 XI482_bbn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI482_MN17 (XI482_e B_1_b3_0 XI482_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI482_MN26 (two0 one0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0696p pd=0.67997u ps=1.15997u
    I_MXI482_MN25 (VSS XI482_e two0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0408p as=0.0408p pd=0.67997u ps=0.67997u
    I_MXI1660_I512_MN1 (XI1660_I512_Bn I1660_G44_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I512_MN5 (XI1660_I512_n2 XI1660_I512_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I512_MN4 (P_45 XI1660_I512_An XI1660_I512_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I512_MN2 (XI1660_I512_n1 I1660_pn45 P_45 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I512_MN3 (VSS I1660_G44_0n XI1660_I512_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I512_MN0 (XI1660_I512_An I1660_pn45 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I528_MN1 (XI1660_I528_Bn I1660_G60_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I528_MN5 (XI1660_I528_n2 XI1660_I528_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I528_MN4 (P_61 XI1660_I528_An XI1660_I528_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I528_MN2 (XI1660_I528_n1 I1660_pn61 P_61 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I528_MN3 (VSS I1660_G60_0n XI1660_I528_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I528_MN0 (XI1660_I528_An I1660_pn61 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I514_MN1 (XI1660_I514_Bn I1660_G46_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I514_MN5 (XI1660_I514_n2 XI1660_I514_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I514_MN4 (P_47 XI1660_I514_An XI1660_I514_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I514_MN2 (XI1660_I514_n1 I1660_pn47 P_47 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I514_MN3 (VSS I1660_G46_0n XI1660_I514_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I514_MN0 (XI1660_I514_An I1660_pn47 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I524_MN1 (XI1660_I524_Bn I1660_G56_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I524_MN5 (XI1660_I524_n2 XI1660_I524_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I524_MN4 (P_57 XI1660_I524_An XI1660_I524_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I524_MN2 (XI1660_I524_n1 I1660_pn57 P_57 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I524_MN3 (VSS I1660_G56_0n XI1660_I524_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I524_MN0 (XI1660_I524_An I1660_pn57 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I530_MN1 (XI1660_I530_Bn I1660_G62_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I530_MN5 (XI1660_I530_n2 XI1660_I530_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I530_MN4 (P_63 XI1660_I530_An XI1660_I530_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I530_MN2 (XI1660_I530_n1 I1660_pn63 P_63 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I530_MN3 (VSS I1660_G62_0n XI1660_I530_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I530_MN0 (XI1660_I530_An I1660_pn63 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I520_MN1 (XI1660_I520_Bn I1660_G52_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I520_MN5 (XI1660_I520_n2 XI1660_I520_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I520_MN4 (P_53 XI1660_I520_An XI1660_I520_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I520_MN2 (XI1660_I520_n1 I1660_pn53 P_53 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I520_MN3 (VSS I1660_G52_0n XI1660_I520_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I520_MN0 (XI1660_I520_An I1660_pn53 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I526_MN1 (XI1660_I526_Bn I1660_G58_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I526_MN5 (XI1660_I526_n2 XI1660_I526_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I526_MN4 (P_59 XI1660_I526_An XI1660_I526_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I526_MN2 (XI1660_I526_n1 I1660_pn59 P_59 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I526_MN3 (VSS I1660_G58_0n XI1660_I526_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I526_MN0 (XI1660_I526_An I1660_pn59 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I522_MN1 (XI1660_I522_Bn I1660_G54_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I522_MN5 (XI1660_I522_n2 XI1660_I522_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I522_MN4 (P_55 XI1660_I522_An XI1660_I522_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I522_MN2 (XI1660_I522_n1 I1660_pn55 P_55 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I522_MN3 (VSS I1660_G54_0n XI1660_I522_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I522_MN0 (XI1660_I522_An I1660_pn55 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I513_MN1 (XI1660_I513_Bn I1660_G45_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I513_MN5 (XI1660_I513_n2 XI1660_I513_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I513_MN4 (P_46 XI1660_I513_An XI1660_I513_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I513_MN2 (XI1660_I513_n1 I1660_pn46 P_46 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I513_MN3 (VSS I1660_G45_0n XI1660_I513_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I513_MN0 (XI1660_I513_An I1660_pn46 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I518_MN1 (XI1660_I518_Bn I1660_G50_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I518_MN5 (XI1660_I518_n2 XI1660_I518_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I518_MN4 (P_51 XI1660_I518_An XI1660_I518_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I518_MN2 (XI1660_I518_n1 I1660_pn51 P_51 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I518_MN3 (VSS I1660_G50_0n XI1660_I518_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I518_MN0 (XI1660_I518_An I1660_pn51 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I529_MN1 (XI1660_I529_Bn I1660_G61_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I529_MN5 (XI1660_I529_n2 XI1660_I529_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I529_MN4 (P_62 XI1660_I529_An XI1660_I529_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I529_MN2 (XI1660_I529_n1 I1660_pn62 P_62 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I529_MN3 (VSS I1660_G61_0n XI1660_I529_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I529_MN0 (XI1660_I529_An I1660_pn62 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I511_MN1 (XI1660_I511_Bn I1660_G43_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I511_MN5 (XI1660_I511_n2 XI1660_I511_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I511_MN4 (P_44 XI1660_I511_An XI1660_I511_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I511_MN2 (XI1660_I511_n1 I1660_pn44 P_44 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I511_MN3 (VSS I1660_G43_0n XI1660_I511_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I511_MN0 (XI1660_I511_An I1660_pn44 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I508_MN1 (XI1660_I508_Bn I1660_G40_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I508_MN5 (XI1660_I508_n2 XI1660_I508_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I508_MN4 (P_41 XI1660_I508_An XI1660_I508_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I508_MN2 (XI1660_I508_n1 I1660_pn41 P_41 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I508_MN3 (VSS I1660_G40_0n XI1660_I508_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I508_MN0 (XI1660_I508_An I1660_pn41 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I510_MN1 (XI1660_I510_Bn I1660_G42_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I510_MN5 (XI1660_I510_n2 XI1660_I510_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I510_MN4 (P_43 XI1660_I510_An XI1660_I510_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I510_MN2 (XI1660_I510_n1 I1660_pn43 P_43 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I510_MN3 (VSS I1660_G42_0n XI1660_I510_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I510_MN0 (XI1660_I510_An I1660_pn43 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I516_MN1 (XI1660_I516_Bn I1660_G48_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I516_MN5 (XI1660_I516_n2 XI1660_I516_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I516_MN4 (P_49 XI1660_I516_An XI1660_I516_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I516_MN2 (XI1660_I516_n1 I1660_pn49 P_49 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I516_MN3 (VSS I1660_G48_0n XI1660_I516_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I516_MN0 (XI1660_I516_An I1660_pn49 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I517_MN1 (XI1660_I517_Bn I1660_G49_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I517_MN5 (XI1660_I517_n2 XI1660_I517_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I517_MN4 (P_50 XI1660_I517_An XI1660_I517_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I517_MN2 (XI1660_I517_n1 I1660_pn50 P_50 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I517_MN3 (VSS I1660_G49_0n XI1660_I517_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I517_MN0 (XI1660_I517_An I1660_pn50 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I525_MN1 (XI1660_I525_Bn I1660_G57_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I525_MN5 (XI1660_I525_n2 XI1660_I525_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I525_MN4 (P_58 XI1660_I525_An XI1660_I525_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I525_MN2 (XI1660_I525_n1 I1660_pn58 P_58 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I525_MN3 (VSS I1660_G57_0n XI1660_I525_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I525_MN0 (XI1660_I525_An I1660_pn58 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I521_MN1 (XI1660_I521_Bn I1660_G53_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I521_MN5 (XI1660_I521_n2 XI1660_I521_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I521_MN4 (P_54 XI1660_I521_An XI1660_I521_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I521_MN2 (XI1660_I521_n1 I1660_pn54 P_54 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I521_MN3 (VSS I1660_G53_0n XI1660_I521_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I521_MN0 (XI1660_I521_An I1660_pn54 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I506_MN1 (XI1660_I506_Bn I1660_G38_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I506_MN5 (XI1660_I506_n2 XI1660_I506_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I506_MN4 (P_39 XI1660_I506_An XI1660_I506_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I506_MN2 (XI1660_I506_n1 I1660_pn39 P_39 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I506_MN3 (VSS I1660_G38_0n XI1660_I506_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I506_MN0 (XI1660_I506_An I1660_pn39 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I519_MN1 (XI1660_I519_Bn I1660_G51_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I519_MN5 (XI1660_I519_n2 XI1660_I519_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I519_MN4 (P_52 XI1660_I519_An XI1660_I519_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I519_MN2 (XI1660_I519_n1 I1660_pn52 P_52 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I519_MN3 (VSS I1660_G51_0n XI1660_I519_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I519_MN0 (XI1660_I519_An I1660_pn52 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I527_MN1 (XI1660_I527_Bn I1660_G59_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I527_MN5 (XI1660_I527_n2 XI1660_I527_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I527_MN4 (P_60 XI1660_I527_An XI1660_I527_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I527_MN2 (XI1660_I527_n1 I1660_pn60 P_60 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I527_MN3 (VSS I1660_G59_0n XI1660_I527_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I527_MN0 (XI1660_I527_An I1660_pn60 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I515_MN1 (XI1660_I515_Bn I1660_G47_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I515_MN5 (XI1660_I515_n2 XI1660_I515_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I515_MN4 (P_48 XI1660_I515_An XI1660_I515_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I515_MN2 (XI1660_I515_n1 I1660_pn48 P_48 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I515_MN3 (VSS I1660_G47_0n XI1660_I515_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I515_MN0 (XI1660_I515_An I1660_pn48 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I523_MN1 (XI1660_I523_Bn I1660_G55_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I523_MN5 (XI1660_I523_n2 XI1660_I523_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I523_MN4 (P_56 XI1660_I523_An XI1660_I523_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I523_MN2 (XI1660_I523_n1 I1660_pn56 P_56 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I523_MN3 (VSS I1660_G55_0n XI1660_I523_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I523_MN0 (XI1660_I523_An I1660_pn56 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I504_MN1 (XI1660_I504_Bn I1660_G36_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I504_MN5 (XI1660_I504_n2 XI1660_I504_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I504_MN4 (P_37 XI1660_I504_An XI1660_I504_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I504_MN2 (XI1660_I504_n1 I1660_pn37 P_37 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I504_MN3 (VSS I1660_G36_0n XI1660_I504_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I504_MN0 (XI1660_I504_An I1660_pn37 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I502_MN1 (XI1660_I502_Bn I1660_G34_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I502_MN5 (XI1660_I502_n2 XI1660_I502_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I502_MN4 (P_35 XI1660_I502_An XI1660_I502_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I502_MN2 (XI1660_I502_n1 I1660_pn35 P_35 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I502_MN3 (VSS I1660_G34_0n XI1660_I502_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I502_MN0 (XI1660_I502_An I1660_pn35 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I509_MN1 (XI1660_I509_Bn I1660_G41_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I509_MN5 (XI1660_I509_n2 XI1660_I509_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I509_MN4 (P_42 XI1660_I509_An XI1660_I509_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I509_MN2 (XI1660_I509_n1 I1660_pn42 P_42 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I509_MN3 (VSS I1660_G41_0n XI1660_I509_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I509_MN0 (XI1660_I509_An I1660_pn42 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I500_MN1 (XI1660_I500_Bn I1660_G32_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I500_MN5 (XI1660_I500_n2 XI1660_I500_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I500_MN4 (P_33 XI1660_I500_An XI1660_I500_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I500_MN2 (XI1660_I500_n1 I1660_pn33 P_33 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I500_MN3 (VSS I1660_G32_0n XI1660_I500_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I500_MN0 (XI1660_I500_An I1660_pn33 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I482_MN1 (XI1660_I482_Bn I1660_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I482_MN5 (XI1660_I482_n2 XI1660_I482_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I482_MN4 (P_15 XI1660_I482_An XI1660_I482_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I482_MN2 (XI1660_I482_n1 I1660_pn15 P_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I482_MN3 (VSS I1660_G14_0n XI1660_I482_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I482_MN0 (XI1660_I482_An I1660_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I505_MN1 (XI1660_I505_Bn I1660_G37_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I505_MN5 (XI1660_I505_n2 XI1660_I505_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I505_MN4 (P_38 XI1660_I505_An XI1660_I505_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I505_MN2 (XI1660_I505_n1 I1660_pn38 P_38 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I505_MN3 (VSS I1660_G37_0n XI1660_I505_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I505_MN0 (XI1660_I505_An I1660_pn38 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I507_MN1 (XI1660_I507_Bn I1660_G39_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I507_MN5 (XI1660_I507_n2 XI1660_I507_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I507_MN4 (P_40 XI1660_I507_An XI1660_I507_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I507_MN2 (XI1660_I507_n1 I1660_pn40 P_40 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I507_MN3 (VSS I1660_G39_0n XI1660_I507_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I507_MN0 (XI1660_I507_An I1660_pn40 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I483_MN1 (XI1660_I483_Bn I1660_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I483_MN5 (XI1660_I483_n2 XI1660_I483_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I483_MN4 (P_16 XI1660_I483_An XI1660_I483_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I483_MN2 (XI1660_I483_n1 I1660_pn16 P_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I483_MN3 (VSS I1660_G15_0n XI1660_I483_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I483_MN0 (XI1660_I483_An I1660_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I501_MN1 (XI1660_I501_Bn I1660_G33_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I501_MN5 (XI1660_I501_n2 XI1660_I501_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I501_MN4 (P_34 XI1660_I501_An XI1660_I501_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I501_MN2 (XI1660_I501_n1 I1660_pn34 P_34 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I501_MN3 (VSS I1660_G33_0n XI1660_I501_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I501_MN0 (XI1660_I501_An I1660_pn34 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I481_MN1 (XI1660_I481_Bn I1660_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I481_MN5 (XI1660_I481_n2 XI1660_I481_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I481_MN4 (P_14 XI1660_I481_An XI1660_I481_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I481_MN2 (XI1660_I481_n1 I1660_pn14 P_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I481_MN3 (VSS I1660_G13_0n XI1660_I481_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I481_MN0 (XI1660_I481_An I1660_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I480_MN1 (XI1660_I480_Bn I1660_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I480_MN5 (XI1660_I480_n2 XI1660_I480_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I480_MN4 (P_13 XI1660_I480_An XI1660_I480_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I480_MN2 (XI1660_I480_n1 I1660_pn13 P_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I480_MN3 (VSS I1660_G12_0n XI1660_I480_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I480_MN0 (XI1660_I480_An I1660_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I478_MN1 (XI1660_I478_Bn I1660_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I478_MN5 (XI1660_I478_n2 XI1660_I478_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I478_MN4 (P_11 XI1660_I478_An XI1660_I478_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I478_MN2 (XI1660_I478_n1 I1660_pn11 P_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I478_MN3 (VSS I1660_G10_0n XI1660_I478_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I478_MN0 (XI1660_I478_An I1660_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I479_MN1 (XI1660_I479_Bn I1660_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I479_MN5 (XI1660_I479_n2 XI1660_I479_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I479_MN4 (P_12 XI1660_I479_An XI1660_I479_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I479_MN2 (XI1660_I479_n1 I1660_pn12 P_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I479_MN3 (VSS I1660_G11_0n XI1660_I479_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I479_MN0 (XI1660_I479_An I1660_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I503_MN1 (XI1660_I503_Bn I1660_G35_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I503_MN5 (XI1660_I503_n2 XI1660_I503_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I503_MN4 (P_36 XI1660_I503_An XI1660_I503_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I503_MN2 (XI1660_I503_n1 I1660_pn36 P_36 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I503_MN3 (VSS I1660_G35_0n XI1660_I503_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I503_MN0 (XI1660_I503_An I1660_pn36 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I476_MN1 (XI1660_I476_Bn I1660_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I476_MN5 (XI1660_I476_n2 XI1660_I476_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I476_MN4 (P_9 XI1660_I476_An XI1660_I476_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I476_MN2 (XI1660_I476_n1 I1660_pn9 P_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I476_MN3 (VSS I1660_G8_0n XI1660_I476_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I476_MN0 (XI1660_I476_An I1660_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I470_MN1 (XI1660_I470_Bn I1660_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I470_MN5 (XI1660_I470_n2 XI1660_I470_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I470_MN4 (P_3 XI1660_I470_An XI1660_I470_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I470_MN2 (XI1660_I470_n1 I1660_pn3 P_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I470_MN3 (VSS I1660_G2_0n XI1660_I470_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I470_MN0 (XI1660_I470_An I1660_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I477_MN1 (XI1660_I477_Bn I1660_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I477_MN5 (XI1660_I477_n2 XI1660_I477_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I477_MN4 (P_10 XI1660_I477_An XI1660_I477_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I477_MN2 (XI1660_I477_n1 I1660_pn10 P_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I477_MN3 (VSS I1660_G9_0n XI1660_I477_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I477_MN0 (XI1660_I477_An I1660_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I471_MN1 (XI1660_I471_Bn I1660_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI1660_I471_MN5 (XI1660_I471_n2 XI1660_I471_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.67997u ps=1.15997u
    I_MXI1660_I471_MN4 (P_4 XI1660_I471_An XI1660_I471_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I471_MN2 (XI1660_I471_n1 I1660_pn4 P_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.67997u ps=0.67997u
    I_MXI1660_I471_MN3 (VSS I1660_G3_0n XI1660_I471_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.15997u ps=0.67997u
    I_MXI1660_I471_MN0 (XI1660_I471_An I1660_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0696p as=0.0696p pd=1.15997u ps=1.15997u
    I_MXI931_MP2 (one8_b3_4 one8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI931_MP2_1 (VDD one8_b2_1 one8_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI941_MP2 (two8_b3_4 two8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI941_MP2_1 (VDD two8_b2_1 two8_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI272_MP2 (A_26_b2_0 A_26_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI272_MP2_1 (VDD A_26_b1_0 A_26_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI232_MP2 (A_22_b2_0 A_22_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI232_MP2_1 (VDD A_22_b1_0 A_22_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI207_MP2 (A_19_b3_3 A_19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI207_MP2_1 (VDD A_19_b2_1 A_19_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI404_MP2 (B_17_b2_0 B_17_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI404_MP2_1 (VDD B_17_b1_0 B_17_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI262_MP2 (A_25_b2_0 A_25_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI262_MP2_1 (VDD A_25_b1_0 A_25_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI242_MP2 (A_23_b2_0 A_23_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI242_MP2_1 (VDD A_23_b1_0 A_23_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI298_MP2 (A_28_b3_4 A_28_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI298_MP2_1 (VDD A_28_b2_1 A_28_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI289_MP2 (A_27_b3_5 A_27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI289_MP2_1 (VDD A_27_b2_1 A_27_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1325_MP2 (two15_b3_3 two15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1325_MP2_1 (VDD two15_b2_1 two15_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI318_MP2 (A_30_b3_4 A_30_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI318_MP2_1 (VDD A_30_b2_1 A_30_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI137_MP2 (A_12_b3_3 A_12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI137_MP2_1 (VDD A_12_b2_1 A_12_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI414_MP2 (B_19_b2_0 B_19_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI414_MP2_1 (VDD B_19_b1_0 B_19_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI710_MP2 (one4_b3_3 one4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI710_MP2_1 (VDD one4_b2_1 one4_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI185_MP2 (A_17_b3_1 A_17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI185_MP2_1 (VDD A_17_b2_0 A_17_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI114_MP2 (A_10_b3_0 A_10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI114_MP2_1 (VDD A_10_b2_0 A_10_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI112_MP2 (A_10_b2_0 A_10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI112_MP2_1 (VDD A_10_b1_0 A_10_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI347_MP2 (B_5_b3_1 B_5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI347_MP2_1 (VDD B_5_b2_0 B_5_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI84_MP2 (A_7_b3_0 A_7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI84_MP2_1 (VDD A_7_b2_0 A_7_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI74_MP2 (A_6_b3_0 A_6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI74_MP2_1 (VDD A_6_b2_0 A_6_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I107_MP1 (VDD fa287_0 XI1660_I107_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I107_MP5 (I1660_pn43 fa287_0 XI1660_I107_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I107_MP4 (XI1660_I107_p1 XI1660_I107_An I1660_pn43 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I107_MP2 (VDD ha286_1 XI1660_I107_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I107_MP3 (XI1660_I107_p1 XI1660_I107_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I107_MP0 (VDD ha286_1 XI1660_I107_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I119_MP1 (VDD fa245_0 XI1660_I119_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I119_MP5 (I1660_pn55 fa245_0 XI1660_I119_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I119_MP4 (XI1660_I119_p1 XI1660_I119_An I1660_pn55 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I119_MP2 (VDD fa296_1 XI1660_I119_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I119_MP3 (XI1660_I119_p1 XI1660_I119_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I119_MP0 (VDD fa296_1 XI1660_I119_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I102_MP1 (VDD ha282_0 XI1660_I102_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I102_MP5 (I1660_pn38 ha282_0 XI1660_I102_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I102_MP4 (XI1660_I102_p1 XI1660_I102_An I1660_pn38 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I102_MP2 (VDD fa281_1 XI1660_I102_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I102_MP3 (XI1660_I102_p1 XI1660_I102_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I102_MP0 (VDD fa281_1 XI1660_I102_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I104_MP1 (VDD ha284_0 XI1660_I104_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I104_MP5 (I1660_pn40 ha284_0 XI1660_I104_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I104_MP4 (XI1660_I104_p1 XI1660_I104_An I1660_pn40 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I104_MP2 (VDD fa283_1 XI1660_I104_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I104_MP3 (XI1660_I104_p1 XI1660_I104_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I104_MP0 (VDD fa283_1 XI1660_I104_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I106_MP1 (VDD ha286_0 XI1660_I106_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I106_MP5 (I1660_pn42 ha286_0 XI1660_I106_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I106_MP4 (XI1660_I106_p1 XI1660_I106_An I1660_pn42 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I106_MP2 (VDD fa285_1 XI1660_I106_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I106_MP3 (XI1660_I106_p1 XI1660_I106_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I106_MP0 (VDD fa285_1 XI1660_I106_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I108_MP1 (VDD ha288_0 XI1660_I108_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I108_MP5 (I1660_pn44 ha288_0 XI1660_I108_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I108_MP4 (XI1660_I108_p1 XI1660_I108_An I1660_pn44 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I108_MP2 (VDD fa287_1 XI1660_I108_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I108_MP3 (XI1660_I108_p1 XI1660_I108_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I108_MP0 (VDD fa287_1 XI1660_I108_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I110_MP1 (VDD ha290_0 XI1660_I110_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I110_MP5 (I1660_pn46 ha290_0 XI1660_I110_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I110_MP4 (XI1660_I110_p1 XI1660_I110_An I1660_pn46 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I110_MP2 (VDD fa289_1 XI1660_I110_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I110_MP3 (XI1660_I110_p1 XI1660_I110_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I110_MP0 (VDD fa289_1 XI1660_I110_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I112_MP1 (VDD ha292_0 XI1660_I112_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I112_MP5 (I1660_pn48 ha292_0 XI1660_I112_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I112_MP4 (XI1660_I112_p1 XI1660_I112_An I1660_pn48 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I112_MP2 (VDD fa291_1 XI1660_I112_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I112_MP3 (XI1660_I112_p1 XI1660_I112_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I112_MP0 (VDD fa291_1 XI1660_I112_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I117_MP1 (VDD fa244_0 XI1660_I117_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I117_MP5 (I1660_pn53 fa244_0 XI1660_I117_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I117_MP4 (XI1660_I117_p1 XI1660_I117_An I1660_pn53 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I117_MP2 (VDD fa295_1 XI1660_I117_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I117_MP3 (XI1660_I117_p1 XI1660_I117_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I117_MP0 (VDD fa295_1 XI1660_I117_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I121_MP1 (VDD fa246_0 XI1660_I121_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I121_MP5 (I1660_pn57 fa246_0 XI1660_I121_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I121_MP4 (XI1660_I121_p1 XI1660_I121_An I1660_pn57 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I121_MP2 (VDD fa297_1 XI1660_I121_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I121_MP3 (XI1660_I121_p1 XI1660_I121_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I121_MP0 (VDD fa297_1 XI1660_I121_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I103_MP1 (VDD fa283_0 XI1660_I103_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I103_MP5 (I1660_pn39 fa283_0 XI1660_I103_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I103_MP4 (XI1660_I103_p1 XI1660_I103_An I1660_pn39 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I103_MP2 (VDD ha282_1 XI1660_I103_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I103_MP3 (XI1660_I103_p1 XI1660_I103_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I103_MP0 (VDD ha282_1 XI1660_I103_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I105_MP1 (VDD fa285_0 XI1660_I105_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I105_MP5 (I1660_pn41 fa285_0 XI1660_I105_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I105_MP4 (XI1660_I105_p1 XI1660_I105_An I1660_pn41 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I105_MP2 (VDD ha284_1 XI1660_I105_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I105_MP3 (XI1660_I105_p1 XI1660_I105_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I105_MP0 (VDD ha284_1 XI1660_I105_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I109_MP1 (VDD fa289_0 XI1660_I109_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I109_MP5 (I1660_pn45 fa289_0 XI1660_I109_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I109_MP4 (XI1660_I109_p1 XI1660_I109_An I1660_pn45 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I109_MP2 (VDD ha288_1 XI1660_I109_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I109_MP3 (XI1660_I109_p1 XI1660_I109_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I109_MP0 (VDD ha288_1 XI1660_I109_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I111_MP1 (VDD fa291_0 XI1660_I111_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I111_MP5 (I1660_pn47 fa291_0 XI1660_I111_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I111_MP4 (XI1660_I111_p1 XI1660_I111_An I1660_pn47 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I111_MP2 (VDD ha290_1 XI1660_I111_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I111_MP3 (XI1660_I111_p1 XI1660_I111_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I111_MP0 (VDD ha290_1 XI1660_I111_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I123_MP1 (VDD fa207_0 XI1660_I123_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I123_MP5 (I1660_pn59 fa207_0 XI1660_I123_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I123_MP4 (XI1660_I123_p1 XI1660_I123_An I1660_pn59 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I123_MP2 (VDD fa298_1 XI1660_I123_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I123_MP3 (XI1660_I123_p1 XI1660_I123_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I123_MP0 (VDD fa298_1 XI1660_I123_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I116_MP1 (VDD VSS XI1660_I116_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I116_MP5 (I1660_pn52 VSS XI1660_I116_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I116_MP4 (XI1660_I116_p1 XI1660_I116_An I1660_pn52 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I116_MP2 (VDD fa295_0 XI1660_I116_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I116_MP3 (XI1660_I116_p1 XI1660_I116_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I116_MP0 (VDD fa295_0 XI1660_I116_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I118_MP1 (VDD VSS XI1660_I118_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I118_MP5 (I1660_pn54 VSS XI1660_I118_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I118_MP4 (XI1660_I118_p1 XI1660_I118_An I1660_pn54 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I118_MP2 (VDD fa296_0 XI1660_I118_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I118_MP3 (XI1660_I118_p1 XI1660_I118_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I118_MP0 (VDD fa296_0 XI1660_I118_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I100_MP1 (VDD fa280_0 XI1660_I100_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I100_MP5 (I1660_pn36 fa280_0 XI1660_I100_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I100_MP4 (XI1660_I100_p1 XI1660_I100_An I1660_pn36 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I100_MP2 (VDD ha279_1 XI1660_I100_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I100_MP3 (XI1660_I100_p1 XI1660_I100_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I100_MP0 (VDD ha279_1 XI1660_I100_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I101_MP1 (VDD fa281_0 XI1660_I101_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I101_MP5 (I1660_pn37 fa281_0 XI1660_I101_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I101_MP4 (XI1660_I101_p1 XI1660_I101_An I1660_pn37 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I101_MP2 (VDD fa280_1 XI1660_I101_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I101_MP3 (XI1660_I101_p1 XI1660_I101_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I101_MP0 (VDD fa280_1 XI1660_I101_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I113_MP1 (VDD fa293_0 XI1660_I113_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I113_MP5 (I1660_pn49 fa293_0 XI1660_I113_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I113_MP4 (XI1660_I113_p1 XI1660_I113_An I1660_pn49 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I113_MP2 (VDD ha292_1 XI1660_I113_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I113_MP3 (XI1660_I113_p1 XI1660_I113_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I113_MP0 (VDD ha292_1 XI1660_I113_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I114_MP1 (VDD ha294_0 XI1660_I114_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I114_MP5 (I1660_pn50 ha294_0 XI1660_I114_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I114_MP4 (XI1660_I114_p1 XI1660_I114_An I1660_pn50 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I114_MP2 (VDD fa293_1 XI1660_I114_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I114_MP3 (XI1660_I114_p1 XI1660_I114_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I114_MP0 (VDD fa293_1 XI1660_I114_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I115_MP1 (VDD fa243_0 XI1660_I115_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I115_MP5 (I1660_pn51 fa243_0 XI1660_I115_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I115_MP4 (XI1660_I115_p1 XI1660_I115_An I1660_pn51 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I115_MP2 (VDD ha294_1 XI1660_I115_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I115_MP3 (XI1660_I115_p1 XI1660_I115_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I115_MP0 (VDD ha294_1 XI1660_I115_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I99_MP1 (VDD ha279_0 XI1660_I99_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I99_MP5 (I1660_pn35 ha279_0 XI1660_I99_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I99_MP4 (XI1660_I99_p1 XI1660_I99_An I1660_pn35 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I99_MP2 (VDD ha278_1 XI1660_I99_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I99_MP3 (XI1660_I99_p1 XI1660_I99_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I99_MP0 (VDD ha278_1 XI1660_I99_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I125_MP1 (VDD fa208_0 XI1660_I125_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I125_MP5 (I1660_pn61 fa208_0 XI1660_I125_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I125_MP4 (XI1660_I125_p1 XI1660_I125_An I1660_pn61 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I125_MP2 (VDD fa247_1 XI1660_I125_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I125_MP3 (XI1660_I125_p1 XI1660_I125_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I125_MP0 (VDD fa247_1 XI1660_I125_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I122_MP1 (VDD VSS XI1660_I122_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I122_MP5 (I1660_pn58 VSS XI1660_I122_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I122_MP4 (XI1660_I122_p1 XI1660_I122_An I1660_pn58 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I122_MP2 (VDD fa298_0 XI1660_I122_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I122_MP3 (XI1660_I122_p1 XI1660_I122_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I122_MP0 (VDD fa298_0 XI1660_I122_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I120_MP1 (VDD VSS XI1660_I120_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I120_MP5 (I1660_pn56 VSS XI1660_I120_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I120_MP4 (XI1660_I120_p1 XI1660_I120_An I1660_pn56 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I120_MP2 (VDD fa297_0 XI1660_I120_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I120_MP3 (XI1660_I120_p1 XI1660_I120_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I120_MP0 (VDD fa297_0 XI1660_I120_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I98_MP1 (VDD ha278_0 XI1660_I98_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I98_MP5 (I1660_pn34 ha278_0 XI1660_I98_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I98_MP4 (XI1660_I98_p1 XI1660_I98_An I1660_pn34 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I98_MP2 (VDD ha277_1 XI1660_I98_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I98_MP3 (XI1660_I98_p1 XI1660_I98_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I98_MP0 (VDD ha277_1 XI1660_I98_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I124_MP1 (VDD VSS XI1660_I124_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I124_MP5 (I1660_pn60 VSS XI1660_I124_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I124_MP4 (XI1660_I124_p1 XI1660_I124_An I1660_pn60 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I124_MP2 (VDD fa247_0 XI1660_I124_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I124_MP3 (XI1660_I124_p1 XI1660_I124_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I124_MP0 (VDD fa247_0 XI1660_I124_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I96_MP1 (VDD ha276_0 XI1660_I96_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I96_MP5 (I1660_pn32 ha276_0 XI1660_I96_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I96_MP4 (XI1660_I96_p1 XI1660_I96_An I1660_pn32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I96_MP2 (VDD ha275_1 XI1660_I96_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I96_MP3 (XI1660_I96_p1 XI1660_I96_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I96_MP0 (VDD ha275_1 XI1660_I96_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I97_MP1 (VDD ha277_0 XI1660_I97_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I97_MP5 (I1660_pn33 ha277_0 XI1660_I97_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I97_MP4 (XI1660_I97_p1 XI1660_I97_An I1660_pn33 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I97_MP2 (VDD ha276_1 XI1660_I97_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I97_MP3 (XI1660_I97_p1 XI1660_I97_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I97_MP0 (VDD ha276_1 XI1660_I97_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I126_MP1 (VDD VSS XI1660_I126_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I126_MP5 (I1660_pn62 VSS XI1660_I126_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I126_MP4 (XI1660_I126_p1 XI1660_I126_An I1660_pn62 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I126_MP2 (VDD fa248_0 XI1660_I126_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I126_MP3 (XI1660_I126_p1 XI1660_I126_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I126_MP0 (VDD fa248_0 XI1660_I126_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I127_MP1 (VDD sn15 XI1660_I127_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I127_MP5 (I1660_pn63 sn15 XI1660_I127_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I127_MP4 (XI1660_I127_p1 XI1660_I127_An I1660_pn63 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I127_MP2 (VDD fa248_1 XI1660_I127_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I127_MP3 (XI1660_I127_p1 XI1660_I127_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I127_MP0 (VDD fa248_1 XI1660_I127_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I95_MP1 (VDD ha275_0 XI1660_I95_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I95_MP5 (I1660_pn31 ha275_0 XI1660_I95_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I95_MP4 (XI1660_I95_p1 XI1660_I95_An I1660_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I95_MP2 (VDD ha274_1 XI1660_I95_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I95_MP3 (XI1660_I95_p1 XI1660_I95_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I95_MP0 (VDD ha274_1 XI1660_I95_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I94_MP1 (VDD ha274_0 XI1660_I94_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I94_MP5 (I1660_pn30 ha274_0 XI1660_I94_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I94_MP4 (XI1660_I94_p1 XI1660_I94_An I1660_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I94_MP2 (VDD ha273_1 XI1660_I94_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I94_MP3 (XI1660_I94_p1 XI1660_I94_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I94_MP0 (VDD ha273_1 XI1660_I94_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I93_MP1 (VDD ha273_0 XI1660_I93_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I93_MP5 (I1660_pn29 ha273_0 XI1660_I93_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I93_MP4 (XI1660_I93_p1 XI1660_I93_An I1660_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I93_MP2 (VDD ha272_1 XI1660_I93_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I93_MP3 (XI1660_I93_p1 XI1660_I93_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I93_MP0 (VDD ha272_1 XI1660_I93_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I496_MP1 (VDD I1660_G28_0 XI1660_I496_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I496_MP5 (P_29 I1660_G28_0 XI1660_I496_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I496_MP4 (XI1660_I496_p1 XI1660_I496_An P_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I496_MP2 (VDD I1660_pn29 XI1660_I496_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I496_MP3 (XI1660_I496_p1 XI1660_I496_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I496_MP0 (VDD I1660_pn29 XI1660_I496_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I498_MP1 (VDD I1660_G30_0 XI1660_I498_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I498_MP5 (P_31 I1660_G30_0 XI1660_I498_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I498_MP4 (XI1660_I498_p1 XI1660_I498_An P_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I498_MP2 (VDD I1660_pn31 XI1660_I498_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I498_MP3 (XI1660_I498_p1 XI1660_I498_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I498_MP0 (VDD I1660_pn31 XI1660_I498_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I92_MP1 (VDD ha272_0 XI1660_I92_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I92_MP5 (I1660_pn28 ha272_0 XI1660_I92_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I92_MP4 (XI1660_I92_p1 XI1660_I92_An I1660_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I92_MP2 (VDD ha271_1 XI1660_I92_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I92_MP3 (XI1660_I92_p1 XI1660_I92_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I92_MP0 (VDD ha271_1 XI1660_I92_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I91_MP1 (VDD ha271_0 XI1660_I91_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I91_MP5 (I1660_pn27 ha271_0 XI1660_I91_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I91_MP4 (XI1660_I91_p1 XI1660_I91_An I1660_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I91_MP2 (VDD ha270_1 XI1660_I91_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I91_MP3 (XI1660_I91_p1 XI1660_I91_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I91_MP0 (VDD ha270_1 XI1660_I91_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I90_MP1 (VDD ha270_0 XI1660_I90_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I90_MP5 (I1660_pn26 ha270_0 XI1660_I90_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I90_MP4 (XI1660_I90_p1 XI1660_I90_An I1660_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I90_MP2 (VDD ha269_1 XI1660_I90_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I90_MP3 (XI1660_I90_p1 XI1660_I90_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I90_MP0 (VDD ha269_1 XI1660_I90_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I494_MP1 (VDD I1660_G26_0 XI1660_I494_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I494_MP5 (P_27 I1660_G26_0 XI1660_I494_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I494_MP4 (XI1660_I494_p1 XI1660_I494_An P_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I494_MP2 (VDD I1660_pn27 XI1660_I494_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I494_MP3 (XI1660_I494_p1 XI1660_I494_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I494_MP0 (VDD I1660_pn27 XI1660_I494_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I497_MP1 (VDD I1660_G29_0 XI1660_I497_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I497_MP5 (P_30 I1660_G29_0 XI1660_I497_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I497_MP4 (XI1660_I497_p1 XI1660_I497_An P_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I497_MP2 (VDD I1660_pn30 XI1660_I497_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I497_MP3 (XI1660_I497_p1 XI1660_I497_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I497_MP0 (VDD I1660_pn30 XI1660_I497_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I88_MP1 (VDD ha268_0 XI1660_I88_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I88_MP5 (I1660_pn24 ha268_0 XI1660_I88_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I88_MP4 (XI1660_I88_p1 XI1660_I88_An I1660_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I88_MP2 (VDD ha267_1 XI1660_I88_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I88_MP3 (XI1660_I88_p1 XI1660_I88_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I88_MP0 (VDD ha267_1 XI1660_I88_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I89_MP1 (VDD ha269_0 XI1660_I89_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I89_MP5 (I1660_pn25 ha269_0 XI1660_I89_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I89_MP4 (XI1660_I89_p1 XI1660_I89_An I1660_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I89_MP2 (VDD ha268_1 XI1660_I89_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I89_MP3 (XI1660_I89_p1 XI1660_I89_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I89_MP0 (VDD ha268_1 XI1660_I89_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I87_MP1 (VDD ha267_0 XI1660_I87_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I87_MP5 (I1660_pn23 ha267_0 XI1660_I87_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I87_MP4 (XI1660_I87_p1 XI1660_I87_An I1660_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I87_MP2 (VDD ha266_1 XI1660_I87_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I87_MP3 (XI1660_I87_p1 XI1660_I87_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I87_MP0 (VDD ha266_1 XI1660_I87_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I490_MP1 (VDD I1660_G22_0 XI1660_I490_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I490_MP5 (P_23 I1660_G22_0 XI1660_I490_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I490_MP4 (XI1660_I490_p1 XI1660_I490_An P_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I490_MP2 (VDD I1660_pn23 XI1660_I490_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I490_MP3 (XI1660_I490_p1 XI1660_I490_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I490_MP0 (VDD I1660_pn23 XI1660_I490_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I495_MP1 (VDD I1660_G27_0 XI1660_I495_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I495_MP5 (P_28 I1660_G27_0 XI1660_I495_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I495_MP4 (XI1660_I495_p1 XI1660_I495_An P_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I495_MP2 (VDD I1660_pn28 XI1660_I495_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I495_MP3 (XI1660_I495_p1 XI1660_I495_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I495_MP0 (VDD I1660_pn28 XI1660_I495_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I85_MP1 (VDD ha265_0 XI1660_I85_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I85_MP5 (I1660_pn21 ha265_0 XI1660_I85_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I85_MP4 (XI1660_I85_p1 XI1660_I85_An I1660_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I85_MP2 (VDD ha264_1 XI1660_I85_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I85_MP3 (XI1660_I85_p1 XI1660_I85_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I85_MP0 (VDD ha264_1 XI1660_I85_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I86_MP1 (VDD ha266_0 XI1660_I86_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I86_MP5 (I1660_pn22 ha266_0 XI1660_I86_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I86_MP4 (XI1660_I86_p1 XI1660_I86_An I1660_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I86_MP2 (VDD ha265_1 XI1660_I86_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I86_MP3 (XI1660_I86_p1 XI1660_I86_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I86_MP0 (VDD ha265_1 XI1660_I86_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I492_MP1 (VDD I1660_G24_0 XI1660_I492_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I492_MP5 (P_25 I1660_G24_0 XI1660_I492_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I492_MP4 (XI1660_I492_p1 XI1660_I492_An P_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I492_MP2 (VDD I1660_pn25 XI1660_I492_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I492_MP3 (XI1660_I492_p1 XI1660_I492_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I492_MP0 (VDD I1660_pn25 XI1660_I492_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I493_MP1 (VDD I1660_G25_0 XI1660_I493_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I493_MP5 (P_26 I1660_G25_0 XI1660_I493_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I493_MP4 (XI1660_I493_p1 XI1660_I493_An P_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I493_MP2 (VDD I1660_pn26 XI1660_I493_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I493_MP3 (XI1660_I493_p1 XI1660_I493_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I493_MP0 (VDD I1660_pn26 XI1660_I493_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I84_MP1 (VDD ha264_0 XI1660_I84_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I84_MP5 (I1660_pn20 ha264_0 XI1660_I84_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I84_MP4 (XI1660_I84_p1 XI1660_I84_An I1660_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I84_MP2 (VDD ha263_1 XI1660_I84_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I84_MP3 (XI1660_I84_p1 XI1660_I84_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I84_MP0 (VDD ha263_1 XI1660_I84_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I499_MP1 (VDD I1660_G31_0 XI1660_I499_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I499_MP5 (P_32 I1660_G31_0 XI1660_I499_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I499_MP4 (XI1660_I499_p1 XI1660_I499_An P_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I499_MP2 (VDD I1660_pn32 XI1660_I499_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I499_MP3 (XI1660_I499_p1 XI1660_I499_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I499_MP0 (VDD I1660_pn32 XI1660_I499_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I83_MP1 (VDD ha263_0 XI1660_I83_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I83_MP5 (I1660_pn19 ha263_0 XI1660_I83_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I83_MP4 (XI1660_I83_p1 XI1660_I83_An I1660_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I83_MP2 (VDD ha262_1 XI1660_I83_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I83_MP3 (XI1660_I83_p1 XI1660_I83_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I83_MP0 (VDD ha262_1 XI1660_I83_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I488_MP1 (VDD I1660_G20_0 XI1660_I488_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I488_MP5 (P_21 I1660_G20_0 XI1660_I488_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I488_MP4 (XI1660_I488_p1 XI1660_I488_An P_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I488_MP2 (VDD I1660_pn21 XI1660_I488_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I488_MP3 (XI1660_I488_p1 XI1660_I488_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I488_MP0 (VDD I1660_pn21 XI1660_I488_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I64_MP1 (VDD B_1_b3_5 XI1660_I64_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I64_MP5 (I1660_pn0 B_1_b3_5 XI1660_I64_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I64_MP4 (XI1660_I64_p1 XI1660_I64_An I1660_pn0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I64_MP2 (VDD pp0_0 XI1660_I64_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I64_MP3 (XI1660_I64_p1 XI1660_I64_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I64_MP0 (VDD pp0_0 XI1660_I64_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I82_MP1 (VDD ha262_0 XI1660_I82_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I82_MP5 (I1660_pn18 ha262_0 XI1660_I82_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I82_MP4 (XI1660_I82_p1 XI1660_I82_An I1660_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I82_MP2 (VDD ha261_1 XI1660_I82_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I82_MP3 (XI1660_I82_p1 XI1660_I82_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I82_MP0 (VDD ha261_1 XI1660_I82_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I81_MP1 (VDD ha261_0 XI1660_I81_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I81_MP5 (I1660_pn17 ha261_0 XI1660_I81_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I81_MP4 (XI1660_I81_p1 XI1660_I81_An I1660_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I81_MP2 (VDD ha260_1 XI1660_I81_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I81_MP3 (XI1660_I81_p1 XI1660_I81_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I81_MP0 (VDD ha260_1 XI1660_I81_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I486_MP1 (VDD I1660_G18_0 XI1660_I486_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I486_MP5 (P_19 I1660_G18_0 XI1660_I486_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I486_MP4 (XI1660_I486_p1 XI1660_I486_An P_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I486_MP2 (VDD I1660_pn19 XI1660_I486_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I486_MP3 (XI1660_I486_p1 XI1660_I486_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I486_MP0 (VDD I1660_pn19 XI1660_I486_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I489_MP1 (VDD I1660_G21_0 XI1660_I489_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I489_MP5 (P_22 I1660_G21_0 XI1660_I489_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I489_MP4 (XI1660_I489_p1 XI1660_I489_An P_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I489_MP2 (VDD I1660_pn22 XI1660_I489_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I489_MP3 (XI1660_I489_p1 XI1660_I489_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I489_MP0 (VDD I1660_pn22 XI1660_I489_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I467_MP1 (VDD VSS XI1660_I467_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I467_MP5 (P_0 VSS XI1660_I467_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I467_MP4 (XI1660_I467_p1 XI1660_I467_An P_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I467_MP2 (VDD I1660_pn0 XI1660_I467_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I467_MP3 (XI1660_I467_p1 XI1660_I467_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I467_MP0 (VDD I1660_pn0 XI1660_I467_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I80_MP1 (VDD ha260_0 XI1660_I80_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I80_MP5 (I1660_pn16 ha260_0 XI1660_I80_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I80_MP4 (XI1660_I80_p1 XI1660_I80_An I1660_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I80_MP2 (VDD ha259_1 XI1660_I80_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I80_MP3 (XI1660_I80_p1 XI1660_I80_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I80_MP0 (VDD ha259_1 XI1660_I80_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I484_MP1 (VDD I1660_G16_0 XI1660_I484_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I484_MP5 (P_17 I1660_G16_0 XI1660_I484_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I484_MP4 (XI1660_I484_p1 XI1660_I484_An P_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I484_MP2 (VDD I1660_pn17 XI1660_I484_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I484_MP3 (XI1660_I484_p1 XI1660_I484_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I484_MP0 (VDD I1660_pn17 XI1660_I484_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I491_MP1 (VDD I1660_G23_0 XI1660_I491_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I491_MP5 (P_24 I1660_G23_0 XI1660_I491_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I491_MP4 (XI1660_I491_p1 XI1660_I491_An P_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I491_MP2 (VDD I1660_pn24 XI1660_I491_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I491_MP3 (XI1660_I491_p1 XI1660_I491_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I491_MP0 (VDD I1660_pn24 XI1660_I491_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I487_MP1 (VDD I1660_G19_0 XI1660_I487_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I487_MP5 (P_20 I1660_G19_0 XI1660_I487_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I487_MP4 (XI1660_I487_p1 XI1660_I487_An P_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I487_MP2 (VDD I1660_pn20 XI1660_I487_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I487_MP3 (XI1660_I487_p1 XI1660_I487_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I487_MP0 (VDD I1660_pn20 XI1660_I487_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I79_MP1 (VDD ha259_0 XI1660_I79_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I79_MP5 (I1660_pn15 ha259_0 XI1660_I79_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I79_MP4 (XI1660_I79_p1 XI1660_I79_An I1660_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I79_MP2 (VDD ha258_1 XI1660_I79_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I79_MP3 (XI1660_I79_p1 XI1660_I79_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I79_MP0 (VDD ha258_1 XI1660_I79_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I485_MP1 (VDD I1660_G17_0 XI1660_I485_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I485_MP5 (P_18 I1660_G17_0 XI1660_I485_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I485_MP4 (XI1660_I485_p1 XI1660_I485_An P_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I485_MP2 (VDD I1660_pn18 XI1660_I485_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I485_MP3 (XI1660_I485_p1 XI1660_I485_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I485_MP0 (VDD I1660_pn18 XI1660_I485_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I78_MP1 (VDD ha258_0 XI1660_I78_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I78_MP5 (I1660_pn14 ha258_0 XI1660_I78_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I78_MP4 (XI1660_I78_p1 XI1660_I78_An I1660_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I78_MP2 (VDD ha257_1 XI1660_I78_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I78_MP3 (XI1660_I78_p1 XI1660_I78_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I78_MP0 (VDD ha257_1 XI1660_I78_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I65_MP1 (VDD VSS XI1660_I65_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I65_MP5 (I1660_pn1 VSS XI1660_I65_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I65_MP4 (XI1660_I65_p1 XI1660_I65_An I1660_pn1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I65_MP2 (VDD pp0_1 XI1660_I65_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I65_MP3 (XI1660_I65_p1 XI1660_I65_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I65_MP0 (VDD pp0_1 XI1660_I65_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I468_MP1 (VDD I1660_G0_0 XI1660_I468_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I468_MP5 (P_1 I1660_G0_0 XI1660_I468_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I468_MP4 (XI1660_I468_p1 XI1660_I468_An P_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I468_MP2 (VDD I1660_pn1 XI1660_I468_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I468_MP3 (XI1660_I468_p1 XI1660_I468_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I468_MP0 (VDD I1660_pn1 XI1660_I468_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I77_MP1 (VDD ha257_0 XI1660_I77_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I77_MP5 (I1660_pn13 ha257_0 XI1660_I77_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I77_MP4 (XI1660_I77_p1 XI1660_I77_An I1660_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I77_MP2 (VDD ha256_1 XI1660_I77_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I77_MP3 (XI1660_I77_p1 XI1660_I77_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I77_MP0 (VDD ha256_1 XI1660_I77_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I66_MP1 (VDD VSS XI1660_I66_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I66_MP5 (I1660_pn2 VSS XI1660_I66_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I66_MP4 (XI1660_I66_p1 XI1660_I66_An I1660_pn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I66_MP2 (VDD fa1_0 XI1660_I66_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I66_MP3 (XI1660_I66_p1 XI1660_I66_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I66_MP0 (VDD fa1_0 XI1660_I66_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I67_MP1 (VDD VSS XI1660_I67_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I67_MP5 (I1660_pn3 VSS XI1660_I67_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I67_MP4 (XI1660_I67_p1 XI1660_I67_An I1660_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I67_MP2 (VDD fa137_0 XI1660_I67_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I67_MP3 (XI1660_I67_p1 XI1660_I67_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I67_MP0 (VDD fa137_0 XI1660_I67_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I76_MP1 (VDD ha256_0 XI1660_I76_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I76_MP5 (I1660_pn12 ha256_0 XI1660_I76_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I76_MP4 (XI1660_I76_p1 XI1660_I76_An I1660_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I76_MP2 (VDD ha255_1 XI1660_I76_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I76_MP3 (XI1660_I76_p1 XI1660_I76_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I76_MP0 (VDD ha255_1 XI1660_I76_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I75_MP1 (VDD ha255_0 XI1660_I75_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I75_MP5 (I1660_pn11 ha255_0 XI1660_I75_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I75_MP4 (XI1660_I75_p1 XI1660_I75_An I1660_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I75_MP2 (VDD ha254_1 XI1660_I75_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I75_MP3 (XI1660_I75_p1 XI1660_I75_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I75_MP0 (VDD ha254_1 XI1660_I75_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I70_MP1 (VDD ha250_0 XI1660_I70_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I70_MP5 (I1660_pn6 ha250_0 XI1660_I70_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I70_MP4 (XI1660_I70_p1 XI1660_I70_An I1660_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I70_MP2 (VDD fa249_1 XI1660_I70_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I70_MP3 (XI1660_I70_p1 XI1660_I70_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I70_MP0 (VDD fa249_1 XI1660_I70_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I74_MP1 (VDD ha254_0 XI1660_I74_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I74_MP5 (I1660_pn10 ha254_0 XI1660_I74_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I74_MP4 (XI1660_I74_p1 XI1660_I74_An I1660_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I74_MP2 (VDD ha253_1 XI1660_I74_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I74_MP3 (XI1660_I74_p1 XI1660_I74_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I74_MP0 (VDD ha253_1 XI1660_I74_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I73_MP1 (VDD ha253_0 XI1660_I73_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I73_MP5 (I1660_pn9 ha253_0 XI1660_I73_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I73_MP4 (XI1660_I73_p1 XI1660_I73_An I1660_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I73_MP2 (VDD ha252_1 XI1660_I73_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I73_MP3 (XI1660_I73_p1 XI1660_I73_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I73_MP0 (VDD ha252_1 XI1660_I73_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I72_MP1 (VDD ha252_0 XI1660_I72_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I72_MP5 (I1660_pn8 ha252_0 XI1660_I72_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I72_MP4 (XI1660_I72_p1 XI1660_I72_An I1660_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I72_MP2 (VDD ha251_1 XI1660_I72_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I72_MP3 (XI1660_I72_p1 XI1660_I72_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I72_MP0 (VDD ha251_1 XI1660_I72_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I71_MP1 (VDD ha251_0 XI1660_I71_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I71_MP5 (I1660_pn7 ha251_0 XI1660_I71_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I71_MP4 (XI1660_I71_p1 XI1660_I71_An I1660_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I71_MP2 (VDD ha250_1 XI1660_I71_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I71_MP3 (XI1660_I71_p1 XI1660_I71_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I71_MP0 (VDD ha250_1 XI1660_I71_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I472_MP1 (VDD I1660_G4_0 XI1660_I472_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I472_MP5 (P_5 I1660_G4_0 XI1660_I472_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I472_MP4 (XI1660_I472_p1 XI1660_I472_An P_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I472_MP2 (VDD I1660_pn5 XI1660_I472_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I472_MP3 (XI1660_I472_p1 XI1660_I472_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I472_MP0 (VDD I1660_pn5 XI1660_I472_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I69_MP1 (VDD VSS XI1660_I69_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I69_MP5 (I1660_pn5 VSS XI1660_I69_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I69_MP4 (XI1660_I69_p1 XI1660_I69_An I1660_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I69_MP2 (VDD fa249_0 XI1660_I69_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I69_MP3 (XI1660_I69_p1 XI1660_I69_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I69_MP0 (VDD fa249_0 XI1660_I69_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I68_MP1 (VDD VSS XI1660_I68_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I68_MP5 (I1660_pn4 VSS XI1660_I68_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I68_MP4 (XI1660_I68_p1 XI1660_I68_An I1660_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I68_MP2 (VDD fa209_0 XI1660_I68_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I68_MP3 (XI1660_I68_p1 XI1660_I68_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I68_MP0 (VDD fa209_0 XI1660_I68_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I474_MP1 (VDD I1660_G6_0 XI1660_I474_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I474_MP5 (P_7 I1660_G6_0 XI1660_I474_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I474_MP4 (XI1660_I474_p1 XI1660_I474_An P_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I474_MP2 (VDD I1660_pn7 XI1660_I474_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I474_MP3 (XI1660_I474_p1 XI1660_I474_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I474_MP0 (VDD I1660_pn7 XI1660_I474_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I469_MP1 (VDD I1660_G1_0 XI1660_I469_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I469_MP5 (P_2 I1660_G1_0 XI1660_I469_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I469_MP4 (XI1660_I469_p1 XI1660_I469_An P_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I469_MP2 (VDD I1660_pn2 XI1660_I469_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I469_MP3 (XI1660_I469_p1 XI1660_I469_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I469_MP0 (VDD I1660_pn2 XI1660_I469_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I473_MP1 (VDD I1660_G5_0 XI1660_I473_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I473_MP5 (P_6 I1660_G5_0 XI1660_I473_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I473_MP4 (XI1660_I473_p1 XI1660_I473_An P_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I473_MP2 (VDD I1660_pn6 XI1660_I473_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I473_MP3 (XI1660_I473_p1 XI1660_I473_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I473_MP0 (VDD I1660_pn6 XI1660_I473_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I475_MP1 (VDD I1660_G7_0 XI1660_I475_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1660_I475_MP5 (P_8 I1660_G7_0 XI1660_I475_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1660_I475_MP4 (XI1660_I475_p1 XI1660_I475_An P_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I475_MP2 (VDD I1660_pn8 XI1660_I475_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1660_I475_MP3 (XI1660_I475_p1 XI1660_I475_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1660_I475_MP0 (VDD I1660_pn8 XI1660_I475_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI413_MP2 (B_19_b1_0 B_19_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI413_MP2_1 (VDD B_19_b0 B_19_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI415_MP2 (B_19_b2_1 B_19_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI415_MP2_1 (VDD B_19_b1_0 B_19_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI423_MP2 (B_21_b1_0 B_21_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI423_MP2_1 (VDD B_21_b0 B_21_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI411_MP2 (B_17_b3_5 B_17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI411_MP2_1 (VDD B_17_b2_1 B_17_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI997_MP2 (two9_b3_5 two9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI997_MP2_1 (VDD two9_b2_1 two9_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI421_MP2 (B_19_b3_5 B_19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI421_MP2_1 (VDD B_19_b2_1 B_19_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI987_MP2 (one9_b3_5 one9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI987_MP2_1 (VDD one9_b2_1 one9_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI887_MP2 (two7_b3_5 two7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI887_MP2_1 (VDD two7_b2_1 two7_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI251_MP2 (A_24_b1_0 A_24_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI251_MP2_1 (VDD A_24_b0 A_24_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI985_MP2 (one9_b3_3 one9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI985_MP2_1 (VDD one9_b2_1 one9_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI403_MP2 (B_17_b1_0 B_17_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI403_MP2_1 (VDD B_17_b0 B_17_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI409_MP2 (B_17_b3_3 B_17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI409_MP2_1 (VDD B_17_b2_1 B_17_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI405_MP2 (B_17_b2_1 B_17_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI405_MP2_1 (VDD B_17_b1_0 B_17_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI932_MP2 (one8_b3_5 one8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI932_MP2_1 (VDD one8_b2_1 one8_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI942_MP2 (two8_b3_5 two8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI942_MP2_1 (VDD two8_b2_1 two8_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI419_MP2 (B_19_b3_3 B_19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI419_MP2_1 (VDD B_19_b2_1 B_19_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI995_MP2 (two9_b3_3 two9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI995_MP2_1 (VDD two9_b2_1 two9_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI996_MP2 (two9_b3_4 two9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI996_MP2_1 (VDD two9_b2_1 two9_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI410_MP2 (B_17_b3_4 B_17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI410_MP2_1 (VDD B_17_b2_1 B_17_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI991_MP2 (two9_b2_1 two9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI991_MP2_1 (VDD two9_b1_0 two9_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI986_MP2 (one9_b3_4 one9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI986_MP2_1 (VDD one9_b2_1 one9_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI420_MP2 (B_19_b3_4 B_19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI420_MP2_1 (VDD B_19_b2_1 B_19_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI876_MP2 (one7_b3_4 one7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI876_MP2_1 (VDD one7_b2_1 one7_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI877_MP2 (one7_b3_5 one7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI877_MP2_1 (VDD one7_b2_1 one7_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI886_MP2 (two7_b3_4 two7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI886_MP2_1 (VDD two7_b2_1 two7_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI241_MP2 (A_23_b1_0 A_23_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI241_MP2_1 (VDD A_23_b0 A_23_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI327_MP2 (A_31_b3_3 A_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI327_MP2_1 (VDD A_31_b2_0 A_31_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI981_MP2 (one9_b2_1 one9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI981_MP2_1 (VDD one9_b1_0 one9_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI277_MP2 (A_26_b3_3 A_26_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI277_MP2_1 (VDD A_26_b2_1 A_26_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI287_MP2 (A_27_b3_3 A_27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI287_MP2_1 (VDD A_27_b2_1 A_27_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI832_MP2 (two6_b3_5 two6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI832_MP2_1 (VDD two6_b2_1 two6_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI400_MP2 (B_15_b3_4 B_15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI400_MP2_1 (VDD B_15_b2_1 B_15_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI191_MP2 (A_18_b1_0 A_18_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI191_MP2_1 (VDD A_18_b0 A_18_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI316_MP2 (A_30_b3_2 A_30_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI316_MP2_1 (VDD A_30_b2_0 A_30_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI261_MP2 (A_25_b1_0 A_25_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI261_MP2_1 (VDD A_25_b0 A_25_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI227_MP2 (A_21_b3_3 A_21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI227_MP2_1 (VDD A_21_b2_1 A_21_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1050_MP2 (two10_b3_3 two10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1050_MP2_1 (VDD two10_b2_1 two10_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1040_MP2 (one10_b3_3 one10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1040_MP2_1 (VDD one10_b2_1 one10_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI425_MP2 (B_21_b2_1 B_21_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI425_MP2_1 (VDD B_21_b1_0 B_21_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI429_MP2 (B_21_b3_3 B_21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI429_MP2_1 (VDD B_21_b2_1 B_21_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI430_MP2 (B_21_b3_4 B_21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI430_MP2_1 (VDD B_21_b2_1 B_21_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI431_MP2 (B_21_b3_5 B_21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI431_MP2_1 (VDD B_21_b2_1 B_21_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1036_MP2 (one10_b2_1 one10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1036_MP2_1 (VDD one10_b1_0 one10_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI247_MP2 (A_23_b3_3 A_23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI247_MP2_1 (VDD A_23_b2_1 A_23_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1046_MP2 (two10_b2_1 two10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1046_MP2_1 (VDD two10_b1_0 two10_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1041_MP2 (one10_b3_4 one10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1041_MP2_1 (VDD one10_b2_1 one10_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1051_MP2 (two10_b3_4 two10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1051_MP2_1 (VDD two10_b2_1 two10_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI257_MP2 (A_24_b3_3 A_24_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI257_MP2_1 (VDD A_24_b2_1 A_24_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI267_MP2 (A_25_b3_3 A_25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI267_MP2_1 (VDD A_25_b2_1 A_25_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1042_MP2 (one10_b3_5 one10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1042_MP2_1 (VDD one10_b2_1 one10_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1052_MP2 (two10_b3_5 two10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1052_MP2_1 (VDD two10_b2_1 two10_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI822_MP2 (one6_b3_5 one6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI822_MP2_1 (VDD one6_b2_1 one6_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI399_MP2 (B_15_b3_3 B_15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI399_MP2_1 (VDD B_15_b2_1 B_15_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI401_MP2 (B_15_b3_5 B_15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI401_MP2_1 (VDD B_15_b2_1 B_15_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI326_MP2 (A_31_b3_2 A_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI326_MP2_1 (VDD A_31_b2_0 A_31_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI306_MP2 (A_29_b3_2 A_29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI306_MP2_1 (VDD A_29_b2_0 A_29_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI271_MP2 (A_26_b1_0 A_26_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI271_MP2_1 (VDD A_26_b0 A_26_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI231_MP2 (A_22_b1_0 A_22_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI231_MP2_1 (VDD A_22_b0 A_22_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI263_MP2 (A_25_b2_1 A_25_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI263_MP2_1 (VDD A_25_b1_0 A_25_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI233_MP2 (A_22_b2_1 A_22_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI233_MP2_1 (VDD A_22_b1_0 A_22_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI243_MP2 (A_23_b2_1 A_23_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI243_MP2_1 (VDD A_23_b1_0 A_23_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI282_MP2 (A_27_b2_0 A_27_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI282_MP2_1 (VDD A_27_b1_0 A_27_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI930_MP2 (one8_b3_3 one8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI930_MP2_1 (VDD one8_b2_1 one8_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI940_MP2 (two8_b3_3 two8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI940_MP2_1 (VDD two8_b2_1 two8_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI253_MP2 (A_24_b2_1 A_24_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI253_MP2_1 (VDD A_24_b1_0 A_24_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI237_MP2 (A_22_b3_3 A_22_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI237_MP2_1 (VDD A_22_b2_1 A_22_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI221_MP2 (A_21_b1_0 A_21_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI221_MP2_1 (VDD A_21_b0 A_21_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI395_MP2 (B_15_b2_1 B_15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI395_MP2_1 (VDD B_15_b1_0 B_15_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI821_MP2 (one6_b3_4 one6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI821_MP2_1 (VDD one6_b2_1 one6_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI831_MP2 (two6_b3_4 two6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI831_MP2_1 (VDD two6_b2_1 two6_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI315_MP2 (A_30_b3_1 A_30_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI315_MP2_1 (VDD A_30_b2_0 A_30_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI223_MP2 (A_21_b2_1 A_21_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI223_MP2_1 (VDD A_21_b1_0 A_21_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI217_MP2 (A_20_b3_3 A_20_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI217_MP2_1 (VDD A_20_b2_1 A_20_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI197_MP2 (A_18_b3_3 A_18_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI197_MP2_1 (VDD A_18_b2_1 A_18_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI187_MP2 (A_17_b3_3 A_17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI187_MP2_1 (VDD A_17_b2_1 A_17_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI926_MP2 (one8_b2_1 one8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI926_MP2_1 (VDD one8_b1_0 one8_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI936_MP2 (two8_b2_1 two8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI936_MP2_1 (VDD two8_b1_0 two8_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI273_MP2 (A_26_b2_1 A_26_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI273_MP2_1 (VDD A_26_b1_0 A_26_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI218_MP2 (A_20_b3_4 A_20_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI218_MP2_1 (VDD A_20_b2_1 A_20_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI228_MP2 (A_21_b3_4 A_21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI228_MP2_1 (VDD A_21_b2_1 A_21_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI219_MP2 (A_20_b3_5 A_20_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI219_MP2_1 (VDD A_20_b2_1 A_20_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI238_MP2 (A_22_b3_4 A_22_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI238_MP2_1 (VDD A_22_b2_1 A_22_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI258_MP2 (A_24_b3_4 A_24_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI258_MP2_1 (VDD A_24_b2_1 A_24_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI268_MP2 (A_25_b3_4 A_25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI268_MP2_1 (VDD A_25_b2_1 A_25_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI393_MP2 (B_15_b1_0 B_15_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI393_MP2_1 (VDD B_15_b0 B_15_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI394_MP2 (B_15_b2_0 B_15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI394_MP2_1 (VDD B_15_b1_0 B_15_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI391_MP2 (B_13_b3_5 B_13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI391_MP2_1 (VDD B_13_b2_1 B_13_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI390_MP2 (B_13_b3_4 B_13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI390_MP2_1 (VDD B_13_b2_1 B_13_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI777_MP2 (two5_b3_5 two5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI777_MP2_1 (VDD two5_b2_1 two5_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI767_MP2 (one5_b3_5 one5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI767_MP2_1 (VDD one5_b2_1 one5_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI236_MP2 (A_22_b3_2 A_22_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI236_MP2_1 (VDD A_22_b2_0 A_22_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI276_MP2 (A_26_b3_2 A_26_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI276_MP2_1 (VDD A_26_b2_0 A_26_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI286_MP2 (A_27_b3_2 A_27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI286_MP2_1 (VDD A_27_b2_0 A_27_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI296_MP2 (A_28_b3_2 A_28_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI296_MP2_1 (VDD A_28_b2_0 A_28_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI305_MP2 (A_29_b3_1 A_29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI305_MP2_1 (VDD A_29_b2_0 A_29_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI193_MP2 (A_18_b2_1 A_18_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI193_MP2_1 (VDD A_18_b1_0 A_18_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI203_MP2 (A_19_b2_1 A_19_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI203_MP2_1 (VDD A_19_b1_0 A_19_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI213_MP2 (A_20_b2_1 A_20_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI213_MP2_1 (VDD A_20_b1_0 A_20_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI281_MP2 (A_27_b1_0 A_27_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI281_MP2_1 (VDD A_27_b0 A_27_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI283_MP2 (A_27_b2_1 A_27_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI283_MP2_1 (VDD A_27_b1_0 A_27_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI198_MP2 (A_18_b3_4 A_18_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI198_MP2_1 (VDD A_18_b2_1 A_18_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI199_MP2 (A_18_b3_5 A_18_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI199_MP2_1 (VDD A_18_b2_1 A_18_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI229_MP2 (A_21_b3_5 A_21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI229_MP2_1 (VDD A_21_b2_1 A_21_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1161_MP2 (two12_b3_4 two12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1161_MP2_1 (VDD two12_b2_1 two12_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI248_MP2 (A_23_b3_4 A_23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI248_MP2_1 (VDD A_23_b2_1 A_23_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI239_MP2 (A_22_b3_5 A_22_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI239_MP2_1 (VDD A_22_b2_1 A_22_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI259_MP2 (A_24_b3_5 A_24_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI259_MP2_1 (VDD A_24_b2_1 A_24_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI278_MP2 (A_26_b3_4 A_26_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI278_MP2_1 (VDD A_26_b2_1 A_26_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI249_MP2 (A_23_b3_5 A_23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI249_MP2_1 (VDD A_23_b2_1 A_23_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI383_MP2 (B_13_b1_0 B_13_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI383_MP2_1 (VDD B_13_b0 B_13_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI385_MP2 (B_13_b2_1 B_13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI385_MP2_1 (VDD B_13_b1_0 B_13_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI389_MP2 (B_13_b3_3 B_13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI389_MP2_1 (VDD B_13_b2_1 B_13_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI776_MP2 (two5_b3_4 two5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI776_MP2_1 (VDD two5_b2_1 two5_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI766_MP2 (one5_b3_4 one5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI766_MP2_1 (VDD one5_b2_1 one5_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI246_MP2 (A_23_b3_2 A_23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI246_MP2_1 (VDD A_23_b2_0 A_23_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI266_MP2 (A_25_b3_2 A_25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI266_MP2_1 (VDD A_25_b2_0 A_25_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI285_MP2 (A_27_b3_1 A_27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI285_MP2_1 (VDD A_27_b2_0 A_27_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI274_MP2 (A_26_b3_0 A_26_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI274_MP2_1 (VDD A_26_b2_0 A_26_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI252_MP2 (A_24_b2_0 A_24_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI252_MP2_1 (VDD A_24_b1_0 A_24_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI292_MP2 (A_28_b2_0 A_28_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI292_MP2_1 (VDD A_28_b1_0 A_28_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI208_MP2 (A_19_b3_4 A_19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI208_MP2_1 (VDD A_19_b2_1 A_19_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI291_MP2 (A_28_b1_0 A_28_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI291_MP2_1 (VDD A_28_b0 A_28_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1150_MP2 (one12_b3_3 one12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1150_MP2_1 (VDD one12_b2_1 one12_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1160_MP2 (two12_b3_3 two12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1160_MP2_1 (VDD two12_b2_1 two12_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI293_MP2 (A_28_b2_1 A_28_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI293_MP2_1 (VDD A_28_b1_0 A_28_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI209_MP2 (A_19_b3_5 A_19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI209_MP2_1 (VDD A_19_b2_1 A_19_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1151_MP2 (one12_b3_4 one12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1151_MP2_1 (VDD one12_b2_1 one12_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI297_MP2 (A_28_b3_3 A_28_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI297_MP2_1 (VDD A_28_b2_1 A_28_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI269_MP2 (A_25_b3_5 A_25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI269_MP2_1 (VDD A_25_b2_1 A_25_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI288_MP2 (A_27_b3_4 A_27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI288_MP2_1 (VDD A_27_b2_1 A_27_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI279_MP2 (A_26_b3_5 A_26_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI279_MP2_1 (VDD A_26_b2_1 A_26_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI201_MP2 (A_19_b1_0 A_19_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI201_MP2_1 (VDD A_19_b0 A_19_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI211_MP2 (A_20_b1_0 A_20_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI211_MP2_1 (VDD A_20_b0 A_20_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI275_MP2 (A_26_b3_1 A_26_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI275_MP2_1 (VDD A_26_b2_0 A_26_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI222_MP2 (A_21_b2_0 A_21_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI222_MP2_1 (VDD A_21_b1_0 A_21_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI256_MP2 (A_24_b3_2 A_24_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI256_MP2_1 (VDD A_24_b2_0 A_24_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI245_MP2 (A_23_b3_1 A_23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI245_MP2_1 (VDD A_23_b2_0 A_23_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI255_MP2 (A_24_b3_1 A_24_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI255_MP2_1 (VDD A_24_b2_0 A_24_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI244_MP2 (A_23_b3_0 A_23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI244_MP2_1 (VDD A_23_b2_0 A_23_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI284_MP2 (A_27_b3_0 A_27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI284_MP2_1 (VDD A_27_b2_0 A_27_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI177_MP2 (A_16_b3_3 A_16_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI177_MP2_1 (VDD A_16_b2_1 A_16_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI178_MP2 (A_16_b3_4 A_16_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI178_MP2_1 (VDD A_16_b2_1 A_16_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI312_MP2 (A_30_b2_0 A_30_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI312_MP2_1 (VDD A_30_b1_0 A_30_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI188_MP2 (A_17_b3_4 A_17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI188_MP2_1 (VDD A_17_b2_1 A_17_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1095_MP2 (one11_b3_3 one11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1095_MP2_1 (VDD one11_b2_1 one11_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1105_MP2 (two11_b3_3 two11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1105_MP2_1 (VDD two11_b2_1 two11_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI189_MP2 (A_17_b3_5 A_17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI189_MP2_1 (VDD A_17_b2_1 A_17_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI311_MP2 (A_30_b1_0 A_30_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI311_MP2_1 (VDD A_30_b0 A_30_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1215_MP2 (two13_b3_3 two13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1215_MP2_1 (VDD two13_b2_1 two13_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI439_MP2 (B_23_b3_3 B_23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI439_MP2_1 (VDD B_23_b2_1 B_23_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI313_MP2 (A_30_b2_1 A_30_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI313_MP2_1 (VDD A_30_b1_0 A_30_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1096_MP2 (one11_b3_4 one11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1096_MP2_1 (VDD one11_b2_1 one11_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1106_MP2 (two11_b3_4 two11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1106_MP2_1 (VDD two11_b2_1 two11_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI317_MP2 (A_30_b3_3 A_30_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI317_MP2_1 (VDD A_30_b2_1 A_30_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI328_MP2 (A_31_b3_4 A_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI328_MP2_1 (VDD A_31_b2_1 A_31_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1216_MP2 (two13_b3_4 two13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1216_MP2_1 (VDD two13_b2_1 two13_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1206_MP2 (one13_b3_4 one13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1206_MP2_1 (VDD one13_b2_1 one13_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI384_MP2 (B_13_b2_0 B_13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI384_MP2_1 (VDD B_13_b1_0 B_13_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI181_MP2 (A_17_b1_0 A_17_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI181_MP2_1 (VDD A_17_b0 A_17_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI380_MP2 (B_11_b3_4 B_11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI380_MP2_1 (VDD B_11_b2_1 B_11_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI226_MP2 (A_21_b3_2 A_21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI226_MP2_1 (VDD A_21_b2_0 A_21_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI212_MP2 (A_20_b2_0 A_20_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI212_MP2_1 (VDD A_20_b1_0 A_20_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI265_MP2 (A_25_b3_1 A_25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI265_MP2_1 (VDD A_25_b2_0 A_25_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI325_MP2 (A_31_b3_1 A_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI325_MP2_1 (VDD A_31_b2_0 A_31_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI264_MP2 (A_25_b3_0 A_25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI264_MP2_1 (VDD A_25_b2_0 A_25_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI254_MP2 (A_24_b3_0 A_24_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI254_MP2_1 (VDD A_24_b2_0 A_24_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI183_MP2 (A_17_b2_1 A_17_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI183_MP2_1 (VDD A_17_b1_0 A_17_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI149_MP2 (A_13_b3_5 A_13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI149_MP2_1 (VDD A_13_b2_1 A_13_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI158_MP2 (A_14_b3_4 A_14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI158_MP2_1 (VDD A_14_b2_1 A_14_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI168_MP2 (A_15_b3_4 A_15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI168_MP2_1 (VDD A_15_b2_1 A_15_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI159_MP2 (A_14_b3_5 A_14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI159_MP2_1 (VDD A_14_b2_1 A_14_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI179_MP2 (A_16_b3_5 A_16_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI179_MP2_1 (VDD A_16_b2_1 A_16_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1205_MP2 (one13_b3_3 one13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1205_MP2_1 (VDD one13_b2_1 one13_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI449_MP2 (B_25_b3_3 B_25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI449_MP2_1 (VDD B_25_b2_1 B_25_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI440_MP2 (B_23_b3_4 B_23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI440_MP2_1 (VDD B_23_b2_1 B_23_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI307_MP2 (A_29_b3_3 A_29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI307_MP2_1 (VDD A_29_b2_1 A_29_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI450_MP2 (B_25_b3_4 B_25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI450_MP2_1 (VDD B_25_b2_1 B_25_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI329_MP2 (A_31_b3_5 A_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI329_MP2_1 (VDD A_31_b2_1 A_31_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI885_MP2 (two7_b3_3 two7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI885_MP2_1 (VDD two7_b2_1 two7_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI295_MP2 (A_28_b3_1 A_28_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI295_MP2_1 (VDD A_28_b2_0 A_28_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI294_MP2 (A_28_b3_0 A_28_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI294_MP2_1 (VDD A_28_b2_0 A_28_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI314_MP2 (A_30_b3_0 A_30_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI314_MP2_1 (VDD A_30_b2_0 A_30_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI173_MP2 (A_16_b2_1 A_16_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI173_MP2_1 (VDD A_16_b1_0 A_16_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI148_MP2 (A_13_b3_4 A_13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI148_MP2_1 (VDD A_13_b2_1 A_13_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI169_MP2 (A_15_b3_5 A_15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI169_MP2_1 (VDD A_15_b2_1 A_15_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1259_MP2 (one14_b3_2 one14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1259_MP2_1 (VDD one14_b2_0 one14_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1091_MP2 (one11_b2_1 one11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1091_MP2_1 (VDD one11_b1_0 one11_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1101_MP2 (two11_b2_1 two11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1101_MP2_1 (VDD two11_b1_0 two11_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI434_MP2 (B_23_b2_0 B_23_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI434_MP2_1 (VDD B_23_b1_0 B_23_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI433_MP2 (B_23_b1_0 B_23_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI433_MP2_1 (VDD B_23_b0 B_23_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI302_MP2 (A_29_b2_0 A_29_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI302_MP2_1 (VDD A_29_b1_0 A_29_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI301_MP2 (A_29_b1_0 A_29_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI301_MP2_1 (VDD A_29_b0 A_29_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI435_MP2 (B_23_b2_1 B_23_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI435_MP2_1 (VDD B_23_b1_0 B_23_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI441_MP2 (B_23_b3_5 B_23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI441_MP2_1 (VDD B_23_b2_1 B_23_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI303_MP2 (A_29_b2_1 A_29_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI303_MP2_1 (VDD A_29_b1_0 A_29_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1097_MP2 (one11_b3_5 one11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1097_MP2_1 (VDD one11_b2_1 one11_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1107_MP2 (two11_b3_5 two11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1107_MP2_1 (VDD two11_b2_1 two11_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI881_MP2 (two7_b2_1 two7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI881_MP2_1 (VDD two7_b1_0 two7_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI171_MP2 (A_16_b1_0 A_16_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI171_MP2_1 (VDD A_16_b0 A_16_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI875_MP2 (one7_b3_3 one7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI875_MP2_1 (VDD one7_b2_1 one7_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI381_MP2 (B_11_b3_5 B_11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI381_MP2_1 (VDD B_11_b2_1 B_11_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI722_MP2 (two4_b3_5 two4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI722_MP2_1 (VDD two4_b2_1 two4_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI667_MP2 (two3_b3_5 two3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI667_MP2_1 (VDD two3_b2_1 two3_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI304_MP2 (A_29_b3_0 A_29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI304_MP2_1 (VDD A_29_b2_0 A_29_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI139_MP2 (A_12_b3_5 A_12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI139_MP2_1 (VDD A_12_b2_1 A_12_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI138_MP2 (A_12_b3_4 A_12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI138_MP2_1 (VDD A_12_b2_1 A_12_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1094_MP2 (one11_b3_2 one11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1094_MP2_1 (VDD one11_b2_0 one11_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI438_MP2 (B_23_b3_2 B_23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI438_MP2_1 (VDD B_23_b2_0 B_23_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI129_MP2 (A_11_b3_5 A_11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI129_MP2_1 (VDD A_11_b2_1 A_11_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1269_MP2 (two14_b3_2 two14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1269_MP2_1 (VDD two14_b2_0 two14_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1313_MP2 (one15_b3_1 one15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1313_MP2_1 (VDD one15_b2_0 one15_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1324_MP2 (two15_b3_2 two15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1324_MP2_1 (VDD two15_b2_0 two15_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1314_MP2 (one15_b3_2 one15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1314_MP2_1 (VDD one15_b2_0 one15_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1089_MP2 (one11_b1_0 one11_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1089_MP2_1 (VDD one11_b0 one11_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1099_MP2 (two11_b1_0 two11_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1099_MP2_1 (VDD two11_b0 two11_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1260_MP2 (one14_b3_3 one14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1260_MP2_1 (VDD one14_b2_1 one14_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI459_MP2 (B_27_b3_3 B_27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI459_MP2_1 (VDD B_27_b2_1 B_27_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1162_MP2 (two12_b3_5 two12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1162_MP2_1 (VDD two12_b2_1 two12_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1270_MP2 (two14_b3_3 two14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1270_MP2_1 (VDD two14_b2_1 two14_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1315_MP2 (one15_b3_3 one15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1315_MP2_1 (VDD one15_b2_1 one15_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1261_MP2 (one14_b3_4 one14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1261_MP2_1 (VDD one14_b2_1 one14_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1271_MP2 (two14_b3_4 two14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1271_MP2_1 (VDD two14_b2_1 two14_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1326_MP2 (two15_b3_4 two15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1326_MP2_1 (VDD two15_b2_1 two15_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI308_MP2 (A_29_b3_4 A_29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI308_MP2_1 (VDD A_29_b2_1 A_29_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI871_MP2 (one7_b2_1 one7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI871_MP2_1 (VDD one7_b1_0 one7_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI235_MP2 (A_22_b3_1 A_22_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI235_MP2_1 (VDD A_22_b2_0 A_22_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI712_MP2 (one4_b3_5 one4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI712_MP2_1 (VDD one4_b2_1 one4_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI721_MP2 (two4_b3_4 two4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI721_MP2_1 (VDD two4_b2_1 two4_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI657_MP2 (one3_b3_5 one3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI657_MP2_1 (VDD one3_b2_1 one3_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI167_MP2 (A_15_b3_3 A_15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI167_MP2_1 (VDD A_15_b2_1 A_15_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI147_MP2 (A_13_b3_3 A_13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI147_MP2_1 (VDD A_13_b2_1 A_13_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI157_MP2 (A_14_b3_3 A_14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI157_MP2_1 (VDD A_14_b2_1 A_14_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI128_MP2 (A_11_b3_4 A_11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI128_MP2_1 (VDD A_11_b2_1 A_11_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1104_MP2 (two11_b3_2 two11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1104_MP2_1 (VDD two11_b2_0 two11_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1159_MP2 (two12_b3_2 two12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1159_MP2_1 (VDD two12_b2_0 two12_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1149_MP2 (one12_b3_2 one12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1149_MP2_1 (VDD one12_b2_0 one12_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1100_MP2 (two11_b2_0 two11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1100_MP2_1 (VDD two11_b1_0 two11_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1214_MP2 (two13_b3_2 two13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1214_MP2_1 (VDD two13_b2_0 two13_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI448_MP2 (B_25_b3_2 B_25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI448_MP2_1 (VDD B_25_b2_0 B_25_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1204_MP2 (one13_b3_2 one13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1204_MP2_1 (VDD one13_b2_0 one13_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1268_MP2 (two14_b3_1 two14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1268_MP2_1 (VDD two14_b2_0 two14_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI458_MP2 (B_27_b3_2 B_27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI458_MP2_1 (VDD B_27_b2_0 B_27_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1258_MP2 (one14_b3_1 one14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1258_MP2_1 (VDD one14_b2_0 one14_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1323_MP2 (two15_b3_1 two15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1323_MP2_1 (VDD two15_b2_0 two15_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI467_MP2 (B_29_b3_1 B_29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI467_MP2_1 (VDD B_29_b2_0 B_29_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI468_MP2 (B_29_b3_2 B_29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI468_MP2_1 (VDD B_29_b2_0 B_29_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI477_MP2 (B_31_b3_1 B_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI477_MP2_1 (VDD B_31_b2_0 B_31_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1090_MP2 (one11_b2_0 one11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1090_MP2_1 (VDD one11_b1_0 one11_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1155_MP2 (two12_b2_0 two12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1155_MP2_1 (VDD two12_b1_0 two12_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI478_MP2 (B_31_b3_2 B_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI478_MP2_1 (VDD B_31_b2_0 B_31_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI322_MP2 (A_31_b2_0 A_31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI322_MP2_1 (VDD A_31_b1_0 A_31_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1146_MP2 (one12_b2_1 one12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1146_MP2_1 (VDD one12_b1_0 one12_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1156_MP2 (two12_b2_1 two12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1156_MP2_1 (VDD two12_b1_0 two12_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1201_MP2 (one13_b2_1 one13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1201_MP2_1 (VDD one13_b1_0 one13_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI445_MP2 (B_25_b2_1 B_25_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI445_MP2_1 (VDD B_25_b1_0 B_25_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI451_MP2 (B_25_b3_5 B_25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI451_MP2_1 (VDD B_25_b2_1 B_25_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1152_MP2 (one12_b3_5 one12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1152_MP2_1 (VDD one12_b2_1 one12_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI469_MP2 (B_29_b3_3 B_29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI469_MP2_1 (VDD B_29_b2_1 B_29_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI461_MP2 (B_27_b3_5 B_27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI461_MP2_1 (VDD B_27_b2_1 B_27_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI460_MP2 (B_27_b3_4 B_27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI460_MP2_1 (VDD B_27_b2_1 B_27_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI323_MP2 (A_31_b2_1 A_31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI323_MP2_1 (VDD A_31_b1_0 A_31_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI479_MP2 (B_31_b3_3 B_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI479_MP2_1 (VDD B_31_b2_1 B_31_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1217_MP2 (two13_b3_5 two13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1217_MP2_1 (VDD two13_b2_1 two13_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1316_MP2 (one15_b3_4 one15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1316_MP2_1 (VDD one15_b2_1 one15_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI299_MP2 (A_28_b3_5 A_28_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI299_MP2_1 (VDD A_28_b2_1 A_28_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1207_MP2 (one13_b3_5 one13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1207_MP2_1 (VDD one13_b2_1 one13_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI820_MP2 (one6_b3_3 one6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI820_MP2_1 (VDD one6_b2_1 one6_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI375_MP2 (B_11_b2_1 B_11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI375_MP2_1 (VDD B_11_b1_0 B_11_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI830_MP2 (two6_b3_3 two6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI830_MP2_1 (VDD two6_b2_1 two6_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI216_MP2 (A_20_b3_2 A_20_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI216_MP2_1 (VDD A_20_b2_0 A_20_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI202_MP2 (A_19_b2_0 A_19_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI202_MP2_1 (VDD A_19_b1_0 A_19_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI234_MP2 (A_22_b3_0 A_22_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI234_MP2_1 (VDD A_22_b2_0 A_22_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI324_MP2 (A_31_b3_0 A_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI324_MP2_1 (VDD A_31_b2_0 A_31_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI163_MP2 (A_15_b2_1 A_15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI163_MP2_1 (VDD A_15_b1_0 A_15_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI133_MP2 (A_12_b2_1 A_12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI133_MP2_1 (VDD A_12_b1_0 A_12_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI153_MP2 (A_14_b2_1 A_14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI153_MP2_1 (VDD A_14_b1_0 A_14_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI143_MP2 (A_13_b2_1 A_13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI143_MP2_1 (VDD A_13_b1_0 A_13_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI119_MP2 (A_10_b3_5 A_10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI119_MP2_1 (VDD A_10_b2_1 A_10_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI424_MP2 (B_21_b2_0 B_21_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI424_MP2_1 (VDD B_21_b1_0 B_21_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI437_MP2 (B_23_b3_1 B_23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI437_MP2_1 (VDD B_23_b2_0 B_23_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1257_MP2 (one14_b3_0 one14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1257_MP2_1 (VDD one14_b2_0 one14_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1267_MP2 (two14_b3_0 two14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1267_MP2_1 (VDD two14_b2_0 two14_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1322_MP2 (two15_b3_0 two15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1322_MP2_1 (VDD two15_b2_0 two15_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI436_MP2 (B_23_b3_0 B_23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI436_MP2_1 (VDD B_23_b2_0 B_23_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1145_MP2 (one12_b2_0 one12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1145_MP2_1 (VDD one12_b1_0 one12_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1144_MP2 (one12_b1_0 one12_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1144_MP2_1 (VDD one12_b0 one12_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1154_MP2 (two12_b1_0 two12_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1154_MP2_1 (VDD two12_b0 two12_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1255_MP2 (one14_b2_0 one14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1255_MP2_1 (VDD one14_b1_0 one14_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1210_MP2 (two13_b2_0 two13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1210_MP2_1 (VDD two13_b1_0 two13_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1265_MP2 (two14_b2_0 two14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1265_MP2_1 (VDD two14_b1_0 two14_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI444_MP2 (B_25_b2_0 B_25_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI444_MP2_1 (VDD B_25_b1_0 B_25_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI454_MP2 (B_27_b2_0 B_27_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI454_MP2_1 (VDD B_27_b1_0 B_27_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1211_MP2 (two13_b2_1 two13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1211_MP2_1 (VDD two13_b1_0 two13_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1264_MP2 (two14_b1_0 two14_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1264_MP2_1 (VDD two14_b0 two14_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1310_MP2 (one15_b2_0 one15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1310_MP2_1 (VDD one15_b1_0 one15_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI443_MP2 (B_25_b1_0 B_25_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI443_MP2_1 (VDD B_25_b0 B_25_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1256_MP2 (one14_b2_1 one14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1256_MP2_1 (VDD one14_b1_0 one14_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1266_MP2 (two14_b2_1 two14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1266_MP2_1 (VDD two14_b1_0 two14_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI455_MP2 (B_27_b2_1 B_27_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI455_MP2_1 (VDD B_27_b1_0 B_27_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI453_MP2 (B_27_b1_0 B_27_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI453_MP2_1 (VDD B_27_b0 B_27_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI470_MP2 (B_29_b3_4 B_29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI470_MP2_1 (VDD B_29_b2_1 B_29_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1262_MP2 (one14_b3_5 one14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1262_MP2_1 (VDD one14_b2_1 one14_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI321_MP2 (A_31_b1_0 A_31_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI321_MP2_1 (VDD A_31_b0 A_31_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI319_MP2 (A_30_b3_5 A_30_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI319_MP2_1 (VDD A_30_b2_1 A_30_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI309_MP2 (A_29_b3_5 A_29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI309_MP2_1 (VDD A_29_b2_1 A_29_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI379_MP2 (B_11_b3_3 B_11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI379_MP2_1 (VDD B_11_b2_1 B_11_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI371_MP2 (B_9_b3_5 B_9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI371_MP2_1 (VDD B_9_b2_1 B_9_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI370_MP2 (B_9_b3_4 B_9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI370_MP2_1 (VDD B_9_b2_1 B_9_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI161_MP2 (A_15_b1_0 A_15_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI161_MP2_1 (VDD A_15_b0 A_15_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI151_MP2 (A_14_b1_0 A_14_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI151_MP2_1 (VDD A_14_b0 A_14_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI711_MP2 (one4_b3_4 one4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI711_MP2_1 (VDD one4_b2_1 one4_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI418_MP2 (B_19_b3_2 B_19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI418_MP2_1 (VDD B_19_b2_0 B_19_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI118_MP2 (A_10_b3_4 A_10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI118_MP2_1 (VDD A_10_b2_1 A_10_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI428_MP2 (B_21_b3_2 B_21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI428_MP2_1 (VDD B_21_b2_0 B_21_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI127_MP2 (A_11_b3_3 A_11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI127_MP2_1 (VDD A_11_b2_1 A_11_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI108_MP2 (A_9_b3_4 A_9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI108_MP2_1 (VDD A_9_b2_1 A_9_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI109_MP2 (A_9_b3_5 A_9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI109_MP2_1 (VDD A_9_b2_1 A_9_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1213_MP2 (two13_b3_1 two13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1213_MP2_1 (VDD two13_b2_0 two13_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1203_MP2 (one13_b3_1 one13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1203_MP2_1 (VDD one13_b2_0 one13_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI457_MP2 (B_27_b3_1 B_27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI457_MP2_1 (VDD B_27_b2_0 B_27_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1312_MP2 (one15_b3_0 one15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1312_MP2_1 (VDD one15_b2_0 one15_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1200_MP2 (one13_b2_0 one13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1200_MP2_1 (VDD one13_b1_0 one13_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI466_MP2 (B_29_b3_0 B_29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI466_MP2_1 (VDD B_29_b2_0 B_29_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI456_MP2 (B_27_b3_0 B_27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI456_MP2_1 (VDD B_27_b2_0 B_27_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1199_MP2 (one13_b1_0 one13_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1199_MP2_1 (VDD one13_b0 one13_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1209_MP2 (two13_b1_0 two13_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1209_MP2_1 (VDD two13_b0 two13_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI464_MP2 (B_29_b2_0 B_29_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI464_MP2_1 (VDD B_29_b1_0 B_29_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1320_MP2 (two15_b2_0 two15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1320_MP2_1 (VDD two15_b1_0 two15_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1254_MP2 (one14_b1_0 one14_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1254_MP2_1 (VDD one14_b0 one14_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1309_MP2 (one15_b1_0 one15_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1309_MP2_1 (VDD one15_b0 one15_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1319_MP2 (two15_b1_0 two15_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1319_MP2_1 (VDD two15_b0 two15_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI465_MP2 (B_29_b2_1 B_29_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI465_MP2_1 (VDD B_29_b1_0 B_29_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1311_MP2 (one15_b2_1 one15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1311_MP2_1 (VDD one15_b1_0 one15_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI463_MP2 (B_29_b1_0 B_29_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI463_MP2_1 (VDD B_29_b0 B_29_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1321_MP2 (two15_b2_1 two15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1321_MP2_1 (VDD two15_b1_0 two15_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI480_MP2 (B_31_b3_4 B_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI480_MP2_1 (VDD B_31_b2_1 B_31_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1317_MP2 (one15_b3_5 one15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1317_MP2_1 (VDD one15_b2_1 one15_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1327_MP2 (two15_b3_5 two15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1327_MP2_1 (VDD two15_b2_1 two15_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1272_MP2 (two14_b3_5 two14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1272_MP2_1 (VDD two14_b2_1 two14_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI206_MP2 (A_19_b3_2 A_19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI206_MP2_1 (VDD A_19_b2_0 A_19_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI666_MP2 (two3_b3_4 two3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI666_MP2_1 (VDD two3_b2_1 two3_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI656_MP2 (one3_b3_4 one3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI656_MP2_1 (VDD one3_b2_1 one3_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI612_MP2 (two2_b3_5 two2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI612_MP2_1 (VDD two2_b2_1 two2_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI602_MP2 (one2_b3_5 one2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI602_MP2_1 (VDD one2_b2_1 one2_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI192_MP2 (A_18_b2_0 A_18_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI192_MP2_1 (VDD A_18_b1_0 A_18_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI123_MP2 (A_11_b2_1 A_11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI123_MP2_1 (VDD A_11_b1_0 A_11_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1049_MP2 (two10_b3_2 two10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1049_MP2_1 (VDD two10_b2_0 two10_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI99_MP2 (A_8_b3_5 A_8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI99_MP2_1 (VDD A_8_b2_1 A_8_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI89_MP2 (A_7_b3_5 A_7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI89_MP2_1 (VDD A_7_b2_1 A_7_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI447_MP2 (B_25_b3_1 B_25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI447_MP2_1 (VDD B_25_b2_0 B_25_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI446_MP2 (B_25_b3_0 B_25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI446_MP2_1 (VDD B_25_b2_0 B_25_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI476_MP2 (B_31_b3_0 B_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI476_MP2_1 (VDD B_31_b2_0 B_31_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI471_MP2 (B_29_b3_5 B_29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI471_MP2_1 (VDD B_29_b2_1 B_29_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI473_MP2 (B_31_b1_0 B_31_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI473_MP2_1 (VDD B_31_b0 B_31_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI330_MP2 (A_31_b3_6 A_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI330_MP2_1 (VDD A_31_b2_1 A_31_b3_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI373_MP2 (B_11_b1_0 B_11_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI373_MP2_1 (VDD B_11_b0 B_11_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI816_MP2 (one6_b2_1 one6_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI816_MP2_1 (VDD one6_b1_0 one6_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI369_MP2 (B_9_b3_3 B_9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI369_MP2_1 (VDD B_9_b2_1 B_9_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI225_MP2 (A_21_b3_1 A_21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI225_MP2_1 (VDD A_21_b2_0 A_21_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI141_MP2 (A_13_b1_0 A_13_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI141_MP2_1 (VDD A_13_b0 A_13_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI224_MP2 (A_21_b3_0 A_21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI224_MP2_1 (VDD A_21_b2_0 A_21_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI131_MP2 (A_12_b1_0 A_12_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI131_MP2_1 (VDD A_12_b0 A_12_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI360_MP2 (B_7_b3_4 B_7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI360_MP2_1 (VDD B_7_b2_1 B_7_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI172_MP2 (A_16_b2_0 A_16_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI172_MP2_1 (VDD A_16_b1_0 A_16_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1039_MP2 (one10_b3_2 one10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1039_MP2_1 (VDD one10_b2_0 one10_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1103_MP2 (two11_b3_1 two11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1103_MP2_1 (VDD two11_b2_0 two11_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI98_MP2 (A_8_b3_4 A_8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI98_MP2_1 (VDD A_8_b2_1 A_8_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1035_MP2 (one10_b2_0 one10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1035_MP2_1 (VDD one10_b1_0 one10_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1045_MP2 (two10_b2_0 two10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1045_MP2_1 (VDD two10_b1_0 two10_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1034_MP2 (one10_b1_0 one10_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1034_MP2_1 (VDD one10_b0 one10_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1044_MP2 (two10_b1_0 two10_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1044_MP2_1 (VDD two10_b0 two10_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1212_MP2 (two13_b3_0 two13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1212_MP2_1 (VDD two13_b2_0 two13_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1202_MP2 (one13_b3_0 one13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1202_MP2_1 (VDD one13_b2_0 one13_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI474_MP2 (B_31_b2_0 B_31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI474_MP2_1 (VDD B_31_b1_0 B_31_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI475_MP2 (B_31_b2_1 B_31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI475_MP2_1 (VDD B_31_b1_0 B_31_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI331_MP2 (A_31_b3_7 A_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI331_MP2_1 (VDD A_31_b2_1 A_31_b3_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI869_MP2 (one7_b1_0 one7_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI869_MP2_1 (VDD one7_b0 one7_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI374_MP2 (B_11_b2_0 B_11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI374_MP2_1 (VDD B_11_b1_0 B_11_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI365_MP2 (B_9_b2_1 B_9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI365_MP2_1 (VDD B_9_b1_0 B_9_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI826_MP2 (two6_b2_1 two6_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI826_MP2_1 (VDD two6_b1_0 two6_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI765_MP2 (one5_b3_3 one5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI765_MP2_1 (VDD one5_b2_1 one5_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI186_MP2 (A_17_b3_2 A_17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI186_MP2_1 (VDD A_17_b2_0 A_17_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI196_MP2 (A_18_b3_2 A_18_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI196_MP2_1 (VDD A_18_b2_0 A_18_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI182_MP2 (A_17_b2_0 A_17_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI182_MP2_1 (VDD A_17_b1_0 A_17_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI215_MP2 (A_20_b3_1 A_20_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI215_MP2_1 (VDD A_20_b2_0 A_20_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI195_MP2 (A_18_b3_1 A_18_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI195_MP2_1 (VDD A_18_b2_0 A_18_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI152_MP2 (A_14_b2_0 A_14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI152_MP2_1 (VDD A_14_b1_0 A_14_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI361_MP2 (B_7_b3_5 B_7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI361_MP2_1 (VDD B_7_b2_1 B_7_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI359_MP2 (B_7_b3_3 B_7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI359_MP2_1 (VDD B_7_b2_1 B_7_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI408_MP2 (B_17_b3_2 B_17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI408_MP2_1 (VDD B_17_b2_0 B_17_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1093_MP2 (one11_b3_1 one11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1093_MP2_1 (VDD one11_b2_0 one11_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI994_MP2 (two9_b3_2 two9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI994_MP2_1 (VDD two9_b2_0 two9_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI88_MP2 (A_7_b3_4 A_7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI88_MP2_1 (VDD A_7_b2_1 A_7_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI984_MP2 (one9_b3_2 one9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI984_MP2_1 (VDD one9_b2_0 one9_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1148_MP2 (one12_b3_1 one12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1148_MP2_1 (VDD one12_b2_0 one12_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI69_MP2 (A_5_b3_5 A_5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI69_MP2_1 (VDD A_5_b2_1 A_5_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI79_MP2 (A_6_b3_5 A_6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI79_MP2_1 (VDD A_6_b2_1 A_6_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1158_MP2 (two12_b3_1 two12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1158_MP2_1 (VDD two12_b2_0 two12_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI481_MP2 (B_31_b3_5 B_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI481_MP2_1 (VDD B_31_b2_1 B_31_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI879_MP2 (two7_b1_0 two7_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI879_MP2_1 (VDD two7_b0 two7_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI363_MP2 (B_9_b1_0 B_9_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI363_MP2_1 (VDD B_9_b0 B_9_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI761_MP2 (one5_b2_1 one5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI761_MP2_1 (VDD one5_b1_0 one5_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI775_MP2 (two5_b3_3 two5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI775_MP2_1 (VDD two5_b2_1 two5_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI205_MP2 (A_19_b3_1 A_19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI205_MP2_1 (VDD A_19_b2_0 A_19_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI204_MP2 (A_19_b3_0 A_19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI204_MP2_1 (VDD A_19_b2_0 A_19_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI176_MP2 (A_16_b3_2 A_16_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI176_MP2_1 (VDD A_16_b2_0 A_16_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI665_MP2 (two3_b3_3 two3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI665_MP2_1 (VDD two3_b2_1 two3_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI355_MP2 (B_7_b2_1 B_7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI355_MP2_1 (VDD B_7_b1_0 B_7_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI214_MP2 (A_20_b3_0 A_20_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI214_MP2_1 (VDD A_20_b2_0 A_20_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI162_MP2 (A_15_b2_0 A_15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
