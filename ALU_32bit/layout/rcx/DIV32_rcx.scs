    I_MXI2279_MN1 (XI2279_n1 z0_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2279_MN0 (z1_1 z0_2 XI2279_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2278_MN1 (XI2278_n1 z0_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2278_MN0 (z1_0 z0_0 XI2278_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2290_MN1 (XI2290_n1 z2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2290_MN0 (z3_0 z2_0 XI2290_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I100_XP_MN1 (XI2066_I100_XP_n1 I2066_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I100_XP_MN0 (I2066_P4_1n I2066_P4_3 XI2066_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I5_MN1 (XI2066_I5_n1 dm5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I5_MN0 (I2066_gn5 p31_5 XI2066_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I7_MN1 (XI2066_I7_n1 dm7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I7_MN0 (I2066_gn7 p31_7 XI2066_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I6_MN1 (XI2066_I6_n1 dm6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I6_MN0 (I2066_gn6 p31_6 XI2066_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2016_MN1 (XI2016_n1 p31_32_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2016_MN0 (dmn7 dd7_b3_5 XI2016_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2014_MN1 (XI2014_n1 p31_32_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2014_MN0 (dmn6 dd6_b3_5 XI2014_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2018_MN1 (XI2018_n1 p31_32_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2018_MN0 (dmn8 dd8_b3_5 XI2018_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I167_XP_MN1 (XI1988_I167_XP_n1 I1988_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I167_XP_MN0 (I1988_P16_1n I1988_P16_9 XI1988_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I102_XP_MN1 (XI1988_I102_XP_n1 I1988_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I102_XP_MN0 (I1988_P6_3n I1988_P6_5 XI1988_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I104_XP_MN1 (XI1988_I104_XP_n1 I1988_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I104_XP_MN0 (I1988_P8_5n I1988_P8_7 XI1988_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I101_XP_MN1 (XI1988_I101_XP_n1 I1988_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I101_XP_MN0 (I1988_P5_2n I1988_P5_4 XI1988_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I103_XP_MN1 (XI1988_I103_XP_n1 I1988_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I103_XP_MN0 (I1988_P7_4n I1988_P7_6 XI1988_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I7_MN1 (XI1988_I7_n1 b31_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I7_MN0 (I1988_gn7 p30_6 XI1988_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I6_MN1 (XI1988_I6_n1 b31_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I6_MN0 (I1988_gn6 p30_5 XI1988_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I8_MN1 (XI1988_I8_n1 b31_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I8_MN0 (I1988_gn8 p30_7 XI1988_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I102_XP_MN1 (XI1942_I102_XP_n1 I1942_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I102_XP_MN0 (I1942_P6_3n I1942_P6_5 XI1942_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I100_XP_MN1 (XI1942_I100_XP_n1 I1942_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I100_XP_MN0 (I1942_P4_1n I1942_P4_3 XI1942_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I101_XP_MN1 (XI1942_I101_XP_n1 I1942_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I101_XP_MN0 (I1942_P5_2n I1942_P5_4 XI1942_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I6_MN1 (XI1942_I6_n1 b30_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I6_MN0 (I1942_gn6 p29_5 XI1942_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I5_MN1 (XI1896_I5_n1 b29_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I5_MN0 (I1896_gn5 p28_4 XI1896_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I8_MN1 (XI1896_I8_n1 b29_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I8_MN0 (I1896_gn8 p28_7 XI1896_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I101_XP_MN1 (XI1850_I101_XP_n1 I1850_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I101_XP_MN0 (I1850_P5_2n I1850_P5_4 XI1850_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I119_XP_MN1 (XI1850_I119_XP_n1 I1850_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I119_XP_MN0 (I1850_P23_20n I1850_P23_22 XI1850_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I121_XP_MN1 (XI1850_I121_XP_n1 I1850_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I121_XP_MN0 (I1850_P25_22n I1850_P25_24 XI1850_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I123_XP_MN1 (XI1850_I123_XP_n1 I1850_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I123_XP_MN0 (I1850_P27_24n I1850_P27_26 XI1850_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I125_XP_MN1 (XI1850_I125_XP_n1 I1850_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I125_XP_MN0 (I1850_P29_26n I1850_P29_28 XI1850_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I127_XP_MN1 (XI1850_I127_XP_n1 I1850_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I127_XP_MN0 (I1850_P31_28n I1850_P31_30 XI1850_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I124_XP_MN1 (XI700_I124_XP_n1 I700_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I124_XP_MN0 (I700_P28_25n I700_P28_27 XI700_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I122_XP_MN1 (XI700_I122_XP_n1 I700_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I122_XP_MN0 (I700_P26_23n I700_P26_25 XI700_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I120_XP_MN1 (XI700_I120_XP_n1 I700_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I120_XP_MN0 (I700_P24_21n I700_P24_23 XI700_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I118_XP_MN1 (XI700_I118_XP_n1 I700_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I118_XP_MN0 (I700_P22_19n I700_P22_21 XI700_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I116_XP_MN1 (XI700_I116_XP_n1 I700_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I116_XP_MN0 (I700_P20_17n I700_P20_19 XI700_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I103_XP_MN1 (XI700_I103_XP_n1 I700_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I103_XP_MN0 (I700_P7_4n I700_P7_6 XI700_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I7_MN1 (XI700_I7_n1 b3_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I7_MN0 (I700_gn7 p2_6 XI700_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I6_MN1 (XI700_I6_n1 b3_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I6_MN0 (I700_gn6 p2_5 XI700_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I3_MN1 (XI654_I3_n1 b2_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I3_MN0 (I654_gn3 p1_2 XI654_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I1_MN1 (XI654_I1_n1 b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I1_MN0 (I654_gn1 p1_0 XI654_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I3_MN1 (XI608_I3_n1 b1_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I3_MN0 (I608_gn3 p0_2 XI608_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I4_MN1 (XI608_I4_n1 b1_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I4_MN0 (I608_gn4 p0_3 XI608_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2294_MN1 (XI2294_n1 sqn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2294_MN0 (vn Q_31 XI2294_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I1_MN1 (XI562_I1_n1 b0_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I1_MN0 (I562_gn1 VSS XI562_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I8_MN1 (XI562_I8_n1 b0_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I8_MN0 (I562_gn8 VSS XI562_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2280_MN1 (XI2280_n1 z0_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2280_MN0 (z1_2 z0_4 XI2280_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2170_MN1 (XI2170_n1 R_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2170_MN0 (nrkn1 A_31_b3_5 XI2170_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I3_MN1 (XI2066_I3_n1 dm3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I3_MN0 (I2066_gn3 p31_3 XI2066_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I4_MN1 (XI2066_I4_n1 dm4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I4_MN0 (I2066_gn4 p31_4 XI2066_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2012_MN1 (XI2012_n1 p31_32_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2012_MN0 (dmn5 dd5_b3_5 XI2012_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I100_XP_MN1 (XI1988_I100_XP_n1 I1988_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I100_XP_MN0 (I1988_P4_1n I1988_P4_3 XI1988_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I5_MN1 (XI1988_I5_n1 b31_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I5_MN0 (I1988_gn5 p30_4 XI1988_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I3_MN1 (XI1942_I3_n1 b30_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I3_MN0 (I1942_gn3 p29_2 XI1942_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I4_MN1 (XI1942_I4_n1 b30_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I4_MN0 (I1942_gn4 p29_3 XI1942_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I5_MN1 (XI1942_I5_n1 b30_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I5_MN0 (I1942_gn5 p29_4 XI1942_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I3_MN1 (XI1896_I3_n1 b29_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I3_MN0 (I1896_gn3 p28_2 XI1896_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I4_MN1 (XI1896_I4_n1 b29_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I4_MN0 (I1896_gn4 p28_3 XI1896_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I167_XP_MN1 (XI1850_I167_XP_n1 I1850_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I167_XP_MN0 (I1850_P16_1n I1850_P16_9 XI1850_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I169_XP_MN1 (XI1850_I169_XP_n1 I1850_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I169_XP_MN0 (I1850_P18_3n I1850_P18_11 XI1850_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I175_XP_MN1 (XI1850_I175_XP_n1 I1850_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I175_XP_MN0 (I1850_P24_9n I1850_P24_17 XI1850_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I181_XP_MN1 (XI700_I181_XP_n1 I700_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I181_XP_MN0 (I700_P30_15n I700_P30_23 XI700_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I173_XP_MN1 (XI700_I173_XP_n1 I700_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I173_XP_MN0 (I700_P22_7n I700_P22_15 XI700_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I114_XP_MN1 (XI700_I114_XP_n1 I700_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I114_XP_MN0 (I700_P18_15n I700_P18_17 XI700_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I112_XP_MN1 (XI700_I112_XP_n1 I700_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I112_XP_MN0 (I700_P16_13n I700_P16_15 XI700_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I110_XP_MN1 (XI700_I110_XP_n1 I700_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I110_XP_MN0 (I700_P14_11n I700_P14_13 XI700_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I108_XP_MN1 (XI700_I108_XP_n1 I700_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I108_XP_MN0 (I700_P12_9n I700_P12_11 XI700_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I101_XP_MN1 (XI700_I101_XP_n1 I700_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I101_XP_MN0 (I700_P5_2n I700_P5_4 XI700_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I5_MN1 (XI700_I5_n1 b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I5_MN0 (I700_gn5 p2_4 XI700_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I4_MN1 (XI700_I4_n1 b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I4_MN0 (I700_gn4 p2_3 XI700_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I2_MN1 (XI654_I2_n1 b2_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I2_MN0 (I654_gn2 p1_1 XI654_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I0_MN1 (XI654_I0_n1 b2_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I0_MN0 (I654_gn0 aa29 XI654_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I2_MN1 (XI608_I2_n1 b1_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I2_MN0 (I608_gn2 p0_1 XI608_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I0_MN1 (XI608_I0_n1 b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I0_MN0 (I608_gn0 aa30 XI608_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I2_MN1 (XI562_I2_n1 b0_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I2_MN0 (I562_gn2 VSS XI562_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I3_MN1 (XI562_I3_n1 b0_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I3_MN0 (I562_gn3 VSS XI562_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I6_MN1 (XI562_I6_n1 b0_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I6_MN0 (I562_gn6 VSS XI562_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I7_MN1 (XI562_I7_n1 b0_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I7_MN0 (I562_gn7 VSS XI562_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2281_MN1 (XI2281_n1 z0_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2281_MN0 (z1_3 z0_6 XI2281_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2282_MN1 (XI2282_n1 z0_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2282_MN0 (z1_4 z0_8 XI2282_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2291_MN1 (XI2291_n1 z2_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2291_MN0 (z3_1 z2_2 XI2291_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I1_MN1 (XI2066_I1_n1 dm1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I1_MN0 (I2066_gn1 p31_1 XI2066_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2283_MN1 (XI2283_n1 z0_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2283_MN0 (z1_5 z0_10 XI2283_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I2_MN1 (XI2066_I2_n1 dm2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I2_MN0 (I2066_gn2 p31_2 XI2066_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2010_MN1 (XI2010_n1 p31_32_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2010_MN0 (dmn4 dd4_b3_5 XI2010_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2008_MN1 (XI2008_n1 p31_32_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2008_MN0 (dmn3 dd3_b3_5 XI2008_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I1_MN1 (XI1988_I1_n1 b31_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I1_MN0 (I1988_gn1 p30_0 XI1988_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I3_MN1 (XI1988_I3_n1 b31_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I3_MN0 (I1988_gn3 p30_2 XI1988_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I4_MN1 (XI1988_I4_n1 b31_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I4_MN0 (I1988_gn4 p30_3 XI1988_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2078_MN1 (XI2078_n1 Q_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2078_MN0 (nqkn1 sq_b3_0 XI2078_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I2_MN1 (XI1942_I2_n1 b30_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I2_MN0 (I1942_gn2 p29_1 XI1942_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I1_MN1 (XI1896_I1_n1 b29_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I1_MN0 (I1896_gn1 p28_0 XI1896_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I2_MN1 (XI1896_I2_n1 b29_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I2_MN0 (I1896_gn2 p28_1 XI1896_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I100_XP_MN1 (XI1850_I100_XP_n1 I1850_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I100_XP_MN0 (I1850_P4_1n I1850_P4_3 XI1850_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I102_XP_MN1 (XI1850_I102_XP_n1 I1850_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I102_XP_MN0 (I1850_P6_3n I1850_P6_5 XI1850_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I104_XP_MN1 (XI1850_I104_XP_n1 I1850_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I104_XP_MN0 (I1850_P8_5n I1850_P8_7 XI1850_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I106_XP_MN1 (XI1850_I106_XP_n1 I1850_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I106_XP_MN0 (I1850_P10_7n I1850_P10_9 XI1850_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I108_XP_MN1 (XI1850_I108_XP_n1 I1850_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I108_XP_MN0 (I1850_P12_9n I1850_P12_11 XI1850_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I171_XP_MN1 (XI1850_I171_XP_n1 I1850_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I171_XP_MN0 (I1850_P20_5n I1850_P20_13 XI1850_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I173_XP_MN1 (XI1850_I173_XP_n1 I1850_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I173_XP_MN0 (I1850_P22_7n I1850_P22_15 XI1850_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I177_XP_MN1 (XI1850_I177_XP_n1 I1850_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I177_XP_MN0 (I1850_P26_11n I1850_P26_19 XI1850_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I179_XP_MN1 (XI1850_I179_XP_n1 I1850_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I179_XP_MN0 (I1850_P28_13n I1850_P28_21 XI1850_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I181_XP_MN1 (XI1850_I181_XP_n1 I1850_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I181_XP_MN0 (I1850_P30_15n I1850_P30_23 XI1850_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I106_XP_MN1 (XI700_I106_XP_n1 I700_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I106_XP_MN0 (I700_P10_7n I700_P10_9 XI700_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I104_XP_MN1 (XI700_I104_XP_n1 I700_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I104_XP_MN0 (I700_P8_5n I700_P8_7 XI700_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I102_XP_MN1 (XI700_I102_XP_n1 I700_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I102_XP_MN0 (I700_P6_3n I700_P6_5 XI700_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I3_MN1 (XI700_I3_n1 b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I3_MN0 (I700_gn3 p2_2 XI700_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I2_MN1 (XI700_I2_n1 b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I2_MN0 (I700_gn2 p2_1 XI700_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I1_MN1 (XI700_I1_n1 b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I1_MN0 (I700_gn1 p2_0 XI700_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I1_MN1 (XI608_I1_n1 b1_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I1_MN0 (I608_gn1 p0_0 XI608_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I0_MN1 (XI562_I0_n1 b0_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I0_MN0 (I562_gn0 aa31 XI562_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I4_MN1 (XI562_I4_n1 b0_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I4_MN0 (I562_gn4 VSS XI562_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I5_MN1 (XI562_I5_n1 b0_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I5_MN0 (I562_gn5 VSS XI562_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI128_MN1 (XI128_n1 B_0_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI128_MN0 (nbkn1 B_31_b3_0 XI128_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I0_MN1 (XI2066_I0_n1 dm0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I0_MN0 (I2066_gn0 p31_0 XI2066_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2002_MN1 (XI2002_n1 p31_32_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2002_MN0 (dmn0 B_0_b3_5 XI2002_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2004_MN1 (XI2004_n1 p31_32_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2004_MN0 (dmn1 dd1_b3_5 XI2004_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2006_MN1 (XI2006_n1 p31_32_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2006_MN0 (dmn2 dd2_b3_5 XI2006_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I2_MN1 (XI1988_I2_n1 b31_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I2_MN0 (I1988_gn2 p30_1 XI1988_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I0_MN1 (XI1942_I0_n1 b30_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I0_MN0 (I1942_gn0 aa1 XI1942_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I1_MN1 (XI1942_I1_n1 b30_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I1_MN0 (I1942_gn1 p29_0 XI1942_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I1_MN1 (XI1850_I1_n1 b28_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I1_MN0 (I1850_gn1 p27_0 XI1850_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I2_MN1 (XI1850_I2_n1 b28_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I2_MN0 (I1850_gn2 p27_1 XI1850_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I3_MN1 (XI1850_I3_n1 b28_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I3_MN0 (I1850_gn3 p27_2 XI1850_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I4_MN1 (XI1850_I4_n1 b28_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I4_MN0 (I1850_gn4 p27_3 XI1850_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I110_XP_MN1 (XI1850_I110_XP_n1 I1850_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I110_XP_MN0 (I1850_P14_11n I1850_P14_13 XI1850_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I112_XP_MN1 (XI1850_I112_XP_n1 I1850_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I112_XP_MN0 (I1850_P16_13n I1850_P16_15 XI1850_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I114_XP_MN1 (XI1850_I114_XP_n1 I1850_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I114_XP_MN0 (I1850_P18_15n I1850_P18_17 XI1850_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I116_XP_MN1 (XI1850_I116_XP_n1 I1850_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I116_XP_MN0 (I1850_P20_17n I1850_P20_19 XI1850_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I118_XP_MN1 (XI1850_I118_XP_n1 I1850_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I118_XP_MN0 (I1850_P22_19n I1850_P22_21 XI1850_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I120_XP_MN1 (XI1850_I120_XP_n1 I1850_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I120_XP_MN0 (I1850_P24_21n I1850_P24_23 XI1850_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I122_XP_MN1 (XI1850_I122_XP_n1 I1850_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I122_XP_MN0 (I1850_P26_23n I1850_P26_25 XI1850_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I124_XP_MN1 (XI1850_I124_XP_n1 I1850_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I124_XP_MN0 (I1850_P28_25n I1850_P28_27 XI1850_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I179_XP_MN1 (XI700_I179_XP_n1 I700_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I179_XP_MN0 (I700_P28_13n I700_P28_21 XI700_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I177_XP_MN1 (XI700_I177_XP_n1 I700_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I177_XP_MN0 (I700_P26_11n I700_P26_19 XI700_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I171_XP_MN1 (XI700_I171_XP_n1 I700_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I171_XP_MN0 (I700_P20_5n I700_P20_13 XI700_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I175_XP_MN1 (XI700_I175_XP_n1 I700_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I175_XP_MN0 (I700_P24_9n I700_P24_17 XI700_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I169_XP_MN1 (XI700_I169_XP_n1 I700_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I169_XP_MN0 (I700_P18_3n I700_P18_11 XI700_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I167_XP_MN1 (XI700_I167_XP_n1 I700_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I167_XP_MN0 (I700_P16_1n I700_P16_9 XI700_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I100_XP_MN1 (XI700_I100_XP_n1 I700_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I100_XP_MN0 (I700_P4_1n I700_P4_3 XI700_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I3_MN1 (XI746_I3_n1 b4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I3_MN0 (I746_gn3 p3_2 XI746_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I0_MN1 (XI700_I0_n1 b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I0_MN0 (I700_gn0 aa28 XI700_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I0_MN1 (XI746_I0_n1 b4_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I0_MN0 (I746_gn0 aa27 XI746_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2285_MN1 (XI2285_n1 z0_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2285_MN0 (z1_7 z0_14 XI2285_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I0_MN1 (XI1988_I0_n1 b31_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I0_MN0 (I1988_gn0 A_0 XI1988_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI36_MN1 (XI36_n1 A_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI36_MN0 (nakn1 A_31_b3_0 XI36_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I0_MN1 (XI1896_I0_n1 b29_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I0_MN0 (I1896_gn0 aa2 XI1896_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I0_MN1 (XI1850_I0_n1 b28_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I0_MN0 (I1850_gn0 aa3 XI1850_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I5_MN1 (XI1850_I5_n1 b28_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I5_MN0 (I1850_gn5 p27_4 XI1850_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I6_MN1 (XI1850_I6_n1 b28_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I6_MN0 (I1850_gn6 p27_5 XI1850_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I10_MN1 (XI1850_I10_n1 b28_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I10_MN0 (I1850_gn10 p27_9 XI1850_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I11_MN1 (XI1850_I11_n1 b28_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I11_MN0 (I1850_gn11 p27_10 XI1850_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I14_MN1 (XI1850_I14_n1 b28_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I14_MN0 (I1850_gn14 p27_13 XI1850_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I15_MN1 (XI1850_I15_n1 b28_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I15_MN0 (I1850_gn15 p27_14 XI1850_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I126_XP_MN1 (XI1850_I126_XP_n1 I1850_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I126_XP_MN0 (I1850_P30_27n I1850_P30_29 XI1850_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I17_MN1 (XI746_I17_n1 b4_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I17_MN0 (I746_gn17 p3_16 XI746_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I11_MN1 (XI746_I11_n1 b4_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I11_MN0 (I746_gn11 p3_10 XI746_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I10_MN1 (XI746_I10_n1 b4_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I10_MN0 (I746_gn10 p3_9 XI746_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I4_MN1 (XI746_I4_n1 b4_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I4_MN0 (I746_gn4 p3_3 XI746_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I2_MN1 (XI746_I2_n1 b4_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I2_MN0 (I746_gn2 p3_1 XI746_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I1_MN1 (XI746_I1_n1 b4_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I1_MN0 (I746_gn1 p3_0 XI746_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I1_MN1 (XI792_I1_n1 b5_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I1_MN0 (I792_gn1 p4_0 XI792_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I0_MN1 (XI792_I0_n1 b5_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I0_MN0 (I792_gn0 aa26 XI792_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I1_MN1 (XI838_I1_n1 b6_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I1_MN0 (I838_gn1 p5_0 XI838_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I0_MN1 (XI838_I0_n1 b6_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I0_MN0 (I838_gn0 aa25 XI838_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2284_MN1 (XI2284_n1 z0_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2284_MN0 (z1_6 z0_12 XI2284_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I7_MN1 (XI1850_I7_n1 b28_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I7_MN0 (I1850_gn7 p27_6 XI1850_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I8_MN1 (XI1850_I8_n1 b28_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I8_MN0 (I1850_gn8 p27_7 XI1850_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I9_MN1 (XI1850_I9_n1 b28_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I9_MN0 (I1850_gn9 p27_8 XI1850_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I12_MN1 (XI1850_I12_n1 b28_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I12_MN0 (I1850_gn12 p27_11 XI1850_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I16_MN1 (XI1850_I16_n1 b28_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I16_MN0 (I1850_gn16 p27_15 XI1850_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I21_MN1 (XI1850_I21_n1 b28_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I21_MN0 (I1850_gn21 p27_20 XI1850_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I22_MN1 (XI1850_I22_n1 b28_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I22_MN0 (I1850_gn22 p27_21 XI1850_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I28_MN1 (XI1850_I28_n1 b28_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I28_MN0 (I1850_gn28 p27_27 XI1850_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I21_MN1 (XI746_I21_n1 b4_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I21_MN0 (I746_gn21 p3_20 XI746_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I20_MN1 (XI746_I20_n1 b4_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I20_MN0 (I746_gn20 p3_19 XI746_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I16_MN1 (XI746_I16_n1 b4_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I16_MN0 (I746_gn16 p3_15 XI746_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I15_MN1 (XI746_I15_n1 b4_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I15_MN0 (I746_gn15 p3_14 XI746_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I9_MN1 (XI746_I9_n1 b4_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I9_MN0 (I746_gn9 p3_8 XI746_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I7_MN1 (XI746_I7_n1 b4_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I7_MN0 (I746_gn7 p3_6 XI746_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I6_MN1 (XI746_I6_n1 b4_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I6_MN0 (I746_gn6 p3_5 XI746_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I5_MN1 (XI746_I5_n1 b4_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I5_MN0 (I746_gn5 p3_4 XI746_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I3_MN1 (XI792_I3_n1 b5_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I3_MN0 (I792_gn3 p4_2 XI792_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I2_MN1 (XI792_I2_n1 b5_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I2_MN0 (I792_gn2 p4_1 XI792_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I3_MN1 (XI838_I3_n1 b6_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I3_MN0 (I838_gn3 p5_2 XI838_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I2_MN1 (XI838_I2_n1 b6_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I2_MN0 (I838_gn2 p5_1 XI838_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I1_MN1 (XI884_I1_n1 b7_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I1_MN0 (I884_gn1 p6_0 XI884_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I3_MN1 (XI884_I3_n1 b7_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I3_MN0 (I884_gn3 p6_2 XI884_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I2_MN1 (XI884_I2_n1 b7_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I2_MN0 (I884_gn2 p6_1 XI884_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I0_MN1 (XI1712_I0_n1 b25_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I0_MN0 (I1712_gn0 aa6 XI1712_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I0_MN1 (XI1758_I0_n1 b26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I0_MN0 (I1758_gn0 aa5 XI1758_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I0_MN1 (XI1804_I0_n1 b27_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I0_MN0 (I1804_gn0 aa4 XI1804_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I1_MN1 (XI1804_I1_n1 b27_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I1_MN0 (I1804_gn1 p26_0 XI1804_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I2_MN1 (XI1804_I2_n1 b27_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I2_MN0 (I1804_gn2 p26_1 XI1804_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I13_MN1 (XI1850_I13_n1 b28_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I13_MN0 (I1850_gn13 p27_12 XI1850_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I17_MN1 (XI1850_I17_n1 b28_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I17_MN0 (I1850_gn17 p27_16 XI1850_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I18_MN1 (XI1850_I18_n1 b28_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I18_MN0 (I1850_gn18 p27_17 XI1850_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I19_MN1 (XI1850_I19_n1 b28_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I19_MN0 (I1850_gn19 p27_18 XI1850_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I20_MN1 (XI1850_I20_n1 b28_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I20_MN0 (I1850_gn20 p27_19 XI1850_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I23_MN1 (XI1850_I23_n1 b28_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I23_MN0 (I1850_gn23 p27_22 XI1850_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I29_MN1 (XI1850_I29_n1 b28_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I29_MN0 (I1850_gn29 p27_28 XI1850_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I22_MN1 (XI746_I22_n1 b4_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I22_MN0 (I746_gn22 p3_21 XI746_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I19_MN1 (XI746_I19_n1 b4_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I19_MN0 (I746_gn19 p3_18 XI746_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I14_MN1 (XI746_I14_n1 b4_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I14_MN0 (I746_gn14 p3_13 XI746_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I13_MN1 (XI746_I13_n1 b4_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I13_MN0 (I746_gn13 p3_12 XI746_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I12_MN1 (XI746_I12_n1 b4_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I12_MN0 (I746_gn12 p3_11 XI746_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I8_MN1 (XI746_I8_n1 b4_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I8_MN0 (I746_gn8 p3_7 XI746_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I7_MN1 (XI792_I7_n1 b5_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I7_MN0 (I792_gn7 p4_6 XI792_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I6_MN1 (XI792_I6_n1 b5_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I6_MN0 (I792_gn6 p4_5 XI792_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I5_MN1 (XI792_I5_n1 b5_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I5_MN0 (I792_gn5 p4_4 XI792_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I4_MN1 (XI792_I4_n1 b5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I4_MN0 (I792_gn4 p4_3 XI792_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I5_MN1 (XI838_I5_n1 b6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I5_MN0 (I838_gn5 p5_4 XI838_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I6_MN1 (XI838_I6_n1 b6_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I6_MN0 (I838_gn6 p5_5 XI838_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I4_MN1 (XI838_I4_n1 b6_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I4_MN0 (I838_gn4 p5_3 XI838_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I100_XP_MN1 (XI838_I100_XP_n1 I838_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I100_XP_MN0 (I838_P4_1n I838_P4_3 XI838_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I0_MN1 (XI884_I0_n1 b7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I0_MN0 (I884_gn0 aa24 XI884_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I5_MN1 (XI884_I5_n1 b7_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I5_MN0 (I884_gn5 p6_4 XI884_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I4_MN1 (XI884_I4_n1 b7_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I4_MN0 (I884_gn4 p6_3 XI884_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I100_XP_MN1 (XI1712_I100_XP_n1 I1712_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I100_XP_MN0 (I1712_P4_1n I1712_P4_3 XI1712_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I2_MN1 (XI1712_I2_n1 b25_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I2_MN0 (I1712_gn2 p24_1 XI1712_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I3_MN1 (XI1712_I3_n1 b25_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I3_MN0 (I1712_gn3 p24_2 XI1712_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I1_MN1 (XI1712_I1_n1 b25_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I1_MN0 (I1712_gn1 p24_0 XI1712_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I2_MN1 (XI1758_I2_n1 b26_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I2_MN0 (I1758_gn2 p25_1 XI1758_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I3_MN1 (XI1758_I3_n1 b26_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I3_MN0 (I1758_gn3 p25_2 XI1758_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I1_MN1 (XI1758_I1_n1 b26_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I1_MN0 (I1758_gn1 p25_0 XI1758_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I3_MN1 (XI1804_I3_n1 b27_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I3_MN0 (I1804_gn3 p26_2 XI1804_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I100_XP_MN1 (XI1804_I100_XP_n1 I1804_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I100_XP_MN0 (I1804_P4_1n I1804_P4_3 XI1804_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I102_XP_MN1 (XI1804_I102_XP_n1 I1804_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I102_XP_MN0 (I1804_P6_3n I1804_P6_5 XI1804_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I25_MN1 (XI1850_I25_n1 b28_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I25_MN0 (I1850_gn25 p27_24 XI1850_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I27_MN1 (XI1850_I27_n1 b28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I27_MN0 (I1850_gn27 p27_26 XI1850_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I26_MN1 (XI1850_I26_n1 b28_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I26_MN0 (I1850_gn26 p27_25 XI1850_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I30_MN1 (XI1850_I30_n1 b28_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I30_MN0 (I1850_gn30 p27_29 XI1850_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I23_MN1 (XI746_I23_n1 b4_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I23_MN0 (I746_gn23 p3_22 XI746_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I18_MN1 (XI746_I18_n1 b4_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I18_MN0 (I746_gn18 p3_17 XI746_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I105_XP_MN1 (XI746_I105_XP_n1 I746_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I105_XP_MN0 (I746_P9_6n I746_P9_8 XI746_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I103_XP_MN1 (XI746_I103_XP_n1 I746_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I103_XP_MN0 (I746_P7_4n I746_P7_6 XI746_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I101_XP_MN1 (XI746_I101_XP_n1 I746_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I101_XP_MN0 (I746_P5_2n I746_P5_4 XI746_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I8_MN1 (XI792_I8_n1 b5_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I8_MN0 (I792_gn8 p4_7 XI792_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I9_MN1 (XI792_I9_n1 b5_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I9_MN0 (I792_gn9 p4_8 XI792_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I103_XP_MN1 (XI792_I103_XP_n1 I792_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I103_XP_MN0 (I792_P7_4n I792_P7_6 XI792_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I101_XP_MN1 (XI792_I101_XP_n1 I792_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I101_XP_MN0 (I792_P5_2n I792_P5_4 XI792_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I104_XP_MN1 (XI792_I104_XP_n1 I792_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I104_XP_MN0 (I792_P8_5n I792_P8_7 XI792_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I102_XP_MN1 (XI792_I102_XP_n1 I792_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I102_XP_MN0 (I792_P6_3n I792_P6_5 XI792_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I100_XP_MN1 (XI792_I100_XP_n1 I792_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I100_XP_MN0 (I792_P4_1n I792_P4_3 XI792_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I7_MN1 (XI838_I7_n1 b6_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I7_MN0 (I838_gn7 p5_6 XI838_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I101_XP_MN1 (XI838_I101_XP_n1 I838_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I101_XP_MN0 (I838_P5_2n I838_P5_4 XI838_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I104_XP_MN1 (XI838_I104_XP_n1 I838_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I104_XP_MN0 (I838_P8_5n I838_P8_7 XI838_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I102_XP_MN1 (XI838_I102_XP_n1 I838_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I102_XP_MN0 (I838_P6_3n I838_P6_5 XI838_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I6_MN1 (XI884_I6_n1 b7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I6_MN0 (I884_gn6 p6_5 XI884_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I100_XP_MN1 (XI884_I100_XP_n1 I884_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I100_XP_MN0 (I884_P4_1n I884_P4_3 XI884_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I101_XP_MN1 (XI884_I101_XP_n1 I884_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I101_XP_MN0 (I884_P5_2n I884_P5_4 XI884_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I103_XP_MN1 (XI884_I103_XP_n1 I884_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I103_XP_MN0 (I884_P7_4n I884_P7_6 XI884_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I167_XP_MN1 (XI1712_I167_XP_n1 I1712_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I167_XP_MN0 (I1712_P16_1n I1712_P16_9 XI1712_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I102_XP_MN1 (XI1712_I102_XP_n1 I1712_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I102_XP_MN0 (I1712_P6_3n I1712_P6_5 XI1712_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I4_MN1 (XI1712_I4_n1 b25_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I4_MN0 (I1712_gn4 p24_3 XI1712_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I101_XP_MN1 (XI1712_I101_XP_n1 I1712_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I101_XP_MN0 (I1712_P5_2n I1712_P5_4 XI1712_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I4_MN1 (XI1758_I4_n1 b26_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I4_MN0 (I1758_gn4 p25_3 XI1758_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I5_MN1 (XI1758_I5_n1 b26_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I5_MN0 (I1758_gn5 p25_4 XI1758_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I102_XP_MN1 (XI1758_I102_XP_n1 I1758_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I102_XP_MN0 (I1758_P6_3n I1758_P6_5 XI1758_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I100_XP_MN1 (XI1758_I100_XP_n1 I1758_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I100_XP_MN0 (I1758_P4_1n I1758_P4_3 XI1758_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I101_XP_MN1 (XI1758_I101_XP_n1 I1758_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I101_XP_MN0 (I1758_P5_2n I1758_P5_4 XI1758_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I4_MN1 (XI1804_I4_n1 b27_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I4_MN0 (I1804_gn4 p26_3 XI1804_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I5_MN1 (XI1804_I5_n1 b27_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I5_MN0 (I1804_gn5 p26_4 XI1804_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I101_XP_MN1 (XI1804_I101_XP_n1 I1804_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I101_XP_MN0 (I1804_P5_2n I1804_P5_4 XI1804_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I104_XP_MN1 (XI1804_I104_XP_n1 I1804_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I104_XP_MN0 (I1804_P8_5n I1804_P8_7 XI1804_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I167_XP_MN1 (XI1804_I167_XP_n1 I1804_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I167_XP_MN0 (I1804_P16_1n I1804_P16_9 XI1804_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I24_MN1 (XI1850_I24_n1 b28_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I24_MN0 (I1850_gn24 p27_23 XI1850_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I31_MN1 (XI1850_I31_n1 b28_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I31_MN0 (I1850_gn31 p27_30 XI1850_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I174_XP_MN1 (XI746_I174_XP_n1 I746_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I174_XP_MN0 (I746_P23_8n I746_P23_16 XI746_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I111_XP_MN1 (XI746_I111_XP_n1 I746_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I111_XP_MN0 (I746_P15_12n I746_P15_14 XI746_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I109_XP_MN1 (XI746_I109_XP_n1 I746_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I109_XP_MN0 (I746_P13_10n I746_P13_12 XI746_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I107_XP_MN1 (XI746_I107_XP_n1 I746_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I107_XP_MN0 (I746_P11_8n I746_P11_10 XI746_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I100_XP_MN1 (XI746_I100_XP_n1 I746_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I100_XP_MN0 (I746_P4_1n I746_P4_3 XI746_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I11_MN1 (XI792_I11_n1 b5_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I11_MN0 (I792_gn11 p4_10 XI792_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I10_MN1 (XI792_I10_n1 b5_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I10_MN0 (I792_gn10 p4_9 XI792_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I105_XP_MN1 (XI792_I105_XP_n1 I792_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I105_XP_MN0 (I792_P9_6n I792_P9_8 XI792_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I106_XP_MN1 (XI792_I106_XP_n1 I792_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I106_XP_MN0 (I792_P10_7n I792_P10_9 XI792_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I9_MN1 (XI838_I9_n1 b6_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I9_MN0 (I838_gn9 p5_8 XI838_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I8_MN1 (XI838_I8_n1 b6_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I8_MN0 (I838_gn8 p5_7 XI838_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I105_XP_MN1 (XI838_I105_XP_n1 I838_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I105_XP_MN0 (I838_P9_6n I838_P9_8 XI838_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I103_XP_MN1 (XI838_I103_XP_n1 I838_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I103_XP_MN0 (I838_P7_4n I838_P7_6 XI838_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I106_XP_MN1 (XI838_I106_XP_n1 I838_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I106_XP_MN0 (I838_P10_7n I838_P10_9 XI838_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I167_XP_MN1 (XI838_I167_XP_n1 I838_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I167_XP_MN0 (I838_P16_1n I838_P16_9 XI838_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I8_MN1 (XI884_I8_n1 b7_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I8_MN0 (I884_gn8 p6_7 XI884_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I7_MN1 (XI884_I7_n1 b7_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I7_MN0 (I884_gn7 p6_6 XI884_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I104_XP_MN1 (XI884_I104_XP_n1 I884_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I104_XP_MN0 (I884_P8_5n I884_P8_7 XI884_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I102_XP_MN1 (XI884_I102_XP_n1 I884_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I102_XP_MN0 (I884_P6_3n I884_P6_5 XI884_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I104_XP_MN1 (XI1712_I104_XP_n1 I1712_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I104_XP_MN0 (I1712_P8_5n I1712_P8_7 XI1712_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I6_MN1 (XI1712_I6_n1 b25_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I6_MN0 (I1712_gn6 p24_5 XI1712_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I5_MN1 (XI1712_I5_n1 b25_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I5_MN0 (I1712_gn5 p24_4 XI1712_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I103_XP_MN1 (XI1712_I103_XP_n1 I1712_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I103_XP_MN0 (I1712_P7_4n I1712_P7_6 XI1712_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I6_MN1 (XI1758_I6_n1 b26_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I6_MN0 (I1758_gn6 p25_5 XI1758_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I7_MN1 (XI1758_I7_n1 b26_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I7_MN0 (I1758_gn7 p25_6 XI1758_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I104_XP_MN1 (XI1758_I104_XP_n1 I1758_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I104_XP_MN0 (I1758_P8_5n I1758_P8_7 XI1758_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I167_XP_MN1 (XI1758_I167_XP_n1 I1758_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I167_XP_MN0 (I1758_P16_1n I1758_P16_9 XI1758_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I103_XP_MN1 (XI1758_I103_XP_n1 I1758_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I103_XP_MN0 (I1758_P7_4n I1758_P7_6 XI1758_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I7_MN1 (XI1804_I7_n1 b27_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I7_MN0 (I1804_gn7 p26_6 XI1804_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I6_MN1 (XI1804_I6_n1 b27_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I6_MN0 (I1804_gn6 p26_5 XI1804_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I103_XP_MN1 (XI1804_I103_XP_n1 I1804_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I103_XP_MN0 (I1804_P7_4n I1804_P7_6 XI1804_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I106_XP_MN1 (XI1804_I106_XP_n1 I1804_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I106_XP_MN0 (I1804_P10_7n I1804_P10_9 XI1804_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I108_XP_MN1 (XI1804_I108_XP_n1 I1804_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I108_XP_MN0 (I1804_P12_9n I1804_P12_11 XI1804_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I169_XP_MN1 (XI1804_I169_XP_n1 I1804_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I169_XP_MN0 (I1804_P18_3n I1804_P18_11 XI1804_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I175_XP_MN1 (XI1804_I175_XP_n1 I1804_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I175_XP_MN0 (I1804_P24_9n I1804_P24_17 XI1804_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I170_XP_MN1 (XI746_I170_XP_n1 I746_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I170_XP_MN0 (I746_P19_4n I746_P19_12 XI746_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I117_XP_MN1 (XI746_I117_XP_n1 I746_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I117_XP_MN0 (I746_P21_18n I746_P21_20 XI746_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I115_XP_MN1 (XI746_I115_XP_n1 I746_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I115_XP_MN0 (I746_P19_16n I746_P19_18 XI746_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I113_XP_MN1 (XI746_I113_XP_n1 I746_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I113_XP_MN0 (I746_P17_14n I746_P17_16 XI746_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I168_XP_MN1 (XI746_I168_XP_n1 I746_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I168_XP_MN0 (I746_P17_2n I746_P17_10 XI746_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I104_XP_MN1 (XI746_I104_XP_n1 I746_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I104_XP_MN0 (I746_P8_5n I746_P8_7 XI746_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I102_XP_MN1 (XI746_I102_XP_n1 I746_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I102_XP_MN0 (I746_P6_3n I746_P6_5 XI746_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I18_MN1 (XI792_I18_n1 b5_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I18_MN0 (I792_gn18 p4_17 XI792_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I17_MN1 (XI792_I17_n1 b5_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I17_MN0 (I792_gn17 p4_16 XI792_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I12_MN1 (XI792_I12_n1 b5_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I12_MN0 (I792_gn12 p4_11 XI792_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I13_MN1 (XI792_I13_n1 b5_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I13_MN0 (I792_gn13 p4_12 XI792_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I107_XP_MN1 (XI792_I107_XP_n1 I792_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I107_XP_MN0 (I792_P11_8n I792_P11_10 XI792_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I168_XP_MN1 (XI792_I168_XP_n1 I792_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I168_XP_MN0 (I792_P17_2n I792_P17_10 XI792_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I108_XP_MN1 (XI792_I108_XP_n1 I792_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I108_XP_MN0 (I792_P12_9n I792_P12_11 XI792_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I167_XP_MN1 (XI792_I167_XP_n1 I792_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I167_XP_MN0 (I792_P16_1n I792_P16_9 XI792_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I10_MN1 (XI838_I10_n1 b6_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I10_MN0 (I838_gn10 p5_9 XI838_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I109_XP_MN1 (XI838_I109_XP_n1 I838_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I109_XP_MN0 (I838_P13_10n I838_P13_12 XI838_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I107_XP_MN1 (XI838_I107_XP_n1 I838_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I107_XP_MN0 (I838_P11_8n I838_P11_10 XI838_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I168_XP_MN1 (XI838_I168_XP_n1 I838_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I168_XP_MN0 (I838_P17_2n I838_P17_10 XI838_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I108_XP_MN1 (XI838_I108_XP_n1 I838_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I108_XP_MN0 (I838_P12_9n I838_P12_11 XI838_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I175_XP_MN1 (XI838_I175_XP_n1 I838_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I175_XP_MN0 (I838_P24_9n I838_P24_17 XI838_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I169_XP_MN1 (XI838_I169_XP_n1 I838_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I169_XP_MN0 (I838_P18_3n I838_P18_11 XI838_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I9_MN1 (XI884_I9_n1 b7_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I9_MN0 (I884_gn9 p6_8 XI884_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I10_MN1 (XI884_I10_n1 b7_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I10_MN0 (I884_gn10 p6_9 XI884_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I106_XP_MN1 (XI884_I106_XP_n1 I884_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I106_XP_MN0 (I884_P10_7n I884_P10_9 XI884_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I167_XP_MN1 (XI884_I167_XP_n1 I884_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I167_XP_MN0 (I884_P16_1n I884_P16_9 XI884_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I105_XP_MN1 (XI884_I105_XP_n1 I884_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I105_XP_MN0 (I884_P9_6n I884_P9_8 XI884_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I171_XP_MN1 (XI1712_I171_XP_n1 I1712_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I171_XP_MN0 (I1712_P20_5n I1712_P20_13 XI1712_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I106_XP_MN1 (XI1712_I106_XP_n1 I1712_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I106_XP_MN0 (I1712_P10_7n I1712_P10_9 XI1712_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I7_MN1 (XI1712_I7_n1 b25_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I7_MN0 (I1712_gn7 p24_6 XI1712_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I105_XP_MN1 (XI1712_I105_XP_n1 I1712_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I105_XP_MN0 (I1712_P9_6n I1712_P9_8 XI1712_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I8_MN1 (XI1758_I8_n1 b26_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I8_MN0 (I1758_gn8 p25_7 XI1758_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I9_MN1 (XI1758_I9_n1 b26_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I9_MN0 (I1758_gn9 p25_8 XI1758_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I106_XP_MN1 (XI1758_I106_XP_n1 I1758_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I106_XP_MN0 (I1758_P10_7n I1758_P10_9 XI1758_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I105_XP_MN1 (XI1758_I105_XP_n1 I1758_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I105_XP_MN0 (I1758_P9_6n I1758_P9_8 XI1758_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I8_MN1 (XI1804_I8_n1 b27_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I8_MN0 (I1804_gn8 p26_7 XI1804_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I105_XP_MN1 (XI1804_I105_XP_n1 I1804_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I105_XP_MN0 (I1804_P9_6n I1804_P9_8 XI1804_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I107_XP_MN1 (XI1804_I107_XP_n1 I1804_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I107_XP_MN0 (I1804_P11_8n I1804_P11_10 XI1804_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I168_XP_MN1 (XI1804_I168_XP_n1 I1804_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I168_XP_MN0 (I1804_P17_2n I1804_P17_10 XI1804_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I171_XP_MN1 (XI1804_I171_XP_n1 I1804_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I171_XP_MN0 (I1804_P20_5n I1804_P20_13 XI1804_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I179_XP_MN1 (XI1804_I179_XP_n1 I1804_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I179_XP_MN0 (I1804_P28_13n I1804_P28_21 XI1804_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I177_XP_MN1 (XI1804_I177_XP_n1 I1804_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I177_XP_MN0 (I1804_P26_11n I1804_P26_19 XI1804_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I182_XP_MN1 (XI746_I182_XP_n1 I746_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I182_XP_MN0 (I746_P31_16n I746_P31_24 XI746_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I178_XP_MN1 (XI746_I178_XP_n1 I746_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I178_XP_MN0 (I746_P27_12n I746_P27_20 XI746_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I119_XP_MN1 (XI746_I119_XP_n1 I746_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I119_XP_MN0 (I746_P23_20n I746_P23_22 XI746_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I172_XP_MN1 (XI746_I172_XP_n1 I746_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I172_XP_MN0 (I746_P21_6n I746_P21_14 XI746_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I176_XP_MN1 (XI746_I176_XP_n1 I746_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I176_XP_MN0 (I746_P25_10n I746_P25_18 XI746_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I108_XP_MN1 (XI746_I108_XP_n1 I746_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I108_XP_MN0 (I746_P12_9n I746_P12_11 XI746_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I106_XP_MN1 (XI746_I106_XP_n1 I746_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I106_XP_MN0 (I746_P10_7n I746_P10_9 XI746_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I167_XP_MN1 (XI746_I167_XP_n1 I746_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I167_XP_MN0 (I746_P16_1n I746_P16_9 XI746_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I15_MN1 (XI792_I15_n1 b5_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I15_MN0 (I792_gn15 p4_14 XI792_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I109_XP_MN1 (XI792_I109_XP_n1 I792_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I109_XP_MN0 (I792_P13_10n I792_P13_12 XI792_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I110_XP_MN1 (XI792_I110_XP_n1 I792_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I110_XP_MN0 (I792_P14_11n I792_P14_13 XI792_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I169_XP_MN1 (XI792_I169_XP_n1 I792_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I169_XP_MN0 (I792_P18_3n I792_P18_11 XI792_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I11_MN1 (XI838_I11_n1 b6_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I11_MN0 (I838_gn11 p5_10 XI838_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I13_MN1 (XI838_I13_n1 b6_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I13_MN0 (I838_gn13 p5_12 XI838_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I12_MN1 (XI838_I12_n1 b6_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I12_MN0 (I838_gn12 p5_11 XI838_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I176_XP_MN1 (XI838_I176_XP_n1 I838_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I176_XP_MN0 (I838_P25_10n I838_P25_18 XI838_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I110_XP_MN1 (XI838_I110_XP_n1 I838_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I110_XP_MN0 (I838_P14_11n I838_P14_13 XI838_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I12_MN1 (XI884_I12_n1 b7_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I12_MN0 (I884_gn12 p6_11 XI884_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I11_MN1 (XI884_I11_n1 b7_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I11_MN0 (I884_gn11 p6_10 XI884_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I108_XP_MN1 (XI884_I108_XP_n1 I884_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I108_XP_MN0 (I884_P12_9n I884_P12_11 XI884_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I110_XP_MN1 (XI884_I110_XP_n1 I884_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I110_XP_MN0 (I884_P14_11n I884_P14_13 XI884_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I169_XP_MN1 (XI884_I169_XP_n1 I884_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I169_XP_MN0 (I884_P18_3n I884_P18_11 XI884_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I175_XP_MN1 (XI884_I175_XP_n1 I884_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I175_XP_MN0 (I884_P24_9n I884_P24_17 XI884_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I107_XP_MN1 (XI884_I107_XP_n1 I884_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I107_XP_MN0 (I884_P11_8n I884_P11_10 XI884_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I168_XP_MN1 (XI884_I168_XP_n1 I884_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I168_XP_MN0 (I884_P17_2n I884_P17_10 XI884_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I169_XP_MN1 (XI1712_I169_XP_n1 I1712_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I169_XP_MN0 (I1712_P18_3n I1712_P18_11 XI1712_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I175_XP_MN1 (XI1712_I175_XP_n1 I1712_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I175_XP_MN0 (I1712_P24_9n I1712_P24_17 XI1712_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I108_XP_MN1 (XI1712_I108_XP_n1 I1712_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I108_XP_MN0 (I1712_P12_9n I1712_P12_11 XI1712_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I10_MN1 (XI1712_I10_n1 b25_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I10_MN0 (I1712_gn10 p24_9 XI1712_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I8_MN1 (XI1712_I8_n1 b25_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I8_MN0 (I1712_gn8 p24_7 XI1712_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I9_MN1 (XI1712_I9_n1 b25_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I9_MN0 (I1712_gn9 p24_8 XI1712_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I168_XP_MN1 (XI1712_I168_XP_n1 I1712_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I168_XP_MN0 (I1712_P17_2n I1712_P17_10 XI1712_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I10_MN1 (XI1758_I10_n1 b26_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I10_MN0 (I1758_gn10 p25_9 XI1758_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I11_MN1 (XI1758_I11_n1 b26_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I11_MN0 (I1758_gn11 p25_10 XI1758_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I108_XP_MN1 (XI1758_I108_XP_n1 I1758_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I108_XP_MN0 (I1758_P12_9n I1758_P12_11 XI1758_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I175_XP_MN1 (XI1758_I175_XP_n1 I1758_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I175_XP_MN0 (I1758_P24_9n I1758_P24_17 XI1758_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I169_XP_MN1 (XI1758_I169_XP_n1 I1758_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I169_XP_MN0 (I1758_P18_3n I1758_P18_11 XI1758_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I107_XP_MN1 (XI1758_I107_XP_n1 I1758_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I107_XP_MN0 (I1758_P11_8n I1758_P11_10 XI1758_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I168_XP_MN1 (XI1758_I168_XP_n1 I1758_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I168_XP_MN0 (I1758_P17_2n I1758_P17_10 XI1758_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I9_MN1 (XI1804_I9_n1 b27_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I9_MN0 (I1804_gn9 p26_8 XI1804_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I11_MN1 (XI1804_I11_n1 b27_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I11_MN0 (I1804_gn11 p26_10 XI1804_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I10_MN1 (XI1804_I10_n1 b27_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I10_MN0 (I1804_gn10 p26_9 XI1804_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I170_XP_MN1 (XI1804_I170_XP_n1 I1804_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I170_XP_MN0 (I1804_P19_4n I1804_P19_12 XI1804_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I110_XP_MN1 (XI1804_I110_XP_n1 I1804_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I110_XP_MN0 (I1804_P14_11n I1804_P14_13 XI1804_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I173_XP_MN1 (XI1804_I173_XP_n1 I1804_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I173_XP_MN0 (I1804_P22_7n I1804_P22_15 XI1804_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I123_XP_MN1 (XI746_I123_XP_n1 I746_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I123_XP_MN0 (I746_P27_24n I746_P27_26 XI746_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I121_XP_MN1 (XI746_I121_XP_n1 I746_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I121_XP_MN0 (I746_P25_22n I746_P25_24 XI746_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I180_XP_MN1 (XI746_I180_XP_n1 I746_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I180_XP_MN0 (I746_P29_14n I746_P29_22 XI746_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I114_XP_MN1 (XI746_I114_XP_n1 I746_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I114_XP_MN0 (I746_P18_15n I746_P18_17 XI746_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I112_XP_MN1 (XI746_I112_XP_n1 I746_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I112_XP_MN0 (I746_P16_13n I746_P16_15 XI746_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I110_XP_MN1 (XI746_I110_XP_n1 I746_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I110_XP_MN0 (I746_P14_11n I746_P14_13 XI746_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I19_MN1 (XI792_I19_n1 b5_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I19_MN0 (I792_gn19 p4_18 XI792_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I16_MN1 (XI792_I16_n1 b5_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I16_MN0 (I792_gn16 p4_15 XI792_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I14_MN1 (XI792_I14_n1 b5_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I14_MN0 (I792_gn14 p4_13 XI792_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I113_XP_MN1 (XI792_I113_XP_n1 I792_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I113_XP_MN0 (I792_P17_14n I792_P17_16 XI792_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I111_XP_MN1 (XI792_I111_XP_n1 I792_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I111_XP_MN0 (I792_P15_12n I792_P15_14 XI792_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I170_XP_MN1 (XI792_I170_XP_n1 I792_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I170_XP_MN0 (I792_P19_4n I792_P19_12 XI792_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I114_XP_MN1 (XI792_I114_XP_n1 I792_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I114_XP_MN0 (I792_P18_15n I792_P18_17 XI792_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I112_XP_MN1 (XI792_I112_XP_n1 I792_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I112_XP_MN0 (I792_P16_13n I792_P16_15 XI792_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I111_XP_MN1 (XI838_I111_XP_n1 I838_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I111_XP_MN0 (I838_P15_12n I838_P15_14 XI838_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I170_XP_MN1 (XI838_I170_XP_n1 I838_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I170_XP_MN0 (I838_P19_4n I838_P19_12 XI838_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I172_XP_MN1 (XI838_I172_XP_n1 I838_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I172_XP_MN0 (I838_P21_6n I838_P21_14 XI838_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I112_XP_MN1 (XI838_I112_XP_n1 I838_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I112_XP_MN0 (I838_P16_13n I838_P16_15 XI838_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I171_XP_MN1 (XI838_I171_XP_n1 I838_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I171_XP_MN0 (I838_P20_5n I838_P20_13 XI838_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I177_XP_MN1 (XI838_I177_XP_n1 I838_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I177_XP_MN0 (I838_P26_11n I838_P26_19 XI838_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I13_MN1 (XI884_I13_n1 b7_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I13_MN0 (I884_gn13 p6_12 XI884_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I14_MN1 (XI884_I14_n1 b7_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I14_MN0 (I884_gn14 p6_13 XI884_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I112_XP_MN1 (XI884_I112_XP_n1 I884_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I112_XP_MN0 (I884_P16_13n I884_P16_15 XI884_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I177_XP_MN1 (XI884_I177_XP_n1 I884_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I177_XP_MN0 (I884_P26_11n I884_P26_19 XI884_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I109_XP_MN1 (XI884_I109_XP_n1 I884_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I109_XP_MN0 (I884_P13_10n I884_P13_12 XI884_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I176_XP_MN1 (XI884_I176_XP_n1 I884_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I176_XP_MN0 (I884_P25_10n I884_P25_18 XI884_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I112_XP_MN1 (XI1712_I112_XP_n1 I1712_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I112_XP_MN0 (I1712_P16_13n I1712_P16_15 XI1712_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I110_XP_MN1 (XI1712_I110_XP_n1 I1712_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I110_XP_MN0 (I1712_P14_11n I1712_P14_13 XI1712_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I11_MN1 (XI1712_I11_n1 b25_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I11_MN0 (I1712_gn11 p24_10 XI1712_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I107_XP_MN1 (XI1712_I107_XP_n1 I1712_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I107_XP_MN0 (I1712_P11_8n I1712_P11_10 XI1712_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I12_MN1 (XI1758_I12_n1 b26_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I12_MN0 (I1758_gn12 p25_11 XI1758_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I110_XP_MN1 (XI1758_I110_XP_n1 I1758_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I110_XP_MN0 (I1758_P14_11n I1758_P14_13 XI1758_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I171_XP_MN1 (XI1758_I171_XP_n1 I1758_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I171_XP_MN0 (I1758_P20_5n I1758_P20_13 XI1758_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I109_XP_MN1 (XI1758_I109_XP_n1 I1758_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I109_XP_MN0 (I1758_P13_10n I1758_P13_12 XI1758_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I176_XP_MN1 (XI1758_I176_XP_n1 I1758_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I176_XP_MN0 (I1758_P25_10n I1758_P25_18 XI1758_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I13_MN1 (XI1804_I13_n1 b27_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I13_MN0 (I1804_gn13 p26_12 XI1804_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I12_MN1 (XI1804_I12_n1 b27_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I12_MN0 (I1804_gn12 p26_11 XI1804_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I109_XP_MN1 (XI1804_I109_XP_n1 I1804_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I109_XP_MN0 (I1804_P13_10n I1804_P13_12 XI1804_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I112_XP_MN1 (XI1804_I112_XP_n1 I1804_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I112_XP_MN0 (I1804_P16_13n I1804_P16_15 XI1804_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I114_XP_MN1 (XI1804_I114_XP_n1 I1804_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I114_XP_MN0 (I1804_P18_15n I1804_P18_17 XI1804_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I116_XP_MN1 (XI1804_I116_XP_n1 I1804_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I116_XP_MN0 (I1804_P20_17n I1804_P20_19 XI1804_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I181_XP_MN1 (XI1804_I181_XP_n1 I1804_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I181_XP_MN0 (I1804_P30_15n I1804_P30_23 XI1804_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I24_MN1 (XI746_I24_n1 b4_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I24_MN0 (I746_gn24 p3_23 XI746_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I25_MN1 (XI746_I25_n1 b4_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I25_MN0 (I746_gn25 p3_24 XI746_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I120_XP_MN1 (XI746_I120_XP_n1 I746_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I120_XP_MN0 (I746_P24_21n I746_P24_23 XI746_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I118_XP_MN1 (XI746_I118_XP_n1 I746_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I118_XP_MN0 (I746_P22_19n I746_P22_21 XI746_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I116_XP_MN1 (XI746_I116_XP_n1 I746_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I116_XP_MN0 (I746_P20_17n I746_P20_19 XI746_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I175_XP_MN1 (XI746_I175_XP_n1 I746_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I175_XP_MN0 (I746_P24_9n I746_P24_17 XI746_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I171_XP_MN1 (XI746_I171_XP_n1 I746_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I171_XP_MN0 (I746_P20_5n I746_P20_13 XI746_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I169_XP_MN1 (XI746_I169_XP_n1 I746_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I169_XP_MN0 (I746_P18_3n I746_P18_11 XI746_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I21_MN1 (XI792_I21_n1 b5_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I21_MN0 (I792_gn21 p4_20 XI792_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I20_MN1 (XI792_I20_n1 b5_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I20_MN0 (I792_gn20 p4_19 XI792_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I115_XP_MN1 (XI792_I115_XP_n1 I792_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I115_XP_MN0 (I792_P19_16n I792_P19_18 XI792_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I116_XP_MN1 (XI792_I116_XP_n1 I792_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I116_XP_MN0 (I792_P20_17n I792_P20_19 XI792_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I171_XP_MN1 (XI792_I171_XP_n1 I792_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I171_XP_MN0 (I792_P20_5n I792_P20_13 XI792_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I175_XP_MN1 (XI792_I175_XP_n1 I792_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I175_XP_MN0 (I792_P24_9n I792_P24_17 XI792_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I14_MN1 (XI838_I14_n1 b6_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I14_MN0 (I838_gn14 p5_13 XI838_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I113_XP_MN1 (XI838_I113_XP_n1 I838_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I113_XP_MN0 (I838_P17_14n I838_P17_16 XI838_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I180_XP_MN1 (XI838_I180_XP_n1 I838_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I180_XP_MN0 (I838_P29_14n I838_P29_22 XI838_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I114_XP_MN1 (XI838_I114_XP_n1 I838_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I114_XP_MN0 (I838_P18_15n I838_P18_17 XI838_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I116_XP_MN1 (XI838_I116_XP_n1 I838_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I116_XP_MN0 (I838_P20_17n I838_P20_19 XI838_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I15_MN1 (XI884_I15_n1 b7_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I15_MN0 (I884_gn15 p6_14 XI884_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I16_MN1 (XI884_I16_n1 b7_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I16_MN0 (I884_gn16 p6_15 XI884_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I114_XP_MN1 (XI884_I114_XP_n1 I884_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I114_XP_MN0 (I884_P18_15n I884_P18_17 XI884_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I171_XP_MN1 (XI884_I171_XP_n1 I884_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I171_XP_MN0 (I884_P20_5n I884_P20_13 XI884_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I111_XP_MN1 (XI884_I111_XP_n1 I884_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I111_XP_MN0 (I884_P15_12n I884_P15_14 XI884_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I113_XP_MN1 (XI884_I113_XP_n1 I884_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I113_XP_MN0 (I884_P17_14n I884_P17_16 XI884_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I172_XP_MN1 (XI884_I172_XP_n1 I884_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I172_XP_MN0 (I884_P21_6n I884_P21_14 XI884_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I173_XP_MN1 (XI1712_I173_XP_n1 I1712_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I173_XP_MN0 (I1712_P22_7n I1712_P22_15 XI1712_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I179_XP_MN1 (XI1712_I179_XP_n1 I1712_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I179_XP_MN0 (I1712_P28_13n I1712_P28_21 XI1712_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I12_MN1 (XI1712_I12_n1 b25_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I12_MN0 (I1712_gn12 p24_11 XI1712_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I13_MN1 (XI1712_I13_n1 b25_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I13_MN0 (I1712_gn13 p24_12 XI1712_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I109_XP_MN1 (XI1712_I109_XP_n1 I1712_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I109_XP_MN0 (I1712_P13_10n I1712_P13_12 XI1712_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I176_XP_MN1 (XI1712_I176_XP_n1 I1712_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I176_XP_MN0 (I1712_P25_10n I1712_P25_18 XI1712_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I170_XP_MN1 (XI1712_I170_XP_n1 I1712_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I170_XP_MN0 (I1712_P19_4n I1712_P19_12 XI1712_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I14_MN1 (XI1758_I14_n1 b26_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I14_MN0 (I1758_gn14 p25_13 XI1758_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I13_MN1 (XI1758_I13_n1 b26_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I13_MN0 (I1758_gn13 p25_12 XI1758_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I112_XP_MN1 (XI1758_I112_XP_n1 I1758_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I112_XP_MN0 (I1758_P16_13n I1758_P16_15 XI1758_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I177_XP_MN1 (XI1758_I177_XP_n1 I1758_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I177_XP_MN0 (I1758_P26_11n I1758_P26_19 XI1758_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I111_XP_MN1 (XI1758_I111_XP_n1 I1758_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I111_XP_MN0 (I1758_P15_12n I1758_P15_14 XI1758_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I113_XP_MN1 (XI1758_I113_XP_n1 I1758_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I113_XP_MN0 (I1758_P17_14n I1758_P17_16 XI1758_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I172_XP_MN1 (XI1758_I172_XP_n1 I1758_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I172_XP_MN0 (I1758_P21_6n I1758_P21_14 XI1758_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I170_XP_MN1 (XI1758_I170_XP_n1 I1758_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I170_XP_MN0 (I1758_P19_4n I1758_P19_12 XI1758_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I15_MN1 (XI1804_I15_n1 b27_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I15_MN0 (I1804_gn15 p26_14 XI1804_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I14_MN1 (XI1804_I14_n1 b27_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I14_MN0 (I1804_gn14 p26_13 XI1804_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I111_XP_MN1 (XI1804_I111_XP_n1 I1804_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I111_XP_MN0 (I1804_P15_12n I1804_P15_14 XI1804_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I113_XP_MN1 (XI1804_I113_XP_n1 I1804_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I113_XP_MN0 (I1804_P17_14n I1804_P17_16 XI1804_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I176_XP_MN1 (XI1804_I176_XP_n1 I1804_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I176_XP_MN0 (I1804_P25_10n I1804_P25_18 XI1804_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I172_XP_MN1 (XI1804_I172_XP_n1 I1804_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I172_XP_MN0 (I1804_P21_6n I1804_P21_14 XI1804_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I118_XP_MN1 (XI1804_I118_XP_n1 I1804_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I118_XP_MN0 (I1804_P22_19n I1804_P22_21 XI1804_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I127_XP_MN1 (XI746_I127_XP_n1 I746_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I127_XP_MN0 (I746_P31_28n I746_P31_30 XI746_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I125_XP_MN1 (XI746_I125_XP_n1 I746_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I125_XP_MN0 (I746_P29_26n I746_P29_28 XI746_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I26_MN1 (XI746_I26_n1 b4_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I26_MN0 (I746_gn26 p3_25 XI746_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I124_XP_MN1 (XI746_I124_XP_n1 I746_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I124_XP_MN0 (I746_P28_25n I746_P28_27 XI746_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I179_XP_MN1 (XI746_I179_XP_n1 I746_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I179_XP_MN0 (I746_P28_13n I746_P28_21 XI746_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I173_XP_MN1 (XI746_I173_XP_n1 I746_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I173_XP_MN0 (I746_P22_7n I746_P22_15 XI746_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I25_MN1 (XI792_I25_n1 b5_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I25_MN0 (I792_gn25 p4_24 XI792_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I23_MN1 (XI792_I23_n1 b5_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I23_MN0 (I792_gn23 p4_22 XI792_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I22_MN1 (XI792_I22_n1 b5_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I22_MN0 (I792_gn22 p4_21 XI792_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I117_XP_MN1 (XI792_I117_XP_n1 I792_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I117_XP_MN0 (I792_P21_18n I792_P21_20 XI792_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I172_XP_MN1 (XI792_I172_XP_n1 I792_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I172_XP_MN0 (I792_P21_6n I792_P21_14 XI792_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I176_XP_MN1 (XI792_I176_XP_n1 I792_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I176_XP_MN0 (I792_P25_10n I792_P25_18 XI792_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I179_XP_MN1 (XI792_I179_XP_n1 I792_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I179_XP_MN0 (I792_P28_13n I792_P28_21 XI792_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I15_MN1 (XI838_I15_n1 b6_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I15_MN0 (I838_gn15 p5_14 XI838_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I16_MN1 (XI838_I16_n1 b6_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I16_MN0 (I838_gn16 p5_15 XI838_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I115_XP_MN1 (XI838_I115_XP_n1 I838_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I115_XP_MN0 (I838_P19_16n I838_P19_18 XI838_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I178_XP_MN1 (XI838_I178_XP_n1 I838_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I178_XP_MN0 (I838_P27_12n I838_P27_20 XI838_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I117_XP_MN1 (XI838_I117_XP_n1 I838_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I117_XP_MN0 (I838_P21_18n I838_P21_20 XI838_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I18_MN1 (XI838_I18_n1 b6_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I18_MN0 (I838_gn18 p5_17 XI838_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I179_XP_MN1 (XI838_I179_XP_n1 I838_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I179_XP_MN0 (I838_P28_13n I838_P28_21 XI838_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I173_XP_MN1 (XI838_I173_XP_n1 I838_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I173_XP_MN0 (I838_P22_7n I838_P22_15 XI838_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I116_XP_MN1 (XI884_I116_XP_n1 I884_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I116_XP_MN0 (I884_P20_17n I884_P20_19 XI884_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I173_XP_MN1 (XI884_I173_XP_n1 I884_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I173_XP_MN0 (I884_P22_7n I884_P22_15 XI884_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I115_XP_MN1 (XI884_I115_XP_n1 I884_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I115_XP_MN0 (I884_P19_16n I884_P19_18 XI884_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I177_XP_MN1 (XI1712_I177_XP_n1 I1712_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I177_XP_MN0 (I1712_P26_11n I1712_P26_19 XI1712_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I114_XP_MN1 (XI1712_I114_XP_n1 I1712_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I114_XP_MN0 (I1712_P18_15n I1712_P18_17 XI1712_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I14_MN1 (XI1712_I14_n1 b25_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I14_MN0 (I1712_gn14 p24_13 XI1712_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I15_MN1 (XI1712_I15_n1 b25_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I15_MN0 (I1712_gn15 p24_14 XI1712_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I113_XP_MN1 (XI1712_I113_XP_n1 I1712_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I113_XP_MN0 (I1712_P17_14n I1712_P17_16 XI1712_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I111_XP_MN1 (XI1712_I111_XP_n1 I1712_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I111_XP_MN0 (I1712_P15_12n I1712_P15_14 XI1712_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I172_XP_MN1 (XI1712_I172_XP_n1 I1712_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I172_XP_MN0 (I1712_P21_6n I1712_P21_14 XI1712_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I16_MN1 (XI1758_I16_n1 b26_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I16_MN0 (I1758_gn16 p25_15 XI1758_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I15_MN1 (XI1758_I15_n1 b26_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I15_MN0 (I1758_gn15 p25_14 XI1758_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I114_XP_MN1 (XI1758_I114_XP_n1 I1758_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I114_XP_MN0 (I1758_P18_15n I1758_P18_17 XI1758_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I116_XP_MN1 (XI1758_I116_XP_n1 I1758_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I116_XP_MN0 (I1758_P20_17n I1758_P20_19 XI1758_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I179_XP_MN1 (XI1758_I179_XP_n1 I1758_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I179_XP_MN0 (I1758_P28_13n I1758_P28_21 XI1758_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I115_XP_MN1 (XI1758_I115_XP_n1 I1758_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I115_XP_MN0 (I1758_P19_16n I1758_P19_18 XI1758_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I16_MN1 (XI1804_I16_n1 b27_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I16_MN0 (I1804_gn16 p26_15 XI1804_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I17_MN1 (XI1804_I17_n1 b27_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I17_MN0 (I1804_gn17 p26_16 XI1804_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I178_XP_MN1 (XI1804_I178_XP_n1 I1804_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I178_XP_MN0 (I1804_P27_12n I1804_P27_20 XI1804_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I115_XP_MN1 (XI1804_I115_XP_n1 I1804_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I115_XP_MN0 (I1804_P19_16n I1804_P19_18 XI1804_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I120_XP_MN1 (XI1804_I120_XP_n1 I1804_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I120_XP_MN0 (I1804_P24_21n I1804_P24_23 XI1804_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I122_XP_MN1 (XI1804_I122_XP_n1 I1804_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I122_XP_MN0 (I1804_P26_23n I1804_P26_25 XI1804_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I31_MN1 (XI746_I31_n1 b4_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I31_MN0 (I746_gn31 p3_30 XI746_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I27_MN1 (XI746_I27_n1 b4_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I27_MN0 (I746_gn27 p3_26 XI746_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I122_XP_MN1 (XI746_I122_XP_n1 I746_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I122_XP_MN0 (I746_P26_23n I746_P26_25 XI746_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I177_XP_MN1 (XI746_I177_XP_n1 I746_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I177_XP_MN0 (I746_P26_11n I746_P26_19 XI746_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I24_MN1 (XI792_I24_n1 b5_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I24_MN0 (I792_gn24 p4_23 XI792_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I121_XP_MN1 (XI792_I121_XP_n1 I792_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I121_XP_MN0 (I792_P25_22n I792_P25_24 XI792_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I119_XP_MN1 (XI792_I119_XP_n1 I792_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I119_XP_MN0 (I792_P23_20n I792_P23_22 XI792_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I180_XP_MN1 (XI792_I180_XP_n1 I792_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I180_XP_MN0 (I792_P29_14n I792_P29_22 XI792_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I120_XP_MN1 (XI792_I120_XP_n1 I792_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I120_XP_MN0 (I792_P24_21n I792_P24_23 XI792_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I118_XP_MN1 (XI792_I118_XP_n1 I792_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I118_XP_MN0 (I792_P22_19n I792_P22_21 XI792_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I173_XP_MN1 (XI792_I173_XP_n1 I792_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I173_XP_MN0 (I792_P22_7n I792_P22_15 XI792_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I17_MN1 (XI838_I17_n1 b6_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I17_MN0 (I838_gn17 p5_16 XI838_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I182_XP_MN1 (XI838_I182_XP_n1 I838_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I182_XP_MN0 (I838_P31_16n I838_P31_24 XI838_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I174_XP_MN1 (XI838_I174_XP_n1 I838_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I174_XP_MN0 (I838_P23_8n I838_P23_16 XI838_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I19_MN1 (XI838_I19_n1 b6_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I19_MN0 (I838_gn19 p5_18 XI838_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I118_XP_MN1 (XI838_I118_XP_n1 I838_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I118_XP_MN0 (I838_P22_19n I838_P22_21 XI838_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I17_MN1 (XI884_I17_n1 b7_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I17_MN0 (I884_gn17 p6_16 XI884_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I18_MN1 (XI884_I18_n1 b7_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I18_MN0 (I884_gn18 p6_17 XI884_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I118_XP_MN1 (XI884_I118_XP_n1 I884_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I118_XP_MN0 (I884_P22_19n I884_P22_21 XI884_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I179_XP_MN1 (XI884_I179_XP_n1 I884_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I179_XP_MN0 (I884_P28_13n I884_P28_21 XI884_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I117_XP_MN1 (XI884_I117_XP_n1 I884_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I117_XP_MN0 (I884_P21_18n I884_P21_20 XI884_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I170_XP_MN1 (XI884_I170_XP_n1 I884_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I170_XP_MN0 (I884_P19_4n I884_P19_12 XI884_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I116_XP_MN1 (XI1712_I116_XP_n1 I1712_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I116_XP_MN0 (I1712_P20_17n I1712_P20_19 XI1712_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I16_MN1 (XI1712_I16_n1 b25_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I16_MN0 (I1712_gn16 p24_15 XI1712_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I178_XP_MN1 (XI1712_I178_XP_n1 I1712_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I178_XP_MN0 (I1712_P27_12n I1712_P27_20 XI1712_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I17_MN1 (XI1758_I17_n1 b26_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I17_MN0 (I1758_gn17 p25_16 XI1758_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I18_MN1 (XI1758_I18_n1 b26_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I18_MN0 (I1758_gn18 p25_17 XI1758_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I118_XP_MN1 (XI1758_I118_XP_n1 I1758_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I118_XP_MN0 (I1758_P22_19n I1758_P22_21 XI1758_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I173_XP_MN1 (XI1758_I173_XP_n1 I1758_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I173_XP_MN0 (I1758_P22_7n I1758_P22_15 XI1758_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I117_XP_MN1 (XI1758_I117_XP_n1 I1758_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I117_XP_MN0 (I1758_P21_18n I1758_P21_20 XI1758_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I178_XP_MN1 (XI1758_I178_XP_n1 I1758_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I178_XP_MN0 (I1758_P27_12n I1758_P27_20 XI1758_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I19_MN1 (XI1804_I19_n1 b27_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I19_MN0 (I1804_gn19 p26_18 XI1804_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I18_MN1 (XI1804_I18_n1 b27_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I18_MN0 (I1804_gn18 p26_17 XI1804_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I20_MN1 (XI1804_I20_n1 b27_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I20_MN0 (I1804_gn20 p26_19 XI1804_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I174_XP_MN1 (XI1804_I174_XP_n1 I1804_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I174_XP_MN0 (I1804_P23_8n I1804_P23_16 XI1804_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I117_XP_MN1 (XI1804_I117_XP_n1 I1804_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I117_XP_MN0 (I1804_P21_18n I1804_P21_20 XI1804_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I180_XP_MN1 (XI1804_I180_XP_n1 I1804_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I180_XP_MN0 (I1804_P29_14n I1804_P29_22 XI1804_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I124_XP_MN1 (XI1804_I124_XP_n1 I1804_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I124_XP_MN0 (I1804_P28_25n I1804_P28_27 XI1804_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I126_XP_MN1 (XI1804_I126_XP_n1 I1804_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I126_XP_MN0 (I1804_P30_27n I1804_P30_29 XI1804_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I30_MN1 (XI746_I30_n1 b4_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I30_MN0 (I746_gn30 p3_29 XI746_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I28_MN1 (XI746_I28_n1 b4_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I28_MN0 (I746_gn28 p3_27 XI746_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I126_XP_MN1 (XI746_I126_XP_n1 I746_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I126_XP_MN0 (I746_P30_27n I746_P30_29 XI746_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I181_XP_MN1 (XI746_I181_XP_n1 I746_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I181_XP_MN0 (I746_P30_15n I746_P30_23 XI746_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I27_MN1 (XI792_I27_n1 b5_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I27_MN0 (I792_gn27 p4_26 XI792_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I26_MN1 (XI792_I26_n1 b5_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I26_MN0 (I792_gn26 p4_25 XI792_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I123_XP_MN1 (XI792_I123_XP_n1 I792_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I123_XP_MN0 (I792_P27_24n I792_P27_26 XI792_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I178_XP_MN1 (XI792_I178_XP_n1 I792_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I178_XP_MN0 (I792_P27_12n I792_P27_20 XI792_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I122_XP_MN1 (XI792_I122_XP_n1 I792_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I122_XP_MN0 (I792_P26_23n I792_P26_25 XI792_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I124_XP_MN1 (XI792_I124_XP_n1 I792_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I124_XP_MN0 (I792_P28_25n I792_P28_27 XI792_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I181_XP_MN1 (XI792_I181_XP_n1 I792_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I181_XP_MN0 (I792_P30_15n I792_P30_23 XI792_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I177_XP_MN1 (XI792_I177_XP_n1 I792_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I177_XP_MN0 (I792_P26_11n I792_P26_19 XI792_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I121_XP_MN1 (XI838_I121_XP_n1 I838_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I121_XP_MN0 (I838_P25_22n I838_P25_24 XI838_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I119_XP_MN1 (XI838_I119_XP_n1 I838_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I119_XP_MN0 (I838_P23_20n I838_P23_22 XI838_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I20_MN1 (XI838_I20_n1 b6_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I20_MN0 (I838_gn20 p5_19 XI838_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I21_MN1 (XI838_I21_n1 b6_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I21_MN0 (I838_gn21 p5_20 XI838_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I120_XP_MN1 (XI838_I120_XP_n1 I838_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I120_XP_MN0 (I838_P24_21n I838_P24_23 XI838_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I181_XP_MN1 (XI838_I181_XP_n1 I838_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I181_XP_MN0 (I838_P30_15n I838_P30_23 XI838_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I19_MN1 (XI884_I19_n1 b7_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I19_MN0 (I884_gn19 p6_18 XI884_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I21_MN1 (XI884_I21_n1 b7_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I21_MN0 (I884_gn21 p6_20 XI884_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I20_MN1 (XI884_I20_n1 b7_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I20_MN0 (I884_gn20 p6_19 XI884_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I181_XP_MN1 (XI884_I181_XP_n1 I884_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I181_XP_MN0 (I884_P30_15n I884_P30_23 XI884_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I120_XP_MN1 (XI884_I120_XP_n1 I884_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I120_XP_MN0 (I884_P24_21n I884_P24_23 XI884_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I119_XP_MN1 (XI884_I119_XP_n1 I884_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I119_XP_MN0 (I884_P23_20n I884_P23_22 XI884_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I180_XP_MN1 (XI884_I180_XP_n1 I884_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I180_XP_MN0 (I884_P29_14n I884_P29_22 XI884_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I178_XP_MN1 (XI884_I178_XP_n1 I884_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I178_XP_MN0 (I884_P27_12n I884_P27_20 XI884_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I181_XP_MN1 (XI1712_I181_XP_n1 I1712_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I181_XP_MN0 (I1712_P30_15n I1712_P30_23 XI1712_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I120_XP_MN1 (XI1712_I120_XP_n1 I1712_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I120_XP_MN0 (I1712_P24_21n I1712_P24_23 XI1712_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I118_XP_MN1 (XI1712_I118_XP_n1 I1712_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I118_XP_MN0 (I1712_P22_19n I1712_P22_21 XI1712_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I17_MN1 (XI1712_I17_n1 b25_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I17_MN0 (I1712_gn17 p24_16 XI1712_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I117_XP_MN1 (XI1712_I117_XP_n1 I1712_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I117_XP_MN0 (I1712_P21_18n I1712_P21_20 XI1712_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I115_XP_MN1 (XI1712_I115_XP_n1 I1712_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I115_XP_MN0 (I1712_P19_16n I1712_P19_18 XI1712_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I180_XP_MN1 (XI1712_I180_XP_n1 I1712_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I180_XP_MN0 (I1712_P29_14n I1712_P29_22 XI1712_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I174_XP_MN1 (XI1712_I174_XP_n1 I1712_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I174_XP_MN0 (I1712_P23_8n I1712_P23_16 XI1712_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I20_MN1 (XI1758_I20_n1 b26_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I20_MN0 (I1758_gn20 p25_19 XI1758_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I19_MN1 (XI1758_I19_n1 b26_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I19_MN0 (I1758_gn19 p25_18 XI1758_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I120_XP_MN1 (XI1758_I120_XP_n1 I1758_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I120_XP_MN0 (I1758_P24_21n I1758_P24_23 XI1758_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I181_XP_MN1 (XI1758_I181_XP_n1 I1758_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I181_XP_MN0 (I1758_P30_15n I1758_P30_23 XI1758_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I119_XP_MN1 (XI1758_I119_XP_n1 I1758_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I119_XP_MN0 (I1758_P23_20n I1758_P23_22 XI1758_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I180_XP_MN1 (XI1758_I180_XP_n1 I1758_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I180_XP_MN0 (I1758_P29_14n I1758_P29_22 XI1758_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I174_XP_MN1 (XI1758_I174_XP_n1 I1758_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I174_XP_MN0 (I1758_P23_8n I1758_P23_16 XI1758_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I21_MN1 (XI1804_I21_n1 b27_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I21_MN0 (I1804_gn21 p26_20 XI1804_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I119_XP_MN1 (XI1804_I119_XP_n1 I1804_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I119_XP_MN0 (I1804_P23_20n I1804_P23_22 XI1804_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I121_XP_MN1 (XI1804_I121_XP_n1 I1804_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I121_XP_MN0 (I1804_P25_22n I1804_P25_24 XI1804_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I123_XP_MN1 (XI1804_I123_XP_n1 I1804_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I123_XP_MN0 (I1804_P27_24n I1804_P27_26 XI1804_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I125_XP_MN1 (XI1804_I125_XP_n1 I1804_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I125_XP_MN0 (I1804_P29_26n I1804_P29_28 XI1804_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I29_MN1 (XI746_I29_n1 b4_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I29_MN0 (I746_gn29 p3_28 XI746_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I31_MN1 (XI792_I31_n1 b5_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I31_MN0 (I792_gn31 p4_30 XI792_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I30_MN1 (XI792_I30_n1 b5_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I30_MN0 (I792_gn30 p4_29 XI792_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I28_MN1 (XI792_I28_n1 b5_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I28_MN0 (I792_gn28 p4_27 XI792_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I127_XP_MN1 (XI792_I127_XP_n1 I792_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I127_XP_MN0 (I792_P31_28n I792_P31_30 XI792_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I125_XP_MN1 (XI792_I125_XP_n1 I792_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I125_XP_MN0 (I792_P29_26n I792_P29_28 XI792_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I182_XP_MN1 (XI792_I182_XP_n1 I792_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I182_XP_MN0 (I792_P31_16n I792_P31_24 XI792_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I174_XP_MN1 (XI792_I174_XP_n1 I792_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I174_XP_MN0 (I792_P23_8n I792_P23_16 XI792_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I126_XP_MN1 (XI792_I126_XP_n1 I792_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I126_XP_MN0 (I792_P30_27n I792_P30_29 XI792_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I127_XP_MN1 (XI838_I127_XP_n1 I838_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I127_XP_MN0 (I838_P31_28n I838_P31_30 XI838_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I27_MN1 (XI838_I27_n1 b6_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I27_MN0 (I838_gn27 p5_26 XI838_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I125_XP_MN1 (XI838_I125_XP_n1 I838_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I125_XP_MN0 (I838_P29_26n I838_P29_28 XI838_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I123_XP_MN1 (XI838_I123_XP_n1 I838_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I123_XP_MN0 (I838_P27_24n I838_P27_26 XI838_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I23_MN1 (XI838_I23_n1 b6_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I23_MN0 (I838_gn23 p5_22 XI838_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I22_MN1 (XI838_I22_n1 b6_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I22_MN0 (I838_gn22 p5_21 XI838_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I122_XP_MN1 (XI838_I122_XP_n1 I838_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I122_XP_MN0 (I838_P26_23n I838_P26_25 XI838_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I22_MN1 (XI884_I22_n1 b7_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I22_MN0 (I884_gn22 p6_21 XI884_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I23_MN1 (XI884_I23_n1 b7_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I23_MN0 (I884_gn23 p6_22 XI884_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I24_MN1 (XI884_I24_n1 b7_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I24_MN0 (I884_gn24 p6_23 XI884_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I122_XP_MN1 (XI884_I122_XP_n1 I884_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I122_XP_MN0 (I884_P26_23n I884_P26_25 XI884_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I124_XP_MN1 (XI884_I124_XP_n1 I884_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I124_XP_MN0 (I884_P28_25n I884_P28_27 XI884_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I121_XP_MN1 (XI884_I121_XP_n1 I884_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I121_XP_MN0 (I884_P25_22n I884_P25_24 XI884_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I122_XP_MN1 (XI1712_I122_XP_n1 I1712_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I122_XP_MN0 (I1712_P26_23n I1712_P26_25 XI1712_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I18_MN1 (XI1712_I18_n1 b25_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I18_MN0 (I1712_gn18 p24_17 XI1712_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I19_MN1 (XI1712_I19_n1 b25_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I19_MN0 (I1712_gn19 p24_18 XI1712_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I121_XP_MN1 (XI1712_I121_XP_n1 I1712_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I121_XP_MN0 (I1712_P25_22n I1712_P25_24 XI1712_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I119_XP_MN1 (XI1712_I119_XP_n1 I1712_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I119_XP_MN0 (I1712_P23_20n I1712_P23_22 XI1712_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I182_XP_MN1 (XI1712_I182_XP_n1 I1712_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I182_XP_MN0 (I1712_P31_16n I1712_P31_24 XI1712_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I22_MN1 (XI1758_I22_n1 b26_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I22_MN0 (I1758_gn22 p25_21 XI1758_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I21_MN1 (XI1758_I21_n1 b26_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I21_MN0 (I1758_gn21 p25_20 XI1758_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I23_MN1 (XI1758_I23_n1 b26_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I23_MN0 (I1758_gn23 p25_22 XI1758_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I122_XP_MN1 (XI1758_I122_XP_n1 I1758_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I122_XP_MN0 (I1758_P26_23n I1758_P26_25 XI1758_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I124_XP_MN1 (XI1758_I124_XP_n1 I1758_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I124_XP_MN0 (I1758_P28_25n I1758_P28_27 XI1758_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I126_XP_MN1 (XI1758_I126_XP_n1 I1758_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I126_XP_MN0 (I1758_P30_27n I1758_P30_29 XI1758_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I121_XP_MN1 (XI1758_I121_XP_n1 I1758_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I121_XP_MN0 (I1758_P25_22n I1758_P25_24 XI1758_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I125_XP_MN1 (XI1758_I125_XP_n1 I1758_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I125_XP_MN0 (I1758_P29_26n I1758_P29_28 XI1758_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I123_XP_MN1 (XI1758_I123_XP_n1 I1758_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I123_XP_MN0 (I1758_P27_24n I1758_P27_26 XI1758_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I182_XP_MN1 (XI1758_I182_XP_n1 I1758_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I182_XP_MN0 (I1758_P31_16n I1758_P31_24 XI1758_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I23_MN1 (XI1804_I23_n1 b27_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I23_MN0 (I1804_gn23 p26_22 XI1804_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I182_XP_MN1 (XI1804_I182_XP_n1 I1804_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I182_XP_MN0 (I1804_P31_16n I1804_P31_24 XI1804_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I127_XP_MN1 (XI1804_I127_XP_n1 I1804_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I127_XP_MN0 (I1804_P31_28n I1804_P31_30 XI1804_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I25_MN1 (XI1804_I25_n1 b27_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I25_MN0 (I1804_gn25 p26_24 XI1804_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I26_MN1 (XI1804_I26_n1 b27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I26_MN0 (I1804_gn26 p26_25 XI1804_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I29_MN1 (XI792_I29_n1 b5_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I29_MN0 (I792_gn29 p4_28 XI792_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I31_MN1 (XI838_I31_n1 b6_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I31_MN0 (I838_gn31 p5_30 XI838_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I30_MN1 (XI838_I30_n1 b6_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I30_MN0 (I838_gn30 p5_29 XI838_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I28_MN1 (XI838_I28_n1 b6_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I28_MN0 (I838_gn28 p5_27 XI838_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I26_MN1 (XI838_I26_n1 b6_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I26_MN0 (I838_gn26 p5_25 XI838_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I24_MN1 (XI838_I24_n1 b6_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I24_MN0 (I838_gn24 p5_23 XI838_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I25_MN1 (XI838_I25_n1 b6_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I25_MN0 (I838_gn25 p5_24 XI838_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I124_XP_MN1 (XI838_I124_XP_n1 I838_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I124_XP_MN0 (I838_P28_25n I838_P28_27 XI838_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I126_XP_MN1 (XI838_I126_XP_n1 I838_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I126_XP_MN0 (I838_P30_27n I838_P30_29 XI838_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I25_MN1 (XI884_I25_n1 b7_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I25_MN0 (I884_gn25 p6_24 XI884_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I26_MN1 (XI884_I26_n1 b7_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I26_MN0 (I884_gn26 p6_25 XI884_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I126_XP_MN1 (XI884_I126_XP_n1 I884_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I126_XP_MN0 (I884_P30_27n I884_P30_29 XI884_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I125_XP_MN1 (XI884_I125_XP_n1 I884_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I125_XP_MN0 (I884_P29_26n I884_P29_28 XI884_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I123_XP_MN1 (XI884_I123_XP_n1 I884_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I123_XP_MN0 (I884_P27_24n I884_P27_26 XI884_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I182_XP_MN1 (XI884_I182_XP_n1 I884_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I182_XP_MN0 (I884_P31_16n I884_P31_24 XI884_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I174_XP_MN1 (XI884_I174_XP_n1 I884_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I174_XP_MN0 (I884_P23_8n I884_P23_16 XI884_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I126_XP_MN1 (XI1712_I126_XP_n1 I1712_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I126_XP_MN0 (I1712_P30_27n I1712_P30_29 XI1712_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I124_XP_MN1 (XI1712_I124_XP_n1 I1712_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I124_XP_MN0 (I1712_P28_25n I1712_P28_27 XI1712_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I22_MN1 (XI1712_I22_n1 b25_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I22_MN0 (I1712_gn22 p24_21 XI1712_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I20_MN1 (XI1712_I20_n1 b25_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I20_MN0 (I1712_gn20 p24_19 XI1712_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I123_XP_MN1 (XI1712_I123_XP_n1 I1712_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I123_XP_MN0 (I1712_P27_24n I1712_P27_26 XI1712_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I125_XP_MN1 (XI1712_I125_XP_n1 I1712_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I125_XP_MN0 (I1712_P29_26n I1712_P29_28 XI1712_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I127_XP_MN1 (XI1712_I127_XP_n1 I1712_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I127_XP_MN0 (I1712_P31_28n I1712_P31_30 XI1712_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I25_MN1 (XI1758_I25_n1 b26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I25_MN0 (I1758_gn25 p25_24 XI1758_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I24_MN1 (XI1758_I24_n1 b26_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I24_MN0 (I1758_gn24 p25_23 XI1758_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I127_XP_MN1 (XI1758_I127_XP_n1 I1758_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I127_XP_MN0 (I1758_P31_28n I1758_P31_30 XI1758_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I22_MN1 (XI1804_I22_n1 b27_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I22_MN0 (I1804_gn22 p26_21 XI1804_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I24_MN1 (XI1804_I24_n1 b27_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I24_MN0 (I1804_gn24 p26_23 XI1804_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I29_MN1 (XI1804_I29_n1 b27_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I29_MN0 (I1804_gn29 p26_28 XI1804_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I28_MN1 (XI1804_I28_n1 b27_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I28_MN0 (I1804_gn28 p26_27 XI1804_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I27_MN1 (XI1804_I27_n1 b27_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I27_MN0 (I1804_gn27 p26_26 XI1804_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I180_XP_MN1 (XI1068_I180_XP_n1 I1068_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I180_XP_MN0 (I1068_P29_14n I1068_P29_22 XI1068_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I176_XP_MN1 (XI1068_I176_XP_n1 I1068_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I176_XP_MN0 (I1068_P25_10n I1068_P25_18 XI1068_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I172_XP_MN1 (XI1068_I172_XP_n1 I1068_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I172_XP_MN0 (I1068_P21_6n I1068_P21_14 XI1068_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I168_XP_MN1 (XI1068_I168_XP_n1 I1068_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I168_XP_MN0 (I1068_P17_2n I1068_P17_10 XI1068_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I105_XP_MN1 (XI1068_I105_XP_n1 I1068_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I105_XP_MN0 (I1068_P9_6n I1068_P9_8 XI1068_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I101_XP_MN1 (XI1068_I101_XP_n1 I1068_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I101_XP_MN0 (I1068_P5_2n I1068_P5_4 XI1068_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I5_MN1 (XI1068_I5_n1 b11_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I5_MN0 (I1068_gn5 p10_4 XI1068_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I4_MN1 (XI1068_I4_n1 b11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I4_MN0 (I1068_gn4 p10_3 XI1068_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I29_MN1 (XI838_I29_n1 b6_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I29_MN0 (I838_gn29 p5_28 XI838_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I30_MN1 (XI884_I30_n1 b7_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I30_MN0 (I884_gn30 p6_29 XI884_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I127_XP_MN1 (XI884_I127_XP_n1 I884_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I127_XP_MN0 (I884_P31_28n I884_P31_30 XI884_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I23_MN1 (XI1712_I23_n1 b25_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I23_MN0 (I1712_gn23 p24_22 XI1712_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I21_MN1 (XI1712_I21_n1 b25_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I21_MN0 (I1712_gn21 p24_20 XI1712_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I26_MN1 (XI1758_I26_n1 b26_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I26_MN0 (I1758_gn26 p25_25 XI1758_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I27_MN1 (XI1758_I27_n1 b26_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I27_MN0 (I1758_gn27 p25_26 XI1758_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I28_MN1 (XI1758_I28_n1 b26_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I28_MN0 (I1758_gn28 p25_27 XI1758_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I29_MN1 (XI1758_I29_n1 b26_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I29_MN0 (I1758_gn29 p25_28 XI1758_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I30_MN1 (XI1758_I30_n1 b26_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I30_MN0 (I1758_gn30 p25_29 XI1758_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I31_MN1 (XI1758_I31_n1 b26_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I31_MN0 (I1758_gn31 p25_30 XI1758_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I30_MN1 (XI1804_I30_n1 b27_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I30_MN0 (I1804_gn30 p26_29 XI1804_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I31_MN1 (XI1804_I31_n1 b27_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I31_MN0 (I1804_gn31 p26_30 XI1804_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I178_XP_MN1 (XI1068_I178_XP_n1 I1068_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I178_XP_MN0 (I1068_P27_12n I1068_P27_20 XI1068_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I174_XP_MN1 (XI1068_I174_XP_n1 I1068_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I174_XP_MN0 (I1068_P23_8n I1068_P23_16 XI1068_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I170_XP_MN1 (XI1068_I170_XP_n1 I1068_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I170_XP_MN0 (I1068_P19_4n I1068_P19_12 XI1068_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I107_XP_MN1 (XI1068_I107_XP_n1 I1068_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I107_XP_MN0 (I1068_P11_8n I1068_P11_10 XI1068_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I103_XP_MN1 (XI1068_I103_XP_n1 I1068_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I103_XP_MN0 (I1068_P7_4n I1068_P7_6 XI1068_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I6_MN1 (XI1068_I6_n1 b11_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I6_MN0 (I1068_gn6 p10_5 XI1068_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I3_MN1 (XI1068_I3_n1 b11_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I3_MN0 (I1068_gn3 p10_2 XI1068_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I0_MN1 (XI1022_I0_n1 b10_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I0_MN0 (I1022_gn0 aa21 XI1022_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I0_MN1 (XI976_I0_n1 b9_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I0_MN0 (I976_gn0 aa22 XI976_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I0_MN1 (XI930_I0_n1 b8_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I0_MN0 (I930_gn0 aa23 XI930_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I31_MN1 (XI884_I31_n1 b7_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I31_MN0 (I884_gn31 p6_30 XI884_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I29_MN1 (XI884_I29_n1 b7_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I29_MN0 (I884_gn29 p6_28 XI884_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I28_MN1 (XI884_I28_n1 b7_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I28_MN0 (I884_gn28 p6_27 XI884_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I27_MN1 (XI884_I27_n1 b7_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I27_MN0 (I884_gn27 p6_26 XI884_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I26_MN1 (XI1712_I26_n1 b25_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I26_MN0 (I1712_gn26 p24_25 XI1712_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I24_MN1 (XI1712_I24_n1 b25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I24_MN0 (I1712_gn24 p24_23 XI1712_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I27_MN1 (XI1712_I27_n1 b25_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I27_MN0 (I1712_gn27 p24_26 XI1712_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I28_MN1 (XI1712_I28_n1 b25_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I28_MN0 (I1712_gn28 p24_27 XI1712_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I29_MN1 (XI1712_I29_n1 b25_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I29_MN0 (I1712_gn29 p24_28 XI1712_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I31_MN1 (XI1712_I31_n1 b25_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I31_MN0 (I1712_gn31 p24_30 XI1712_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I30_MN1 (XI1712_I30_n1 b25_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I30_MN0 (I1712_gn30 p24_29 XI1712_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I0_MN1 (XI1666_I0_n1 b24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I0_MN0 (I1666_gn0 aa7 XI1666_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I0_MN1 (XI1620_I0_n1 b23_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I0_MN0 (I1620_gn0 aa8 XI1620_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I1_MN1 (XI1574_I1_n1 b22_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I1_MN0 (I1574_gn1 p21_0 XI1574_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I2_MN1 (XI1574_I2_n1 b22_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I2_MN0 (I1574_gn2 p21_1 XI1574_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I3_MN1 (XI1574_I3_n1 b22_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I3_MN0 (I1574_gn3 p21_2 XI1574_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I127_XP_MN1 (XI1068_I127_XP_n1 I1068_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I127_XP_MN0 (I1068_P31_28n I1068_P31_30 XI1068_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I125_XP_MN1 (XI1068_I125_XP_n1 I1068_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I125_XP_MN0 (I1068_P29_26n I1068_P29_28 XI1068_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I123_XP_MN1 (XI1068_I123_XP_n1 I1068_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I123_XP_MN0 (I1068_P27_24n I1068_P27_26 XI1068_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I121_XP_MN1 (XI1068_I121_XP_n1 I1068_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I121_XP_MN0 (I1068_P25_22n I1068_P25_24 XI1068_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I182_XP_MN1 (XI1068_I182_XP_n1 I1068_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I182_XP_MN0 (I1068_P31_16n I1068_P31_24 XI1068_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I115_XP_MN1 (XI1068_I115_XP_n1 I1068_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I115_XP_MN0 (I1068_P19_16n I1068_P19_18 XI1068_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I113_XP_MN1 (XI1068_I113_XP_n1 I1068_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I113_XP_MN0 (I1068_P17_14n I1068_P17_16 XI1068_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I111_XP_MN1 (XI1068_I111_XP_n1 I1068_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I111_XP_MN0 (I1068_P15_12n I1068_P15_14 XI1068_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I109_XP_MN1 (XI1068_I109_XP_n1 I1068_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I109_XP_MN0 (I1068_P13_10n I1068_P13_12 XI1068_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I8_MN1 (XI1068_I8_n1 b11_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I8_MN0 (I1068_gn8 p10_7 XI1068_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I1_MN1 (XI1068_I1_n1 b11_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I1_MN0 (I1068_gn1 p10_0 XI1068_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I2_MN1 (XI1068_I2_n1 b11_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I2_MN0 (I1068_gn2 p10_1 XI1068_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I1_MN1 (XI1022_I1_n1 b10_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I1_MN0 (I1022_gn1 p9_0 XI1022_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I2_MN1 (XI1022_I2_n1 b10_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I2_MN0 (I1022_gn2 p9_1 XI1022_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I1_MN1 (XI976_I1_n1 b9_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I1_MN0 (I976_gn1 p8_0 XI976_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I1_MN1 (XI930_I1_n1 b8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I1_MN0 (I930_gn1 p7_0 XI930_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I2_MN1 (XI930_I2_n1 b8_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I2_MN0 (I930_gn2 p7_1 XI930_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I3_MN1 (XI930_I3_n1 b8_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I3_MN0 (I930_gn3 p7_2 XI930_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I4_MN1 (XI930_I4_n1 b8_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I4_MN0 (I930_gn4 p7_3 XI930_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I5_MN1 (XI930_I5_n1 b8_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I5_MN0 (I930_gn5 p7_4 XI930_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I7_MN1 (XI930_I7_n1 b8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I7_MN0 (I930_gn7 p7_6 XI930_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I25_MN1 (XI1712_I25_n1 b25_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I25_MN0 (I1712_gn25 p24_24 XI1712_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I1_MN1 (XI1666_I1_n1 b24_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I1_MN0 (I1666_gn1 p23_0 XI1666_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I2_MN1 (XI1666_I2_n1 b24_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I2_MN0 (I1666_gn2 p23_1 XI1666_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I3_MN1 (XI1666_I3_n1 b24_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I3_MN0 (I1666_gn3 p23_2 XI1666_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I2_MN1 (XI1620_I2_n1 b23_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I2_MN0 (I1620_gn2 p22_1 XI1620_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I4_MN1 (XI1620_I4_n1 b23_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I4_MN0 (I1620_gn4 p22_3 XI1620_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I0_MN1 (XI1574_I0_n1 b22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I0_MN0 (I1574_gn0 aa9 XI1574_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I4_MN1 (XI1574_I4_n1 b22_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I4_MN0 (I1574_gn4 p21_3 XI1574_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I5_MN1 (XI1574_I5_n1 b22_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I5_MN0 (I1574_gn5 p21_4 XI1574_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I100_XP_MN1 (XI1574_I100_XP_n1 I1574_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I100_XP_MN0 (I1574_P4_1n I1574_P4_3 XI1574_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I27_MN1 (XI1068_I27_n1 b11_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I27_MN0 (I1068_gn27 p10_26 XI1068_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I119_XP_MN1 (XI1068_I119_XP_n1 I1068_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I119_XP_MN0 (I1068_P23_20n I1068_P23_22 XI1068_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I117_XP_MN1 (XI1068_I117_XP_n1 I1068_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I117_XP_MN0 (I1068_P21_18n I1068_P21_20 XI1068_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I177_XP_MN1 (XI1068_I177_XP_n1 I1068_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I177_XP_MN0 (I1068_P26_11n I1068_P26_19 XI1068_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I169_XP_MN1 (XI1068_I169_XP_n1 I1068_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I169_XP_MN0 (I1068_P18_3n I1068_P18_11 XI1068_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I106_XP_MN1 (XI1068_I106_XP_n1 I1068_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I106_XP_MN0 (I1068_P10_7n I1068_P10_9 XI1068_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I104_XP_MN1 (XI1068_I104_XP_n1 I1068_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I104_XP_MN0 (I1068_P8_5n I1068_P8_7 XI1068_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I102_XP_MN1 (XI1068_I102_XP_n1 I1068_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I102_XP_MN0 (I1068_P6_3n I1068_P6_5 XI1068_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I7_MN1 (XI1068_I7_n1 b11_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I7_MN0 (I1068_gn7 p10_6 XI1068_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I100_XP_MN1 (XI1068_I100_XP_n1 I1068_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I100_XP_MN0 (I1068_P4_1n I1068_P4_3 XI1068_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I6_MN1 (XI1022_I6_n1 b10_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I6_MN0 (I1022_gn6 p9_5 XI1022_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I4_MN1 (XI1022_I4_n1 b10_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I4_MN0 (I1022_gn4 p9_3 XI1022_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I3_MN1 (XI1022_I3_n1 b10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I3_MN0 (I1022_gn3 p9_2 XI1022_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I2_MN1 (XI976_I2_n1 b9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I2_MN0 (I976_gn2 p8_1 XI976_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I3_MN1 (XI976_I3_n1 b9_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I3_MN0 (I976_gn3 p8_2 XI976_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I4_MN1 (XI976_I4_n1 b9_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I4_MN0 (I976_gn4 p8_3 XI976_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I5_MN1 (XI976_I5_n1 b9_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I5_MN0 (I976_gn5 p8_4 XI976_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I6_MN1 (XI930_I6_n1 b8_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I6_MN0 (I930_gn6 p7_5 XI930_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I8_MN1 (XI930_I8_n1 b8_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I8_MN0 (I930_gn8 p7_7 XI930_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I101_XP_MN1 (XI930_I101_XP_n1 I930_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I101_XP_MN0 (I930_P5_2n I930_P5_4 XI930_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I102_XP_MN1 (XI1666_I102_XP_n1 I1666_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I102_XP_MN0 (I1666_P6_3n I1666_P6_5 XI1666_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I100_XP_MN1 (XI1666_I100_XP_n1 I1666_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I100_XP_MN0 (I1666_P4_1n I1666_P4_3 XI1666_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I101_XP_MN1 (XI1666_I101_XP_n1 I1666_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I101_XP_MN0 (I1666_P5_2n I1666_P5_4 XI1666_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I5_MN1 (XI1666_I5_n1 b24_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I5_MN0 (I1666_gn5 p23_4 XI1666_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I4_MN1 (XI1666_I4_n1 b24_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I4_MN0 (I1666_gn4 p23_3 XI1666_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I101_XP_MN1 (XI1620_I101_XP_n1 I1620_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I101_XP_MN0 (I1620_P5_2n I1620_P5_4 XI1620_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I1_MN1 (XI1620_I1_n1 b23_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I1_MN0 (I1620_gn1 p22_0 XI1620_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I3_MN1 (XI1620_I3_n1 b23_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I3_MN0 (I1620_gn3 p22_2 XI1620_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I5_MN1 (XI1620_I5_n1 b23_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I5_MN0 (I1620_gn5 p22_4 XI1620_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I6_MN1 (XI1620_I6_n1 b23_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I6_MN0 (I1620_gn6 p22_5 XI1620_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I102_XP_MN1 (XI1574_I102_XP_n1 I1574_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I102_XP_MN0 (I1574_P6_3n I1574_P6_5 XI1574_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I104_XP_MN1 (XI1574_I104_XP_n1 I1574_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I104_XP_MN0 (I1574_P8_5n I1574_P8_7 XI1574_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I167_XP_MN1 (XI1574_I167_XP_n1 I1574_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I167_XP_MN0 (I1574_P16_1n I1574_P16_9 XI1574_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I26_MN1 (XI1068_I26_n1 b11_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I26_MN0 (I1068_gn26 p10_25 XI1068_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I181_XP_MN1 (XI1068_I181_XP_n1 I1068_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I181_XP_MN0 (I1068_P30_15n I1068_P30_23 XI1068_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I173_XP_MN1 (XI1068_I173_XP_n1 I1068_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I173_XP_MN0 (I1068_P22_7n I1068_P22_15 XI1068_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I108_XP_MN1 (XI1068_I108_XP_n1 I1068_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I108_XP_MN0 (I1068_P12_9n I1068_P12_11 XI1068_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I101_XP_MN1 (XI1022_I101_XP_n1 I1022_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I101_XP_MN0 (I1022_P5_2n I1022_P5_4 XI1022_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I103_XP_MN1 (XI1022_I103_XP_n1 I1022_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I103_XP_MN0 (I1022_P7_4n I1022_P7_6 XI1022_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I100_XP_MN1 (XI1022_I100_XP_n1 I1022_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I100_XP_MN0 (I1022_P4_1n I1022_P4_3 XI1022_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I102_XP_MN1 (XI1022_I102_XP_n1 I1022_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I102_XP_MN0 (I1022_P6_3n I1022_P6_5 XI1022_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I5_MN1 (XI1022_I5_n1 b10_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I5_MN0 (I1022_gn5 p9_4 XI1022_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I100_XP_MN1 (XI976_I100_XP_n1 I976_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I100_XP_MN0 (I976_P4_1n I976_P4_3 XI976_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I6_MN1 (XI976_I6_n1 b9_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I6_MN0 (I976_gn6 p8_5 XI976_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I7_MN1 (XI976_I7_n1 b9_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I7_MN0 (I976_gn7 p8_6 XI976_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I100_XP_MN1 (XI930_I100_XP_n1 I930_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I100_XP_MN0 (I930_P4_1n I930_P4_3 XI930_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I102_XP_MN1 (XI930_I102_XP_n1 I930_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I102_XP_MN0 (I930_P6_3n I930_P6_5 XI930_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I104_XP_MN1 (XI930_I104_XP_n1 I930_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I104_XP_MN0 (I930_P8_5n I930_P8_7 XI930_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I10_MN1 (XI930_I10_n1 b8_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I10_MN0 (I930_gn10 p7_9 XI930_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I9_MN1 (XI930_I9_n1 b8_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I9_MN0 (I930_gn9 p7_8 XI930_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I103_XP_MN1 (XI930_I103_XP_n1 I930_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I103_XP_MN0 (I930_P7_4n I930_P7_6 XI930_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I175_XP_MN1 (XI1666_I175_XP_n1 I1666_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I175_XP_MN0 (I1666_P24_9n I1666_P24_17 XI1666_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I167_XP_MN1 (XI1666_I167_XP_n1 I1666_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I167_XP_MN0 (I1666_P16_1n I1666_P16_9 XI1666_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I104_XP_MN1 (XI1666_I104_XP_n1 I1666_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I104_XP_MN0 (I1666_P8_5n I1666_P8_7 XI1666_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I103_XP_MN1 (XI1666_I103_XP_n1 I1666_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I103_XP_MN0 (I1666_P7_4n I1666_P7_6 XI1666_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I7_MN1 (XI1666_I7_n1 b24_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I7_MN0 (I1666_gn7 p23_6 XI1666_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I6_MN1 (XI1666_I6_n1 b24_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I6_MN0 (I1666_gn6 p23_5 XI1666_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I103_XP_MN1 (XI1620_I103_XP_n1 I1620_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I103_XP_MN0 (I1620_P7_4n I1620_P7_6 XI1620_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I100_XP_MN1 (XI1620_I100_XP_n1 I1620_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I100_XP_MN0 (I1620_P4_1n I1620_P4_3 XI1620_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I102_XP_MN1 (XI1620_I102_XP_n1 I1620_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I102_XP_MN0 (I1620_P6_3n I1620_P6_5 XI1620_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I104_XP_MN1 (XI1620_I104_XP_n1 I1620_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I104_XP_MN0 (I1620_P8_5n I1620_P8_7 XI1620_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I7_MN1 (XI1620_I7_n1 b23_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I7_MN0 (I1620_gn7 p22_6 XI1620_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I8_MN1 (XI1620_I8_n1 b23_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I8_MN0 (I1620_gn8 p22_7 XI1620_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I101_XP_MN1 (XI1574_I101_XP_n1 I1574_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I101_XP_MN0 (I1574_P5_2n I1574_P5_4 XI1574_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I103_XP_MN1 (XI1574_I103_XP_n1 I1574_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I103_XP_MN0 (I1574_P7_4n I1574_P7_6 XI1574_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I6_MN1 (XI1574_I6_n1 b22_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I6_MN0 (I1574_gn6 p21_5 XI1574_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I7_MN1 (XI1574_I7_n1 b22_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I7_MN0 (I1574_gn7 p21_6 XI1574_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I106_XP_MN1 (XI1574_I106_XP_n1 I1574_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I106_XP_MN0 (I1574_P10_7n I1574_P10_9 XI1574_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I171_XP_MN1 (XI1574_I171_XP_n1 I1574_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I171_XP_MN0 (I1574_P20_5n I1574_P20_13 XI1574_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I28_MN1 (XI1068_I28_n1 b11_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I28_MN0 (I1068_gn28 p10_27 XI1068_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I126_XP_MN1 (XI1068_I126_XP_n1 I1068_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I126_XP_MN0 (I1068_P30_27n I1068_P30_29 XI1068_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I122_XP_MN1 (XI1068_I122_XP_n1 I1068_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I122_XP_MN0 (I1068_P26_23n I1068_P26_25 XI1068_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I124_XP_MN1 (XI1068_I124_XP_n1 I1068_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I124_XP_MN0 (I1068_P28_25n I1068_P28_27 XI1068_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I120_XP_MN1 (XI1068_I120_XP_n1 I1068_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I120_XP_MN0 (I1068_P24_21n I1068_P24_23 XI1068_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I179_XP_MN1 (XI1068_I179_XP_n1 I1068_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I179_XP_MN0 (I1068_P28_13n I1068_P28_21 XI1068_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I171_XP_MN1 (XI1068_I171_XP_n1 I1068_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I171_XP_MN0 (I1068_P20_5n I1068_P20_13 XI1068_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I175_XP_MN1 (XI1068_I175_XP_n1 I1068_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I175_XP_MN0 (I1068_P24_9n I1068_P24_17 XI1068_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I110_XP_MN1 (XI1068_I110_XP_n1 I1068_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I110_XP_MN0 (I1068_P14_11n I1068_P14_13 XI1068_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I167_XP_MN1 (XI1068_I167_XP_n1 I1068_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I167_XP_MN0 (I1068_P16_1n I1068_P16_9 XI1068_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I9_MN1 (XI1068_I9_n1 b11_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I9_MN0 (I1068_gn9 p10_8 XI1068_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I10_MN1 (XI1068_I10_n1 b11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I10_MN0 (I1068_gn10 p10_9 XI1068_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I168_XP_MN1 (XI1022_I168_XP_n1 I1022_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I168_XP_MN0 (I1022_P17_2n I1022_P17_10 XI1022_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I105_XP_MN1 (XI1022_I105_XP_n1 I1022_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I105_XP_MN0 (I1022_P9_6n I1022_P9_8 XI1022_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I167_XP_MN1 (XI1022_I167_XP_n1 I1022_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I167_XP_MN0 (I1022_P16_1n I1022_P16_9 XI1022_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I104_XP_MN1 (XI1022_I104_XP_n1 I1022_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I104_XP_MN0 (I1022_P8_5n I1022_P8_7 XI1022_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I106_XP_MN1 (XI1022_I106_XP_n1 I1022_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I106_XP_MN0 (I1022_P10_7n I1022_P10_9 XI1022_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I7_MN1 (XI1022_I7_n1 b10_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I7_MN0 (I1022_gn7 p9_6 XI1022_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I9_MN1 (XI1022_I9_n1 b10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I9_MN0 (I1022_gn9 p9_8 XI1022_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I8_MN1 (XI1022_I8_n1 b10_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I8_MN0 (I1022_gn8 p9_7 XI1022_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I104_XP_MN1 (XI976_I104_XP_n1 I976_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I104_XP_MN0 (I976_P8_5n I976_P8_7 XI976_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I102_XP_MN1 (XI976_I102_XP_n1 I976_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I102_XP_MN0 (I976_P6_3n I976_P6_5 XI976_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I101_XP_MN1 (XI976_I101_XP_n1 I976_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I101_XP_MN0 (I976_P5_2n I976_P5_4 XI976_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I103_XP_MN1 (XI976_I103_XP_n1 I976_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I103_XP_MN0 (I976_P7_4n I976_P7_6 XI976_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I8_MN1 (XI976_I8_n1 b9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I8_MN0 (I976_gn8 p8_7 XI976_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I10_MN1 (XI976_I10_n1 b9_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I10_MN0 (I976_gn10 p8_9 XI976_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I167_XP_MN1 (XI930_I167_XP_n1 I930_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I167_XP_MN0 (I930_P16_1n I930_P16_9 XI930_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I108_XP_MN1 (XI930_I108_XP_n1 I930_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I108_XP_MN0 (I930_P12_9n I930_P12_11 XI930_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I106_XP_MN1 (XI930_I106_XP_n1 I930_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I106_XP_MN0 (I930_P10_7n I930_P10_9 XI930_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I11_MN1 (XI930_I11_n1 b8_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I11_MN0 (I930_gn11 p7_10 XI930_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I105_XP_MN1 (XI930_I105_XP_n1 I930_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I105_XP_MN0 (I930_P9_6n I930_P9_8 XI930_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I169_XP_MN1 (XI1666_I169_XP_n1 I1666_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I169_XP_MN0 (I1666_P18_3n I1666_P18_11 XI1666_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I108_XP_MN1 (XI1666_I108_XP_n1 I1666_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I108_XP_MN0 (I1666_P12_9n I1666_P12_11 XI1666_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I106_XP_MN1 (XI1666_I106_XP_n1 I1666_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I106_XP_MN0 (I1666_P10_7n I1666_P10_9 XI1666_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I105_XP_MN1 (XI1666_I105_XP_n1 I1666_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I105_XP_MN0 (I1666_P9_6n I1666_P9_8 XI1666_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I10_MN1 (XI1666_I10_n1 b24_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I10_MN0 (I1666_gn10 p23_9 XI1666_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I9_MN1 (XI1666_I9_n1 b24_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I9_MN0 (I1666_gn9 p23_8 XI1666_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I8_MN1 (XI1666_I8_n1 b24_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I8_MN0 (I1666_gn8 p23_7 XI1666_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I105_XP_MN1 (XI1620_I105_XP_n1 I1620_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I105_XP_MN0 (I1620_P9_6n I1620_P9_8 XI1620_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I106_XP_MN1 (XI1620_I106_XP_n1 I1620_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I106_XP_MN0 (I1620_P10_7n I1620_P10_9 XI1620_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I9_MN1 (XI1620_I9_n1 b23_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I9_MN0 (I1620_gn9 p22_8 XI1620_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I8_MN1 (XI1574_I8_n1 b22_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I8_MN0 (I1574_gn8 p21_7 XI1574_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I105_XP_MN1 (XI1574_I105_XP_n1 I1574_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I105_XP_MN0 (I1574_P9_6n I1574_P9_8 XI1574_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I10_MN1 (XI1574_I10_n1 b22_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I10_MN0 (I1574_gn10 p21_9 XI1574_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I9_MN1 (XI1574_I9_n1 b22_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I9_MN0 (I1574_gn9 p21_8 XI1574_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I108_XP_MN1 (XI1574_I108_XP_n1 I1574_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I108_XP_MN0 (I1574_P12_9n I1574_P12_11 XI1574_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I118_XP_MN1 (XI1068_I118_XP_n1 I1068_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I118_XP_MN0 (I1068_P22_19n I1068_P22_21 XI1068_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I116_XP_MN1 (XI1068_I116_XP_n1 I1068_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I116_XP_MN0 (I1068_P20_17n I1068_P20_19 XI1068_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I114_XP_MN1 (XI1068_I114_XP_n1 I1068_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I114_XP_MN0 (I1068_P18_15n I1068_P18_17 XI1068_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I112_XP_MN1 (XI1068_I112_XP_n1 I1068_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I112_XP_MN0 (I1068_P16_13n I1068_P16_15 XI1068_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I11_MN1 (XI1068_I11_n1 b11_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I11_MN0 (I1068_gn11 p10_10 XI1068_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I107_XP_MN1 (XI1022_I107_XP_n1 I1022_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I107_XP_MN0 (I1022_P11_8n I1022_P11_10 XI1022_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I175_XP_MN1 (XI1022_I175_XP_n1 I1022_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I175_XP_MN0 (I1022_P24_9n I1022_P24_17 XI1022_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I108_XP_MN1 (XI1022_I108_XP_n1 I1022_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I108_XP_MN0 (I1022_P12_9n I1022_P12_11 XI1022_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I10_MN1 (XI1022_I10_n1 b10_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I10_MN0 (I1022_gn10 p9_9 XI1022_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I11_MN1 (XI1022_I11_n1 b10_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I11_MN0 (I1022_gn11 p9_10 XI1022_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I106_XP_MN1 (XI976_I106_XP_n1 I976_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I106_XP_MN0 (I976_P10_7n I976_P10_9 XI976_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I105_XP_MN1 (XI976_I105_XP_n1 I976_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I105_XP_MN0 (I976_P9_6n I976_P9_8 XI976_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I9_MN1 (XI976_I9_n1 b9_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I9_MN0 (I976_gn9 p8_8 XI976_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I11_MN1 (XI976_I11_n1 b9_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I11_MN0 (I976_gn11 p8_10 XI976_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I175_XP_MN1 (XI930_I175_XP_n1 I930_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I175_XP_MN0 (I930_P24_9n I930_P24_17 XI930_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I12_MN1 (XI930_I12_n1 b8_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I12_MN0 (I930_gn12 p7_11 XI930_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I13_MN1 (XI930_I13_n1 b8_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I13_MN0 (I930_gn13 p7_12 XI930_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I107_XP_MN1 (XI930_I107_XP_n1 I930_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I107_XP_MN0 (I930_P11_8n I930_P11_10 XI930_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I168_XP_MN1 (XI930_I168_XP_n1 I930_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I168_XP_MN0 (I930_P17_2n I930_P17_10 XI930_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I171_XP_MN1 (XI1666_I171_XP_n1 I1666_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I171_XP_MN0 (I1666_P20_5n I1666_P20_13 XI1666_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I168_XP_MN1 (XI1666_I168_XP_n1 I1666_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I168_XP_MN0 (I1666_P17_2n I1666_P17_10 XI1666_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I107_XP_MN1 (XI1666_I107_XP_n1 I1666_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I107_XP_MN0 (I1666_P11_8n I1666_P11_10 XI1666_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I12_MN1 (XI1666_I12_n1 b24_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I12_MN0 (I1666_gn12 p23_11 XI1666_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I11_MN1 (XI1666_I11_n1 b24_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I11_MN0 (I1666_gn11 p23_10 XI1666_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I168_XP_MN1 (XI1620_I168_XP_n1 I1620_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I168_XP_MN0 (I1620_P17_2n I1620_P17_10 XI1620_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I107_XP_MN1 (XI1620_I107_XP_n1 I1620_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I107_XP_MN0 (I1620_P11_8n I1620_P11_10 XI1620_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I167_XP_MN1 (XI1620_I167_XP_n1 I1620_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I167_XP_MN0 (I1620_P16_1n I1620_P16_9 XI1620_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I108_XP_MN1 (XI1620_I108_XP_n1 I1620_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I108_XP_MN0 (I1620_P12_9n I1620_P12_11 XI1620_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I11_MN1 (XI1620_I11_n1 b23_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I11_MN0 (I1620_gn11 p22_10 XI1620_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I10_MN1 (XI1620_I10_n1 b23_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I10_MN0 (I1620_gn10 p22_9 XI1620_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I168_XP_MN1 (XI1574_I168_XP_n1 I1574_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I168_XP_MN0 (I1574_P17_2n I1574_P17_10 XI1574_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I107_XP_MN1 (XI1574_I107_XP_n1 I1574_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I107_XP_MN0 (I1574_P11_8n I1574_P11_10 XI1574_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I12_MN1 (XI1574_I12_n1 b22_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I12_MN0 (I1574_gn12 p21_11 XI1574_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I11_MN1 (XI1574_I11_n1 b22_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I11_MN0 (I1574_gn11 p21_10 XI1574_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I169_XP_MN1 (XI1574_I169_XP_n1 I1574_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I169_XP_MN0 (I1574_P18_3n I1574_P18_11 XI1574_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I175_XP_MN1 (XI1574_I175_XP_n1 I1574_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I175_XP_MN0 (I1574_P24_9n I1574_P24_17 XI1574_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I29_MN1 (XI1068_I29_n1 b11_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I29_MN0 (I1068_gn29 p10_28 XI1068_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I25_MN1 (XI1068_I25_n1 b11_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I25_MN0 (I1068_gn25 p10_24 XI1068_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I20_MN1 (XI1068_I20_n1 b11_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I20_MN0 (I1068_gn20 p10_19 XI1068_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I19_MN1 (XI1068_I19_n1 b11_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I19_MN0 (I1068_gn19 p10_18 XI1068_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I12_MN1 (XI1068_I12_n1 b11_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I12_MN0 (I1068_gn12 p10_11 XI1068_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I13_MN1 (XI1068_I13_n1 b11_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I13_MN0 (I1068_gn13 p10_12 XI1068_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I176_XP_MN1 (XI1022_I176_XP_n1 I1022_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I176_XP_MN0 (I1022_P25_10n I1022_P25_18 XI1022_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I109_XP_MN1 (XI1022_I109_XP_n1 I1022_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I109_XP_MN0 (I1022_P13_10n I1022_P13_12 XI1022_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I169_XP_MN1 (XI1022_I169_XP_n1 I1022_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I169_XP_MN0 (I1022_P18_3n I1022_P18_11 XI1022_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I12_MN1 (XI1022_I12_n1 b10_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I12_MN0 (I1022_gn12 p9_11 XI1022_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I167_XP_MN1 (XI976_I167_XP_n1 I976_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I167_XP_MN0 (I976_P16_1n I976_P16_9 XI976_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I108_XP_MN1 (XI976_I108_XP_n1 I976_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I108_XP_MN0 (I976_P12_9n I976_P12_11 XI976_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I168_XP_MN1 (XI976_I168_XP_n1 I976_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I168_XP_MN0 (I976_P17_2n I976_P17_10 XI976_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I107_XP_MN1 (XI976_I107_XP_n1 I976_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I107_XP_MN0 (I976_P11_8n I976_P11_10 XI976_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I16_MN1 (XI930_I16_n1 b8_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I16_MN0 (I930_gn16 p7_15 XI930_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I171_XP_MN1 (XI930_I171_XP_n1 I930_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I171_XP_MN0 (I930_P20_5n I930_P20_13 XI930_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I110_XP_MN1 (XI930_I110_XP_n1 I930_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I110_XP_MN0 (I930_P14_11n I930_P14_13 XI930_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I14_MN1 (XI930_I14_n1 b8_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I14_MN0 (I930_gn14 p7_13 XI930_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I109_XP_MN1 (XI930_I109_XP_n1 I930_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I109_XP_MN0 (I930_P13_10n I930_P13_12 XI930_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I177_XP_MN1 (XI1666_I177_XP_n1 I1666_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I177_XP_MN0 (I1666_P26_11n I1666_P26_19 XI1666_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I112_XP_MN1 (XI1666_I112_XP_n1 I1666_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I112_XP_MN0 (I1666_P16_13n I1666_P16_15 XI1666_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I110_XP_MN1 (XI1666_I110_XP_n1 I1666_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I110_XP_MN0 (I1666_P14_11n I1666_P14_13 XI1666_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I176_XP_MN1 (XI1666_I176_XP_n1 I1666_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I176_XP_MN0 (I1666_P25_10n I1666_P25_18 XI1666_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I170_XP_MN1 (XI1666_I170_XP_n1 I1666_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I170_XP_MN0 (I1666_P19_4n I1666_P19_12 XI1666_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I109_XP_MN1 (XI1666_I109_XP_n1 I1666_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I109_XP_MN0 (I1666_P13_10n I1666_P13_12 XI1666_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I13_MN1 (XI1666_I13_n1 b24_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I13_MN0 (I1666_gn13 p23_12 XI1666_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I109_XP_MN1 (XI1620_I109_XP_n1 I1620_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I109_XP_MN0 (I1620_P13_10n I1620_P13_12 XI1620_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I175_XP_MN1 (XI1620_I175_XP_n1 I1620_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I175_XP_MN0 (I1620_P24_9n I1620_P24_17 XI1620_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I169_XP_MN1 (XI1620_I169_XP_n1 I1620_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I169_XP_MN0 (I1620_P18_3n I1620_P18_11 XI1620_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I110_XP_MN1 (XI1620_I110_XP_n1 I1620_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I110_XP_MN0 (I1620_P14_11n I1620_P14_13 XI1620_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I13_MN1 (XI1620_I13_n1 b23_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I13_MN0 (I1620_gn13 p22_12 XI1620_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I12_MN1 (XI1620_I12_n1 b23_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I12_MN0 (I1620_gn12 p22_11 XI1620_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I170_XP_MN1 (XI1574_I170_XP_n1 I1574_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I170_XP_MN0 (I1574_P19_4n I1574_P19_12 XI1574_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I109_XP_MN1 (XI1574_I109_XP_n1 I1574_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I109_XP_MN0 (I1574_P13_10n I1574_P13_12 XI1574_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I13_MN1 (XI1574_I13_n1 b22_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I13_MN0 (I1574_gn13 p21_12 XI1574_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I110_XP_MN1 (XI1574_I110_XP_n1 I1574_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I110_XP_MN0 (I1574_P14_11n I1574_P14_13 XI1574_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I112_XP_MN1 (XI1574_I112_XP_n1 I1574_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I112_XP_MN0 (I1574_P16_13n I1574_P16_15 XI1574_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I177_XP_MN1 (XI1574_I177_XP_n1 I1574_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I177_XP_MN0 (I1574_P26_11n I1574_P26_19 XI1574_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I30_MN1 (XI1068_I30_n1 b11_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I30_MN0 (I1068_gn30 p10_29 XI1068_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I24_MN1 (XI1068_I24_n1 b11_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I24_MN0 (I1068_gn24 p10_23 XI1068_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I23_MN1 (XI1068_I23_n1 b11_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I23_MN0 (I1068_gn23 p10_22 XI1068_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I22_MN1 (XI1068_I22_n1 b11_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I22_MN0 (I1068_gn22 p10_21 XI1068_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I18_MN1 (XI1068_I18_n1 b11_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I18_MN0 (I1068_gn18 p10_17 XI1068_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I16_MN1 (XI1068_I16_n1 b11_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I16_MN0 (I1068_gn16 p10_15 XI1068_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I15_MN1 (XI1068_I15_n1 b11_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I15_MN0 (I1068_gn15 p10_14 XI1068_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I17_MN1 (XI1068_I17_n1 b11_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I17_MN0 (I1068_gn17 p10_16 XI1068_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I14_MN1 (XI1068_I14_n1 b11_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I14_MN0 (I1068_gn14 p10_13 XI1068_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I170_XP_MN1 (XI1022_I170_XP_n1 I1022_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I170_XP_MN0 (I1022_P19_4n I1022_P19_12 XI1022_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I111_XP_MN1 (XI1022_I111_XP_n1 I1022_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I111_XP_MN0 (I1022_P15_12n I1022_P15_14 XI1022_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I171_XP_MN1 (XI1022_I171_XP_n1 I1022_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I171_XP_MN0 (I1022_P20_5n I1022_P20_13 XI1022_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I112_XP_MN1 (XI1022_I112_XP_n1 I1022_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I112_XP_MN0 (I1022_P16_13n I1022_P16_15 XI1022_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I110_XP_MN1 (XI1022_I110_XP_n1 I1022_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I110_XP_MN0 (I1022_P14_11n I1022_P14_13 XI1022_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I13_MN1 (XI1022_I13_n1 b10_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I13_MN0 (I1022_gn13 p9_12 XI1022_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I14_MN1 (XI1022_I14_n1 b10_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I14_MN0 (I1022_gn14 p9_13 XI1022_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I109_XP_MN1 (XI976_I109_XP_n1 I976_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I109_XP_MN0 (I976_P13_10n I976_P13_12 XI976_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I12_MN1 (XI976_I12_n1 b9_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I12_MN0 (I976_gn12 p8_11 XI976_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I13_MN1 (XI976_I13_n1 b9_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I13_MN0 (I976_gn13 p8_12 XI976_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I14_MN1 (XI976_I14_n1 b9_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I14_MN0 (I976_gn14 p8_13 XI976_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I15_MN1 (XI930_I15_n1 b8_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I15_MN0 (I930_gn15 p7_14 XI930_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I112_XP_MN1 (XI930_I112_XP_n1 I930_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I112_XP_MN0 (I930_P16_13n I930_P16_15 XI930_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I169_XP_MN1 (XI930_I169_XP_n1 I930_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I169_XP_MN0 (I930_P18_3n I930_P18_11 XI930_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I111_XP_MN1 (XI930_I111_XP_n1 I930_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I111_XP_MN0 (I930_P15_12n I930_P15_14 XI930_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I170_XP_MN1 (XI930_I170_XP_n1 I930_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I170_XP_MN0 (I930_P19_4n I930_P19_12 XI930_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I176_XP_MN1 (XI930_I176_XP_n1 I930_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I176_XP_MN0 (I930_P25_10n I930_P25_18 XI930_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I179_XP_MN1 (XI1666_I179_XP_n1 I1666_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I179_XP_MN0 (I1666_P28_13n I1666_P28_21 XI1666_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I114_XP_MN1 (XI1666_I114_XP_n1 I1666_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I114_XP_MN0 (I1666_P18_15n I1666_P18_17 XI1666_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I113_XP_MN1 (XI1666_I113_XP_n1 I1666_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I113_XP_MN0 (I1666_P17_14n I1666_P17_16 XI1666_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I111_XP_MN1 (XI1666_I111_XP_n1 I1666_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I111_XP_MN0 (I1666_P15_12n I1666_P15_14 XI1666_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I14_MN1 (XI1666_I14_n1 b24_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I14_MN0 (I1666_gn14 p23_13 XI1666_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I15_MN1 (XI1666_I15_n1 b24_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I15_MN0 (I1666_gn15 p23_14 XI1666_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I111_XP_MN1 (XI1620_I111_XP_n1 I1620_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I111_XP_MN0 (I1620_P15_12n I1620_P15_14 XI1620_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I112_XP_MN1 (XI1620_I112_XP_n1 I1620_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I112_XP_MN0 (I1620_P16_13n I1620_P16_15 XI1620_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I15_MN1 (XI1620_I15_n1 b23_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I15_MN0 (I1620_gn15 p22_14 XI1620_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I14_MN1 (XI1620_I14_n1 b23_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I14_MN0 (I1620_gn14 p22_13 XI1620_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I176_XP_MN1 (XI1574_I176_XP_n1 I1574_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I176_XP_MN0 (I1574_P25_10n I1574_P25_18 XI1574_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I111_XP_MN1 (XI1574_I111_XP_n1 I1574_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I111_XP_MN0 (I1574_P15_12n I1574_P15_14 XI1574_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I14_MN1 (XI1574_I14_n1 b22_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I14_MN0 (I1574_gn14 p21_13 XI1574_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I15_MN1 (XI1574_I15_n1 b22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I15_MN0 (I1574_gn15 p21_14 XI1574_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I114_XP_MN1 (XI1574_I114_XP_n1 I1574_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I114_XP_MN0 (I1574_P18_15n I1574_P18_17 XI1574_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I116_XP_MN1 (XI1574_I116_XP_n1 I1574_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I116_XP_MN0 (I1574_P20_17n I1574_P20_19 XI1574_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I179_XP_MN1 (XI1574_I179_XP_n1 I1574_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I179_XP_MN0 (I1574_P28_13n I1574_P28_21 XI1574_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I31_MN1 (XI1068_I31_n1 b11_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I31_MN0 (I1068_gn31 p10_30 XI1068_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I21_MN1 (XI1068_I21_n1 b11_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I21_MN0 (I1068_gn21 p10_20 XI1068_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I14_MN1 (XI1114_I14_n1 b12_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I14_MN0 (I1114_gn14 p11_13 XI1114_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I172_XP_MN1 (XI1022_I172_XP_n1 I1022_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I172_XP_MN0 (I1022_P21_6n I1022_P21_14 XI1022_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I113_XP_MN1 (XI1022_I113_XP_n1 I1022_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I113_XP_MN0 (I1022_P17_14n I1022_P17_16 XI1022_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I177_XP_MN1 (XI1022_I177_XP_n1 I1022_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I177_XP_MN0 (I1022_P26_11n I1022_P26_19 XI1022_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I114_XP_MN1 (XI1022_I114_XP_n1 I1022_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I114_XP_MN0 (I1022_P18_15n I1022_P18_17 XI1022_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I16_MN1 (XI1022_I16_n1 b10_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I16_MN0 (I1022_gn16 p9_15 XI1022_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I15_MN1 (XI1022_I15_n1 b10_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I15_MN0 (I1022_gn15 p9_14 XI1022_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I110_XP_MN1 (XI976_I110_XP_n1 I976_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I110_XP_MN0 (I976_P14_11n I976_P14_13 XI976_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I111_XP_MN1 (XI976_I111_XP_n1 I976_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I111_XP_MN0 (I976_P15_12n I976_P15_14 XI976_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I17_MN1 (XI976_I17_n1 b9_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I17_MN0 (I976_gn17 p8_16 XI976_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I15_MN1 (XI976_I15_n1 b9_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I15_MN0 (I976_gn15 p8_14 XI976_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I17_MN1 (XI930_I17_n1 b8_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I17_MN0 (I930_gn17 p7_16 XI930_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I116_XP_MN1 (XI930_I116_XP_n1 I930_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I116_XP_MN0 (I930_P20_17n I930_P20_19 XI930_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I114_XP_MN1 (XI930_I114_XP_n1 I930_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I114_XP_MN0 (I930_P18_15n I930_P18_17 XI930_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I115_XP_MN1 (XI930_I115_XP_n1 I930_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I115_XP_MN0 (I930_P19_16n I930_P19_18 XI930_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I113_XP_MN1 (XI930_I113_XP_n1 I930_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I113_XP_MN0 (I930_P17_14n I930_P17_16 XI930_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I172_XP_MN1 (XI930_I172_XP_n1 I930_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I172_XP_MN0 (I930_P21_6n I930_P21_14 XI930_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I173_XP_MN1 (XI1666_I173_XP_n1 I1666_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I173_XP_MN0 (I1666_P22_7n I1666_P22_15 XI1666_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I116_XP_MN1 (XI1666_I116_XP_n1 I1666_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I116_XP_MN0 (I1666_P20_17n I1666_P20_19 XI1666_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I172_XP_MN1 (XI1666_I172_XP_n1 I1666_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I172_XP_MN0 (I1666_P21_6n I1666_P21_14 XI1666_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I115_XP_MN1 (XI1666_I115_XP_n1 I1666_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I115_XP_MN0 (I1666_P19_16n I1666_P19_18 XI1666_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I16_MN1 (XI1666_I16_n1 b24_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I16_MN0 (I1666_gn16 p23_15 XI1666_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I18_MN1 (XI1666_I18_n1 b24_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I18_MN0 (I1666_gn18 p23_17 XI1666_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I17_MN1 (XI1666_I17_n1 b24_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I17_MN0 (I1666_gn17 p23_16 XI1666_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I170_XP_MN1 (XI1620_I170_XP_n1 I1620_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I170_XP_MN0 (I1620_P19_4n I1620_P19_12 XI1620_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I113_XP_MN1 (XI1620_I113_XP_n1 I1620_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I113_XP_MN0 (I1620_P17_14n I1620_P17_16 XI1620_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I171_XP_MN1 (XI1620_I171_XP_n1 I1620_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I171_XP_MN0 (I1620_P20_5n I1620_P20_13 XI1620_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I177_XP_MN1 (XI1620_I177_XP_n1 I1620_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I177_XP_MN0 (I1620_P26_11n I1620_P26_19 XI1620_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I114_XP_MN1 (XI1620_I114_XP_n1 I1620_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I114_XP_MN0 (I1620_P18_15n I1620_P18_17 XI1620_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I116_XP_MN1 (XI1620_I116_XP_n1 I1620_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I116_XP_MN0 (I1620_P20_17n I1620_P20_19 XI1620_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I16_MN1 (XI1620_I16_n1 b23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I16_MN0 (I1620_gn16 p22_15 XI1620_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I172_XP_MN1 (XI1574_I172_XP_n1 I1574_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I172_XP_MN0 (I1574_P21_6n I1574_P21_14 XI1574_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I113_XP_MN1 (XI1574_I113_XP_n1 I1574_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I113_XP_MN0 (I1574_P17_14n I1574_P17_16 XI1574_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I16_MN1 (XI1574_I16_n1 b22_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I16_MN0 (I1574_gn16 p21_15 XI1574_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I173_XP_MN1 (XI1574_I173_XP_n1 I1574_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I173_XP_MN0 (I1574_P22_7n I1574_P22_15 XI1574_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I27_MN1 (XI1114_I27_n1 b12_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I27_MN0 (I1114_gn27 p11_26 XI1114_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I26_MN1 (XI1114_I26_n1 b12_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I26_MN0 (I1114_gn26 p11_25 XI1114_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I25_MN1 (XI1114_I25_n1 b12_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I25_MN0 (I1114_gn25 p11_24 XI1114_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I22_MN1 (XI1114_I22_n1 b12_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I22_MN0 (I1114_gn22 p11_21 XI1114_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I19_MN1 (XI1114_I19_n1 b12_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I19_MN0 (I1114_gn19 p11_18 XI1114_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I18_MN1 (XI1114_I18_n1 b12_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I18_MN0 (I1114_gn18 p11_17 XI1114_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I16_MN1 (XI1114_I16_n1 b12_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I16_MN0 (I1114_gn16 p11_15 XI1114_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I12_MN1 (XI1114_I12_n1 b12_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I12_MN0 (I1114_gn12 p11_11 XI1114_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I178_XP_MN1 (XI1022_I178_XP_n1 I1022_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I178_XP_MN0 (I1022_P27_12n I1022_P27_20 XI1022_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I115_XP_MN1 (XI1022_I115_XP_n1 I1022_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I115_XP_MN0 (I1022_P19_16n I1022_P19_18 XI1022_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I117_XP_MN1 (XI1022_I117_XP_n1 I1022_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I117_XP_MN0 (I1022_P21_18n I1022_P21_20 XI1022_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I116_XP_MN1 (XI1022_I116_XP_n1 I1022_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I116_XP_MN0 (I1022_P20_17n I1022_P20_19 XI1022_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I17_MN1 (XI1022_I17_n1 b10_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I17_MN0 (I1022_gn17 p9_16 XI1022_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I19_MN1 (XI1022_I19_n1 b10_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I19_MN0 (I1022_gn19 p9_18 XI1022_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I18_MN1 (XI1022_I18_n1 b10_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I18_MN0 (I1022_gn18 p9_17 XI1022_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I169_XP_MN1 (XI976_I169_XP_n1 I976_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I169_XP_MN0 (I976_P18_3n I976_P18_11 XI976_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I112_XP_MN1 (XI976_I112_XP_n1 I976_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I112_XP_MN0 (I976_P16_13n I976_P16_15 XI976_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I113_XP_MN1 (XI976_I113_XP_n1 I976_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I113_XP_MN0 (I976_P17_14n I976_P17_16 XI976_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I18_MN1 (XI976_I18_n1 b9_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I18_MN0 (I976_gn18 p8_17 XI976_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I16_MN1 (XI976_I16_n1 b9_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I16_MN0 (I976_gn16 p8_15 XI976_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I18_MN1 (XI930_I18_n1 b8_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I18_MN0 (I930_gn18 p7_17 XI930_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I19_MN1 (XI930_I19_n1 b8_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I19_MN0 (I930_gn19 p7_18 XI930_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I173_XP_MN1 (XI930_I173_XP_n1 I930_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I173_XP_MN0 (I930_P22_7n I930_P22_15 XI930_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I177_XP_MN1 (XI930_I177_XP_n1 I930_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I177_XP_MN0 (I930_P26_11n I930_P26_19 XI930_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I117_XP_MN1 (XI930_I117_XP_n1 I930_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I117_XP_MN0 (I930_P21_18n I930_P21_20 XI930_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I182_XP_MN1 (XI930_I182_XP_n1 I930_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I182_XP_MN0 (I930_P31_16n I930_P31_24 XI930_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I174_XP_MN1 (XI930_I174_XP_n1 I930_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I174_XP_MN0 (I930_P23_8n I930_P23_16 XI930_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I120_XP_MN1 (XI1666_I120_XP_n1 I1666_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I120_XP_MN0 (I1666_P24_21n I1666_P24_23 XI1666_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I118_XP_MN1 (XI1666_I118_XP_n1 I1666_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I118_XP_MN0 (I1666_P22_19n I1666_P22_21 XI1666_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I180_XP_MN1 (XI1666_I180_XP_n1 I1666_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I180_XP_MN0 (I1666_P29_14n I1666_P29_22 XI1666_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I117_XP_MN1 (XI1666_I117_XP_n1 I1666_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I117_XP_MN0 (I1666_P21_18n I1666_P21_20 XI1666_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I20_MN1 (XI1666_I20_n1 b24_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I20_MN0 (I1666_gn20 p23_19 XI1666_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I19_MN1 (XI1666_I19_n1 b24_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I19_MN0 (I1666_gn19 p23_18 XI1666_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I172_XP_MN1 (XI1620_I172_XP_n1 I1620_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I172_XP_MN0 (I1620_P21_6n I1620_P21_14 XI1620_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I115_XP_MN1 (XI1620_I115_XP_n1 I1620_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I115_XP_MN0 (I1620_P19_16n I1620_P19_18 XI1620_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I173_XP_MN1 (XI1620_I173_XP_n1 I1620_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I173_XP_MN0 (I1620_P22_7n I1620_P22_15 XI1620_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I118_XP_MN1 (XI1620_I118_XP_n1 I1620_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I118_XP_MN0 (I1620_P22_19n I1620_P22_21 XI1620_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I17_MN1 (XI1620_I17_n1 b23_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I17_MN0 (I1620_gn17 p22_16 XI1620_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I18_MN1 (XI1620_I18_n1 b23_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I18_MN0 (I1620_gn18 p22_17 XI1620_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I19_MN1 (XI1620_I19_n1 b23_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I19_MN0 (I1620_gn19 p22_18 XI1620_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I18_MN1 (XI1574_I18_n1 b22_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I18_MN0 (I1574_gn18 p21_17 XI1574_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I115_XP_MN1 (XI1574_I115_XP_n1 I1574_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I115_XP_MN0 (I1574_P19_16n I1574_P19_18 XI1574_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I117_XP_MN1 (XI1574_I117_XP_n1 I1574_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I117_XP_MN0 (I1574_P21_18n I1574_P21_20 XI1574_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I19_MN1 (XI1574_I19_n1 b22_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I19_MN0 (I1574_gn19 p21_18 XI1574_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I17_MN1 (XI1574_I17_n1 b22_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I17_MN0 (I1574_gn17 p21_16 XI1574_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I118_XP_MN1 (XI1574_I118_XP_n1 I1574_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I118_XP_MN0 (I1574_P22_19n I1574_P22_21 XI1574_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I28_MN1 (XI1114_I28_n1 b12_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I28_MN0 (I1114_gn28 p11_27 XI1114_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I24_MN1 (XI1114_I24_n1 b12_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I24_MN0 (I1114_gn24 p11_23 XI1114_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I23_MN1 (XI1114_I23_n1 b12_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I23_MN0 (I1114_gn23 p11_22 XI1114_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I21_MN1 (XI1114_I21_n1 b12_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I21_MN0 (I1114_gn21 p11_20 XI1114_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I17_MN1 (XI1114_I17_n1 b12_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I17_MN0 (I1114_gn17 p11_16 XI1114_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I15_MN1 (XI1114_I15_n1 b12_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I15_MN0 (I1114_gn15 p11_14 XI1114_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I13_MN1 (XI1114_I13_n1 b12_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I13_MN0 (I1114_gn13 p11_12 XI1114_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I10_MN1 (XI1114_I10_n1 b12_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I10_MN0 (I1114_gn10 p11_9 XI1114_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I8_MN1 (XI1114_I8_n1 b12_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I8_MN0 (I1114_gn8 p11_7 XI1114_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I180_XP_MN1 (XI1022_I180_XP_n1 I1022_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I180_XP_MN0 (I1022_P29_14n I1022_P29_22 XI1022_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I174_XP_MN1 (XI1022_I174_XP_n1 I1022_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I174_XP_MN0 (I1022_P23_8n I1022_P23_16 XI1022_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I119_XP_MN1 (XI1022_I119_XP_n1 I1022_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I119_XP_MN0 (I1022_P23_20n I1022_P23_22 XI1022_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I173_XP_MN1 (XI1022_I173_XP_n1 I1022_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I173_XP_MN0 (I1022_P22_7n I1022_P22_15 XI1022_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I118_XP_MN1 (XI1022_I118_XP_n1 I1022_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I118_XP_MN0 (I1022_P22_19n I1022_P22_21 XI1022_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I20_MN1 (XI1022_I20_n1 b10_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I20_MN0 (I1022_gn20 p9_19 XI1022_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I171_XP_MN1 (XI976_I171_XP_n1 I976_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I171_XP_MN0 (I976_P20_5n I976_P20_13 XI976_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I116_XP_MN1 (XI976_I116_XP_n1 I976_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I116_XP_MN0 (I976_P20_17n I976_P20_19 XI976_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I114_XP_MN1 (XI976_I114_XP_n1 I976_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I114_XP_MN0 (I976_P18_15n I976_P18_17 XI976_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I170_XP_MN1 (XI976_I170_XP_n1 I976_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I170_XP_MN0 (I976_P19_4n I976_P19_12 XI976_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I176_XP_MN1 (XI976_I176_XP_n1 I976_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I176_XP_MN0 (I976_P25_10n I976_P25_18 XI976_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I115_XP_MN1 (XI976_I115_XP_n1 I976_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I115_XP_MN0 (I976_P19_16n I976_P19_18 XI976_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I19_MN1 (XI976_I19_n1 b9_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I19_MN0 (I976_gn19 p8_18 XI976_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I20_MN1 (XI930_I20_n1 b8_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I20_MN0 (I930_gn20 p7_19 XI930_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I118_XP_MN1 (XI930_I118_XP_n1 I930_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I118_XP_MN0 (I930_P22_19n I930_P22_21 XI930_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I179_XP_MN1 (XI930_I179_XP_n1 I930_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I179_XP_MN0 (I930_P28_13n I930_P28_21 XI930_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I21_MN1 (XI930_I21_n1 b8_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I21_MN0 (I930_gn21 p7_20 XI930_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I178_XP_MN1 (XI930_I178_XP_n1 I930_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I178_XP_MN0 (I930_P27_12n I930_P27_20 XI930_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I180_XP_MN1 (XI930_I180_XP_n1 I930_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I180_XP_MN0 (I930_P29_14n I930_P29_22 XI930_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I122_XP_MN1 (XI1666_I122_XP_n1 I1666_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I122_XP_MN0 (I1666_P26_23n I1666_P26_25 XI1666_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I124_XP_MN1 (XI1666_I124_XP_n1 I1666_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I124_XP_MN0 (I1666_P28_25n I1666_P28_27 XI1666_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I181_XP_MN1 (XI1666_I181_XP_n1 I1666_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I181_XP_MN0 (I1666_P30_15n I1666_P30_23 XI1666_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I178_XP_MN1 (XI1666_I178_XP_n1 I1666_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I178_XP_MN0 (I1666_P27_12n I1666_P27_20 XI1666_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I174_XP_MN1 (XI1666_I174_XP_n1 I1666_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I174_XP_MN0 (I1666_P23_8n I1666_P23_16 XI1666_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I21_MN1 (XI1666_I21_n1 b24_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I21_MN0 (I1666_gn21 p23_20 XI1666_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I174_XP_MN1 (XI1620_I174_XP_n1 I1620_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I174_XP_MN0 (I1620_P23_8n I1620_P23_16 XI1620_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I176_XP_MN1 (XI1620_I176_XP_n1 I1620_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I176_XP_MN0 (I1620_P25_10n I1620_P25_18 XI1620_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I117_XP_MN1 (XI1620_I117_XP_n1 I1620_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I117_XP_MN0 (I1620_P21_18n I1620_P21_20 XI1620_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I179_XP_MN1 (XI1620_I179_XP_n1 I1620_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I179_XP_MN0 (I1620_P28_13n I1620_P28_21 XI1620_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I120_XP_MN1 (XI1620_I120_XP_n1 I1620_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I120_XP_MN0 (I1620_P24_21n I1620_P24_23 XI1620_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I20_MN1 (XI1620_I20_n1 b23_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I20_MN0 (I1620_gn20 p22_19 XI1620_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I21_MN1 (XI1620_I21_n1 b23_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I21_MN0 (I1620_gn21 p22_20 XI1620_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I174_XP_MN1 (XI1574_I174_XP_n1 I1574_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I174_XP_MN0 (I1574_P23_8n I1574_P23_16 XI1574_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I180_XP_MN1 (XI1574_I180_XP_n1 I1574_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I180_XP_MN0 (I1574_P29_14n I1574_P29_22 XI1574_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I20_MN1 (XI1574_I20_n1 b22_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I20_MN0 (I1574_gn20 p21_19 XI1574_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I120_XP_MN1 (XI1574_I120_XP_n1 I1574_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I120_XP_MN0 (I1574_P24_21n I1574_P24_23 XI1574_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I181_XP_MN1 (XI1574_I181_XP_n1 I1574_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I181_XP_MN0 (I1574_P30_15n I1574_P30_23 XI1574_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I29_MN1 (XI1114_I29_n1 b12_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I29_MN0 (I1114_gn29 p11_28 XI1114_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I20_MN1 (XI1114_I20_n1 b12_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I20_MN0 (I1114_gn20 p11_19 XI1114_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I11_MN1 (XI1114_I11_n1 b12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I11_MN0 (I1114_gn11 p11_10 XI1114_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I9_MN1 (XI1114_I9_n1 b12_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I9_MN0 (I1114_gn9 p11_8 XI1114_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I7_MN1 (XI1114_I7_n1 b12_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I7_MN0 (I1114_gn7 p11_6 XI1114_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I121_XP_MN1 (XI1022_I121_XP_n1 I1022_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I121_XP_MN0 (I1022_P25_22n I1022_P25_24 XI1022_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I179_XP_MN1 (XI1022_I179_XP_n1 I1022_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I179_XP_MN0 (I1022_P28_13n I1022_P28_21 XI1022_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I181_XP_MN1 (XI1022_I181_XP_n1 I1022_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I181_XP_MN0 (I1022_P30_15n I1022_P30_23 XI1022_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I120_XP_MN1 (XI1022_I120_XP_n1 I1022_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I120_XP_MN0 (I1022_P24_21n I1022_P24_23 XI1022_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I22_MN1 (XI1022_I22_n1 b10_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I22_MN0 (I1022_gn22 p9_21 XI1022_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I21_MN1 (XI1022_I21_n1 b10_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I21_MN0 (I1022_gn21 p9_20 XI1022_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I175_XP_MN1 (XI976_I175_XP_n1 I976_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I175_XP_MN0 (I976_P24_9n I976_P24_17 XI976_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I172_XP_MN1 (XI976_I172_XP_n1 I976_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I172_XP_MN0 (I976_P21_6n I976_P21_14 XI976_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I117_XP_MN1 (XI976_I117_XP_n1 I976_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I117_XP_MN0 (I976_P21_18n I976_P21_20 XI976_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I20_MN1 (XI976_I20_n1 b9_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I20_MN0 (I976_gn20 p8_19 XI976_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I21_MN1 (XI976_I21_n1 b9_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I21_MN0 (I976_gn21 p8_20 XI976_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I120_XP_MN1 (XI930_I120_XP_n1 I930_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I120_XP_MN0 (I930_P24_21n I930_P24_23 XI930_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I22_MN1 (XI930_I22_n1 b8_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I22_MN0 (I930_gn22 p7_21 XI930_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I119_XP_MN1 (XI930_I119_XP_n1 I930_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I119_XP_MN0 (I930_P23_20n I930_P23_22 XI930_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I121_XP_MN1 (XI930_I121_XP_n1 I930_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I121_XP_MN0 (I930_P25_22n I930_P25_24 XI930_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I24_MN1 (XI1666_I24_n1 b24_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I24_MN0 (I1666_gn24 p23_23 XI1666_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I126_XP_MN1 (XI1666_I126_XP_n1 I1666_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I126_XP_MN0 (I1666_P30_27n I1666_P30_29 XI1666_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I121_XP_MN1 (XI1666_I121_XP_n1 I1666_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I121_XP_MN0 (I1666_P25_22n I1666_P25_24 XI1666_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I125_XP_MN1 (XI1666_I125_XP_n1 I1666_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I125_XP_MN0 (I1666_P29_26n I1666_P29_28 XI1666_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I123_XP_MN1 (XI1666_I123_XP_n1 I1666_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I123_XP_MN0 (I1666_P27_24n I1666_P27_26 XI1666_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I119_XP_MN1 (XI1666_I119_XP_n1 I1666_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I119_XP_MN0 (I1666_P23_20n I1666_P23_22 XI1666_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I23_MN1 (XI1666_I23_n1 b24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I23_MN0 (I1666_gn23 p23_22 XI1666_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I22_MN1 (XI1666_I22_n1 b24_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I22_MN0 (I1666_gn22 p23_21 XI1666_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I178_XP_MN1 (XI1620_I178_XP_n1 I1620_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I178_XP_MN0 (I1620_P27_12n I1620_P27_20 XI1620_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I180_XP_MN1 (XI1620_I180_XP_n1 I1620_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I180_XP_MN0 (I1620_P29_14n I1620_P29_22 XI1620_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I121_XP_MN1 (XI1620_I121_XP_n1 I1620_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I121_XP_MN0 (I1620_P25_22n I1620_P25_24 XI1620_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I119_XP_MN1 (XI1620_I119_XP_n1 I1620_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I119_XP_MN0 (I1620_P23_20n I1620_P23_22 XI1620_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I181_XP_MN1 (XI1620_I181_XP_n1 I1620_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I181_XP_MN0 (I1620_P30_15n I1620_P30_23 XI1620_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I122_XP_MN1 (XI1620_I122_XP_n1 I1620_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I122_XP_MN0 (I1620_P26_23n I1620_P26_25 XI1620_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I22_MN1 (XI1620_I22_n1 b23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I22_MN0 (I1620_gn22 p22_21 XI1620_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I23_MN1 (XI1620_I23_n1 b23_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I23_MN0 (I1620_gn23 p22_22 XI1620_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I178_XP_MN1 (XI1574_I178_XP_n1 I1574_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I178_XP_MN0 (I1574_P27_12n I1574_P27_20 XI1574_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I119_XP_MN1 (XI1574_I119_XP_n1 I1574_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I119_XP_MN0 (I1574_P23_20n I1574_P23_22 XI1574_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I121_XP_MN1 (XI1574_I121_XP_n1 I1574_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I121_XP_MN0 (I1574_P25_22n I1574_P25_24 XI1574_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I21_MN1 (XI1574_I21_n1 b22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I21_MN0 (I1574_gn21 p21_20 XI1574_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I22_MN1 (XI1574_I22_n1 b22_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I22_MN0 (I1574_gn22 p21_21 XI1574_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I122_XP_MN1 (XI1574_I122_XP_n1 I1574_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I122_XP_MN0 (I1574_P26_23n I1574_P26_25 XI1574_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I30_MN1 (XI1114_I30_n1 b12_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I30_MN0 (I1114_gn30 p11_29 XI1114_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I124_XP_MN1 (XI1114_I124_XP_n1 I1114_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I124_XP_MN0 (I1114_P28_25n I1114_P28_27 XI1114_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I122_XP_MN1 (XI1114_I122_XP_n1 I1114_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I122_XP_MN0 (I1114_P26_23n I1114_P26_25 XI1114_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I120_XP_MN1 (XI1114_I120_XP_n1 I1114_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I120_XP_MN0 (I1114_P24_21n I1114_P24_23 XI1114_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I118_XP_MN1 (XI1114_I118_XP_n1 I1114_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I118_XP_MN0 (I1114_P22_19n I1114_P22_21 XI1114_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I116_XP_MN1 (XI1114_I116_XP_n1 I1114_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I116_XP_MN0 (I1114_P20_17n I1114_P20_19 XI1114_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I114_XP_MN1 (XI1114_I114_XP_n1 I1114_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I114_XP_MN0 (I1114_P18_15n I1114_P18_17 XI1114_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I112_XP_MN1 (XI1114_I112_XP_n1 I1114_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I112_XP_MN0 (I1114_P16_13n I1114_P16_15 XI1114_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I110_XP_MN1 (XI1114_I110_XP_n1 I1114_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I110_XP_MN0 (I1114_P14_11n I1114_P14_13 XI1114_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I108_XP_MN1 (XI1114_I108_XP_n1 I1114_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I108_XP_MN0 (I1114_P12_9n I1114_P12_11 XI1114_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I6_MN1 (XI1114_I6_n1 b12_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I6_MN0 (I1114_gn6 p11_5 XI1114_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I5_MN1 (XI1114_I5_n1 b12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I5_MN0 (I1114_gn5 p11_4 XI1114_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I182_XP_MN1 (XI1022_I182_XP_n1 I1022_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I182_XP_MN0 (I1022_P31_16n I1022_P31_24 XI1022_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I123_XP_MN1 (XI1022_I123_XP_n1 I1022_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I123_XP_MN0 (I1022_P27_24n I1022_P27_26 XI1022_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I125_XP_MN1 (XI1022_I125_XP_n1 I1022_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I125_XP_MN0 (I1022_P29_26n I1022_P29_28 XI1022_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I124_XP_MN1 (XI1022_I124_XP_n1 I1022_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I124_XP_MN0 (I1022_P28_25n I1022_P28_27 XI1022_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I122_XP_MN1 (XI1022_I122_XP_n1 I1022_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I122_XP_MN0 (I1022_P26_23n I1022_P26_25 XI1022_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I24_MN1 (XI1022_I24_n1 b10_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I24_MN0 (I1022_gn24 p9_23 XI1022_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I23_MN1 (XI1022_I23_n1 b10_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I23_MN0 (I1022_gn23 p9_22 XI1022_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I173_XP_MN1 (XI976_I173_XP_n1 I976_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I173_XP_MN0 (I976_P22_7n I976_P22_15 XI976_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I118_XP_MN1 (XI976_I118_XP_n1 I976_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I118_XP_MN0 (I976_P22_19n I976_P22_21 XI976_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I174_XP_MN1 (XI976_I174_XP_n1 I976_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I174_XP_MN0 (I976_P23_8n I976_P23_16 XI976_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I119_XP_MN1 (XI976_I119_XP_n1 I976_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I119_XP_MN0 (I976_P23_20n I976_P23_22 XI976_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I22_MN1 (XI976_I22_n1 b9_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I22_MN0 (I976_gn22 p8_21 XI976_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I23_MN1 (XI976_I23_n1 b9_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I23_MN0 (I976_gn23 p8_22 XI976_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I122_XP_MN1 (XI930_I122_XP_n1 I930_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I122_XP_MN0 (I930_P26_23n I930_P26_25 XI930_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I24_MN1 (XI930_I24_n1 b8_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I24_MN0 (I930_gn24 p7_23 XI930_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I23_MN1 (XI930_I23_n1 b8_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I23_MN0 (I930_gn23 p7_22 XI930_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I25_MN1 (XI930_I25_n1 b8_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I25_MN0 (I930_gn25 p7_24 XI930_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I123_XP_MN1 (XI930_I123_XP_n1 I930_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I123_XP_MN0 (I930_P27_24n I930_P27_26 XI930_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I25_MN1 (XI1666_I25_n1 b24_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I25_MN0 (I1666_gn25 p23_24 XI1666_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I26_MN1 (XI1666_I26_n1 b24_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I26_MN0 (I1666_gn26 p23_25 XI1666_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I127_XP_MN1 (XI1666_I127_XP_n1 I1666_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I127_XP_MN0 (I1666_P31_28n I1666_P31_30 XI1666_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I182_XP_MN1 (XI1666_I182_XP_n1 I1666_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I182_XP_MN0 (I1666_P31_16n I1666_P31_24 XI1666_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I182_XP_MN1 (XI1620_I182_XP_n1 I1620_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I182_XP_MN0 (I1620_P31_16n I1620_P31_24 XI1620_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I123_XP_MN1 (XI1620_I123_XP_n1 I1620_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I123_XP_MN0 (I1620_P27_24n I1620_P27_26 XI1620_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I124_XP_MN1 (XI1620_I124_XP_n1 I1620_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I124_XP_MN0 (I1620_P28_25n I1620_P28_27 XI1620_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I24_MN1 (XI1620_I24_n1 b23_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I24_MN0 (I1620_gn24 p22_23 XI1620_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I25_MN1 (XI1620_I25_n1 b23_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I25_MN0 (I1620_gn25 p22_24 XI1620_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I182_XP_MN1 (XI1574_I182_XP_n1 I1574_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I182_XP_MN0 (I1574_P31_16n I1574_P31_24 XI1574_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I125_XP_MN1 (XI1574_I125_XP_n1 I1574_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I125_XP_MN0 (I1574_P29_26n I1574_P29_28 XI1574_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I123_XP_MN1 (XI1574_I123_XP_n1 I1574_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I123_XP_MN0 (I1574_P27_24n I1574_P27_26 XI1574_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I24_MN1 (XI1574_I24_n1 b22_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I24_MN0 (I1574_gn24 p21_23 XI1574_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I23_MN1 (XI1574_I23_n1 b22_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I23_MN0 (I1574_gn23 p21_22 XI1574_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I124_XP_MN1 (XI1574_I124_XP_n1 I1574_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I124_XP_MN0 (I1574_P28_25n I1574_P28_27 XI1574_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I31_MN1 (XI1114_I31_n1 b12_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I31_MN0 (I1114_gn31 p11_30 XI1114_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I126_XP_MN1 (XI1114_I126_XP_n1 I1114_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I126_XP_MN0 (I1114_P30_27n I1114_P30_29 XI1114_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I181_XP_MN1 (XI1114_I181_XP_n1 I1114_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I181_XP_MN0 (I1114_P30_15n I1114_P30_23 XI1114_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I179_XP_MN1 (XI1114_I179_XP_n1 I1114_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I179_XP_MN0 (I1114_P28_13n I1114_P28_21 XI1114_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I173_XP_MN1 (XI1114_I173_XP_n1 I1114_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I173_XP_MN0 (I1114_P22_7n I1114_P22_15 XI1114_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I177_XP_MN1 (XI1114_I177_XP_n1 I1114_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I177_XP_MN0 (I1114_P26_11n I1114_P26_19 XI1114_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I171_XP_MN1 (XI1114_I171_XP_n1 I1114_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I171_XP_MN0 (I1114_P20_5n I1114_P20_13 XI1114_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I106_XP_MN1 (XI1114_I106_XP_n1 I1114_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I106_XP_MN0 (I1114_P10_7n I1114_P10_9 XI1114_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I104_XP_MN1 (XI1114_I104_XP_n1 I1114_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I104_XP_MN0 (I1114_P8_5n I1114_P8_7 XI1114_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I4_MN1 (XI1114_I4_n1 b12_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I4_MN0 (I1114_gn4 p11_3 XI1114_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I3_MN1 (XI1114_I3_n1 b12_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I3_MN0 (I1114_gn3 p11_2 XI1114_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I127_XP_MN1 (XI1022_I127_XP_n1 I1022_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I127_XP_MN0 (I1022_P31_28n I1022_P31_30 XI1022_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I126_XP_MN1 (XI1022_I126_XP_n1 I1022_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I126_XP_MN0 (I1022_P30_27n I1022_P30_29 XI1022_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I26_MN1 (XI1022_I26_n1 b10_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I26_MN0 (I1022_gn26 p9_25 XI1022_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I25_MN1 (XI1022_I25_n1 b10_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I25_MN0 (I1022_gn25 p9_24 XI1022_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I177_XP_MN1 (XI976_I177_XP_n1 I976_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I177_XP_MN0 (I976_P26_11n I976_P26_19 XI976_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I120_XP_MN1 (XI976_I120_XP_n1 I976_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I120_XP_MN0 (I976_P24_21n I976_P24_23 XI976_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I122_XP_MN1 (XI976_I122_XP_n1 I976_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I122_XP_MN0 (I976_P26_23n I976_P26_25 XI976_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I178_XP_MN1 (XI976_I178_XP_n1 I976_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I178_XP_MN0 (I976_P27_12n I976_P27_20 XI976_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I121_XP_MN1 (XI976_I121_XP_n1 I976_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I121_XP_MN0 (I976_P25_22n I976_P25_24 XI976_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I24_MN1 (XI976_I24_n1 b9_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I24_MN0 (I976_gn24 p8_23 XI976_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I181_XP_MN1 (XI930_I181_XP_n1 I930_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I181_XP_MN0 (I930_P30_15n I930_P30_23 XI930_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I124_XP_MN1 (XI930_I124_XP_n1 I930_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I124_XP_MN0 (I930_P28_25n I930_P28_27 XI930_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I26_MN1 (XI930_I26_n1 b8_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I26_MN0 (I930_gn26 p7_25 XI930_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I125_XP_MN1 (XI930_I125_XP_n1 I930_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I125_XP_MN0 (I930_P29_26n I930_P29_28 XI930_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I27_MN1 (XI1666_I27_n1 b24_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I27_MN0 (I1666_gn27 p23_26 XI1666_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I28_MN1 (XI1666_I28_n1 b24_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I28_MN0 (I1666_gn28 p23_27 XI1666_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I29_MN1 (XI1666_I29_n1 b24_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I29_MN0 (I1666_gn29 p23_28 XI1666_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I30_MN1 (XI1666_I30_n1 b24_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I30_MN0 (I1666_gn30 p23_29 XI1666_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I31_MN1 (XI1666_I31_n1 b24_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I31_MN0 (I1666_gn31 p23_30 XI1666_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I127_XP_MN1 (XI1620_I127_XP_n1 I1620_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I127_XP_MN0 (I1620_P31_28n I1620_P31_30 XI1620_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I125_XP_MN1 (XI1620_I125_XP_n1 I1620_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I125_XP_MN0 (I1620_P29_26n I1620_P29_28 XI1620_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I126_XP_MN1 (XI1620_I126_XP_n1 I1620_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I126_XP_MN0 (I1620_P30_27n I1620_P30_29 XI1620_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I27_MN1 (XI1620_I27_n1 b23_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I27_MN0 (I1620_gn27 p22_26 XI1620_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I26_MN1 (XI1620_I26_n1 b23_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I26_MN0 (I1620_gn26 p22_25 XI1620_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I127_XP_MN1 (XI1574_I127_XP_n1 I1574_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I127_XP_MN0 (I1574_P31_28n I1574_P31_30 XI1574_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I25_MN1 (XI1574_I25_n1 b22_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I25_MN0 (I1574_gn25 p21_24 XI1574_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I126_XP_MN1 (XI1574_I126_XP_n1 I1574_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I126_XP_MN0 (I1574_P30_27n I1574_P30_29 XI1574_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I175_XP_MN1 (XI1114_I175_XP_n1 I1114_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I175_XP_MN0 (I1114_P24_9n I1114_P24_17 XI1114_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I169_XP_MN1 (XI1114_I169_XP_n1 I1114_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I169_XP_MN0 (I1114_P18_3n I1114_P18_11 XI1114_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I167_XP_MN1 (XI1114_I167_XP_n1 I1114_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I167_XP_MN0 (I1114_P16_1n I1114_P16_9 XI1114_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I102_XP_MN1 (XI1114_I102_XP_n1 I1114_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I102_XP_MN0 (I1114_P6_3n I1114_P6_5 XI1114_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I100_XP_MN1 (XI1114_I100_XP_n1 I1114_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I100_XP_MN0 (I1114_P4_1n I1114_P4_3 XI1114_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I2_MN1 (XI1114_I2_n1 b12_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I2_MN0 (I1114_gn2 p11_1 XI1114_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I0_MN1 (XI1068_I0_n1 b11_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I0_MN0 (I1068_gn0 aa20 XI1068_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I31_MN1 (XI1022_I31_n1 b10_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I31_MN0 (I1022_gn31 p9_30 XI1022_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I28_MN1 (XI1022_I28_n1 b10_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I28_MN0 (I1022_gn28 p9_27 XI1022_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I27_MN1 (XI1022_I27_n1 b10_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I27_MN0 (I1022_gn27 p9_26 XI1022_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I179_XP_MN1 (XI976_I179_XP_n1 I976_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I179_XP_MN0 (I976_P28_13n I976_P28_21 XI976_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I181_XP_MN1 (XI976_I181_XP_n1 I976_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I181_XP_MN0 (I976_P30_15n I976_P30_23 XI976_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I124_XP_MN1 (XI976_I124_XP_n1 I976_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I124_XP_MN0 (I976_P28_25n I976_P28_27 XI976_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I180_XP_MN1 (XI976_I180_XP_n1 I976_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I180_XP_MN0 (I976_P29_14n I976_P29_22 XI976_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I123_XP_MN1 (XI976_I123_XP_n1 I976_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I123_XP_MN0 (I976_P27_24n I976_P27_26 XI976_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I125_XP_MN1 (XI976_I125_XP_n1 I976_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I125_XP_MN0 (I976_P29_26n I976_P29_28 XI976_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I26_MN1 (XI976_I26_n1 b9_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I26_MN0 (I976_gn26 p8_25 XI976_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I27_MN1 (XI976_I27_n1 b9_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I27_MN0 (I976_gn27 p8_26 XI976_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I25_MN1 (XI976_I25_n1 b9_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I25_MN0 (I976_gn25 p8_24 XI976_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I31_MN1 (XI930_I31_n1 b8_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I31_MN0 (I930_gn31 p7_30 XI930_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I126_XP_MN1 (XI930_I126_XP_n1 I930_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I126_XP_MN0 (I930_P30_27n I930_P30_29 XI930_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I28_MN1 (XI930_I28_n1 b8_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I28_MN0 (I930_gn28 p7_27 XI930_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I27_MN1 (XI930_I27_n1 b8_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I27_MN0 (I930_gn27 p7_26 XI930_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I127_XP_MN1 (XI930_I127_XP_n1 I930_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I127_XP_MN0 (I930_P31_28n I930_P31_30 XI930_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I31_MN1 (XI1620_I31_n1 b23_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I31_MN0 (I1620_gn31 p22_30 XI1620_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I30_MN1 (XI1620_I30_n1 b23_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I30_MN0 (I1620_gn30 p22_29 XI1620_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I29_MN1 (XI1620_I29_n1 b23_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I29_MN0 (I1620_gn29 p22_28 XI1620_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I28_MN1 (XI1620_I28_n1 b23_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I28_MN0 (I1620_gn28 p22_27 XI1620_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I0_MN1 (XI1528_I0_n1 b21_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I0_MN0 (I1528_gn0 aa10 XI1528_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I31_MN1 (XI1574_I31_n1 b22_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I31_MN0 (I1574_gn31 p21_30 XI1574_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I30_MN1 (XI1574_I30_n1 b22_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I30_MN0 (I1574_gn30 p21_29 XI1574_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I27_MN1 (XI1574_I27_n1 b22_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I27_MN0 (I1574_gn27 p21_26 XI1574_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I127_XP_MN1 (XI1114_I127_XP_n1 I1114_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I127_XP_MN0 (I1114_P31_28n I1114_P31_30 XI1114_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I125_XP_MN1 (XI1114_I125_XP_n1 I1114_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I125_XP_MN0 (I1114_P29_26n I1114_P29_28 XI1114_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I123_XP_MN1 (XI1114_I123_XP_n1 I1114_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I123_XP_MN0 (I1114_P27_24n I1114_P27_26 XI1114_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I121_XP_MN1 (XI1114_I121_XP_n1 I1114_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I121_XP_MN0 (I1114_P25_22n I1114_P25_24 XI1114_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I119_XP_MN1 (XI1114_I119_XP_n1 I1114_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I119_XP_MN0 (I1114_P23_20n I1114_P23_22 XI1114_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I117_XP_MN1 (XI1114_I117_XP_n1 I1114_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I117_XP_MN0 (I1114_P21_18n I1114_P21_20 XI1114_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I111_XP_MN1 (XI1114_I111_XP_n1 I1114_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I111_XP_MN0 (I1114_P15_12n I1114_P15_14 XI1114_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I1_MN1 (XI1114_I1_n1 b12_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I1_MN0 (I1114_gn1 p11_0 XI1114_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I30_MN1 (XI1022_I30_n1 b10_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I30_MN0 (I1022_gn30 p9_29 XI1022_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I29_MN1 (XI1022_I29_n1 b10_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I29_MN0 (I1022_gn29 p9_28 XI1022_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I126_XP_MN1 (XI976_I126_XP_n1 I976_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I126_XP_MN0 (I976_P30_27n I976_P30_29 XI976_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I182_XP_MN1 (XI976_I182_XP_n1 I976_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I182_XP_MN0 (I976_P31_16n I976_P31_24 XI976_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I127_XP_MN1 (XI976_I127_XP_n1 I976_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I127_XP_MN0 (I976_P31_28n I976_P31_30 XI976_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I28_MN1 (XI976_I28_n1 b9_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I28_MN0 (I976_gn28 p8_27 XI976_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I30_MN1 (XI930_I30_n1 b8_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I30_MN0 (I930_gn30 p7_29 XI930_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I29_MN1 (XI930_I29_n1 b8_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I29_MN0 (I930_gn29 p7_28 XI930_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I0_MN1 (XI1344_I0_n1 b17_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I0_MN0 (I1344_gn0 aa14 XI1344_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I0_MN1 (XI1390_I0_n1 b18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I0_MN0 (I1390_gn0 aa13 XI1390_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I0_MN1 (XI1436_I0_n1 b19_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I0_MN0 (I1436_gn0 aa12 XI1436_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I1_MN1 (XI1436_I1_n1 b19_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I1_MN0 (I1436_gn1 p18_0 XI1436_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I0_MN1 (XI1482_I0_n1 b20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I0_MN0 (I1482_gn0 aa11 XI1482_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I1_MN1 (XI1482_I1_n1 b20_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I1_MN0 (I1482_gn1 p19_0 XI1482_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I1_MN1 (XI1528_I1_n1 b21_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I1_MN0 (I1528_gn1 p20_0 XI1528_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I2_MN1 (XI1528_I2_n1 b21_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I2_MN0 (I1528_gn2 p20_1 XI1528_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I29_MN1 (XI1574_I29_n1 b22_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I29_MN0 (I1574_gn29 p21_28 XI1574_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I26_MN1 (XI1574_I26_n1 b22_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I26_MN0 (I1574_gn26 p21_25 XI1574_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I28_MN1 (XI1574_I28_n1 b22_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I28_MN0 (I1574_gn28 p21_27 XI1574_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I180_XP_MN1 (XI1114_I180_XP_n1 I1114_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I180_XP_MN0 (I1114_P29_14n I1114_P29_22 XI1114_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I172_XP_MN1 (XI1114_I172_XP_n1 I1114_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I172_XP_MN0 (I1114_P21_6n I1114_P21_14 XI1114_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I176_XP_MN1 (XI1114_I176_XP_n1 I1114_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I176_XP_MN0 (I1114_P25_10n I1114_P25_18 XI1114_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I115_XP_MN1 (XI1114_I115_XP_n1 I1114_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I115_XP_MN0 (I1114_P19_16n I1114_P19_18 XI1114_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I113_XP_MN1 (XI1114_I113_XP_n1 I1114_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I113_XP_MN0 (I1114_P17_14n I1114_P17_16 XI1114_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I109_XP_MN1 (XI1114_I109_XP_n1 I1114_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I109_XP_MN0 (I1114_P13_10n I1114_P13_12 XI1114_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I107_XP_MN1 (XI1114_I107_XP_n1 I1114_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I107_XP_MN0 (I1114_P11_8n I1114_P11_10 XI1114_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I168_XP_MN1 (XI1114_I168_XP_n1 I1114_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I168_XP_MN0 (I1114_P17_2n I1114_P17_10 XI1114_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I105_XP_MN1 (XI1114_I105_XP_n1 I1114_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I105_XP_MN0 (I1114_P9_6n I1114_P9_8 XI1114_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I101_XP_MN1 (XI1114_I101_XP_n1 I1114_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I101_XP_MN0 (I1114_P5_2n I1114_P5_4 XI1114_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I0_MN1 (XI1114_I0_n1 b12_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I0_MN0 (I1114_gn0 aa19 XI1114_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I0_MN1 (XI1160_I0_n1 b13_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I0_MN0 (I1160_gn0 aa18 XI1160_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I0_MN1 (XI1206_I0_n1 b14_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I0_MN0 (I1206_gn0 aa17 XI1206_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I0_MN1 (XI1252_I0_n1 b15_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I0_MN0 (I1252_gn0 aa16 XI1252_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I31_MN1 (XI976_I31_n1 b9_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I31_MN0 (I976_gn31 p8_30 XI976_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I30_MN1 (XI976_I30_n1 b9_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I30_MN0 (I976_gn30 p8_29 XI976_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I0_MN1 (XI1298_I0_n1 b16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I0_MN0 (I1298_gn0 aa15 XI1298_I0_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I29_MN1 (XI976_I29_n1 b9_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I29_MN0 (I976_gn29 p8_28 XI976_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I2_MN1 (XI1344_I2_n1 b17_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I2_MN0 (I1344_gn2 p16_1 XI1344_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I1_MN1 (XI1344_I1_n1 b17_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I1_MN0 (I1344_gn1 p16_0 XI1344_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I2_MN1 (XI1390_I2_n1 b18_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I2_MN0 (I1390_gn2 p17_1 XI1390_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I1_MN1 (XI1390_I1_n1 b18_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I1_MN0 (I1390_gn1 p17_0 XI1390_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I2_MN1 (XI1436_I2_n1 b19_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I2_MN0 (I1436_gn2 p18_1 XI1436_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I3_MN1 (XI1482_I3_n1 b20_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I3_MN0 (I1482_gn3 p19_2 XI1482_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I2_MN1 (XI1482_I2_n1 b20_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I2_MN0 (I1482_gn2 p19_1 XI1482_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I3_MN1 (XI1528_I3_n1 b21_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I3_MN0 (I1528_gn3 p20_2 XI1528_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I4_MN1 (XI1528_I4_n1 b21_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I4_MN0 (I1528_gn4 p20_3 XI1528_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I100_XP_MN1 (XI1528_I100_XP_n1 I1528_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I100_XP_MN0 (I1528_P4_1n I1528_P4_3 XI1528_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I102_XP_MN1 (XI1528_I102_XP_n1 I1528_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I102_XP_MN0 (I1528_P6_3n I1528_P6_5 XI1528_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I167_XP_MN1 (XI1528_I167_XP_n1 I1528_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I167_XP_MN0 (I1528_P16_1n I1528_P16_9 XI1528_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I101_XP_MN1 (XI1528_I101_XP_n1 I1528_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I101_XP_MN0 (I1528_P5_2n I1528_P5_4 XI1528_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I182_XP_MN1 (XI1114_I182_XP_n1 I1114_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I182_XP_MN0 (I1114_P31_16n I1114_P31_24 XI1114_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I178_XP_MN1 (XI1114_I178_XP_n1 I1114_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I178_XP_MN0 (I1114_P27_12n I1114_P27_20 XI1114_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I174_XP_MN1 (XI1114_I174_XP_n1 I1114_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I174_XP_MN0 (I1114_P23_8n I1114_P23_16 XI1114_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I170_XP_MN1 (XI1114_I170_XP_n1 I1114_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I170_XP_MN0 (I1114_P19_4n I1114_P19_12 XI1114_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I103_XP_MN1 (XI1114_I103_XP_n1 I1114_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I103_XP_MN0 (I1114_P7_4n I1114_P7_6 XI1114_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I5_MN1 (XI1160_I5_n1 b13_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I5_MN0 (I1160_gn5 p12_4 XI1160_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I4_MN1 (XI1160_I4_n1 b13_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I4_MN0 (I1160_gn4 p12_3 XI1160_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I1_MN1 (XI1160_I1_n1 b13_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I1_MN0 (I1160_gn1 p12_0 XI1160_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I1_MN1 (XI1252_I1_n1 b15_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I1_MN0 (I1252_gn1 p14_0 XI1252_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I2_MN1 (XI1298_I2_n1 b16_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I2_MN0 (I1298_gn2 p15_1 XI1298_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I1_MN1 (XI1298_I1_n1 b16_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I1_MN0 (I1298_gn1 p15_0 XI1298_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I5_MN1 (XI1344_I5_n1 b17_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I5_MN0 (I1344_gn5 p16_4 XI1344_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I4_MN1 (XI1344_I4_n1 b17_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I4_MN0 (I1344_gn4 p16_3 XI1344_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I3_MN1 (XI1344_I3_n1 b17_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I3_MN0 (I1344_gn3 p16_2 XI1344_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I4_MN1 (XI1390_I4_n1 b18_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I4_MN0 (I1390_gn4 p17_3 XI1390_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I3_MN1 (XI1390_I3_n1 b18_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I3_MN0 (I1390_gn3 p17_2 XI1390_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I4_MN1 (XI1436_I4_n1 b19_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I4_MN0 (I1436_gn4 p18_3 XI1436_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I3_MN1 (XI1436_I3_n1 b19_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I3_MN0 (I1436_gn3 p18_2 XI1436_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I4_MN1 (XI1482_I4_n1 b20_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I4_MN0 (I1482_gn4 p19_3 XI1482_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I5_MN1 (XI1528_I5_n1 b21_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I5_MN0 (I1528_gn5 p20_4 XI1528_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I6_MN1 (XI1528_I6_n1 b21_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I6_MN0 (I1528_gn6 p20_5 XI1528_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I104_XP_MN1 (XI1528_I104_XP_n1 I1528_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I104_XP_MN0 (I1528_P8_5n I1528_P8_7 XI1528_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I175_XP_MN1 (XI1528_I175_XP_n1 I1528_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I175_XP_MN0 (I1528_P24_9n I1528_P24_17 XI1528_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I103_XP_MN1 (XI1528_I103_XP_n1 I1528_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I103_XP_MN0 (I1528_P7_4n I1528_P7_6 XI1528_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I168_XP_MN1 (XI1528_I168_XP_n1 I1528_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I168_XP_MN0 (I1528_P17_2n I1528_P17_10 XI1528_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I21_MN1 (XI1160_I21_n1 b13_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I21_MN0 (I1160_gn21 p12_20 XI1160_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I13_MN1 (XI1160_I13_n1 b13_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I13_MN0 (I1160_gn13 p12_12 XI1160_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I12_MN1 (XI1160_I12_n1 b13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I12_MN0 (I1160_gn12 p12_11 XI1160_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I7_MN1 (XI1160_I7_n1 b13_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I7_MN0 (I1160_gn7 p12_6 XI1160_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I6_MN1 (XI1160_I6_n1 b13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I6_MN0 (I1160_gn6 p12_5 XI1160_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I3_MN1 (XI1160_I3_n1 b13_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I3_MN0 (I1160_gn3 p12_2 XI1160_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I2_MN1 (XI1206_I2_n1 b14_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I2_MN0 (I1206_gn2 p13_1 XI1206_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I1_MN1 (XI1206_I1_n1 b14_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I1_MN0 (I1206_gn1 p13_0 XI1206_I1_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I2_MN1 (XI1252_I2_n1 b15_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I2_MN0 (I1252_gn2 p14_1 XI1252_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I4_MN1 (XI1298_I4_n1 b16_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I4_MN0 (I1298_gn4 p15_3 XI1298_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I3_MN1 (XI1298_I3_n1 b16_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I3_MN0 (I1298_gn3 p15_2 XI1298_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I100_XP_MN1 (XI1298_I100_XP_n1 I1298_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I100_XP_MN0 (I1298_P4_1n I1298_P4_3 XI1298_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I6_MN1 (XI1344_I6_n1 b17_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I6_MN0 (I1344_gn6 p16_5 XI1344_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I102_XP_MN1 (XI1344_I102_XP_n1 I1344_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I102_XP_MN0 (I1344_P6_3n I1344_P6_5 XI1344_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I100_XP_MN1 (XI1344_I100_XP_n1 I1344_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I100_XP_MN0 (I1344_P4_1n I1344_P4_3 XI1344_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I101_XP_MN1 (XI1344_I101_XP_n1 I1344_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I101_XP_MN0 (I1344_P5_2n I1344_P5_4 XI1344_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I6_MN1 (XI1390_I6_n1 b18_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I6_MN0 (I1390_gn6 p17_5 XI1390_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I7_MN1 (XI1390_I7_n1 b18_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I7_MN0 (I1390_gn7 p17_6 XI1390_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I5_MN1 (XI1390_I5_n1 b18_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I5_MN0 (I1390_gn5 p17_4 XI1390_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I100_XP_MN1 (XI1390_I100_XP_n1 I1390_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I100_XP_MN0 (I1390_P4_1n I1390_P4_3 XI1390_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I101_XP_MN1 (XI1390_I101_XP_n1 I1390_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I101_XP_MN0 (I1390_P5_2n I1390_P5_4 XI1390_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I6_MN1 (XI1436_I6_n1 b19_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I6_MN0 (I1436_gn6 p18_5 XI1436_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I5_MN1 (XI1436_I5_n1 b19_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I5_MN0 (I1436_gn5 p18_4 XI1436_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I102_XP_MN1 (XI1436_I102_XP_n1 I1436_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I102_XP_MN0 (I1436_P6_3n I1436_P6_5 XI1436_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I100_XP_MN1 (XI1436_I100_XP_n1 I1436_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I100_XP_MN0 (I1436_P4_1n I1436_P4_3 XI1436_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I5_MN1 (XI1482_I5_n1 b20_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I5_MN0 (I1482_gn5 p19_4 XI1482_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I6_MN1 (XI1482_I6_n1 b20_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I6_MN0 (I1482_gn6 p19_5 XI1482_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I101_XP_MN1 (XI1482_I101_XP_n1 I1482_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I101_XP_MN0 (I1482_P5_2n I1482_P5_4 XI1482_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I100_XP_MN1 (XI1482_I100_XP_n1 I1482_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I100_XP_MN0 (I1482_P4_1n I1482_P4_3 XI1482_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I102_XP_MN1 (XI1482_I102_XP_n1 I1482_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I102_XP_MN0 (I1482_P6_3n I1482_P6_5 XI1482_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I7_MN1 (XI1528_I7_n1 b21_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I7_MN0 (I1528_gn7 p20_6 XI1528_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I8_MN1 (XI1528_I8_n1 b21_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I8_MN0 (I1528_gn8 p20_7 XI1528_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I106_XP_MN1 (XI1528_I106_XP_n1 I1528_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I106_XP_MN0 (I1528_P10_7n I1528_P10_9 XI1528_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I108_XP_MN1 (XI1528_I108_XP_n1 I1528_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I108_XP_MN0 (I1528_P12_9n I1528_P12_11 XI1528_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I171_XP_MN1 (XI1528_I171_XP_n1 I1528_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I171_XP_MN0 (I1528_P20_5n I1528_P20_13 XI1528_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I107_XP_MN1 (XI1528_I107_XP_n1 I1528_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I107_XP_MN0 (I1528_P11_8n I1528_P11_10 XI1528_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I105_XP_MN1 (XI1528_I105_XP_n1 I1528_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I105_XP_MN0 (I1528_P9_6n I1528_P9_8 XI1528_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I176_XP_MN1 (XI1528_I176_XP_n1 I1528_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I176_XP_MN0 (I1528_P25_10n I1528_P25_18 XI1528_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I23_MN1 (XI1160_I23_n1 b13_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I23_MN0 (I1160_gn23 p12_22 XI1160_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I20_MN1 (XI1160_I20_n1 b13_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I20_MN0 (I1160_gn20 p12_19 XI1160_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I19_MN1 (XI1160_I19_n1 b13_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I19_MN0 (I1160_gn19 p12_18 XI1160_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I16_MN1 (XI1160_I16_n1 b13_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I16_MN0 (I1160_gn16 p12_15 XI1160_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I17_MN1 (XI1160_I17_n1 b13_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I17_MN0 (I1160_gn17 p12_16 XI1160_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I15_MN1 (XI1160_I15_n1 b13_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I15_MN0 (I1160_gn15 p12_14 XI1160_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I14_MN1 (XI1160_I14_n1 b13_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I14_MN0 (I1160_gn14 p12_13 XI1160_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I11_MN1 (XI1160_I11_n1 b13_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I11_MN0 (I1160_gn11 p12_10 XI1160_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I2_MN1 (XI1160_I2_n1 b13_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I2_MN0 (I1160_gn2 p12_1 XI1160_I2_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I3_MN1 (XI1206_I3_n1 b14_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I3_MN0 (I1206_gn3 p13_2 XI1206_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I4_MN1 (XI1252_I4_n1 b15_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I4_MN0 (I1252_gn4 p14_3 XI1252_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I3_MN1 (XI1252_I3_n1 b15_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I3_MN0 (I1252_gn3 p14_2 XI1252_I3_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I100_XP_MN1 (XI1252_I100_XP_n1 I1252_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I100_XP_MN0 (I1252_P4_1n I1252_P4_3 XI1252_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I101_XP_MN1 (XI1252_I101_XP_n1 I1252_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I101_XP_MN0 (I1252_P5_2n I1252_P5_4 XI1252_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I5_MN1 (XI1298_I5_n1 b16_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I5_MN0 (I1298_gn5 p15_4 XI1298_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I6_MN1 (XI1298_I6_n1 b16_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I6_MN0 (I1298_gn6 p15_5 XI1298_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I102_XP_MN1 (XI1298_I102_XP_n1 I1298_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I102_XP_MN0 (I1298_P6_3n I1298_P6_5 XI1298_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I103_XP_MN1 (XI1298_I103_XP_n1 I1298_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I103_XP_MN0 (I1298_P7_4n I1298_P7_6 XI1298_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I101_XP_MN1 (XI1298_I101_XP_n1 I1298_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I101_XP_MN0 (I1298_P5_2n I1298_P5_4 XI1298_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I7_MN1 (XI1344_I7_n1 b17_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I7_MN0 (I1344_gn7 p16_6 XI1344_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I104_XP_MN1 (XI1344_I104_XP_n1 I1344_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I104_XP_MN0 (I1344_P8_5n I1344_P8_7 XI1344_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I9_MN1 (XI1344_I9_n1 b17_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I9_MN0 (I1344_gn9 p16_8 XI1344_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I103_XP_MN1 (XI1344_I103_XP_n1 I1344_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I103_XP_MN0 (I1344_P7_4n I1344_P7_6 XI1344_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I105_XP_MN1 (XI1344_I105_XP_n1 I1344_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I105_XP_MN0 (I1344_P9_6n I1344_P9_8 XI1344_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I8_MN1 (XI1390_I8_n1 b18_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I8_MN0 (I1390_gn8 p17_7 XI1390_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I104_XP_MN1 (XI1390_I104_XP_n1 I1390_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I104_XP_MN0 (I1390_P8_5n I1390_P8_7 XI1390_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I102_XP_MN1 (XI1390_I102_XP_n1 I1390_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I102_XP_MN0 (I1390_P6_3n I1390_P6_5 XI1390_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I105_XP_MN1 (XI1390_I105_XP_n1 I1390_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I105_XP_MN0 (I1390_P9_6n I1390_P9_8 XI1390_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I103_XP_MN1 (XI1390_I103_XP_n1 I1390_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I103_XP_MN0 (I1390_P7_4n I1390_P7_6 XI1390_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I8_MN1 (XI1436_I8_n1 b19_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I8_MN0 (I1436_gn8 p18_7 XI1436_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I7_MN1 (XI1436_I7_n1 b19_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I7_MN0 (I1436_gn7 p18_6 XI1436_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I104_XP_MN1 (XI1436_I104_XP_n1 I1436_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I104_XP_MN0 (I1436_P8_5n I1436_P8_7 XI1436_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I101_XP_MN1 (XI1436_I101_XP_n1 I1436_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I101_XP_MN0 (I1436_P5_2n I1436_P5_4 XI1436_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I8_MN1 (XI1482_I8_n1 b20_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I8_MN0 (I1482_gn8 p19_7 XI1482_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I7_MN1 (XI1482_I7_n1 b20_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I7_MN0 (I1482_gn7 p19_6 XI1482_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I103_XP_MN1 (XI1482_I103_XP_n1 I1482_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I103_XP_MN0 (I1482_P7_4n I1482_P7_6 XI1482_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I104_XP_MN1 (XI1482_I104_XP_n1 I1482_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I104_XP_MN0 (I1482_P8_5n I1482_P8_7 XI1482_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I9_MN1 (XI1528_I9_n1 b21_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I9_MN0 (I1528_gn9 p20_8 XI1528_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I10_MN1 (XI1528_I10_n1 b21_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I10_MN0 (I1528_gn10 p20_9 XI1528_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I11_MN1 (XI1528_I11_n1 b21_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I11_MN0 (I1528_gn11 p20_10 XI1528_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I170_XP_MN1 (XI1528_I170_XP_n1 I1528_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I170_XP_MN0 (I1528_P19_4n I1528_P19_12 XI1528_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I31_MN1 (XI1160_I31_n1 b13_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I31_MN0 (I1160_gn31 p12_30 XI1160_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I30_MN1 (XI1160_I30_n1 b13_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I30_MN0 (I1160_gn30 p12_29 XI1160_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I119_XP_MN1 (XI1160_I119_XP_n1 I1160_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I119_XP_MN0 (I1160_P23_20n I1160_P23_22 XI1160_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I22_MN1 (XI1160_I22_n1 b13_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I22_MN0 (I1160_gn22 p12_21 XI1160_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I18_MN1 (XI1160_I18_n1 b13_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I18_MN0 (I1160_gn18 p12_17 XI1160_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I10_MN1 (XI1160_I10_n1 b13_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I10_MN0 (I1160_gn10 p12_9 XI1160_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I9_MN1 (XI1160_I9_n1 b13_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I9_MN0 (I1160_gn9 p12_8 XI1160_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I8_MN1 (XI1160_I8_n1 b13_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I8_MN0 (I1160_gn8 p12_7 XI1160_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I5_MN1 (XI1252_I5_n1 b15_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I5_MN0 (I1252_gn5 p14_4 XI1252_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I6_MN1 (XI1252_I6_n1 b15_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I6_MN0 (I1252_gn6 p14_5 XI1252_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I104_XP_MN1 (XI1252_I104_XP_n1 I1252_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I104_XP_MN0 (I1252_P8_5n I1252_P8_7 XI1252_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I102_XP_MN1 (XI1252_I102_XP_n1 I1252_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I102_XP_MN0 (I1252_P6_3n I1252_P6_5 XI1252_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I103_XP_MN1 (XI1252_I103_XP_n1 I1252_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I103_XP_MN0 (I1252_P7_4n I1252_P7_6 XI1252_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I8_MN1 (XI1298_I8_n1 b16_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I8_MN0 (I1298_gn8 p15_7 XI1298_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I7_MN1 (XI1298_I7_n1 b16_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I7_MN0 (I1298_gn7 p15_6 XI1298_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I104_XP_MN1 (XI1298_I104_XP_n1 I1298_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I104_XP_MN0 (I1298_P8_5n I1298_P8_7 XI1298_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I105_XP_MN1 (XI1298_I105_XP_n1 I1298_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I105_XP_MN0 (I1298_P9_6n I1298_P9_8 XI1298_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I8_MN1 (XI1344_I8_n1 b17_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I8_MN0 (I1344_gn8 p16_7 XI1344_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I106_XP_MN1 (XI1344_I106_XP_n1 I1344_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I106_XP_MN0 (I1344_P10_7n I1344_P10_9 XI1344_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I167_XP_MN1 (XI1344_I167_XP_n1 I1344_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I167_XP_MN0 (I1344_P16_1n I1344_P16_9 XI1344_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I10_MN1 (XI1344_I10_n1 b17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I10_MN0 (I1344_gn10 p16_9 XI1344_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I168_XP_MN1 (XI1344_I168_XP_n1 I1344_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I168_XP_MN0 (I1344_P17_2n I1344_P17_10 XI1344_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I10_MN1 (XI1390_I10_n1 b18_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I10_MN0 (I1390_gn10 p17_9 XI1390_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I9_MN1 (XI1390_I9_n1 b18_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I9_MN0 (I1390_gn9 p17_8 XI1390_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I106_XP_MN1 (XI1390_I106_XP_n1 I1390_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I106_XP_MN0 (I1390_P10_7n I1390_P10_9 XI1390_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I167_XP_MN1 (XI1390_I167_XP_n1 I1390_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I167_XP_MN0 (I1390_P16_1n I1390_P16_9 XI1390_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I9_MN1 (XI1436_I9_n1 b19_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I9_MN0 (I1436_gn9 p18_8 XI1436_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I106_XP_MN1 (XI1436_I106_XP_n1 I1436_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I106_XP_MN0 (I1436_P10_7n I1436_P10_9 XI1436_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I167_XP_MN1 (XI1436_I167_XP_n1 I1436_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I167_XP_MN0 (I1436_P16_1n I1436_P16_9 XI1436_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I103_XP_MN1 (XI1436_I103_XP_n1 I1436_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I103_XP_MN0 (I1436_P7_4n I1436_P7_6 XI1436_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I105_XP_MN1 (XI1436_I105_XP_n1 I1436_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I105_XP_MN0 (I1436_P9_6n I1436_P9_8 XI1436_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I10_MN1 (XI1482_I10_n1 b20_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I10_MN0 (I1482_gn10 p19_9 XI1482_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I9_MN1 (XI1482_I9_n1 b20_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I9_MN0 (I1482_gn9 p19_8 XI1482_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I105_XP_MN1 (XI1482_I105_XP_n1 I1482_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I105_XP_MN0 (I1482_P9_6n I1482_P9_8 XI1482_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I167_XP_MN1 (XI1482_I167_XP_n1 I1482_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I167_XP_MN0 (I1482_P16_1n I1482_P16_9 XI1482_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I12_MN1 (XI1528_I12_n1 b21_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I12_MN0 (I1528_gn12 p20_11 XI1528_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I110_XP_MN1 (XI1528_I110_XP_n1 I1528_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I110_XP_MN0 (I1528_P14_11n I1528_P14_13 XI1528_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I169_XP_MN1 (XI1528_I169_XP_n1 I1528_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I169_XP_MN0 (I1528_P18_3n I1528_P18_11 XI1528_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I179_XP_MN1 (XI1528_I179_XP_n1 I1528_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I179_XP_MN0 (I1528_P28_13n I1528_P28_21 XI1528_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I109_XP_MN1 (XI1528_I109_XP_n1 I1528_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I109_XP_MN0 (I1528_P13_10n I1528_P13_12 XI1528_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I182_XP_MN1 (XI1160_I182_XP_n1 I1160_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I182_XP_MN0 (I1160_P31_16n I1160_P31_24 XI1160_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I174_XP_MN1 (XI1160_I174_XP_n1 I1160_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I174_XP_MN0 (I1160_P23_8n I1160_P23_16 XI1160_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I117_XP_MN1 (XI1160_I117_XP_n1 I1160_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I117_XP_MN0 (I1160_P21_18n I1160_P21_20 XI1160_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I115_XP_MN1 (XI1160_I115_XP_n1 I1160_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I115_XP_MN0 (I1160_P19_16n I1160_P19_18 XI1160_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I113_XP_MN1 (XI1160_I113_XP_n1 I1160_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I113_XP_MN0 (I1160_P17_14n I1160_P17_16 XI1160_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I111_XP_MN1 (XI1160_I111_XP_n1 I1160_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I111_XP_MN0 (I1160_P15_12n I1160_P15_14 XI1160_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I109_XP_MN1 (XI1160_I109_XP_n1 I1160_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I109_XP_MN0 (I1160_P13_10n I1160_P13_12 XI1160_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I107_XP_MN1 (XI1160_I107_XP_n1 I1160_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I107_XP_MN0 (I1160_P11_8n I1160_P11_10 XI1160_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I105_XP_MN1 (XI1160_I105_XP_n1 I1160_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I105_XP_MN0 (I1160_P9_6n I1160_P9_8 XI1160_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I103_XP_MN1 (XI1160_I103_XP_n1 I1160_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I103_XP_MN0 (I1160_P7_4n I1160_P7_6 XI1160_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I101_XP_MN1 (XI1160_I101_XP_n1 I1160_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I101_XP_MN0 (I1160_P5_2n I1160_P5_4 XI1160_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
