    I_MXI884_I151_XP_MP0 (XI884_I151_XP_p1 I884_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I151_XP_MP1 (I884_P26_19 I884_P22_19n XI884_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I153_XP_MP0 (XI884_I153_XP_p1 I884_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I153_XP_MP1 (I884_P28_21 I884_P24_21n XI884_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I151_XP_MP0 (XI1712_I151_XP_p1 I1712_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I151_XP_MP1 (I1712_P26_19 I1712_P22_19n XI1712_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I153_XP_MP0 (XI1712_I153_XP_p1 I1712_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I153_XP_MP1 (I1712_P28_21 I1712_P24_21n XI1712_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I84_XP_MP0 (XI1712_I84_XP_p1 I1712_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I84_XP_MP1 (I1712_P18_17 I1712_pn17 XI1712_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I83_XP_MP0 (XI1712_I83_XP_p1 I1712_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I83_XP_MP1 (I1712_P17_16 I1712_pn16 XI1712_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I150_XP_MP0 (XI1712_I150_XP_p1 I1712_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I150_XP_MP1 (I1712_P25_18 I1712_P21_18n XI1712_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I86_XP_MP0 (XI1758_I86_XP_p1 I1758_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I86_XP_MP1 (I1758_P20_19 I1758_pn19 XI1758_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I147_XP_MP0 (XI1758_I147_XP_p1 I1758_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I147_XP_MP1 (I1758_P22_15 I1758_P18_15n XI1758_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I151_XP_MP0 (XI1758_I151_XP_p1 I1758_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I151_XP_MP1 (I1758_P26_19 I1758_P22_19n XI1758_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I85_XP_MP0 (XI1758_I85_XP_p1 I1758_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I85_XP_MP1 (I1758_P19_18 I1758_pn18 XI1758_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I148_XP_MP0 (XI1804_I148_XP_p1 I1804_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I148_XP_MP1 (I1804_P23_16 I1804_P19_16n XI1804_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I85_XP_MP0 (XI1804_I85_XP_p1 I1804_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I85_XP_MP1 (I1804_P19_18 I1804_pn18 XI1804_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I87_XP_MP0 (XI1804_I87_XP_p1 I1804_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I87_XP_MP1 (I1804_P21_20 I1804_pn20 XI1804_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I150_XP_MP0 (XI1804_I150_XP_p1 I1804_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I150_XP_MP1 (I1804_P25_18 I1804_P21_18n XI1804_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I154_XP_MP0 (XI1804_I154_XP_p1 I1804_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I154_XP_MP1 (I1804_P29_22 I1804_P25_22n XI1804_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I90_XP_MP0 (XI1804_I90_XP_p1 I1804_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I90_XP_MP1 (I1804_P24_23 I1804_pn23 XI1804_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I94_XP_MP0 (XI1804_I94_XP_p1 I1804_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I94_XP_MP1 (I1804_P28_27 I1804_pn27 XI1804_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I95_XP_MP0 (XI746_I95_XP_p1 I746_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I95_XP_MP1 (I746_P29_28 I746_pn28 XI746_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I94_XP_MP0 (XI746_I94_XP_p1 I746_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I94_XP_MP1 (I746_P28_27 I746_pn27 XI746_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I155_XP_MP0 (XI746_I155_XP_p1 I746_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I155_XP_MP1 (I746_P30_23 I746_P26_23n XI746_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I91_XP_MP0 (XI792_I91_XP_p1 I792_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I91_XP_MP1 (I792_P25_24 I792_pn24 XI792_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I152_XP_MP0 (XI792_I152_XP_p1 I792_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I152_XP_MP1 (I792_P27_20 I792_P23_20n XI792_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I148_XP_MP0 (XI792_I148_XP_p1 I792_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I148_XP_MP1 (I792_P23_16 I792_P19_16n XI792_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I92_XP_MP0 (XI792_I92_XP_p1 I792_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I92_XP_MP1 (I792_P26_25 I792_pn25 XI792_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I151_XP_MP0 (XI792_I151_XP_p1 I792_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I151_XP_MP1 (I792_P26_19 I792_P22_19n XI792_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I156_XP_MP0 (XI838_I156_XP_p1 I838_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I156_XP_MP1 (I838_P31_24 I838_P27_24n XI838_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I89_XP_MP0 (XI838_I89_XP_p1 I838_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I89_XP_MP1 (I838_P23_22 I838_pn22 XI838_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I87_XP_MP0 (XI838_I87_XP_p1 I838_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I87_XP_MP1 (I838_P21_20 I838_pn20 XI838_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I88_XP_MP0 (XI838_I88_XP_p1 I838_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I88_XP_MP1 (I838_P22_21 I838_pn21 XI838_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I155_XP_MP0 (XI838_I155_XP_p1 I838_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I155_XP_MP1 (I838_P30_23 I838_P26_23n XI838_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I88_XP_MP0 (XI884_I88_XP_p1 I884_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I88_XP_MP1 (I884_P22_21 I884_pn21 XI884_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I87_XP_MP0 (XI884_I87_XP_p1 I884_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I87_XP_MP1 (I884_P21_20 I884_pn20 XI884_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I152_XP_MP0 (XI884_I152_XP_p1 I884_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I152_XP_MP1 (I884_P27_20 I884_P23_20n XI884_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I155_XP_MP0 (XI1712_I155_XP_p1 I1712_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I155_XP_MP1 (I1712_P30_23 I1712_P26_23n XI1712_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I86_XP_MP0 (XI1712_I86_XP_p1 I1712_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I86_XP_MP1 (I1712_P20_19 I1712_pn19 XI1712_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I85_XP_MP0 (XI1712_I85_XP_p1 I1712_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I85_XP_MP1 (I1712_P19_18 I1712_pn18 XI1712_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I152_XP_MP0 (XI1712_I152_XP_p1 I1712_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I152_XP_MP1 (I1712_P27_20 I1712_P23_20n XI1712_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I148_XP_MP0 (XI1712_I148_XP_p1 I1712_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I148_XP_MP1 (I1712_P23_16 I1712_P19_16n XI1712_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I88_XP_MP0 (XI1758_I88_XP_p1 I1758_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I88_XP_MP1 (I1758_P22_21 I1758_pn21 XI1758_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I155_XP_MP0 (XI1758_I155_XP_p1 I1758_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I155_XP_MP1 (I1758_P30_23 I1758_P26_23n XI1758_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I87_XP_MP0 (XI1758_I87_XP_p1 I1758_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I87_XP_MP1 (I1758_P21_20 I1758_pn20 XI1758_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I154_XP_MP0 (XI1758_I154_XP_p1 I1758_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I154_XP_MP1 (I1758_P29_22 I1758_P25_22n XI1758_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I152_XP_MP0 (XI1758_I152_XP_p1 I1758_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I152_XP_MP1 (I1758_P27_20 I1758_P23_20n XI1758_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I148_XP_MP0 (XI1758_I148_XP_p1 I1758_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I148_XP_MP1 (I1758_P23_16 I1758_P19_16n XI1758_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I152_XP_MP0 (XI1804_I152_XP_p1 I1804_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I152_XP_MP1 (I1804_P27_20 I1804_P23_20n XI1804_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I89_XP_MP0 (XI1804_I89_XP_p1 I1804_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I89_XP_MP1 (I1804_P23_22 I1804_pn22 XI1804_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I91_XP_MP0 (XI1804_I91_XP_p1 I1804_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I91_XP_MP1 (I1804_P25_24 I1804_pn24 XI1804_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I96_XP_MP0 (XI1804_I96_XP_p1 I1804_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I96_XP_MP1 (I1804_P30_29 I1804_pn29 XI1804_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I93_XP_MP0 (XI1804_I93_XP_p1 I1804_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I93_XP_MP1 (I1804_P27_26 I1804_pn26 XI1804_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I97_XP_MP0 (XI746_I97_XP_p1 I746_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I97_XP_MP1 (I746_P31_30 I746_pn30 XI746_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI746_I96_XP_MP0 (XI746_I96_XP_p1 I746_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI746_I96_XP_MP1 (I746_P30_29 I746_pn29 XI746_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I97_XP_MP0 (XI792_I97_XP_p1 I792_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I97_XP_MP1 (I792_P31_30 I792_pn30 XI792_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I93_XP_MP0 (XI792_I93_XP_p1 I792_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I93_XP_MP1 (I792_P27_26 I792_pn26 XI792_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I156_XP_MP0 (XI792_I156_XP_p1 I792_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I156_XP_MP1 (I792_P31_24 I792_P27_24n XI792_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I94_XP_MP0 (XI792_I94_XP_p1 I792_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I94_XP_MP1 (I792_P28_27 I792_pn27 XI792_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I155_XP_MP0 (XI792_I155_XP_p1 I792_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I155_XP_MP1 (I792_P30_23 I792_P26_23n XI792_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I97_XP_MP0 (XI838_I97_XP_p1 I838_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I97_XP_MP1 (I838_P31_30 I838_pn30 XI838_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I91_XP_MP0 (XI838_I91_XP_p1 I838_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I91_XP_MP1 (I838_P25_24 I838_pn24 XI838_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I90_XP_MP0 (XI838_I90_XP_p1 I838_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I90_XP_MP1 (I838_P24_23 I838_pn23 XI838_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I155_XP_MP0 (XI884_I155_XP_p1 I884_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I155_XP_MP1 (I884_P30_23 I884_P26_23n XI884_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I89_XP_MP0 (XI884_I89_XP_p1 I884_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I89_XP_MP1 (I884_P23_22 I884_pn22 XI884_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I90_XP_MP0 (XI884_I90_XP_p1 I884_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I90_XP_MP1 (I884_P24_23 I884_pn23 XI884_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I154_XP_MP0 (XI884_I154_XP_p1 I884_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I154_XP_MP1 (I884_P29_22 I884_P25_22n XI884_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I148_XP_MP0 (XI884_I148_XP_p1 I884_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I148_XP_MP1 (I884_P23_16 I884_P19_16n XI884_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I88_XP_MP0 (XI1712_I88_XP_p1 I1712_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I88_XP_MP1 (I1712_P22_21 I1712_pn21 XI1712_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I89_XP_MP0 (XI1712_I89_XP_p1 I1712_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I89_XP_MP1 (I1712_P23_22 I1712_pn22 XI1712_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I87_XP_MP0 (XI1712_I87_XP_p1 I1712_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I87_XP_MP1 (I1712_P21_20 I1712_pn20 XI1712_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I154_XP_MP0 (XI1712_I154_XP_p1 I1712_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I154_XP_MP1 (I1712_P29_22 I1712_P25_22n XI1712_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I90_XP_MP0 (XI1758_I90_XP_p1 I1758_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I90_XP_MP1 (I1758_P24_23 I1758_pn23 XI1758_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I92_XP_MP0 (XI1758_I92_XP_p1 I1758_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I92_XP_MP1 (I1758_P26_25 I1758_pn25 XI1758_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I89_XP_MP0 (XI1758_I89_XP_p1 I1758_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I89_XP_MP1 (I1758_P23_22 I1758_pn22 XI1758_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I91_XP_MP0 (XI1758_I91_XP_p1 I1758_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I91_XP_MP1 (I1758_P25_24 I1758_pn24 XI1758_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I156_XP_MP0 (XI1758_I156_XP_p1 I1758_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I156_XP_MP1 (I1758_P31_24 I1758_P27_24n XI1758_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I156_XP_MP0 (XI1804_I156_XP_p1 I1804_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I156_XP_MP1 (I1804_P31_24 I1804_P27_24n XI1804_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I95_XP_MP0 (XI1804_I95_XP_p1 I1804_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I95_XP_MP1 (I1804_P29_28 I1804_pn28 XI1804_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I95_XP_MP0 (XI792_I95_XP_p1 I792_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I95_XP_MP1 (I792_P29_28 I792_pn28 XI792_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI792_I96_XP_MP0 (XI792_I96_XP_p1 I792_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI792_I96_XP_MP1 (I792_P30_29 I792_pn29 XI792_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I95_XP_MP0 (XI838_I95_XP_p1 I838_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I95_XP_MP1 (I838_P29_28 I838_pn28 XI838_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I93_XP_MP0 (XI838_I93_XP_p1 I838_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I93_XP_MP1 (I838_P27_26 I838_pn26 XI838_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I94_XP_MP0 (XI838_I94_XP_p1 I838_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I94_XP_MP1 (I838_P28_27 I838_pn27 XI838_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I92_XP_MP0 (XI838_I92_XP_p1 I838_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I92_XP_MP1 (I838_P26_25 I838_pn25 XI838_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI838_I96_XP_MP0 (XI838_I96_XP_p1 I838_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI838_I96_XP_MP1 (I838_P30_29 I838_pn29 XI838_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I92_XP_MP0 (XI884_I92_XP_p1 I884_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I92_XP_MP1 (I884_P26_25 I884_pn25 XI884_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I91_XP_MP0 (XI884_I91_XP_p1 I884_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I91_XP_MP1 (I884_P25_24 I884_pn24 XI884_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I93_XP_MP0 (XI884_I93_XP_p1 I884_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I93_XP_MP1 (I884_P27_26 I884_pn26 XI884_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I156_XP_MP0 (XI884_I156_XP_p1 I884_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I156_XP_MP1 (I884_P31_24 I884_P27_24n XI884_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I90_XP_MP0 (XI1712_I90_XP_p1 I1712_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I90_XP_MP1 (I1712_P24_23 I1712_pn23 XI1712_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I91_XP_MP0 (XI1712_I91_XP_p1 I1712_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I91_XP_MP1 (I1712_P25_24 I1712_pn24 XI1712_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I156_XP_MP0 (XI1712_I156_XP_p1 I1712_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I156_XP_MP1 (I1712_P31_24 I1712_P27_24n XI1712_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I94_XP_MP0 (XI1758_I94_XP_p1 I1758_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I94_XP_MP1 (I1758_P28_27 I1758_pn27 XI1758_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I93_XP_MP0 (XI1758_I93_XP_p1 I1758_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I93_XP_MP1 (I1758_P27_26 I1758_pn26 XI1758_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I96_XP_MP0 (XI1758_I96_XP_p1 I1758_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I96_XP_MP1 (I1758_P30_29 I1758_pn29 XI1758_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I95_XP_MP0 (XI1758_I95_XP_p1 I1758_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I95_XP_MP1 (I1758_P29_28 I1758_pn28 XI1758_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1758_I97_XP_MP0 (XI1758_I97_XP_p1 I1758_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1758_I97_XP_MP1 (I1758_P31_30 I1758_pn30 XI1758_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1804_I97_XP_MP0 (XI1804_I97_XP_p1 I1804_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1804_I97_XP_MP1 (I1804_P31_30 I1804_pn30 XI1804_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I146_XP_MP0 (XI1068_I146_XP_p1 I1068_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I146_XP_MP1 (I1068_P21_14 I1068_P17_14n XI1068_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I142_XP_MP0 (XI1068_I142_XP_p1 I1068_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I142_XP_MP1 (I1068_P17_10 I1068_P13_10n XI1068_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I138_XP_MP0 (XI1068_I138_XP_p1 I1068_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I138_XP_MP1 (I1068_P13_6 I1068_P9_6n XI1068_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I134_XP_MP0 (XI1068_I134_XP_p1 I1068_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I134_XP_MP1 (I1068_P9_2 I1068_P5_2n XI1068_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I71_XP_MP0 (XI1068_I71_XP_p1 I1068_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I71_XP_MP1 (I1068_P5_4 I1068_pn4 XI1068_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I96_XP_MP0 (XI884_I96_XP_p1 I884_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I96_XP_MP1 (I884_P30_29 I884_pn29 XI884_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I97_XP_MP0 (XI884_I97_XP_p1 I884_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I97_XP_MP1 (I884_P31_30 I884_pn30 XI884_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I94_XP_MP0 (XI884_I94_XP_p1 I884_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I94_XP_MP1 (I884_P28_27 I884_pn27 XI884_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI884_I95_XP_MP0 (XI884_I95_XP_p1 I884_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI884_I95_XP_MP1 (I884_P29_28 I884_pn28 XI884_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I92_XP_MP0 (XI1712_I92_XP_p1 I1712_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I92_XP_MP1 (I1712_P26_25 I1712_pn25 XI1712_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I94_XP_MP0 (XI1712_I94_XP_p1 I1712_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I94_XP_MP1 (I1712_P28_27 I1712_pn27 XI1712_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I93_XP_MP0 (XI1712_I93_XP_p1 I1712_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I93_XP_MP1 (I1712_P27_26 I1712_pn26 XI1712_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I96_XP_MP0 (XI1712_I96_XP_p1 I1712_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I96_XP_MP1 (I1712_P30_29 I1712_pn29 XI1712_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I95_XP_MP0 (XI1712_I95_XP_p1 I1712_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I95_XP_MP1 (I1712_P29_28 I1712_pn28 XI1712_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1712_I97_XP_MP0 (XI1712_I97_XP_p1 I1712_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1712_I97_XP_MP1 (I1712_P31_30 I1712_pn30 XI1712_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I154_XP_MP0 (XI1068_I154_XP_p1 I1068_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I154_XP_MP1 (I1068_P29_22 I1068_P25_22n XI1068_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I150_XP_MP0 (XI1068_I150_XP_p1 I1068_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I150_XP_MP1 (I1068_P25_18 I1068_P21_18n XI1068_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I140_XP_MP0 (XI1068_I140_XP_p1 I1068_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I140_XP_MP1 (I1068_P15_8 I1068_P11_8n XI1068_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I136_XP_MP0 (XI1068_I136_XP_p1 I1068_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I136_XP_MP1 (I1068_P11_4 I1068_P7_4n XI1068_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I73_XP_MP0 (XI1068_I73_XP_p1 I1068_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I73_XP_MP1 (I1068_P7_6 I1068_pn6 XI1068_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I70_XP_MP0 (XI1068_I70_XP_p1 I1068_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I70_XP_MP1 (I1068_P4_3 I1068_pn3 XI1068_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I69_XP_MP0 (XI1068_I69_XP_p1 I1068_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I69_XP_MP1 (I1068_P3_2 I1068_pn2 XI1068_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I93_XP_MP0 (XI1068_I93_XP_p1 I1068_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I93_XP_MP1 (I1068_P27_26 I1068_pn26 XI1068_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I156_XP_MP0 (XI1068_I156_XP_p1 I1068_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I156_XP_MP1 (I1068_P31_24 I1068_P27_24n XI1068_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I152_XP_MP0 (XI1068_I152_XP_p1 I1068_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I152_XP_MP1 (I1068_P27_20 I1068_P23_20n XI1068_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I148_XP_MP0 (XI1068_I148_XP_p1 I1068_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I148_XP_MP1 (I1068_P23_16 I1068_P19_16n XI1068_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I144_XP_MP0 (XI1068_I144_XP_p1 I1068_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I144_XP_MP1 (I1068_P19_12 I1068_P15_12n XI1068_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I75_XP_MP0 (XI1068_I75_XP_p1 I1068_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I75_XP_MP1 (I1068_P9_8 I1068_pn8 XI1068_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I72_XP_MP0 (XI1068_I72_XP_p1 I1068_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I72_XP_MP1 (I1068_P6_5 I1068_pn5 XI1068_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I68_XP_MP0 (XI1022_I68_XP_p1 I1022_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I68_XP_MP1 (I1022_P2_1 I1022_pn1 XI1022_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I68_XP_MP0 (XI1666_I68_XP_p1 I1666_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I68_XP_MP1 (I1666_P2_1 I1666_pn1 XI1666_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I69_XP_MP0 (XI1666_I69_XP_p1 I1666_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I69_XP_MP1 (I1666_P3_2 I1666_pn2 XI1666_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I68_XP_MP0 (XI1620_I68_XP_p1 I1620_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I68_XP_MP1 (I1620_P2_1 I1620_pn1 XI1620_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I69_XP_MP0 (XI1574_I69_XP_p1 I1574_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I69_XP_MP1 (I1574_P3_2 I1574_pn2 XI1574_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I68_XP_MP0 (XI1574_I68_XP_p1 I1574_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I68_XP_MP1 (I1574_P2_1 I1574_pn1 XI1574_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I70_XP_MP0 (XI1574_I70_XP_p1 I1574_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I70_XP_MP1 (I1574_P4_3 I1574_pn3 XI1574_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I133_XP_MP0 (XI1574_I133_XP_p1 I1574_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I133_XP_MP1 (I1574_P8_1 I1574_P4_1n XI1574_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I95_XP_MP0 (XI1068_I95_XP_p1 I1068_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I95_XP_MP1 (I1068_P29_28 I1068_pn28 XI1068_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I135_XP_MP0 (XI1068_I135_XP_p1 I1068_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I135_XP_MP1 (I1068_P10_3 I1068_P6_3n XI1068_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I77_XP_MP0 (XI1068_I77_XP_p1 I1068_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I77_XP_MP1 (I1068_P11_10 I1068_pn10 XI1068_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I74_XP_MP0 (XI1068_I74_XP_p1 I1068_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I74_XP_MP1 (I1068_P8_7 I1068_pn7 XI1068_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I68_XP_MP0 (XI1068_I68_XP_p1 I1068_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I68_XP_MP1 (I1068_P2_1 I1068_pn1 XI1068_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I69_XP_MP0 (XI1022_I69_XP_p1 I1022_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I69_XP_MP1 (I1022_P3_2 I1022_pn2 XI1022_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I70_XP_MP0 (XI1022_I70_XP_p1 I1022_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I70_XP_MP1 (I1022_P4_3 I1022_pn3 XI1022_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I68_XP_MP0 (XI976_I68_XP_p1 I976_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I68_XP_MP1 (I976_P2_1 I976_pn1 XI976_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I70_XP_MP0 (XI976_I70_XP_p1 I976_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I70_XP_MP1 (I976_P4_3 I976_pn3 XI976_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I69_XP_MP0 (XI976_I69_XP_p1 I976_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I69_XP_MP1 (I976_P3_2 I976_pn2 XI976_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I68_XP_MP0 (XI930_I68_XP_p1 I930_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I68_XP_MP1 (I930_P2_1 I930_pn1 XI930_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I69_XP_MP0 (XI930_I69_XP_p1 I930_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I69_XP_MP1 (I930_P3_2 I930_pn2 XI930_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I70_XP_MP0 (XI930_I70_XP_p1 I930_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I70_XP_MP1 (I930_P4_3 I930_pn3 XI930_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I71_XP_MP0 (XI930_I71_XP_p1 I930_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I71_XP_MP1 (I930_P5_4 I930_pn4 XI930_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I133_XP_MP0 (XI1666_I133_XP_p1 I1666_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I133_XP_MP1 (I1666_P8_1 I1666_P4_1n XI1666_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I72_XP_MP0 (XI1666_I72_XP_p1 I1666_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I72_XP_MP1 (I1666_P6_5 I1666_pn5 XI1666_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I70_XP_MP0 (XI1666_I70_XP_p1 I1666_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I70_XP_MP1 (I1666_P4_3 I1666_pn3 XI1666_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I71_XP_MP0 (XI1666_I71_XP_p1 I1666_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I71_XP_MP1 (I1666_P5_4 I1666_pn4 XI1666_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I69_XP_MP0 (XI1620_I69_XP_p1 I1620_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I69_XP_MP1 (I1620_P3_2 I1620_pn2 XI1620_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I71_XP_MP0 (XI1620_I71_XP_p1 I1620_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I71_XP_MP1 (I1620_P5_4 I1620_pn4 XI1620_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I70_XP_MP0 (XI1620_I70_XP_p1 I1620_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I70_XP_MP1 (I1620_P4_3 I1620_pn3 XI1620_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I71_XP_MP0 (XI1574_I71_XP_p1 I1574_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I71_XP_MP1 (I1574_P5_4 I1574_pn4 XI1574_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I72_XP_MP0 (XI1574_I72_XP_p1 I1574_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I72_XP_MP1 (I1574_P6_5 I1574_pn5 XI1574_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I94_XP_MP0 (XI1068_I94_XP_p1 I1068_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I94_XP_MP1 (I1068_P28_27 I1068_pn27 XI1068_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I155_XP_MP0 (XI1068_I155_XP_p1 I1068_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I155_XP_MP1 (I1068_P30_23 I1068_P26_23n XI1068_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I151_XP_MP0 (XI1068_I151_XP_p1 I1068_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I151_XP_MP1 (I1068_P26_19 I1068_P22_19n XI1068_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I147_XP_MP0 (XI1068_I147_XP_p1 I1068_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I147_XP_MP1 (I1068_P22_15 I1068_P18_15n XI1068_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I143_XP_MP0 (XI1068_I143_XP_p1 I1068_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I143_XP_MP1 (I1068_P18_11 I1068_P14_11n XI1068_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I139_XP_MP0 (XI1068_I139_XP_p1 I1068_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I139_XP_MP1 (I1068_P14_7 I1068_P10_7n XI1068_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I76_XP_MP0 (XI1068_I76_XP_p1 I1068_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I76_XP_MP1 (I1068_P10_9 I1068_pn9 XI1068_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I137_XP_MP0 (XI1068_I137_XP_p1 I1068_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I137_XP_MP1 (I1068_P12_5 I1068_P8_5n XI1068_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I133_XP_MP0 (XI1068_I133_XP_p1 I1068_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I133_XP_MP1 (I1068_P8_1 I1068_P4_1n XI1068_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I73_XP_MP0 (XI1022_I73_XP_p1 I1022_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I73_XP_MP1 (I1022_P7_6 I1022_pn6 XI1022_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I71_XP_MP0 (XI1022_I71_XP_p1 I1022_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I71_XP_MP1 (I1022_P5_4 I1022_pn4 XI1022_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I72_XP_MP0 (XI1022_I72_XP_p1 I1022_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I72_XP_MP1 (I1022_P6_5 I1022_pn5 XI1022_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I72_XP_MP0 (XI976_I72_XP_p1 I976_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I72_XP_MP1 (I976_P6_5 I976_pn5 XI976_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I71_XP_MP0 (XI976_I71_XP_p1 I976_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I71_XP_MP1 (I976_P5_4 I976_pn4 XI976_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I72_XP_MP0 (XI930_I72_XP_p1 I930_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I72_XP_MP1 (I930_P6_5 I930_pn5 XI930_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I74_XP_MP0 (XI930_I74_XP_p1 I930_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I74_XP_MP1 (I930_P8_7 I930_pn7 XI930_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I73_XP_MP0 (XI930_I73_XP_p1 I930_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I73_XP_MP1 (I930_P7_6 I930_pn6 XI930_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I74_XP_MP0 (XI1666_I74_XP_p1 I1666_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I74_XP_MP1 (I1666_P8_7 I1666_pn7 XI1666_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I73_XP_MP0 (XI1666_I73_XP_p1 I1666_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I73_XP_MP1 (I1666_P7_6 I1666_pn6 XI1666_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I73_XP_MP0 (XI1620_I73_XP_p1 I1620_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I73_XP_MP1 (I1620_P7_6 I1620_pn6 XI1620_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I133_XP_MP0 (XI1620_I133_XP_p1 I1620_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I133_XP_MP1 (I1620_P8_1 I1620_P4_1n XI1620_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I72_XP_MP0 (XI1620_I72_XP_p1 I1620_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I72_XP_MP1 (I1620_P6_5 I1620_pn5 XI1620_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I74_XP_MP0 (XI1620_I74_XP_p1 I1620_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I74_XP_MP1 (I1620_P8_7 I1620_pn7 XI1620_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I75_XP_MP0 (XI1574_I75_XP_p1 I1574_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I75_XP_MP1 (I1574_P9_8 I1574_pn8 XI1574_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I73_XP_MP0 (XI1574_I73_XP_p1 I1574_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I73_XP_MP1 (I1574_P7_6 I1574_pn6 XI1574_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I74_XP_MP0 (XI1574_I74_XP_p1 I1574_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I74_XP_MP1 (I1574_P8_7 I1574_pn7 XI1574_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I137_XP_MP0 (XI1574_I137_XP_p1 I1574_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I137_XP_MP1 (I1574_P12_5 I1574_P8_5n XI1574_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I92_XP_MP0 (XI1068_I92_XP_p1 I1068_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I92_XP_MP1 (I1068_P26_25 I1068_pn25 XI1068_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I153_XP_MP0 (XI1068_I153_XP_p1 I1068_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I153_XP_MP1 (I1068_P28_21 I1068_P24_21n XI1068_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I145_XP_MP0 (XI1068_I145_XP_p1 I1068_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I145_XP_MP1 (I1068_P20_13 I1068_P16_13n XI1068_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I149_XP_MP0 (XI1068_I149_XP_p1 I1068_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I149_XP_MP1 (I1068_P24_17 I1068_P20_17n XI1068_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I141_XP_MP0 (XI1068_I141_XP_p1 I1068_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I141_XP_MP1 (I1068_P16_9 I1068_P12_9n XI1068_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I78_XP_MP0 (XI1068_I78_XP_p1 I1068_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I78_XP_MP1 (I1068_P12_11 I1068_pn11 XI1068_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I134_XP_MP0 (XI1022_I134_XP_p1 I1022_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I134_XP_MP1 (I1022_P9_2 I1022_P5_2n XI1022_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I75_XP_MP0 (XI1022_I75_XP_p1 I1022_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I75_XP_MP1 (I1022_P9_8 I1022_pn8 XI1022_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I133_XP_MP0 (XI1022_I133_XP_p1 I1022_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I133_XP_MP1 (I1022_P8_1 I1022_P4_1n XI1022_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I74_XP_MP0 (XI1022_I74_XP_p1 I1022_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I74_XP_MP1 (I1022_P8_7 I1022_pn7 XI1022_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I76_XP_MP0 (XI1022_I76_XP_p1 I1022_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I76_XP_MP1 (I1022_P10_9 I1022_pn9 XI1022_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I133_XP_MP0 (XI976_I133_XP_p1 I976_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I133_XP_MP1 (I976_P8_1 I976_P4_1n XI976_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I74_XP_MP0 (XI976_I74_XP_p1 I976_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I74_XP_MP1 (I976_P8_7 I976_pn7 XI976_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I73_XP_MP0 (XI976_I73_XP_p1 I976_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I73_XP_MP1 (I976_P7_6 I976_pn6 XI976_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I133_XP_MP0 (XI930_I133_XP_p1 I930_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I133_XP_MP1 (I930_P8_1 I930_P4_1n XI930_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I137_XP_MP0 (XI930_I137_XP_p1 I930_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I137_XP_MP1 (I930_P12_5 I930_P8_5n XI930_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I76_XP_MP0 (XI930_I76_XP_p1 I930_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I76_XP_MP1 (I930_P10_9 I930_pn9 XI930_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I75_XP_MP0 (XI930_I75_XP_p1 I930_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I75_XP_MP1 (I930_P9_8 I930_pn8 XI930_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I134_XP_MP0 (XI930_I134_XP_p1 I930_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I134_XP_MP1 (I930_P9_2 I930_P5_2n XI930_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I141_XP_MP0 (XI1666_I141_XP_p1 I1666_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I141_XP_MP1 (I1666_P16_9 I1666_P12_9n XI1666_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I137_XP_MP0 (XI1666_I137_XP_p1 I1666_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I137_XP_MP1 (I1666_P12_5 I1666_P8_5n XI1666_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I135_XP_MP0 (XI1666_I135_XP_p1 I1666_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I135_XP_MP1 (I1666_P10_3 I1666_P6_3n XI1666_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I76_XP_MP0 (XI1666_I76_XP_p1 I1666_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I76_XP_MP1 (I1666_P10_9 I1666_pn9 XI1666_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I134_XP_MP0 (XI1666_I134_XP_p1 I1666_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I134_XP_MP1 (I1666_P9_2 I1666_P5_2n XI1666_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I75_XP_MP0 (XI1666_I75_XP_p1 I1666_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I75_XP_MP1 (I1666_P9_8 I1666_pn8 XI1666_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I134_XP_MP0 (XI1620_I134_XP_p1 I1620_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I134_XP_MP1 (I1620_P9_2 I1620_P5_2n XI1620_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I75_XP_MP0 (XI1620_I75_XP_p1 I1620_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I75_XP_MP1 (I1620_P9_8 I1620_pn8 XI1620_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I135_XP_MP0 (XI1620_I135_XP_p1 I1620_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I135_XP_MP1 (I1620_P10_3 I1620_P6_3n XI1620_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I76_XP_MP0 (XI1620_I76_XP_p1 I1620_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I76_XP_MP1 (I1620_P10_9 I1620_pn9 XI1620_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I134_XP_MP0 (XI1574_I134_XP_p1 I1574_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I134_XP_MP1 (I1574_P9_2 I1574_P5_2n XI1574_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I76_XP_MP0 (XI1574_I76_XP_p1 I1574_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I76_XP_MP1 (I1574_P10_9 I1574_pn9 XI1574_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I135_XP_MP0 (XI1574_I135_XP_p1 I1574_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I135_XP_MP1 (I1574_P10_3 I1574_P6_3n XI1574_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I141_XP_MP0 (XI1574_I141_XP_p1 I1574_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I141_XP_MP1 (I1574_P16_9 I1574_P12_9n XI1574_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I97_XP_MP0 (XI1068_I97_XP_p1 I1068_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I97_XP_MP1 (I1068_P31_30 I1068_pn30 XI1068_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I96_XP_MP0 (XI1068_I96_XP_p1 I1068_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I96_XP_MP1 (I1068_P30_29 I1068_pn29 XI1068_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I91_XP_MP0 (XI1068_I91_XP_p1 I1068_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I91_XP_MP1 (I1068_P25_24 I1068_pn24 XI1068_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I90_XP_MP0 (XI1068_I90_XP_p1 I1068_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I90_XP_MP1 (I1068_P24_23 I1068_pn23 XI1068_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I89_XP_MP0 (XI1068_I89_XP_p1 I1068_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I89_XP_MP1 (I1068_P23_22 I1068_pn22 XI1068_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I88_XP_MP0 (XI1068_I88_XP_p1 I1068_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I88_XP_MP1 (I1068_P22_21 I1068_pn21 XI1068_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I87_XP_MP0 (XI1068_I87_XP_p1 I1068_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I87_XP_MP1 (I1068_P21_20 I1068_pn20 XI1068_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I86_XP_MP0 (XI1068_I86_XP_p1 I1068_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I86_XP_MP1 (I1068_P20_19 I1068_pn19 XI1068_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I85_XP_MP0 (XI1068_I85_XP_p1 I1068_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I85_XP_MP1 (I1068_P19_18 I1068_pn18 XI1068_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I79_XP_MP0 (XI1068_I79_XP_p1 I1068_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I79_XP_MP1 (I1068_P13_12 I1068_pn12 XI1068_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I80_XP_MP0 (XI1068_I80_XP_p1 I1068_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I80_XP_MP1 (I1068_P14_13 I1068_pn13 XI1068_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I136_XP_MP0 (XI1022_I136_XP_p1 I1022_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I136_XP_MP1 (I1022_P11_4 I1022_P7_4n XI1022_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I77_XP_MP0 (XI1022_I77_XP_p1 I1022_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I77_XP_MP1 (I1022_P11_10 I1022_pn10 XI1022_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I135_XP_MP0 (XI1022_I135_XP_p1 I1022_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I135_XP_MP1 (I1022_P10_3 I1022_P6_3n XI1022_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I141_XP_MP0 (XI1022_I141_XP_p1 I1022_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I141_XP_MP1 (I1022_P16_9 I1022_P12_9n XI1022_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I78_XP_MP0 (XI1022_I78_XP_p1 I1022_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I78_XP_MP1 (I1022_P12_11 I1022_pn11 XI1022_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I76_XP_MP0 (XI976_I76_XP_p1 I976_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I76_XP_MP1 (I976_P10_9 I976_pn9 XI976_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I134_XP_MP0 (XI976_I134_XP_p1 I976_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I134_XP_MP1 (I976_P9_2 I976_P5_2n XI976_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I75_XP_MP0 (XI976_I75_XP_p1 I976_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I75_XP_MP1 (I976_P9_8 I976_pn8 XI976_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I141_XP_MP0 (XI930_I141_XP_p1 I930_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I141_XP_MP1 (I930_P16_9 I930_P12_9n XI930_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I78_XP_MP0 (XI930_I78_XP_p1 I930_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I78_XP_MP1 (I930_P12_11 I930_pn11 XI930_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I77_XP_MP0 (XI930_I77_XP_p1 I930_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I77_XP_MP1 (I930_P11_10 I930_pn10 XI930_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I78_XP_MP0 (XI1666_I78_XP_p1 I1666_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I78_XP_MP1 (I1666_P12_11 I1666_pn11 XI1666_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I136_XP_MP0 (XI1666_I136_XP_p1 I1666_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I136_XP_MP1 (I1666_P11_4 I1666_P7_4n XI1666_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I77_XP_MP0 (XI1666_I77_XP_p1 I1666_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I77_XP_MP1 (I1666_P11_10 I1666_pn10 XI1666_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I77_XP_MP0 (XI1620_I77_XP_p1 I1620_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I77_XP_MP1 (I1620_P11_10 I1620_pn10 XI1620_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I78_XP_MP0 (XI1620_I78_XP_p1 I1620_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I78_XP_MP1 (I1620_P12_11 I1620_pn11 XI1620_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I136_XP_MP0 (XI1574_I136_XP_p1 I1574_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I136_XP_MP1 (I1574_P11_4 I1574_P7_4n XI1574_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I77_XP_MP0 (XI1574_I77_XP_p1 I1574_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I77_XP_MP1 (I1574_P11_10 I1574_pn10 XI1574_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I78_XP_MP0 (XI1574_I78_XP_p1 I1574_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I78_XP_MP1 (I1574_P12_11 I1574_pn11 XI1574_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I139_XP_MP0 (XI1574_I139_XP_p1 I1574_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I139_XP_MP1 (I1574_P14_7 I1574_P10_7n XI1574_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I84_XP_MP0 (XI1068_I84_XP_p1 I1068_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I84_XP_MP1 (I1068_P18_17 I1068_pn17 XI1068_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I83_XP_MP0 (XI1068_I83_XP_p1 I1068_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I83_XP_MP1 (I1068_P17_16 I1068_pn16 XI1068_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I81_XP_MP0 (XI1068_I81_XP_p1 I1068_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I81_XP_MP1 (I1068_P15_14 I1068_pn14 XI1068_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I82_XP_MP0 (XI1068_I82_XP_p1 I1068_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I82_XP_MP1 (I1068_P16_15 I1068_pn15 XI1068_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I138_XP_MP0 (XI1022_I138_XP_p1 I1022_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I138_XP_MP1 (I1022_P13_6 I1022_P9_6n XI1022_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I142_XP_MP0 (XI1022_I142_XP_p1 I1022_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I142_XP_MP1 (I1022_P17_10 I1022_P13_10n XI1022_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I79_XP_MP0 (XI1022_I79_XP_p1 I1022_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I79_XP_MP1 (I1022_P13_12 I1022_pn12 XI1022_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I137_XP_MP0 (XI1022_I137_XP_p1 I1022_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I137_XP_MP1 (I1022_P12_5 I1022_P8_5n XI1022_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I135_XP_MP0 (XI976_I135_XP_p1 I976_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I135_XP_MP1 (I976_P10_3 I976_P6_3n XI976_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I78_XP_MP0 (XI976_I78_XP_p1 I976_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I78_XP_MP1 (I976_P12_11 I976_pn11 XI976_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I77_XP_MP0 (XI976_I77_XP_p1 I976_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I77_XP_MP1 (I976_P11_10 I976_pn10 XI976_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I135_XP_MP0 (XI930_I135_XP_p1 I930_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I135_XP_MP1 (I930_P10_3 I930_P6_3n XI930_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I80_XP_MP0 (XI930_I80_XP_p1 I930_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I80_XP_MP1 (I930_P14_13 I930_pn13 XI930_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I79_XP_MP0 (XI930_I79_XP_p1 I930_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I79_XP_MP1 (I930_P13_12 I930_pn12 XI930_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I136_XP_MP0 (XI930_I136_XP_p1 I930_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I136_XP_MP1 (I930_P11_4 I930_P7_4n XI930_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I138_XP_MP0 (XI930_I138_XP_p1 I930_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I138_XP_MP1 (I930_P13_6 I930_P9_6n XI930_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I145_XP_MP0 (XI1666_I145_XP_p1 I1666_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I145_XP_MP1 (I1666_P20_13 I1666_P16_13n XI1666_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I143_XP_MP0 (XI1666_I143_XP_p1 I1666_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I143_XP_MP1 (I1666_P18_11 I1666_P14_11n XI1666_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I139_XP_MP0 (XI1666_I139_XP_p1 I1666_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I139_XP_MP1 (I1666_P14_7 I1666_P10_7n XI1666_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I80_XP_MP0 (XI1666_I80_XP_p1 I1666_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I80_XP_MP1 (I1666_P14_13 I1666_pn13 XI1666_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I142_XP_MP0 (XI1666_I142_XP_p1 I1666_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I142_XP_MP1 (I1666_P17_10 I1666_P13_10n XI1666_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I138_XP_MP0 (XI1666_I138_XP_p1 I1666_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I138_XP_MP1 (I1666_P13_6 I1666_P9_6n XI1666_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I79_XP_MP0 (XI1666_I79_XP_p1 I1666_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I79_XP_MP1 (I1666_P13_12 I1666_pn12 XI1666_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I136_XP_MP0 (XI1620_I136_XP_p1 I1620_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I136_XP_MP1 (I1620_P11_4 I1620_P7_4n XI1620_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I138_XP_MP0 (XI1620_I138_XP_p1 I1620_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I138_XP_MP1 (I1620_P13_6 I1620_P9_6n XI1620_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I79_XP_MP0 (XI1620_I79_XP_p1 I1620_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I79_XP_MP1 (I1620_P13_12 I1620_pn12 XI1620_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I137_XP_MP0 (XI1620_I137_XP_p1 I1620_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I137_XP_MP1 (I1620_P12_5 I1620_P8_5n XI1620_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I141_XP_MP0 (XI1620_I141_XP_p1 I1620_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I141_XP_MP1 (I1620_P16_9 I1620_P12_9n XI1620_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I138_XP_MP0 (XI1574_I138_XP_p1 I1574_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I138_XP_MP1 (I1574_P13_6 I1574_P9_6n XI1574_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I142_XP_MP0 (XI1574_I142_XP_p1 I1574_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I142_XP_MP1 (I1574_P17_10 I1574_P13_10n XI1574_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I79_XP_MP0 (XI1574_I79_XP_p1 I1574_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I79_XP_MP1 (I1574_P13_12 I1574_pn12 XI1574_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I80_XP_MP0 (XI1574_I80_XP_p1 I1574_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I80_XP_MP1 (I1574_P14_13 I1574_pn13 XI1574_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I143_XP_MP0 (XI1574_I143_XP_p1 I1574_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I143_XP_MP1 (I1574_P18_11 I1574_P14_11n XI1574_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I81_XP_MP0 (XI1022_I81_XP_p1 I1022_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I81_XP_MP1 (I1022_P15_14 I1022_pn14 XI1022_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I139_XP_MP0 (XI1022_I139_XP_p1 I1022_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I139_XP_MP1 (I1022_P14_7 I1022_P10_7n XI1022_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I80_XP_MP0 (XI1022_I80_XP_p1 I1022_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I80_XP_MP1 (I1022_P14_13 I1022_pn13 XI1022_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I137_XP_MP0 (XI976_I137_XP_p1 I976_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I137_XP_MP1 (I976_P12_5 I976_P8_5n XI976_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I136_XP_MP0 (XI976_I136_XP_p1 I976_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I136_XP_MP1 (I976_P11_4 I976_P7_4n XI976_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I79_XP_MP0 (XI976_I79_XP_p1 I976_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I79_XP_MP1 (I976_P13_12 I976_pn12 XI976_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I82_XP_MP0 (XI930_I82_XP_p1 I930_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I82_XP_MP1 (I930_P16_15 I930_pn15 XI930_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I145_XP_MP0 (XI930_I145_XP_p1 I930_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I145_XP_MP1 (I930_P20_13 I930_P16_13n XI930_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I139_XP_MP0 (XI930_I139_XP_p1 I930_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I139_XP_MP1 (I930_P14_7 I930_P10_7n XI930_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I142_XP_MP0 (XI930_I142_XP_p1 I930_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I142_XP_MP1 (I930_P17_10 I930_P13_10n XI930_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I82_XP_MP0 (XI1666_I82_XP_p1 I1666_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I82_XP_MP1 (I1666_P16_15 I1666_pn15 XI1666_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I83_XP_MP0 (XI1666_I83_XP_p1 I1666_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I83_XP_MP1 (I1666_P17_16 I1666_pn16 XI1666_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I140_XP_MP0 (XI1666_I140_XP_p1 I1666_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I140_XP_MP1 (I1666_P15_8 I1666_P11_8n XI1666_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I81_XP_MP0 (XI1666_I81_XP_p1 I1666_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I81_XP_MP1 (I1666_P15_14 I1666_pn14 XI1666_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I140_XP_MP0 (XI1620_I140_XP_p1 I1620_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I140_XP_MP1 (I1620_P15_8 I1620_P11_8n XI1620_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I142_XP_MP0 (XI1620_I142_XP_p1 I1620_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I142_XP_MP1 (I1620_P17_10 I1620_P13_10n XI1620_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I81_XP_MP0 (XI1620_I81_XP_p1 I1620_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I81_XP_MP1 (I1620_P15_14 I1620_pn14 XI1620_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I139_XP_MP0 (XI1620_I139_XP_p1 I1620_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I139_XP_MP1 (I1620_P14_7 I1620_P10_7n XI1620_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I143_XP_MP0 (XI1620_I143_XP_p1 I1620_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I143_XP_MP1 (I1620_P18_11 I1620_P14_11n XI1620_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I80_XP_MP0 (XI1620_I80_XP_p1 I1620_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I80_XP_MP1 (I1620_P14_13 I1620_pn13 XI1620_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I82_XP_MP0 (XI1620_I82_XP_p1 I1620_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I82_XP_MP1 (I1620_P16_15 I1620_pn15 XI1620_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I81_XP_MP0 (XI1574_I81_XP_p1 I1574_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I81_XP_MP1 (I1574_P15_14 I1574_pn14 XI1574_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I82_XP_MP0 (XI1574_I82_XP_p1 I1574_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I82_XP_MP1 (I1574_P16_15 I1574_pn15 XI1574_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I145_XP_MP0 (XI1574_I145_XP_p1 I1574_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I145_XP_MP1 (I1574_P20_13 I1574_P16_13n XI1574_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I149_XP_MP0 (XI1574_I149_XP_p1 I1574_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I149_XP_MP1 (I1574_P24_17 I1574_P20_17n XI1574_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I140_XP_MP0 (XI1022_I140_XP_p1 I1022_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I140_XP_MP1 (I1022_P15_8 I1022_P11_8n XI1022_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I83_XP_MP0 (XI1022_I83_XP_p1 I1022_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I83_XP_MP1 (I1022_P17_16 I1022_pn16 XI1022_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I143_XP_MP0 (XI1022_I143_XP_p1 I1022_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I143_XP_MP1 (I1022_P18_11 I1022_P14_11n XI1022_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I145_XP_MP0 (XI1022_I145_XP_p1 I1022_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I145_XP_MP1 (I1022_P20_13 I1022_P16_13n XI1022_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I82_XP_MP0 (XI1022_I82_XP_p1 I1022_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I82_XP_MP1 (I1022_P16_15 I1022_pn15 XI1022_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I84_XP_MP0 (XI1022_I84_XP_p1 I1022_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I84_XP_MP1 (I1022_P18_17 I1022_pn17 XI1022_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I141_XP_MP0 (XI976_I141_XP_p1 I976_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I141_XP_MP1 (I976_P16_9 I976_P12_9n XI976_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I82_XP_MP0 (XI976_I82_XP_p1 I976_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I82_XP_MP1 (I976_P16_15 I976_pn15 XI976_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I80_XP_MP0 (XI976_I80_XP_p1 I976_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I80_XP_MP1 (I976_P14_13 I976_pn13 XI976_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I138_XP_MP0 (XI976_I138_XP_p1 I976_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I138_XP_MP1 (I976_P13_6 I976_P9_6n XI976_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I142_XP_MP0 (XI976_I142_XP_p1 I976_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I142_XP_MP1 (I976_P17_10 I976_P13_10n XI976_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I81_XP_MP0 (XI976_I81_XP_p1 I976_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I81_XP_MP1 (I976_P15_14 I976_pn14 XI976_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I84_XP_MP0 (XI930_I84_XP_p1 I930_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I84_XP_MP1 (I930_P18_17 I930_pn17 XI930_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I83_XP_MP0 (XI930_I83_XP_p1 I930_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I83_XP_MP1 (I930_P17_16 I930_pn16 XI930_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I149_XP_MP0 (XI930_I149_XP_p1 I930_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I149_XP_MP1 (I930_P24_17 I930_P20_17n XI930_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I143_XP_MP0 (XI930_I143_XP_p1 I930_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I143_XP_MP1 (I930_P18_11 I930_P14_11n XI930_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I81_XP_MP0 (XI930_I81_XP_p1 I930_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I81_XP_MP1 (I930_P15_14 I930_pn14 XI930_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I140_XP_MP0 (XI930_I140_XP_p1 I930_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I140_XP_MP1 (I930_P15_8 I930_P11_8n XI930_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I144_XP_MP0 (XI930_I144_XP_p1 I930_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I144_XP_MP1 (I930_P19_12 I930_P15_12n XI930_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I149_XP_MP0 (XI1666_I149_XP_p1 I1666_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I149_XP_MP1 (I1666_P24_17 I1666_P20_17n XI1666_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I86_XP_MP0 (XI1666_I86_XP_p1 I1666_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I86_XP_MP1 (I1666_P20_19 I1666_pn19 XI1666_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I84_XP_MP0 (XI1666_I84_XP_p1 I1666_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I84_XP_MP1 (I1666_P18_17 I1666_pn17 XI1666_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I150_XP_MP0 (XI1666_I150_XP_p1 I1666_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I150_XP_MP1 (I1666_P25_18 I1666_P21_18n XI1666_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I146_XP_MP0 (XI1666_I146_XP_p1 I1666_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I146_XP_MP1 (I1666_P21_14 I1666_P17_14n XI1666_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I85_XP_MP0 (XI1666_I85_XP_p1 I1666_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I85_XP_MP1 (I1666_P19_18 I1666_pn18 XI1666_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I144_XP_MP0 (XI1666_I144_XP_p1 I1666_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I144_XP_MP1 (I1666_P19_12 I1666_P15_12n XI1666_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I144_XP_MP0 (XI1620_I144_XP_p1 I1620_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I144_XP_MP1 (I1620_P19_12 I1620_P15_12n XI1620_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I83_XP_MP0 (XI1620_I83_XP_p1 I1620_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I83_XP_MP1 (I1620_P17_16 I1620_pn16 XI1620_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I149_XP_MP0 (XI1620_I149_XP_p1 I1620_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I149_XP_MP1 (I1620_P24_17 I1620_P20_17n XI1620_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I145_XP_MP0 (XI1620_I145_XP_p1 I1620_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I145_XP_MP1 (I1620_P20_13 I1620_P16_13n XI1620_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I84_XP_MP0 (XI1620_I84_XP_p1 I1620_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I84_XP_MP1 (I1620_P18_17 I1620_pn17 XI1620_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I140_XP_MP0 (XI1574_I140_XP_p1 I1574_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I140_XP_MP1 (I1574_P15_8 I1574_P11_8n XI1574_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I146_XP_MP0 (XI1574_I146_XP_p1 I1574_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I146_XP_MP1 (I1574_P21_14 I1574_P17_14n XI1574_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I83_XP_MP0 (XI1574_I83_XP_p1 I1574_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I83_XP_MP1 (I1574_P17_16 I1574_pn16 XI1574_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I84_XP_MP0 (XI1574_I84_XP_p1 I1574_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I84_XP_MP1 (I1574_P18_17 I1574_pn17 XI1574_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I150_XP_MP0 (XI1022_I150_XP_p1 I1022_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I150_XP_MP1 (I1022_P25_18 I1022_P21_18n XI1022_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I146_XP_MP0 (XI1022_I146_XP_p1 I1022_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I146_XP_MP1 (I1022_P21_14 I1022_P17_14n XI1022_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I144_XP_MP0 (XI1022_I144_XP_p1 I1022_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I144_XP_MP1 (I1022_P19_12 I1022_P15_12n XI1022_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I85_XP_MP0 (XI1022_I85_XP_p1 I1022_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I85_XP_MP1 (I1022_P19_18 I1022_pn18 XI1022_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I149_XP_MP0 (XI1022_I149_XP_p1 I1022_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I149_XP_MP1 (I1022_P24_17 I1022_P20_17n XI1022_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I86_XP_MP0 (XI1022_I86_XP_p1 I1022_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I86_XP_MP1 (I1022_P20_19 I1022_pn19 XI1022_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I139_XP_MP0 (XI976_I139_XP_p1 I976_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I139_XP_MP1 (I976_P14_7 I976_P10_7n XI976_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I84_XP_MP0 (XI976_I84_XP_p1 I976_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I84_XP_MP1 (I976_P18_17 I976_pn17 XI976_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I140_XP_MP0 (XI976_I140_XP_p1 I976_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I140_XP_MP1 (I976_P15_8 I976_P11_8n XI976_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I83_XP_MP0 (XI976_I83_XP_p1 I976_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I83_XP_MP1 (I976_P17_16 I976_pn16 XI976_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I85_XP_MP0 (XI930_I85_XP_p1 I930_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I85_XP_MP1 (I930_P19_18 I930_pn18 XI930_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I148_XP_MP0 (XI930_I148_XP_p1 I930_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I148_XP_MP1 (I930_P23_16 I930_P19_16n XI930_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I146_XP_MP0 (XI930_I146_XP_p1 I930_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I146_XP_MP1 (I930_P21_14 I930_P17_14n XI930_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I153_XP_MP0 (XI1666_I153_XP_p1 I1666_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I153_XP_MP1 (I1666_P28_21 I1666_P24_21n XI1666_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I151_XP_MP0 (XI1666_I151_XP_p1 I1666_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I151_XP_MP1 (I1666_P26_19 I1666_P22_19n XI1666_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I147_XP_MP0 (XI1666_I147_XP_p1 I1666_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I147_XP_MP1 (I1666_P22_15 I1666_P18_15n XI1666_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I88_XP_MP0 (XI1666_I88_XP_p1 I1666_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I88_XP_MP1 (I1666_P22_21 I1666_pn21 XI1666_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I87_XP_MP0 (XI1666_I87_XP_p1 I1666_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I87_XP_MP1 (I1666_P21_20 I1666_pn20 XI1666_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I146_XP_MP0 (XI1620_I146_XP_p1 I1620_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I146_XP_MP1 (I1620_P21_14 I1620_P17_14n XI1620_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I85_XP_MP0 (XI1620_I85_XP_p1 I1620_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I85_XP_MP1 (I1620_P19_18 I1620_pn18 XI1620_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I147_XP_MP0 (XI1620_I147_XP_p1 I1620_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I147_XP_MP1 (I1620_P22_15 I1620_P18_15n XI1620_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I86_XP_MP0 (XI1620_I86_XP_p1 I1620_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I86_XP_MP1 (I1620_P20_19 I1620_pn19 XI1620_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I144_XP_MP0 (XI1574_I144_XP_p1 I1574_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I144_XP_MP1 (I1574_P19_12 I1574_P15_12n XI1574_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I150_XP_MP0 (XI1574_I150_XP_p1 I1574_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I150_XP_MP1 (I1574_P25_18 I1574_P21_18n XI1574_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I85_XP_MP0 (XI1574_I85_XP_p1 I1574_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I85_XP_MP1 (I1574_P19_18 I1574_pn18 XI1574_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I86_XP_MP0 (XI1574_I86_XP_p1 I1574_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I86_XP_MP1 (I1574_P20_19 I1574_pn19 XI1574_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I147_XP_MP0 (XI1574_I147_XP_p1 I1574_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I147_XP_MP1 (I1574_P22_15 I1574_P18_15n XI1574_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I151_XP_MP0 (XI1574_I151_XP_p1 I1574_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I151_XP_MP1 (I1574_P26_19 I1574_P22_19n XI1574_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I153_XP_MP0 (XI1574_I153_XP_p1 I1574_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I153_XP_MP1 (I1574_P28_21 I1574_P24_21n XI1574_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I154_XP_MP0 (XI1022_I154_XP_p1 I1022_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I154_XP_MP1 (I1022_P29_22 I1022_P25_22n XI1022_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I148_XP_MP0 (XI1022_I148_XP_p1 I1022_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I148_XP_MP1 (I1022_P23_16 I1022_P19_16n XI1022_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I152_XP_MP0 (XI1022_I152_XP_p1 I1022_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I152_XP_MP1 (I1022_P27_20 I1022_P23_20n XI1022_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I87_XP_MP0 (XI1022_I87_XP_p1 I1022_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I87_XP_MP1 (I1022_P21_20 I1022_pn20 XI1022_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I147_XP_MP0 (XI1022_I147_XP_p1 I1022_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I147_XP_MP1 (I1022_P22_15 I1022_P18_15n XI1022_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I151_XP_MP0 (XI1022_I151_XP_p1 I1022_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I151_XP_MP1 (I1022_P26_19 I1022_P22_19n XI1022_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I88_XP_MP0 (XI1022_I88_XP_p1 I1022_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I88_XP_MP1 (I1022_P22_21 I1022_pn21 XI1022_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I143_XP_MP0 (XI976_I143_XP_p1 I976_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I143_XP_MP1 (I976_P18_11 I976_P14_11n XI976_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I145_XP_MP0 (XI976_I145_XP_p1 I976_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I145_XP_MP1 (I976_P20_13 I976_P16_13n XI976_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I86_XP_MP0 (XI976_I86_XP_p1 I976_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I86_XP_MP1 (I976_P20_19 I976_pn19 XI976_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I144_XP_MP0 (XI976_I144_XP_p1 I976_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I144_XP_MP1 (I976_P19_12 I976_P15_12n XI976_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I85_XP_MP0 (XI976_I85_XP_p1 I976_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I85_XP_MP1 (I976_P19_18 I976_pn18 XI976_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I86_XP_MP0 (XI930_I86_XP_p1 I930_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I86_XP_MP1 (I930_P20_19 I930_pn19 XI930_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I147_XP_MP0 (XI930_I147_XP_p1 I930_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I147_XP_MP1 (I930_P22_15 I930_P18_15n XI930_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I151_XP_MP0 (XI930_I151_XP_p1 I930_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I151_XP_MP1 (I930_P26_19 I930_P22_19n XI930_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I87_XP_MP0 (XI930_I87_XP_p1 I930_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I87_XP_MP1 (I930_P21_20 I930_pn20 XI930_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I150_XP_MP0 (XI930_I150_XP_p1 I930_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I150_XP_MP1 (I930_P25_18 I930_P21_18n XI930_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I90_XP_MP0 (XI1666_I90_XP_p1 I1666_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I90_XP_MP1 (I1666_P24_23 I1666_pn23 XI1666_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I92_XP_MP0 (XI1666_I92_XP_p1 I1666_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I92_XP_MP1 (I1666_P26_25 I1666_pn25 XI1666_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I155_XP_MP0 (XI1666_I155_XP_p1 I1666_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I155_XP_MP1 (I1666_P30_23 I1666_P26_23n XI1666_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I94_XP_MP0 (XI1666_I94_XP_p1 I1666_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I94_XP_MP1 (I1666_P28_27 I1666_pn27 XI1666_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I89_XP_MP0 (XI1666_I89_XP_p1 I1666_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I89_XP_MP1 (I1666_P23_22 I1666_pn22 XI1666_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I154_XP_MP0 (XI1666_I154_XP_p1 I1666_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I154_XP_MP1 (I1666_P29_22 I1666_P25_22n XI1666_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I148_XP_MP0 (XI1620_I148_XP_p1 I1620_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I148_XP_MP1 (I1620_P23_16 I1620_P19_16n XI1620_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I150_XP_MP0 (XI1620_I150_XP_p1 I1620_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I150_XP_MP1 (I1620_P25_18 I1620_P21_18n XI1620_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I87_XP_MP0 (XI1620_I87_XP_p1 I1620_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I87_XP_MP1 (I1620_P21_20 I1620_pn20 XI1620_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I151_XP_MP0 (XI1620_I151_XP_p1 I1620_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I151_XP_MP1 (I1620_P26_19 I1620_P22_19n XI1620_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I153_XP_MP0 (XI1620_I153_XP_p1 I1620_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I153_XP_MP1 (I1620_P28_21 I1620_P24_21n XI1620_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I88_XP_MP0 (XI1620_I88_XP_p1 I1620_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I88_XP_MP1 (I1620_P22_21 I1620_pn21 XI1620_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I148_XP_MP0 (XI1574_I148_XP_p1 I1574_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I148_XP_MP1 (I1574_P23_16 I1574_P19_16n XI1574_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I87_XP_MP0 (XI1574_I87_XP_p1 I1574_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I87_XP_MP1 (I1574_P21_20 I1574_pn20 XI1574_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I88_XP_MP0 (XI1574_I88_XP_p1 I1574_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I88_XP_MP1 (I1574_P22_21 I1574_pn21 XI1574_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I89_XP_MP0 (XI1022_I89_XP_p1 I1022_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I89_XP_MP1 (I1022_P23_22 I1022_pn22 XI1022_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I90_XP_MP0 (XI1022_I90_XP_p1 I1022_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I90_XP_MP1 (I1022_P24_23 I1022_pn23 XI1022_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I153_XP_MP0 (XI1022_I153_XP_p1 I1022_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I153_XP_MP1 (I1022_P28_21 I1022_P24_21n XI1022_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I149_XP_MP0 (XI976_I149_XP_p1 I976_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I149_XP_MP1 (I976_P24_17 I976_P20_17n XI976_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I150_XP_MP0 (XI976_I150_XP_p1 I976_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I150_XP_MP1 (I976_P25_18 I976_P21_18n XI976_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I146_XP_MP0 (XI976_I146_XP_p1 I976_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I146_XP_MP1 (I976_P21_14 I976_P17_14n XI976_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I87_XP_MP0 (XI976_I87_XP_p1 I976_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I87_XP_MP1 (I976_P21_20 I976_pn20 XI976_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I153_XP_MP0 (XI930_I153_XP_p1 I930_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I153_XP_MP1 (I930_P28_21 I930_P24_21n XI930_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I88_XP_MP0 (XI930_I88_XP_p1 I930_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I88_XP_MP1 (I930_P22_21 I930_pn21 XI930_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I89_XP_MP0 (XI930_I89_XP_p1 I930_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I89_XP_MP1 (I930_P23_22 I930_pn22 XI930_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I152_XP_MP0 (XI930_I152_XP_p1 I930_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I152_XP_MP1 (I930_P27_20 I930_P23_20n XI930_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I156_XP_MP0 (XI930_I156_XP_p1 I930_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I156_XP_MP1 (I930_P31_24 I930_P27_24n XI930_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I154_XP_MP0 (XI930_I154_XP_p1 I930_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I154_XP_MP1 (I930_P29_22 I930_P25_22n XI930_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I91_XP_MP0 (XI1666_I91_XP_p1 I1666_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I91_XP_MP1 (I1666_P25_24 I1666_pn24 XI1666_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I93_XP_MP0 (XI1666_I93_XP_p1 I1666_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I93_XP_MP1 (I1666_P27_26 I1666_pn26 XI1666_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I152_XP_MP0 (XI1666_I152_XP_p1 I1666_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I152_XP_MP1 (I1666_P27_20 I1666_P23_20n XI1666_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I148_XP_MP0 (XI1666_I148_XP_p1 I1666_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I148_XP_MP1 (I1666_P23_16 I1666_P19_16n XI1666_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I152_XP_MP0 (XI1620_I152_XP_p1 I1620_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I152_XP_MP1 (I1620_P27_20 I1620_P23_20n XI1620_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I154_XP_MP0 (XI1620_I154_XP_p1 I1620_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I154_XP_MP1 (I1620_P29_22 I1620_P25_22n XI1620_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I89_XP_MP0 (XI1620_I89_XP_p1 I1620_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I89_XP_MP1 (I1620_P23_22 I1620_pn22 XI1620_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I90_XP_MP0 (XI1620_I90_XP_p1 I1620_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I90_XP_MP1 (I1620_P24_23 I1620_pn23 XI1620_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I152_XP_MP0 (XI1574_I152_XP_p1 I1574_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I152_XP_MP1 (I1574_P27_20 I1574_P23_20n XI1574_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I154_XP_MP0 (XI1574_I154_XP_p1 I1574_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I154_XP_MP1 (I1574_P29_22 I1574_P25_22n XI1574_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I89_XP_MP0 (XI1574_I89_XP_p1 I1574_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I89_XP_MP1 (I1574_P23_22 I1574_pn22 XI1574_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I90_XP_MP0 (XI1574_I90_XP_p1 I1574_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I90_XP_MP1 (I1574_P24_23 I1574_pn23 XI1574_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I155_XP_MP0 (XI1574_I155_XP_p1 I1574_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I155_XP_MP1 (I1574_P30_23 I1574_P26_23n XI1574_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I92_XP_MP0 (XI1114_I92_XP_p1 I1114_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I92_XP_MP1 (I1114_P26_25 I1114_pn25 XI1114_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I90_XP_MP0 (XI1114_I90_XP_p1 I1114_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I90_XP_MP1 (I1114_P24_23 I1114_pn23 XI1114_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I88_XP_MP0 (XI1114_I88_XP_p1 I1114_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I88_XP_MP1 (I1114_P22_21 I1114_pn21 XI1114_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I86_XP_MP0 (XI1114_I86_XP_p1 I1114_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I86_XP_MP1 (I1114_P20_19 I1114_pn19 XI1114_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I84_XP_MP0 (XI1114_I84_XP_p1 I1114_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I84_XP_MP1 (I1114_P18_17 I1114_pn17 XI1114_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I80_XP_MP0 (XI1114_I80_XP_p1 I1114_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I80_XP_MP1 (I1114_P14_13 I1114_pn13 XI1114_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I82_XP_MP0 (XI1114_I82_XP_p1 I1114_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I82_XP_MP1 (I1114_P16_15 I1114_pn15 XI1114_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I78_XP_MP0 (XI1114_I78_XP_p1 I1114_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I78_XP_MP1 (I1114_P12_11 I1114_pn11 XI1114_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I156_XP_MP0 (XI1022_I156_XP_p1 I1022_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I156_XP_MP1 (I1022_P31_24 I1022_P27_24n XI1022_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I91_XP_MP0 (XI1022_I91_XP_p1 I1022_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I91_XP_MP1 (I1022_P25_24 I1022_pn24 XI1022_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I93_XP_MP0 (XI1022_I93_XP_p1 I1022_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I93_XP_MP1 (I1022_P27_26 I1022_pn26 XI1022_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I155_XP_MP0 (XI1022_I155_XP_p1 I1022_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I155_XP_MP1 (I1022_P30_23 I1022_P26_23n XI1022_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I92_XP_MP0 (XI1022_I92_XP_p1 I1022_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I92_XP_MP1 (I1022_P26_25 I1022_pn25 XI1022_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I147_XP_MP0 (XI976_I147_XP_p1 I976_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I147_XP_MP1 (I976_P22_15 I976_P18_15n XI976_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I88_XP_MP0 (XI976_I88_XP_p1 I976_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I88_XP_MP1 (I976_P22_21 I976_pn21 XI976_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I148_XP_MP0 (XI976_I148_XP_p1 I976_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I148_XP_MP1 (I976_P23_16 I976_P19_16n XI976_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I89_XP_MP0 (XI976_I89_XP_p1 I976_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I89_XP_MP1 (I976_P23_22 I976_pn22 XI976_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I90_XP_MP0 (XI930_I90_XP_p1 I930_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I90_XP_MP1 (I930_P24_23 I930_pn23 XI930_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I91_XP_MP0 (XI930_I91_XP_p1 I930_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I91_XP_MP1 (I930_P25_24 I930_pn24 XI930_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I95_XP_MP0 (XI1666_I95_XP_p1 I1666_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I95_XP_MP1 (I1666_P29_28 I1666_pn28 XI1666_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I96_XP_MP0 (XI1666_I96_XP_p1 I1666_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I96_XP_MP1 (I1666_P30_29 I1666_pn29 XI1666_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I156_XP_MP0 (XI1666_I156_XP_p1 I1666_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I156_XP_MP1 (I1666_P31_24 I1666_P27_24n XI1666_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I97_XP_MP0 (XI1666_I97_XP_p1 I1666_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I97_XP_MP1 (I1666_P31_30 I1666_pn30 XI1666_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I156_XP_MP0 (XI1620_I156_XP_p1 I1620_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I156_XP_MP1 (I1620_P31_24 I1620_P27_24n XI1620_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I91_XP_MP0 (XI1620_I91_XP_p1 I1620_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I91_XP_MP1 (I1620_P25_24 I1620_pn24 XI1620_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I155_XP_MP0 (XI1620_I155_XP_p1 I1620_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I155_XP_MP1 (I1620_P30_23 I1620_P26_23n XI1620_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I92_XP_MP0 (XI1620_I92_XP_p1 I1620_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I92_XP_MP1 (I1620_P26_25 I1620_pn25 XI1620_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I156_XP_MP0 (XI1574_I156_XP_p1 I1574_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I156_XP_MP1 (I1574_P31_24 I1574_P27_24n XI1574_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I91_XP_MP0 (XI1574_I91_XP_p1 I1574_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I91_XP_MP1 (I1574_P25_24 I1574_pn24 XI1574_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I92_XP_MP0 (XI1574_I92_XP_p1 I1574_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I92_XP_MP1 (I1574_P26_25 I1574_pn25 XI1574_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I96_XP_MP0 (XI1114_I96_XP_p1 I1114_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I96_XP_MP1 (I1114_P30_29 I1114_pn29 XI1114_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I94_XP_MP0 (XI1114_I94_XP_p1 I1114_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I94_XP_MP1 (I1114_P28_27 I1114_pn27 XI1114_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I155_XP_MP0 (XI1114_I155_XP_p1 I1114_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I155_XP_MP1 (I1114_P30_23 I1114_P26_23n XI1114_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I153_XP_MP0 (XI1114_I153_XP_p1 I1114_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I153_XP_MP1 (I1114_P28_21 I1114_P24_21n XI1114_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I151_XP_MP0 (XI1114_I151_XP_p1 I1114_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I151_XP_MP1 (I1114_P26_19 I1114_P22_19n XI1114_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I147_XP_MP0 (XI1114_I147_XP_p1 I1114_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I147_XP_MP1 (I1114_P22_15 I1114_P18_15n XI1114_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I149_XP_MP0 (XI1114_I149_XP_p1 I1114_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I149_XP_MP1 (I1114_P24_17 I1114_P20_17n XI1114_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I143_XP_MP0 (XI1114_I143_XP_p1 I1114_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I143_XP_MP1 (I1114_P18_11 I1114_P14_11n XI1114_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I145_XP_MP0 (XI1114_I145_XP_p1 I1114_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I145_XP_MP1 (I1114_P20_13 I1114_P16_13n XI1114_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I139_XP_MP0 (XI1114_I139_XP_p1 I1114_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I139_XP_MP1 (I1114_P14_7 I1114_P10_7n XI1114_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I141_XP_MP0 (XI1114_I141_XP_p1 I1114_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I141_XP_MP1 (I1114_P16_9 I1114_P12_9n XI1114_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I137_XP_MP0 (XI1114_I137_XP_p1 I1114_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I137_XP_MP1 (I1114_P12_5 I1114_P8_5n XI1114_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I76_XP_MP0 (XI1114_I76_XP_p1 I1114_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I76_XP_MP1 (I1114_P10_9 I1114_pn9 XI1114_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I74_XP_MP0 (XI1114_I74_XP_p1 I1114_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I74_XP_MP1 (I1114_P8_7 I1114_pn7 XI1114_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I95_XP_MP0 (XI1022_I95_XP_p1 I1022_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I95_XP_MP1 (I1022_P29_28 I1022_pn28 XI1022_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I97_XP_MP0 (XI1022_I97_XP_p1 I1022_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I97_XP_MP1 (I1022_P31_30 I1022_pn30 XI1022_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I94_XP_MP0 (XI1022_I94_XP_p1 I1022_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I94_XP_MP1 (I1022_P28_27 I1022_pn27 XI1022_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I96_XP_MP0 (XI1022_I96_XP_p1 I1022_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I96_XP_MP1 (I1022_P30_29 I1022_pn29 XI1022_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I151_XP_MP0 (XI976_I151_XP_p1 I976_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I151_XP_MP1 (I976_P26_19 I976_P22_19n XI976_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I90_XP_MP0 (XI976_I90_XP_p1 I976_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I90_XP_MP1 (I976_P24_23 I976_pn23 XI976_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I92_XP_MP0 (XI976_I92_XP_p1 I976_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I92_XP_MP1 (I976_P26_25 I976_pn25 XI976_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I152_XP_MP0 (XI976_I152_XP_p1 I976_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I152_XP_MP1 (I976_P27_20 I976_P23_20n XI976_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I91_XP_MP0 (XI976_I91_XP_p1 I976_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I91_XP_MP1 (I976_P25_24 I976_pn24 XI976_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I155_XP_MP0 (XI930_I155_XP_p1 I930_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I155_XP_MP1 (I930_P30_23 I930_P26_23n XI930_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I92_XP_MP0 (XI930_I92_XP_p1 I930_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I92_XP_MP1 (I930_P26_25 I930_pn25 XI930_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I93_XP_MP0 (XI930_I93_XP_p1 I930_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I93_XP_MP1 (I930_P27_26 I930_pn26 XI930_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I95_XP_MP0 (XI1620_I95_XP_p1 I1620_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I95_XP_MP1 (I1620_P29_28 I1620_pn28 XI1620_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I93_XP_MP0 (XI1620_I93_XP_p1 I1620_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I93_XP_MP1 (I1620_P27_26 I1620_pn26 XI1620_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I96_XP_MP0 (XI1620_I96_XP_p1 I1620_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I96_XP_MP1 (I1620_P30_29 I1620_pn29 XI1620_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I94_XP_MP0 (XI1620_I94_XP_p1 I1620_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I94_XP_MP1 (I1620_P28_27 I1620_pn27 XI1620_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I97_XP_MP0 (XI1574_I97_XP_p1 I1574_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I97_XP_MP1 (I1574_P31_30 I1574_pn30 XI1574_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I95_XP_MP0 (XI1574_I95_XP_p1 I1574_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I95_XP_MP1 (I1574_P29_28 I1574_pn28 XI1574_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I96_XP_MP0 (XI1574_I96_XP_p1 I1574_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I96_XP_MP1 (I1574_P30_29 I1574_pn29 XI1574_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I93_XP_MP0 (XI1574_I93_XP_p1 I1574_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I93_XP_MP1 (I1574_P27_26 I1574_pn26 XI1574_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I94_XP_MP0 (XI1574_I94_XP_p1 I1574_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I94_XP_MP1 (I1574_P28_27 I1574_pn27 XI1574_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I93_XP_MP0 (XI1114_I93_XP_p1 I1114_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I93_XP_MP1 (I1114_P27_26 I1114_pn26 XI1114_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I91_XP_MP0 (XI1114_I91_XP_p1 I1114_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I91_XP_MP1 (I1114_P25_24 I1114_pn24 XI1114_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I89_XP_MP0 (XI1114_I89_XP_p1 I1114_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I89_XP_MP1 (I1114_P23_22 I1114_pn22 XI1114_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I87_XP_MP0 (XI1114_I87_XP_p1 I1114_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I87_XP_MP1 (I1114_P21_20 I1114_pn20 XI1114_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I135_XP_MP0 (XI1114_I135_XP_p1 I1114_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I135_XP_MP1 (I1114_P10_3 I1114_P6_3n XI1114_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I133_XP_MP0 (XI1114_I133_XP_p1 I1114_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I133_XP_MP1 (I1114_P8_1 I1114_P4_1n XI1114_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I72_XP_MP0 (XI1114_I72_XP_p1 I1114_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I72_XP_MP1 (I1114_P6_5 I1114_pn5 XI1114_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I70_XP_MP0 (XI1114_I70_XP_p1 I1114_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I70_XP_MP1 (I1114_P4_3 I1114_pn3 XI1114_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I153_XP_MP0 (XI976_I153_XP_p1 I976_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I153_XP_MP1 (I976_P28_21 I976_P24_21n XI976_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I154_XP_MP0 (XI976_I154_XP_p1 I976_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I154_XP_MP1 (I976_P29_22 I976_P25_22n XI976_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I93_XP_MP0 (XI976_I93_XP_p1 I976_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I93_XP_MP1 (I976_P27_26 I976_pn26 XI976_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I94_XP_MP0 (XI930_I94_XP_p1 I930_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I94_XP_MP1 (I930_P28_27 I930_pn27 XI930_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I95_XP_MP0 (XI930_I95_XP_p1 I930_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I95_XP_MP1 (I930_P29_28 I930_pn28 XI930_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I97_XP_MP0 (XI1620_I97_XP_p1 I1620_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I97_XP_MP1 (I1620_P31_30 I1620_pn30 XI1620_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I97_XP_MP0 (XI1114_I97_XP_p1 I1114_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I97_XP_MP1 (I1114_P31_30 I1114_pn30 XI1114_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I95_XP_MP0 (XI1114_I95_XP_p1 I1114_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I95_XP_MP1 (I1114_P29_28 I1114_pn28 XI1114_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I154_XP_MP0 (XI1114_I154_XP_p1 I1114_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I154_XP_MP1 (I1114_P29_22 I1114_P25_22n XI1114_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I85_XP_MP0 (XI1114_I85_XP_p1 I1114_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I85_XP_MP1 (I1114_P19_18 I1114_pn18 XI1114_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I83_XP_MP0 (XI1114_I83_XP_p1 I1114_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I83_XP_MP1 (I1114_P17_16 I1114_pn16 XI1114_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I81_XP_MP0 (XI1114_I81_XP_p1 I1114_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I81_XP_MP1 (I1114_P15_14 I1114_pn14 XI1114_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I79_XP_MP0 (XI1114_I79_XP_p1 I1114_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I79_XP_MP1 (I1114_P13_12 I1114_pn12 XI1114_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I77_XP_MP0 (XI1114_I77_XP_p1 I1114_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I77_XP_MP1 (I1114_P11_10 I1114_pn10 XI1114_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I75_XP_MP0 (XI1114_I75_XP_p1 I1114_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I75_XP_MP1 (I1114_P9_8 I1114_pn8 XI1114_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I71_XP_MP0 (XI1114_I71_XP_p1 I1114_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I71_XP_MP1 (I1114_P5_4 I1114_pn4 XI1114_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I68_XP_MP0 (XI1114_I68_XP_p1 I1114_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I68_XP_MP1 (I1114_P2_1 I1114_pn1 XI1114_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I155_XP_MP0 (XI976_I155_XP_p1 I976_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I155_XP_MP1 (I976_P30_23 I976_P26_23n XI976_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I94_XP_MP0 (XI976_I94_XP_p1 I976_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I94_XP_MP1 (I976_P28_27 I976_pn27 XI976_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I156_XP_MP0 (XI976_I156_XP_p1 I976_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I156_XP_MP1 (I976_P31_24 I976_P27_24n XI976_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I95_XP_MP0 (XI976_I95_XP_p1 I976_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I95_XP_MP1 (I976_P29_28 I976_pn28 XI976_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I96_XP_MP0 (XI930_I96_XP_p1 I930_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I96_XP_MP1 (I930_P30_29 I930_pn29 XI930_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I97_XP_MP0 (XI930_I97_XP_p1 I930_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I97_XP_MP1 (I930_P31_30 I930_pn30 XI930_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I68_XP_MP0 (XI1528_I68_XP_p1 I1528_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I68_XP_MP1 (I1528_P2_1 I1528_pn1 XI1528_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I69_XP_MP0 (XI1528_I69_XP_p1 I1528_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I69_XP_MP1 (I1528_P3_2 I1528_pn2 XI1528_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I156_XP_MP0 (XI1114_I156_XP_p1 I1114_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I156_XP_MP1 (I1114_P31_24 I1114_P27_24n XI1114_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I152_XP_MP0 (XI1114_I152_XP_p1 I1114_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I152_XP_MP1 (I1114_P27_20 I1114_P23_20n XI1114_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I150_XP_MP0 (XI1114_I150_XP_p1 I1114_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I150_XP_MP1 (I1114_P25_18 I1114_P21_18n XI1114_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I146_XP_MP0 (XI1114_I146_XP_p1 I1114_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I146_XP_MP1 (I1114_P21_14 I1114_P17_14n XI1114_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I142_XP_MP0 (XI1114_I142_XP_p1 I1114_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I142_XP_MP1 (I1114_P17_10 I1114_P13_10n XI1114_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I138_XP_MP0 (XI1114_I138_XP_p1 I1114_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I138_XP_MP1 (I1114_P13_6 I1114_P9_6n XI1114_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I134_XP_MP0 (XI1114_I134_XP_p1 I1114_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I134_XP_MP1 (I1114_P9_2 I1114_P5_2n XI1114_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I73_XP_MP0 (XI1114_I73_XP_p1 I1114_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I73_XP_MP1 (I1114_P7_6 I1114_pn6 XI1114_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I69_XP_MP0 (XI1114_I69_XP_p1 I1114_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I69_XP_MP1 (I1114_P3_2 I1114_pn2 XI1114_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I96_XP_MP0 (XI976_I96_XP_p1 I976_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I96_XP_MP1 (I976_P30_29 I976_pn29 XI976_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I97_XP_MP0 (XI976_I97_XP_p1 I976_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I97_XP_MP1 (I976_P31_30 I976_pn30 XI976_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I68_XP_MP0 (XI1482_I68_XP_p1 I1482_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I68_XP_MP1 (I1482_P2_1 I1482_pn1 XI1482_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I70_XP_MP0 (XI1528_I70_XP_p1 I1528_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I70_XP_MP1 (I1528_P4_3 I1528_pn3 XI1528_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I72_XP_MP0 (XI1528_I72_XP_p1 I1528_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I72_XP_MP1 (I1528_P6_5 I1528_pn5 XI1528_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I133_XP_MP0 (XI1528_I133_XP_p1 I1528_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I133_XP_MP1 (I1528_P8_1 I1528_P4_1n XI1528_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I71_XP_MP0 (XI1528_I71_XP_p1 I1528_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I71_XP_MP1 (I1528_P5_4 I1528_pn4 XI1528_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I148_XP_MP0 (XI1114_I148_XP_p1 I1114_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I148_XP_MP1 (I1114_P23_16 I1114_P19_16n XI1114_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I144_XP_MP0 (XI1114_I144_XP_p1 I1114_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I144_XP_MP1 (I1114_P19_12 I1114_P15_12n XI1114_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I140_XP_MP0 (XI1114_I140_XP_p1 I1114_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I140_XP_MP1 (I1114_P15_8 I1114_P11_8n XI1114_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I136_XP_MP0 (XI1114_I136_XP_p1 I1114_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I136_XP_MP1 (I1114_P11_4 I1114_P7_4n XI1114_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I68_XP_MP0 (XI1298_I68_XP_p1 I1298_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I68_XP_MP1 (I1298_P2_1 I1298_pn1 XI1298_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I69_XP_MP0 (XI1344_I69_XP_p1 I1344_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I69_XP_MP1 (I1344_P3_2 I1344_pn2 XI1344_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I68_XP_MP0 (XI1344_I68_XP_p1 I1344_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I68_XP_MP1 (I1344_P2_1 I1344_pn1 XI1344_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I70_XP_MP0 (XI1390_I70_XP_p1 I1390_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I70_XP_MP1 (I1390_P4_3 I1390_pn3 XI1390_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I68_XP_MP0 (XI1390_I68_XP_p1 I1390_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I68_XP_MP1 (I1390_P2_1 I1390_pn1 XI1390_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I69_XP_MP0 (XI1390_I69_XP_p1 I1390_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I69_XP_MP1 (I1390_P3_2 I1390_pn2 XI1390_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I70_XP_MP0 (XI1436_I70_XP_p1 I1436_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I70_XP_MP1 (I1436_P4_3 I1436_pn3 XI1436_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I68_XP_MP0 (XI1436_I68_XP_p1 I1436_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I68_XP_MP1 (I1436_P2_1 I1436_pn1 XI1436_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I69_XP_MP0 (XI1436_I69_XP_p1 I1436_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I69_XP_MP1 (I1436_P3_2 I1436_pn2 XI1436_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I69_XP_MP0 (XI1482_I69_XP_p1 I1482_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I69_XP_MP1 (I1482_P3_2 I1482_pn2 XI1482_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I74_XP_MP0 (XI1528_I74_XP_p1 I1528_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I74_XP_MP1 (I1528_P8_7 I1528_pn7 XI1528_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I141_XP_MP0 (XI1528_I141_XP_p1 I1528_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I141_XP_MP1 (I1528_P16_9 I1528_P12_9n XI1528_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I73_XP_MP0 (XI1528_I73_XP_p1 I1528_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I73_XP_MP1 (I1528_P7_6 I1528_pn6 XI1528_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I134_XP_MP0 (XI1528_I134_XP_p1 I1528_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I134_XP_MP1 (I1528_P9_2 I1528_P5_2n XI1528_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I68_XP_MP0 (XI1252_I68_XP_p1 I1252_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I68_XP_MP1 (I1252_P2_1 I1252_pn1 XI1252_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I69_XP_MP0 (XI1252_I69_XP_p1 I1252_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I69_XP_MP1 (I1252_P3_2 I1252_pn2 XI1252_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I70_XP_MP0 (XI1298_I70_XP_p1 I1298_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I70_XP_MP1 (I1298_P4_3 I1298_pn3 XI1298_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I71_XP_MP0 (XI1298_I71_XP_p1 I1298_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I71_XP_MP1 (I1298_P5_4 I1298_pn4 XI1298_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I69_XP_MP0 (XI1298_I69_XP_p1 I1298_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I69_XP_MP1 (I1298_P3_2 I1298_pn2 XI1298_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I72_XP_MP0 (XI1344_I72_XP_p1 I1344_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I72_XP_MP1 (I1344_P6_5 I1344_pn5 XI1344_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I70_XP_MP0 (XI1344_I70_XP_p1 I1344_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I70_XP_MP1 (I1344_P4_3 I1344_pn3 XI1344_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I71_XP_MP0 (XI1344_I71_XP_p1 I1344_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I71_XP_MP1 (I1344_P5_4 I1344_pn4 XI1344_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I72_XP_MP0 (XI1390_I72_XP_p1 I1390_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I72_XP_MP1 (I1390_P6_5 I1390_pn5 XI1390_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I71_XP_MP0 (XI1390_I71_XP_p1 I1390_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I71_XP_MP1 (I1390_P5_4 I1390_pn4 XI1390_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I72_XP_MP0 (XI1436_I72_XP_p1 I1436_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I72_XP_MP1 (I1436_P6_5 I1436_pn5 XI1436_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I71_XP_MP0 (XI1436_I71_XP_p1 I1436_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I71_XP_MP1 (I1436_P5_4 I1436_pn4 XI1436_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I72_XP_MP0 (XI1482_I72_XP_p1 I1482_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I72_XP_MP1 (I1482_P6_5 I1482_pn5 XI1482_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I71_XP_MP0 (XI1482_I71_XP_p1 I1482_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I71_XP_MP1 (I1482_P5_4 I1482_pn4 XI1482_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I70_XP_MP0 (XI1482_I70_XP_p1 I1482_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I70_XP_MP1 (I1482_P4_3 I1482_pn3 XI1482_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I76_XP_MP0 (XI1528_I76_XP_p1 I1528_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I76_XP_MP1 (I1528_P10_9 I1528_pn9 XI1528_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I137_XP_MP0 (XI1528_I137_XP_p1 I1528_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I137_XP_MP1 (I1528_P12_5 I1528_P8_5n XI1528_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I75_XP_MP0 (XI1528_I75_XP_p1 I1528_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I75_XP_MP1 (I1528_P9_8 I1528_pn8 XI1528_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I68_XP_MP0 (XI1160_I68_XP_p1 I1160_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I68_XP_MP1 (I1160_P2_1 I1160_pn1 XI1160_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I68_XP_MP0 (XI1206_I68_XP_p1 I1206_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I68_XP_MP1 (I1206_P2_1 I1206_pn1 XI1206_I68_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I70_XP_MP0 (XI1252_I70_XP_p1 I1252_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I70_XP_MP1 (I1252_P4_3 I1252_pn3 XI1252_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I71_XP_MP0 (XI1252_I71_XP_p1 I1252_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I71_XP_MP1 (I1252_P5_4 I1252_pn4 XI1252_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I72_XP_MP0 (XI1298_I72_XP_p1 I1298_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I72_XP_MP1 (I1298_P6_5 I1298_pn5 XI1298_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I73_XP_MP0 (XI1298_I73_XP_p1 I1298_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I73_XP_MP1 (I1298_P7_6 I1298_pn6 XI1298_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I74_XP_MP0 (XI1344_I74_XP_p1 I1344_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I74_XP_MP1 (I1344_P8_7 I1344_pn7 XI1344_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I133_XP_MP0 (XI1344_I133_XP_p1 I1344_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I133_XP_MP1 (I1344_P8_1 I1344_P4_1n XI1344_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I73_XP_MP0 (XI1344_I73_XP_p1 I1344_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I73_XP_MP1 (I1344_P7_6 I1344_pn6 XI1344_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I75_XP_MP0 (XI1344_I75_XP_p1 I1344_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I75_XP_MP1 (I1344_P9_8 I1344_pn8 XI1344_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I134_XP_MP0 (XI1344_I134_XP_p1 I1344_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I134_XP_MP1 (I1344_P9_2 I1344_P5_2n XI1344_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I74_XP_MP0 (XI1390_I74_XP_p1 I1390_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I74_XP_MP1 (I1390_P8_7 I1390_pn7 XI1390_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I133_XP_MP0 (XI1390_I133_XP_p1 I1390_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I133_XP_MP1 (I1390_P8_1 I1390_P4_1n XI1390_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I75_XP_MP0 (XI1390_I75_XP_p1 I1390_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I75_XP_MP1 (I1390_P9_8 I1390_pn8 XI1390_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I73_XP_MP0 (XI1390_I73_XP_p1 I1390_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I73_XP_MP1 (I1390_P7_6 I1390_pn6 XI1390_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I74_XP_MP0 (XI1436_I74_XP_p1 I1436_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I74_XP_MP1 (I1436_P8_7 I1436_pn7 XI1436_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I133_XP_MP0 (XI1436_I133_XP_p1 I1436_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I133_XP_MP1 (I1436_P8_1 I1436_P4_1n XI1436_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I73_XP_MP0 (XI1436_I73_XP_p1 I1436_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I73_XP_MP1 (I1436_P7_6 I1436_pn6 XI1436_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I73_XP_MP0 (XI1482_I73_XP_p1 I1482_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I73_XP_MP1 (I1482_P7_6 I1482_pn6 XI1482_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I74_XP_MP0 (XI1482_I74_XP_p1 I1482_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I74_XP_MP1 (I1482_P8_7 I1482_pn7 XI1482_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I133_XP_MP0 (XI1482_I133_XP_p1 I1482_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I133_XP_MP1 (I1482_P8_1 I1482_P4_1n XI1482_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I135_XP_MP0 (XI1528_I135_XP_p1 I1528_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I135_XP_MP1 (I1528_P10_3 I1528_P6_3n XI1528_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I77_XP_MP0 (XI1528_I77_XP_p1 I1528_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I77_XP_MP1 (I1528_P11_10 I1528_pn10 XI1528_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I136_XP_MP0 (XI1528_I136_XP_p1 I1528_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I136_XP_MP1 (I1528_P11_4 I1528_P7_4n XI1528_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I138_XP_MP0 (XI1528_I138_XP_p1 I1528_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I138_XP_MP1 (I1528_P13_6 I1528_P9_6n XI1528_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I142_XP_MP0 (XI1528_I142_XP_p1 I1528_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I142_XP_MP1 (I1528_P17_10 I1528_P13_10n XI1528_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I87_XP_MP0 (XI1160_I87_XP_p1 I1160_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I87_XP_MP1 (I1160_P21_20 I1160_pn20 XI1160_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I69_XP_MP0 (XI1160_I69_XP_p1 I1160_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I69_XP_MP1 (I1160_P3_2 I1160_pn2 XI1160_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I69_XP_MP0 (XI1206_I69_XP_p1 I1206_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I69_XP_MP1 (I1206_P3_2 I1206_pn2 XI1206_I69_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I72_XP_MP0 (XI1252_I72_XP_p1 I1252_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I72_XP_MP1 (I1252_P6_5 I1252_pn5 XI1252_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I133_XP_MP0 (XI1252_I133_XP_p1 I1252_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I133_XP_MP1 (I1252_P8_1 I1252_P4_1n XI1252_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I73_XP_MP0 (XI1252_I73_XP_p1 I1252_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I73_XP_MP1 (I1252_P7_6 I1252_pn6 XI1252_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I74_XP_MP0 (XI1298_I74_XP_p1 I1298_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I74_XP_MP1 (I1298_P8_7 I1298_pn7 XI1298_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I133_XP_MP0 (XI1298_I133_XP_p1 I1298_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I133_XP_MP1 (I1298_P8_1 I1298_P4_1n XI1298_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I75_XP_MP0 (XI1298_I75_XP_p1 I1298_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I75_XP_MP1 (I1298_P9_8 I1298_pn8 XI1298_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I134_XP_MP0 (XI1298_I134_XP_p1 I1298_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I134_XP_MP1 (I1298_P9_2 I1298_P5_2n XI1298_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I135_XP_MP0 (XI1344_I135_XP_p1 I1344_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I135_XP_MP1 (I1344_P10_3 I1344_P6_3n XI1344_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I76_XP_MP0 (XI1344_I76_XP_p1 I1344_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I76_XP_MP1 (I1344_P10_9 I1344_pn9 XI1344_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I76_XP_MP0 (XI1390_I76_XP_p1 I1390_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I76_XP_MP1 (I1390_P10_9 I1390_pn9 XI1390_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I135_XP_MP0 (XI1390_I135_XP_p1 I1390_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I135_XP_MP1 (I1390_P10_3 I1390_P6_3n XI1390_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I134_XP_MP0 (XI1390_I134_XP_p1 I1390_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I134_XP_MP1 (I1390_P9_2 I1390_P5_2n XI1390_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I76_XP_MP0 (XI1436_I76_XP_p1 I1436_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I76_XP_MP1 (I1436_P10_9 I1436_pn9 XI1436_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I75_XP_MP0 (XI1436_I75_XP_p1 I1436_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I75_XP_MP1 (I1436_P9_8 I1436_pn8 XI1436_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I134_XP_MP0 (XI1436_I134_XP_p1 I1436_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I134_XP_MP1 (I1436_P9_2 I1436_P5_2n XI1436_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I75_XP_MP0 (XI1482_I75_XP_p1 I1482_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I75_XP_MP1 (I1482_P9_8 I1482_pn8 XI1482_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I134_XP_MP0 (XI1482_I134_XP_p1 I1482_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I134_XP_MP1 (I1482_P9_2 I1482_P5_2n XI1482_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I80_XP_MP0 (XI1528_I80_XP_p1 I1528_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I80_XP_MP1 (I1528_P14_13 I1528_pn13 XI1528_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I78_XP_MP0 (XI1528_I78_XP_p1 I1528_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I78_XP_MP1 (I1528_P12_11 I1528_pn11 XI1528_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I145_XP_MP0 (XI1528_I145_XP_p1 I1528_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I145_XP_MP1 (I1528_P20_13 I1528_P16_13n XI1528_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I79_XP_MP0 (XI1528_I79_XP_p1 I1528_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I79_XP_MP1 (I1528_P13_12 I1528_pn12 XI1528_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I148_XP_MP0 (XI1160_I148_XP_p1 I1160_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I148_XP_MP1 (I1160_P23_16 I1160_P19_16n XI1160_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I89_XP_MP0 (XI1160_I89_XP_p1 I1160_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I89_XP_MP1 (I1160_P23_22 I1160_pn22 XI1160_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I144_XP_MP0 (XI1160_I144_XP_p1 I1160_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I144_XP_MP1 (I1160_P19_12 I1160_P15_12n XI1160_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I85_XP_MP0 (XI1160_I85_XP_p1 I1160_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I85_XP_MP1 (I1160_P19_18 I1160_pn18 XI1160_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I83_XP_MP0 (XI1160_I83_XP_p1 I1160_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I83_XP_MP1 (I1160_P17_16 I1160_pn16 XI1160_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I140_XP_MP0 (XI1160_I140_XP_p1 I1160_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I140_XP_MP1 (I1160_P15_8 I1160_P11_8n XI1160_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I81_XP_MP0 (XI1160_I81_XP_p1 I1160_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I81_XP_MP1 (I1160_P15_14 I1160_pn14 XI1160_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I79_XP_MP0 (XI1160_I79_XP_p1 I1160_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I79_XP_MP1 (I1160_P13_12 I1160_pn12 XI1160_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I77_XP_MP0 (XI1160_I77_XP_p1 I1160_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I77_XP_MP1 (I1160_P11_10 I1160_pn10 XI1160_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I75_XP_MP0 (XI1160_I75_XP_p1 I1160_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I75_XP_MP1 (I1160_P9_8 I1160_pn8 XI1160_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I73_XP_MP0 (XI1160_I73_XP_p1 I1160_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I73_XP_MP1 (I1160_P7_6 I1160_pn6 XI1160_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I71_XP_MP0 (XI1160_I71_XP_p1 I1160_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I71_XP_MP1 (I1160_P5_4 I1160_pn4 XI1160_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I70_XP_MP0 (XI1160_I70_XP_p1 I1160_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I70_XP_MP1 (I1160_P4_3 I1160_pn3 XI1160_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I71_XP_MP0 (XI1206_I71_XP_p1 I1206_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I71_XP_MP1 (I1206_P5_4 I1206_pn4 XI1206_I71_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I70_XP_MP0 (XI1206_I70_XP_p1 I1206_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I70_XP_MP1 (I1206_P4_3 I1206_pn3 XI1206_I70_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I135_XP_MP0 (XI1252_I135_XP_p1 I1252_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I135_XP_MP1 (I1252_P10_3 I1252_P6_3n XI1252_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I74_XP_MP0 (XI1252_I74_XP_p1 I1252_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I74_XP_MP1 (I1252_P8_7 I1252_pn7 XI1252_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I75_XP_MP0 (XI1252_I75_XP_p1 I1252_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I75_XP_MP1 (I1252_P9_8 I1252_pn8 XI1252_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I134_XP_MP0 (XI1252_I134_XP_p1 I1252_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I134_XP_MP1 (I1252_P9_2 I1252_P5_2n XI1252_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I76_XP_MP0 (XI1298_I76_XP_p1 I1298_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I76_XP_MP1 (I1298_P10_9 I1298_pn9 XI1298_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I135_XP_MP0 (XI1298_I135_XP_p1 I1298_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I135_XP_MP1 (I1298_P10_3 I1298_P6_3n XI1298_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I77_XP_MP0 (XI1298_I77_XP_p1 I1298_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I77_XP_MP1 (I1298_P11_10 I1298_pn10 XI1298_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I141_XP_MP0 (XI1344_I141_XP_p1 I1344_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I141_XP_MP1 (I1344_P16_9 I1344_P12_9n XI1344_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I137_XP_MP0 (XI1344_I137_XP_p1 I1344_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I137_XP_MP1 (I1344_P12_5 I1344_P8_5n XI1344_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I78_XP_MP0 (XI1344_I78_XP_p1 I1344_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I78_XP_MP1 (I1344_P12_11 I1344_pn11 XI1344_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I77_XP_MP0 (XI1344_I77_XP_p1 I1344_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I77_XP_MP1 (I1344_P11_10 I1344_pn10 XI1344_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I136_XP_MP0 (XI1344_I136_XP_p1 I1344_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I136_XP_MP1 (I1344_P11_4 I1344_P7_4n XI1344_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I78_XP_MP0 (XI1390_I78_XP_p1 I1390_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I78_XP_MP1 (I1390_P12_11 I1390_pn11 XI1390_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I77_XP_MP0 (XI1390_I77_XP_p1 I1390_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I77_XP_MP1 (I1390_P11_10 I1390_pn10 XI1390_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I136_XP_MP0 (XI1390_I136_XP_p1 I1390_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I136_XP_MP1 (I1390_P11_4 I1390_P7_4n XI1390_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I78_XP_MP0 (XI1436_I78_XP_p1 I1436_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I78_XP_MP1 (I1436_P12_11 I1436_pn11 XI1436_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I135_XP_MP0 (XI1436_I135_XP_p1 I1436_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I135_XP_MP1 (I1436_P10_3 I1436_P6_3n XI1436_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I77_XP_MP0 (XI1436_I77_XP_p1 I1436_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I77_XP_MP1 (I1436_P11_10 I1436_pn10 XI1436_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I77_XP_MP0 (XI1482_I77_XP_p1 I1482_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I77_XP_MP1 (I1482_P11_10 I1482_pn10 XI1482_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I76_XP_MP0 (XI1482_I76_XP_p1 I1482_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I76_XP_MP1 (I1482_P10_9 I1482_pn9 XI1482_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I139_XP_MP0 (XI1528_I139_XP_p1 I1528_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I139_XP_MP1 (I1528_P14_7 I1528_P10_7n XI1528_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I143_XP_MP0 (XI1528_I143_XP_p1 I1528_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I143_XP_MP1 (I1528_P18_11 I1528_P14_11n XI1528_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I149_XP_MP0 (XI1528_I149_XP_p1 I1528_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I149_XP_MP1 (I1528_P24_17 I1528_P20_17n XI1528_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I81_XP_MP0 (XI1528_I81_XP_p1 I1528_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I81_XP_MP1 (I1528_P15_14 I1528_pn14 XI1528_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I140_XP_MP0 (XI1528_I140_XP_p1 I1528_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I140_XP_MP1 (I1528_P15_8 I1528_P11_8n XI1528_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I156_XP_MP0 (XI1160_I156_XP_p1 I1160_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I156_XP_MP1 (I1160_P31_24 I1160_P27_24n XI1160_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I152_XP_MP0 (XI1160_I152_XP_p1 I1160_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I152_XP_MP1 (I1160_P27_20 I1160_P23_20n XI1160_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I150_XP_MP0 (XI1160_I150_XP_p1 I1160_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I150_XP_MP1 (I1160_P25_18 I1160_P21_18n XI1160_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I146_XP_MP0 (XI1160_I146_XP_p1 I1160_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I146_XP_MP1 (I1160_P21_14 I1160_P17_14n XI1160_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I142_XP_MP0 (XI1160_I142_XP_p1 I1160_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I142_XP_MP1 (I1160_P17_10 I1160_P13_10n XI1160_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I138_XP_MP0 (XI1160_I138_XP_p1 I1160_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I138_XP_MP1 (I1160_P13_6 I1160_P9_6n XI1160_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I136_XP_MP0 (XI1160_I136_XP_p1 I1160_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I136_XP_MP1 (I1160_P11_4 I1160_P7_4n XI1160_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I134_XP_MP0 (XI1160_I134_XP_p1 I1160_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I134_XP_MP1 (I1160_P9_2 I1160_P5_2n XI1160_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I74_XP_MP0 (XI1160_I74_XP_p1 I1160_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I74_XP_MP1 (I1160_P8_7 I1160_pn7 XI1160_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I72_XP_MP0 (XI1160_I72_XP_p1 I1160_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I72_XP_MP1 (I1160_P6_5 I1160_pn5 XI1160_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I72_XP_MP0 (XI1206_I72_XP_p1 I1206_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I72_XP_MP1 (I1206_P6_5 I1206_pn5 XI1206_I72_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I76_XP_MP0 (XI1252_I76_XP_p1 I1252_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I76_XP_MP1 (I1252_P10_9 I1252_pn9 XI1252_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I77_XP_MP0 (XI1252_I77_XP_p1 I1252_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I77_XP_MP1 (I1252_P11_10 I1252_pn10 XI1252_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I78_XP_MP0 (XI1298_I78_XP_p1 I1298_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I78_XP_MP1 (I1298_P12_11 I1298_pn11 XI1298_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I137_XP_MP0 (XI1298_I137_XP_p1 I1298_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I137_XP_MP1 (I1298_P12_5 I1298_P8_5n XI1298_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I136_XP_MP0 (XI1298_I136_XP_p1 I1298_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I136_XP_MP1 (I1298_P11_4 I1298_P7_4n XI1298_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I79_XP_MP0 (XI1344_I79_XP_p1 I1344_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I79_XP_MP1 (I1344_P13_12 I1344_pn12 XI1344_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I141_XP_MP0 (XI1390_I141_XP_p1 I1390_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I141_XP_MP1 (I1390_P16_9 I1390_P12_9n XI1390_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I137_XP_MP0 (XI1390_I137_XP_p1 I1390_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I137_XP_MP1 (I1390_P12_5 I1390_P8_5n XI1390_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I79_XP_MP0 (XI1390_I79_XP_p1 I1390_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I79_XP_MP1 (I1390_P13_12 I1390_pn12 XI1390_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I141_XP_MP0 (XI1436_I141_XP_p1 I1436_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I141_XP_MP1 (I1436_P16_9 I1436_P12_9n XI1436_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I137_XP_MP0 (XI1436_I137_XP_p1 I1436_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I137_XP_MP1 (I1436_P12_5 I1436_P8_5n XI1436_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I136_XP_MP0 (XI1436_I136_XP_p1 I1436_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I136_XP_MP1 (I1436_P11_4 I1436_P7_4n XI1436_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I136_XP_MP0 (XI1482_I136_XP_p1 I1482_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I136_XP_MP1 (I1482_P11_4 I1482_P7_4n XI1482_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I78_XP_MP0 (XI1482_I78_XP_p1 I1482_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I78_XP_MP1 (I1482_P12_11 I1482_pn11 XI1482_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I137_XP_MP0 (XI1482_I137_XP_p1 I1482_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I137_XP_MP1 (I1482_P12_5 I1482_P8_5n XI1482_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I135_XP_MP0 (XI1482_I135_XP_p1 I1482_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I135_XP_MP1 (I1482_P10_3 I1482_P6_3n XI1482_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I82_XP_MP0 (XI1528_I82_XP_p1 I1528_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I82_XP_MP1 (I1528_P16_15 I1528_pn15 XI1528_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I144_XP_MP0 (XI1528_I144_XP_p1 I1528_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I144_XP_MP1 (I1528_P19_12 I1528_P15_12n XI1528_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I146_XP_MP0 (XI1528_I146_XP_p1 I1528_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I146_XP_MP1 (I1528_P21_14 I1528_P17_14n XI1528_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I97_XP_MP0 (XI1160_I97_XP_p1 I1160_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I97_XP_MP1 (I1160_P31_30 I1160_pn30 XI1160_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I154_XP_MP0 (XI1160_I154_XP_p1 I1160_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I154_XP_MP1 (I1160_P29_22 I1160_P25_22n XI1160_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I84_XP_MP0 (XI1160_I84_XP_p1 I1160_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I84_XP_MP1 (I1160_P18_17 I1160_pn17 XI1160_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I80_XP_MP0 (XI1160_I80_XP_p1 I1160_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I80_XP_MP1 (I1160_P14_13 I1160_pn13 XI1160_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I78_XP_MP0 (XI1160_I78_XP_p1 I1160_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I78_XP_MP1 (I1160_P12_11 I1160_pn11 XI1160_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I76_XP_MP0 (XI1160_I76_XP_p1 I1160_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I76_XP_MP1 (I1160_P10_9 I1160_pn9 XI1160_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I73_XP_MP0 (XI1206_I73_XP_p1 I1206_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I73_XP_MP1 (I1206_P7_6 I1206_pn6 XI1206_I73_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I74_XP_MP0 (XI1206_I74_XP_p1 I1206_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I74_XP_MP1 (I1206_P8_7 I1206_pn7 XI1206_I74_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I133_XP_MP0 (XI1206_I133_XP_p1 I1206_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I133_XP_MP1 (I1206_P8_1 I1206_P4_1n XI1206_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I78_XP_MP0 (XI1252_I78_XP_p1 I1252_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I78_XP_MP1 (I1252_P12_11 I1252_pn11 XI1252_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I141_XP_MP0 (XI1252_I141_XP_p1 I1252_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I141_XP_MP1 (I1252_P16_9 I1252_P12_9n XI1252_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I137_XP_MP0 (XI1252_I137_XP_p1 I1252_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I137_XP_MP1 (I1252_P12_5 I1252_P8_5n XI1252_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I79_XP_MP0 (XI1252_I79_XP_p1 I1252_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I79_XP_MP1 (I1252_P13_12 I1252_pn12 XI1252_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I136_XP_MP0 (XI1252_I136_XP_p1 I1252_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I136_XP_MP1 (I1252_P11_4 I1252_P7_4n XI1252_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I138_XP_MP0 (XI1252_I138_XP_p1 I1252_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I138_XP_MP1 (I1252_P13_6 I1252_P9_6n XI1252_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I80_XP_MP0 (XI1298_I80_XP_p1 I1298_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I80_XP_MP1 (I1298_P14_13 I1298_pn13 XI1298_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I141_XP_MP0 (XI1298_I141_XP_p1 I1298_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I141_XP_MP1 (I1298_P16_9 I1298_P12_9n XI1298_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I79_XP_MP0 (XI1298_I79_XP_p1 I1298_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I79_XP_MP1 (I1298_P13_12 I1298_pn12 XI1298_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I142_XP_MP0 (XI1298_I142_XP_p1 I1298_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I142_XP_MP1 (I1298_P17_10 I1298_P13_10n XI1298_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I138_XP_MP0 (XI1298_I138_XP_p1 I1298_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I138_XP_MP1 (I1298_P13_6 I1298_P9_6n XI1298_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I139_XP_MP0 (XI1344_I139_XP_p1 I1344_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I139_XP_MP1 (I1344_P14_7 I1344_P10_7n XI1344_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I80_XP_MP0 (XI1344_I80_XP_p1 I1344_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I80_XP_MP1 (I1344_P14_13 I1344_pn13 XI1344_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I142_XP_MP0 (XI1344_I142_XP_p1 I1344_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I142_XP_MP1 (I1344_P17_10 I1344_P13_10n XI1344_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I138_XP_MP0 (XI1344_I138_XP_p1 I1344_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I138_XP_MP1 (I1344_P13_6 I1344_P9_6n XI1344_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I80_XP_MP0 (XI1390_I80_XP_p1 I1390_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I80_XP_MP1 (I1390_P14_13 I1390_pn13 XI1390_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I143_XP_MP0 (XI1390_I143_XP_p1 I1390_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I143_XP_MP1 (I1390_P18_11 I1390_P14_11n XI1390_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I139_XP_MP0 (XI1390_I139_XP_p1 I1390_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I139_XP_MP1 (I1390_P14_7 I1390_P10_7n XI1390_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I142_XP_MP0 (XI1390_I142_XP_p1 I1390_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I142_XP_MP1 (I1390_P17_10 I1390_P13_10n XI1390_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I138_XP_MP0 (XI1390_I138_XP_p1 I1390_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I138_XP_MP1 (I1390_P13_6 I1390_P9_6n XI1390_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I80_XP_MP0 (XI1436_I80_XP_p1 I1436_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I80_XP_MP1 (I1436_P14_13 I1436_pn13 XI1436_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I139_XP_MP0 (XI1436_I139_XP_p1 I1436_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I139_XP_MP1 (I1436_P14_7 I1436_P10_7n XI1436_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I79_XP_MP0 (XI1436_I79_XP_p1 I1436_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I79_XP_MP1 (I1436_P13_12 I1436_pn12 XI1436_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I138_XP_MP0 (XI1436_I138_XP_p1 I1436_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I138_XP_MP1 (I1436_P13_6 I1436_P9_6n XI1436_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I79_XP_MP0 (XI1482_I79_XP_p1 I1482_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I79_XP_MP1 (I1482_P13_12 I1482_pn12 XI1482_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I80_XP_MP0 (XI1482_I80_XP_p1 I1482_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I80_XP_MP1 (I1482_P14_13 I1482_pn13 XI1482_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I141_XP_MP0 (XI1482_I141_XP_p1 I1482_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I141_XP_MP1 (I1482_P16_9 I1482_P12_9n XI1482_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I139_XP_MP0 (XI1482_I139_XP_p1 I1482_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I139_XP_MP1 (I1482_P14_7 I1482_P10_7n XI1482_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I84_XP_MP0 (XI1528_I84_XP_p1 I1528_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I84_XP_MP1 (I1528_P18_17 I1528_pn17 XI1528_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I147_XP_MP0 (XI1528_I147_XP_p1 I1528_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I147_XP_MP1 (I1528_P22_15 I1528_P18_15n XI1528_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I83_XP_MP0 (XI1528_I83_XP_p1 I1528_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I83_XP_MP1 (I1528_P17_16 I1528_pn16 XI1528_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I91_XP_MP0 (XI1160_I91_XP_p1 I1160_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I91_XP_MP1 (I1160_P25_24 I1160_pn24 XI1160_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I88_XP_MP0 (XI1160_I88_XP_p1 I1160_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I88_XP_MP1 (I1160_P22_21 I1160_pn21 XI1160_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I86_XP_MP0 (XI1160_I86_XP_p1 I1160_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I86_XP_MP1 (I1160_P20_19 I1160_pn19 XI1160_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I145_XP_MP0 (XI1160_I145_XP_p1 I1160_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I145_XP_MP1 (I1160_P20_13 I1160_P16_13n XI1160_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I82_XP_MP0 (XI1160_I82_XP_p1 I1160_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I82_XP_MP1 (I1160_P16_15 I1160_pn15 XI1160_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I141_XP_MP0 (XI1160_I141_XP_p1 I1160_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I141_XP_MP1 (I1160_P16_9 I1160_P12_9n XI1160_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I137_XP_MP0 (XI1160_I137_XP_p1 I1160_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I137_XP_MP1 (I1160_P12_5 I1160_P8_5n XI1160_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I133_XP_MP0 (XI1160_I133_XP_p1 I1160_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I133_XP_MP1 (I1160_P8_1 I1160_P4_1n XI1160_I133_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I75_XP_MP0 (XI1206_I75_XP_p1 I1206_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I75_XP_MP1 (I1206_P9_8 I1206_pn8 XI1206_I75_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I76_XP_MP0 (XI1206_I76_XP_p1 I1206_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I76_XP_MP1 (I1206_P10_9 I1206_pn9 XI1206_I76_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I80_XP_MP0 (XI1252_I80_XP_p1 I1252_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I80_XP_MP1 (I1252_P14_13 I1252_pn13 XI1252_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I139_XP_MP0 (XI1252_I139_XP_p1 I1252_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I139_XP_MP1 (I1252_P14_7 I1252_P10_7n XI1252_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I142_XP_MP0 (XI1252_I142_XP_p1 I1252_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I142_XP_MP1 (I1252_P17_10 I1252_P13_10n XI1252_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I143_XP_MP0 (XI1298_I143_XP_p1 I1298_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I143_XP_MP1 (I1298_P18_11 I1298_P14_11n XI1298_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I139_XP_MP0 (XI1298_I139_XP_p1 I1298_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I139_XP_MP1 (I1298_P14_7 I1298_P10_7n XI1298_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I81_XP_MP0 (XI1298_I81_XP_p1 I1298_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I81_XP_MP1 (I1298_P15_14 I1298_pn14 XI1298_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I140_XP_MP0 (XI1298_I140_XP_p1 I1298_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I140_XP_MP1 (I1298_P15_8 I1298_P11_8n XI1298_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I143_XP_MP0 (XI1344_I143_XP_p1 I1344_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I143_XP_MP1 (I1344_P18_11 I1344_P14_11n XI1344_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I145_XP_MP0 (XI1344_I145_XP_p1 I1344_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I145_XP_MP1 (I1344_P20_13 I1344_P16_13n XI1344_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I149_XP_MP0 (XI1344_I149_XP_p1 I1344_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I149_XP_MP1 (I1344_P24_17 I1344_P20_17n XI1344_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I82_XP_MP0 (XI1344_I82_XP_p1 I1344_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I82_XP_MP1 (I1344_P16_15 I1344_pn15 XI1344_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I81_XP_MP0 (XI1344_I81_XP_p1 I1344_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I81_XP_MP1 (I1344_P15_14 I1344_pn14 XI1344_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I140_XP_MP0 (XI1344_I140_XP_p1 I1344_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I140_XP_MP1 (I1344_P15_8 I1344_P11_8n XI1344_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I82_XP_MP0 (XI1390_I82_XP_p1 I1390_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I82_XP_MP1 (I1390_P16_15 I1390_pn15 XI1390_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I145_XP_MP0 (XI1390_I145_XP_p1 I1390_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I145_XP_MP1 (I1390_P20_13 I1390_P16_13n XI1390_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I149_XP_MP0 (XI1390_I149_XP_p1 I1390_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I149_XP_MP1 (I1390_P24_17 I1390_P20_17n XI1390_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I81_XP_MP0 (XI1390_I81_XP_p1 I1390_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I81_XP_MP1 (I1390_P15_14 I1390_pn14 XI1390_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I140_XP_MP0 (XI1390_I140_XP_p1 I1390_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I140_XP_MP1 (I1390_P15_8 I1390_P11_8n XI1390_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I143_XP_MP0 (XI1436_I143_XP_p1 I1436_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I143_XP_MP1 (I1436_P18_11 I1436_P14_11n XI1436_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I81_XP_MP0 (XI1436_I81_XP_p1 I1436_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I81_XP_MP1 (I1436_P15_14 I1436_pn14 XI1436_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I142_XP_MP0 (XI1436_I142_XP_p1 I1436_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I142_XP_MP1 (I1436_P17_10 I1436_P13_10n XI1436_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I81_XP_MP0 (XI1482_I81_XP_p1 I1482_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I81_XP_MP1 (I1482_P15_14 I1482_pn14 XI1482_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I142_XP_MP0 (XI1482_I142_XP_p1 I1482_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I142_XP_MP1 (I1482_P17_10 I1482_P13_10n XI1482_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I138_XP_MP0 (XI1482_I138_XP_p1 I1482_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I138_XP_MP1 (I1482_P13_6 I1482_P9_6n XI1482_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I86_XP_MP0 (XI1528_I86_XP_p1 I1528_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I86_XP_MP1 (I1528_P20_19 I1528_pn19 XI1528_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I88_XP_MP0 (XI1528_I88_XP_p1 I1528_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I88_XP_MP1 (I1528_P22_21 I1528_pn21 XI1528_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I85_XP_MP0 (XI1528_I85_XP_p1 I1528_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I85_XP_MP1 (I1528_P19_18 I1528_pn18 XI1528_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I153_XP_MP0 (XI1528_I153_XP_p1 I1528_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I153_XP_MP1 (I1528_P28_21 I1528_P24_21n XI1528_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I151_XP_MP0 (XI1528_I151_XP_p1 I1528_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I151_XP_MP1 (I1528_P26_19 I1528_P22_19n XI1528_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I87_XP_MP0 (XI1528_I87_XP_p1 I1528_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I87_XP_MP1 (I1528_P21_20 I1528_pn20 XI1528_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I148_XP_MP0 (XI1528_I148_XP_p1 I1528_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I148_XP_MP1 (I1528_P23_16 I1528_P19_16n XI1528_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I150_XP_MP0 (XI1528_I150_XP_p1 I1528_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I150_XP_MP1 (I1528_P25_18 I1528_P21_18n XI1528_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I96_XP_MP0 (XI1160_I96_XP_p1 I1160_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I96_XP_MP1 (I1160_P30_29 I1160_pn29 XI1160_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I90_XP_MP0 (XI1160_I90_XP_p1 I1160_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I90_XP_MP1 (I1160_P24_23 I1160_pn23 XI1160_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I153_XP_MP0 (XI1160_I153_XP_p1 I1160_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I153_XP_MP1 (I1160_P28_21 I1160_P24_21n XI1160_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I149_XP_MP0 (XI1160_I149_XP_p1 I1160_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I149_XP_MP1 (I1160_P24_17 I1160_P20_17n XI1160_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I77_XP_MP0 (XI1206_I77_XP_p1 I1206_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I77_XP_MP1 (I1206_P11_10 I1206_pn10 XI1206_I77_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I78_XP_MP0 (XI1206_I78_XP_p1 I1206_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I78_XP_MP1 (I1206_P12_11 I1206_pn11 XI1206_I78_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I135_XP_MP0 (XI1206_I135_XP_p1 I1206_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I135_XP_MP1 (I1206_P10_3 I1206_P6_3n XI1206_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I143_XP_MP0 (XI1252_I143_XP_p1 I1252_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I143_XP_MP1 (I1252_P18_11 I1252_P14_11n XI1252_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I145_XP_MP0 (XI1252_I145_XP_p1 I1252_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I145_XP_MP1 (I1252_P20_13 I1252_P16_13n XI1252_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I81_XP_MP0 (XI1252_I81_XP_p1 I1252_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I81_XP_MP1 (I1252_P15_14 I1252_pn14 XI1252_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I140_XP_MP0 (XI1252_I140_XP_p1 I1252_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I140_XP_MP1 (I1252_P15_8 I1252_P11_8n XI1252_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I82_XP_MP0 (XI1298_I82_XP_p1 I1298_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I82_XP_MP1 (I1298_P16_15 I1298_pn15 XI1298_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I145_XP_MP0 (XI1298_I145_XP_p1 I1298_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I145_XP_MP1 (I1298_P20_13 I1298_P16_13n XI1298_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I149_XP_MP0 (XI1298_I149_XP_p1 I1298_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I149_XP_MP1 (I1298_P24_17 I1298_P20_17n XI1298_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I83_XP_MP0 (XI1298_I83_XP_p1 I1298_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I83_XP_MP1 (I1298_P17_16 I1298_pn16 XI1298_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I144_XP_MP0 (XI1298_I144_XP_p1 I1298_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I144_XP_MP1 (I1298_P19_12 I1298_P15_12n XI1298_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I83_XP_MP0 (XI1344_I83_XP_p1 I1344_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I83_XP_MP1 (I1344_P17_16 I1344_pn16 XI1344_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I144_XP_MP0 (XI1344_I144_XP_p1 I1344_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I144_XP_MP1 (I1344_P19_12 I1344_P15_12n XI1344_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I84_XP_MP0 (XI1390_I84_XP_p1 I1390_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I84_XP_MP1 (I1390_P18_17 I1390_pn17 XI1390_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I83_XP_MP0 (XI1390_I83_XP_p1 I1390_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I83_XP_MP1 (I1390_P17_16 I1390_pn16 XI1390_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I144_XP_MP0 (XI1390_I144_XP_p1 I1390_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I144_XP_MP1 (I1390_P19_12 I1390_P15_12n XI1390_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I82_XP_MP0 (XI1436_I82_XP_p1 I1436_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I82_XP_MP1 (I1436_P16_15 I1436_pn15 XI1436_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I145_XP_MP0 (XI1436_I145_XP_p1 I1436_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I145_XP_MP1 (I1436_P20_13 I1436_P16_13n XI1436_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I144_XP_MP0 (XI1436_I144_XP_p1 I1436_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I144_XP_MP1 (I1436_P19_12 I1436_P15_12n XI1436_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I140_XP_MP0 (XI1436_I140_XP_p1 I1436_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I140_XP_MP1 (I1436_P15_8 I1436_P11_8n XI1436_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I83_XP_MP0 (XI1482_I83_XP_p1 I1482_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I83_XP_MP1 (I1482_P17_16 I1482_pn16 XI1482_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I82_XP_MP0 (XI1482_I82_XP_p1 I1482_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I82_XP_MP1 (I1482_P16_15 I1482_pn15 XI1482_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I84_XP_MP0 (XI1482_I84_XP_p1 I1482_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I84_XP_MP1 (I1482_P18_17 I1482_pn17 XI1482_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I145_XP_MP0 (XI1482_I145_XP_p1 I1482_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I145_XP_MP1 (I1482_P20_13 I1482_P16_13n XI1482_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I143_XP_MP0 (XI1482_I143_XP_p1 I1482_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I143_XP_MP1 (I1482_P18_11 I1482_P14_11n XI1482_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I89_XP_MP0 (XI1528_I89_XP_p1 I1528_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I89_XP_MP1 (I1528_P23_22 I1528_pn22 XI1528_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I152_XP_MP0 (XI1528_I152_XP_p1 I1528_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I152_XP_MP1 (I1528_P27_20 I1528_P23_20n XI1528_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I154_XP_MP0 (XI1528_I154_XP_p1 I1528_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I154_XP_MP1 (I1528_P29_22 I1528_P25_22n XI1528_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I95_XP_MP0 (XI1160_I95_XP_p1 I1160_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I95_XP_MP1 (I1160_P29_28 I1160_pn28 XI1160_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I151_XP_MP0 (XI1160_I151_XP_p1 I1160_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I151_XP_MP1 (I1160_P26_19 I1160_P22_19n XI1160_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I147_XP_MP0 (XI1160_I147_XP_p1 I1160_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I147_XP_MP1 (I1160_P22_15 I1160_P18_15n XI1160_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I143_XP_MP0 (XI1160_I143_XP_p1 I1160_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I143_XP_MP1 (I1160_P18_11 I1160_P14_11n XI1160_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I139_XP_MP0 (XI1160_I139_XP_p1 I1160_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I139_XP_MP1 (I1160_P14_7 I1160_P10_7n XI1160_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I135_XP_MP0 (XI1160_I135_XP_p1 I1160_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I135_XP_MP1 (I1160_P10_3 I1160_P6_3n XI1160_I135_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I81_XP_MP0 (XI1206_I81_XP_p1 I1206_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I81_XP_MP1 (I1206_P15_14 I1206_pn14 XI1206_I81_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I79_XP_MP0 (XI1206_I79_XP_p1 I1206_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I79_XP_MP1 (I1206_P13_12 I1206_pn12 XI1206_I79_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I80_XP_MP0 (XI1206_I80_XP_p1 I1206_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I80_XP_MP1 (I1206_P14_13 I1206_pn13 XI1206_I80_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I134_XP_MP0 (XI1206_I134_XP_p1 I1206_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I134_XP_MP1 (I1206_P9_2 I1206_P5_2n XI1206_I134_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I137_XP_MP0 (XI1206_I137_XP_p1 I1206_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I137_XP_MP1 (I1206_P12_5 I1206_P8_5n XI1206_I137_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I141_XP_MP0 (XI1206_I141_XP_p1 I1206_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I141_XP_MP1 (I1206_P16_9 I1206_P12_9n XI1206_I141_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I84_XP_MP0 (XI1252_I84_XP_p1 I1252_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I84_XP_MP1 (I1252_P18_17 I1252_pn17 XI1252_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I82_XP_MP0 (XI1252_I82_XP_p1 I1252_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I82_XP_MP1 (I1252_P16_15 I1252_pn15 XI1252_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I149_XP_MP0 (XI1252_I149_XP_p1 I1252_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I149_XP_MP1 (I1252_P24_17 I1252_P20_17n XI1252_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I83_XP_MP0 (XI1252_I83_XP_p1 I1252_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I83_XP_MP1 (I1252_P17_16 I1252_pn16 XI1252_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I144_XP_MP0 (XI1252_I144_XP_p1 I1252_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I144_XP_MP1 (I1252_P19_12 I1252_P15_12n XI1252_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I84_XP_MP0 (XI1298_I84_XP_p1 I1298_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I84_XP_MP1 (I1298_P18_17 I1298_pn17 XI1298_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I151_XP_MP0 (XI1298_I151_XP_p1 I1298_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I151_XP_MP1 (I1298_P26_19 I1298_P22_19n XI1298_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I147_XP_MP0 (XI1298_I147_XP_p1 I1298_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I147_XP_MP1 (I1298_P22_15 I1298_P18_15n XI1298_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I85_XP_MP0 (XI1298_I85_XP_p1 I1298_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I85_XP_MP1 (I1298_P19_18 I1298_pn18 XI1298_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I146_XP_MP0 (XI1298_I146_XP_p1 I1298_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I146_XP_MP1 (I1298_P21_14 I1298_P17_14n XI1298_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I147_XP_MP0 (XI1344_I147_XP_p1 I1344_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I147_XP_MP1 (I1344_P22_15 I1344_P18_15n XI1344_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I84_XP_MP0 (XI1344_I84_XP_p1 I1344_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I84_XP_MP1 (I1344_P18_17 I1344_pn17 XI1344_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I85_XP_MP0 (XI1344_I85_XP_p1 I1344_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I85_XP_MP1 (I1344_P19_18 I1344_pn18 XI1344_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I146_XP_MP0 (XI1344_I146_XP_p1 I1344_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I146_XP_MP1 (I1344_P21_14 I1344_P17_14n XI1344_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I147_XP_MP0 (XI1390_I147_XP_p1 I1390_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I147_XP_MP1 (I1390_P22_15 I1390_P18_15n XI1390_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I151_XP_MP0 (XI1390_I151_XP_p1 I1390_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I151_XP_MP1 (I1390_P26_19 I1390_P22_19n XI1390_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I85_XP_MP0 (XI1390_I85_XP_p1 I1390_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I85_XP_MP1 (I1390_P19_18 I1390_pn18 XI1390_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I150_XP_MP0 (XI1390_I150_XP_p1 I1390_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I150_XP_MP1 (I1390_P25_18 I1390_P21_18n XI1390_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I146_XP_MP0 (XI1390_I146_XP_p1 I1390_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I146_XP_MP1 (I1390_P21_14 I1390_P17_14n XI1390_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I84_XP_MP0 (XI1436_I84_XP_p1 I1436_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I84_XP_MP1 (I1436_P18_17 I1436_pn17 XI1436_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I149_XP_MP0 (XI1436_I149_XP_p1 I1436_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I149_XP_MP1 (I1436_P24_17 I1436_P20_17n XI1436_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I85_XP_MP0 (XI1436_I85_XP_p1 I1436_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I85_XP_MP1 (I1436_P19_18 I1436_pn18 XI1436_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I83_XP_MP0 (XI1436_I83_XP_p1 I1436_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I83_XP_MP1 (I1436_P17_16 I1436_pn16 XI1436_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I146_XP_MP0 (XI1436_I146_XP_p1 I1436_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I146_XP_MP1 (I1436_P21_14 I1436_P17_14n XI1436_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I85_XP_MP0 (XI1482_I85_XP_p1 I1482_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I85_XP_MP1 (I1482_P19_18 I1482_pn18 XI1482_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I144_XP_MP0 (XI1482_I144_XP_p1 I1482_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I144_XP_MP1 (I1482_P19_12 I1482_P15_12n XI1482_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I140_XP_MP0 (XI1482_I140_XP_p1 I1482_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I140_XP_MP1 (I1482_P15_8 I1482_P11_8n XI1482_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I149_XP_MP0 (XI1482_I149_XP_p1 I1482_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I149_XP_MP1 (I1482_P24_17 I1482_P20_17n XI1482_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I90_XP_MP0 (XI1528_I90_XP_p1 I1528_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I90_XP_MP1 (I1528_P24_23 I1528_pn23 XI1528_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I155_XP_MP0 (XI1528_I155_XP_p1 I1528_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I155_XP_MP1 (I1528_P30_23 I1528_P26_23n XI1528_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I91_XP_MP0 (XI1528_I91_XP_p1 I1528_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I91_XP_MP1 (I1528_P25_24 I1528_pn24 XI1528_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I93_XP_MP0 (XI1160_I93_XP_p1 I1160_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I93_XP_MP1 (I1160_P27_26 I1160_pn26 XI1160_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I94_XP_MP0 (XI1160_I94_XP_p1 I1160_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I94_XP_MP1 (I1160_P28_27 I1160_pn27 XI1160_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I155_XP_MP0 (XI1160_I155_XP_p1 I1160_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I155_XP_MP1 (I1160_P30_23 I1160_P26_23n XI1160_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I92_XP_MP0 (XI1160_I92_XP_p1 I1160_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I92_XP_MP1 (I1160_P26_25 I1160_pn25 XI1160_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I82_XP_MP0 (XI1206_I82_XP_p1 I1206_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I82_XP_MP1 (I1206_P16_15 I1206_pn15 XI1206_I82_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I138_XP_MP0 (XI1206_I138_XP_p1 I1206_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I138_XP_MP1 (I1206_P13_6 I1206_P9_6n XI1206_I138_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I136_XP_MP0 (XI1206_I136_XP_p1 I1206_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I136_XP_MP1 (I1206_P11_4 I1206_P7_4n XI1206_I136_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I86_XP_MP0 (XI1252_I86_XP_p1 I1252_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I86_XP_MP1 (I1252_P20_19 I1252_pn19 XI1252_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I151_XP_MP0 (XI1252_I151_XP_p1 I1252_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I151_XP_MP1 (I1252_P26_19 I1252_P22_19n XI1252_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I147_XP_MP0 (XI1252_I147_XP_p1 I1252_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I147_XP_MP1 (I1252_P22_15 I1252_P18_15n XI1252_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I85_XP_MP0 (XI1252_I85_XP_p1 I1252_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I85_XP_MP1 (I1252_P19_18 I1252_pn18 XI1252_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I150_XP_MP0 (XI1252_I150_XP_p1 I1252_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I150_XP_MP1 (I1252_P25_18 I1252_P21_18n XI1252_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I146_XP_MP0 (XI1252_I146_XP_p1 I1252_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I146_XP_MP1 (I1252_P21_14 I1252_P17_14n XI1252_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I86_XP_MP0 (XI1298_I86_XP_p1 I1298_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I86_XP_MP1 (I1298_P20_19 I1298_pn19 XI1298_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I150_XP_MP0 (XI1298_I150_XP_p1 I1298_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I150_XP_MP1 (I1298_P25_18 I1298_P21_18n XI1298_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I151_XP_MP0 (XI1344_I151_XP_p1 I1344_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I151_XP_MP1 (I1344_P26_19 I1344_P22_19n XI1344_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I86_XP_MP0 (XI1344_I86_XP_p1 I1344_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I86_XP_MP1 (I1344_P20_19 I1344_pn19 XI1344_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I87_XP_MP0 (XI1344_I87_XP_p1 I1344_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I87_XP_MP1 (I1344_P21_20 I1344_pn20 XI1344_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I150_XP_MP0 (XI1344_I150_XP_p1 I1344_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I150_XP_MP1 (I1344_P25_18 I1344_P21_18n XI1344_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I86_XP_MP0 (XI1390_I86_XP_p1 I1390_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I86_XP_MP1 (I1390_P20_19 I1390_pn19 XI1390_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I87_XP_MP0 (XI1390_I87_XP_p1 I1390_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I87_XP_MP1 (I1390_P21_20 I1390_pn20 XI1390_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I86_XP_MP0 (XI1436_I86_XP_p1 I1436_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I86_XP_MP1 (I1436_P20_19 I1436_pn19 XI1436_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I147_XP_MP0 (XI1436_I147_XP_p1 I1436_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I147_XP_MP1 (I1436_P22_15 I1436_P18_15n XI1436_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I151_XP_MP0 (XI1436_I151_XP_p1 I1436_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I151_XP_MP1 (I1436_P26_19 I1436_P22_19n XI1436_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I87_XP_MP0 (XI1436_I87_XP_p1 I1436_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I87_XP_MP1 (I1436_P21_20 I1436_pn20 XI1436_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I87_XP_MP0 (XI1482_I87_XP_p1 I1482_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I87_XP_MP1 (I1482_P21_20 I1482_pn20 XI1482_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I146_XP_MP0 (XI1482_I146_XP_p1 I1482_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I146_XP_MP1 (I1482_P21_14 I1482_P17_14n XI1482_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I86_XP_MP0 (XI1482_I86_XP_p1 I1482_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I86_XP_MP1 (I1482_P20_19 I1482_pn19 XI1482_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I147_XP_MP0 (XI1482_I147_XP_p1 I1482_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I147_XP_MP1 (I1482_P22_15 I1482_P18_15n XI1482_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I151_XP_MP0 (XI1482_I151_XP_p1 I1482_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I151_XP_MP1 (I1482_P26_19 I1482_P22_19n XI1482_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I92_XP_MP0 (XI1528_I92_XP_p1 I1528_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I92_XP_MP1 (I1528_P26_25 I1528_pn25 XI1528_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I93_XP_MP0 (XI1528_I93_XP_p1 I1528_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I93_XP_MP1 (I1528_P27_26 I1528_pn26 XI1528_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I156_XP_MP0 (XI1528_I156_XP_p1 I1528_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I156_XP_MP1 (I1528_P31_24 I1528_P27_24n XI1528_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I83_XP_MP0 (XI1206_I83_XP_p1 I1206_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I83_XP_MP1 (I1206_P17_16 I1206_pn16 XI1206_I83_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I142_XP_MP0 (XI1206_I142_XP_p1 I1206_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I142_XP_MP1 (I1206_P17_10 I1206_P13_10n XI1206_I142_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I84_XP_MP0 (XI1206_I84_XP_p1 I1206_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I84_XP_MP1 (I1206_P18_17 I1206_pn17 XI1206_I84_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I143_XP_MP0 (XI1206_I143_XP_p1 I1206_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I143_XP_MP1 (I1206_P18_11 I1206_P14_11n XI1206_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I139_XP_MP0 (XI1206_I139_XP_p1 I1206_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I139_XP_MP1 (I1206_P14_7 I1206_P10_7n XI1206_I139_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I88_XP_MP0 (XI1252_I88_XP_p1 I1252_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I88_XP_MP1 (I1252_P22_21 I1252_pn21 XI1252_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I87_XP_MP0 (XI1252_I87_XP_p1 I1252_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I87_XP_MP1 (I1252_P21_20 I1252_pn20 XI1252_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I88_XP_MP0 (XI1298_I88_XP_p1 I1298_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I88_XP_MP1 (I1298_P22_21 I1298_pn21 XI1298_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I153_XP_MP0 (XI1298_I153_XP_p1 I1298_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I153_XP_MP1 (I1298_P28_21 I1298_P24_21n XI1298_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I87_XP_MP0 (XI1298_I87_XP_p1 I1298_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I87_XP_MP1 (I1298_P21_20 I1298_pn20 XI1298_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I148_XP_MP0 (XI1298_I148_XP_p1 I1298_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I148_XP_MP1 (I1298_P23_16 I1298_P19_16n XI1298_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I153_XP_MP0 (XI1344_I153_XP_p1 I1344_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I153_XP_MP1 (I1344_P28_21 I1344_P24_21n XI1344_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I88_XP_MP0 (XI1344_I88_XP_p1 I1344_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I88_XP_MP1 (I1344_P22_21 I1344_pn21 XI1344_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I152_XP_MP0 (XI1344_I152_XP_p1 I1344_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I152_XP_MP1 (I1344_P27_20 I1344_P23_20n XI1344_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I148_XP_MP0 (XI1344_I148_XP_p1 I1344_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I148_XP_MP1 (I1344_P23_16 I1344_P19_16n XI1344_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I88_XP_MP0 (XI1390_I88_XP_p1 I1390_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I88_XP_MP1 (I1390_P22_21 I1390_pn21 XI1390_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I153_XP_MP0 (XI1390_I153_XP_p1 I1390_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I153_XP_MP1 (I1390_P28_21 I1390_P24_21n XI1390_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I152_XP_MP0 (XI1390_I152_XP_p1 I1390_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I152_XP_MP1 (I1390_P27_20 I1390_P23_20n XI1390_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I148_XP_MP0 (XI1390_I148_XP_p1 I1390_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I148_XP_MP1 (I1390_P23_16 I1390_P19_16n XI1390_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I88_XP_MP0 (XI1436_I88_XP_p1 I1436_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I88_XP_MP1 (I1436_P22_21 I1436_pn21 XI1436_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I153_XP_MP0 (XI1436_I153_XP_p1 I1436_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I153_XP_MP1 (I1436_P28_21 I1436_P24_21n XI1436_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I150_XP_MP0 (XI1436_I150_XP_p1 I1436_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I150_XP_MP1 (I1436_P25_18 I1436_P21_18n XI1436_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I148_XP_MP0 (XI1436_I148_XP_p1 I1436_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I148_XP_MP1 (I1436_P23_16 I1436_P19_16n XI1436_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I150_XP_MP0 (XI1482_I150_XP_p1 I1482_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I150_XP_MP1 (I1482_P25_18 I1482_P21_18n XI1482_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I88_XP_MP0 (XI1482_I88_XP_p1 I1482_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I88_XP_MP1 (I1482_P22_21 I1482_pn21 XI1482_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I155_XP_MP0 (XI1482_I155_XP_p1 I1482_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I155_XP_MP1 (I1482_P30_23 I1482_P26_23n XI1482_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I96_XP_MP0 (XI1528_I96_XP_p1 I1528_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I96_XP_MP1 (I1528_P30_29 I1528_pn29 XI1528_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I97_XP_MP0 (XI1528_I97_XP_p1 I1528_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I97_XP_MP1 (I1528_P31_30 I1528_pn30 XI1528_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I94_XP_MP0 (XI1528_I94_XP_p1 I1528_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I94_XP_MP1 (I1528_P28_27 I1528_pn27 XI1528_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I95_XP_MP0 (XI1528_I95_XP_p1 I1528_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I95_XP_MP1 (I1528_P29_28 I1528_pn28 XI1528_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I87_XP_MP0 (XI1206_I87_XP_p1 I1206_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I87_XP_MP1 (I1206_P21_20 I1206_pn20 XI1206_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I85_XP_MP0 (XI1206_I85_XP_p1 I1206_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I85_XP_MP1 (I1206_P19_18 I1206_pn18 XI1206_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I144_XP_MP0 (XI1206_I144_XP_p1 I1206_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I144_XP_MP1 (I1206_P19_12 I1206_P15_12n XI1206_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I146_XP_MP0 (XI1206_I146_XP_p1 I1206_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I146_XP_MP1 (I1206_P21_14 I1206_P17_14n XI1206_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I140_XP_MP0 (XI1206_I140_XP_p1 I1206_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I140_XP_MP1 (I1206_P15_8 I1206_P11_8n XI1206_I140_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I86_XP_MP0 (XI1206_I86_XP_p1 I1206_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I86_XP_MP1 (I1206_P20_19 I1206_pn19 XI1206_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I149_XP_MP0 (XI1206_I149_XP_p1 I1206_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I149_XP_MP1 (I1206_P24_17 I1206_P20_17n XI1206_I149_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I145_XP_MP0 (XI1206_I145_XP_p1 I1206_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I145_XP_MP1 (I1206_P20_13 I1206_P16_13n XI1206_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I153_XP_MP0 (XI1252_I153_XP_p1 I1252_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I153_XP_MP1 (I1252_P28_21 I1252_P24_21n XI1252_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I89_XP_MP0 (XI1252_I89_XP_p1 I1252_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I89_XP_MP1 (I1252_P23_22 I1252_pn22 XI1252_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I152_XP_MP0 (XI1252_I152_XP_p1 I1252_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I152_XP_MP1 (I1252_P27_20 I1252_P23_20n XI1252_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I148_XP_MP0 (XI1252_I148_XP_p1 I1252_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I148_XP_MP1 (I1252_P23_16 I1252_P19_16n XI1252_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I90_XP_MP0 (XI1298_I90_XP_p1 I1298_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I90_XP_MP1 (I1298_P24_23 I1298_pn23 XI1298_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I155_XP_MP0 (XI1298_I155_XP_p1 I1298_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I155_XP_MP1 (I1298_P30_23 I1298_P26_23n XI1298_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I89_XP_MP0 (XI1298_I89_XP_p1 I1298_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I89_XP_MP1 (I1298_P23_22 I1298_pn22 XI1298_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I152_XP_MP0 (XI1298_I152_XP_p1 I1298_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I152_XP_MP1 (I1298_P27_20 I1298_P23_20n XI1298_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I155_XP_MP0 (XI1344_I155_XP_p1 I1344_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I155_XP_MP1 (I1344_P30_23 I1344_P26_23n XI1344_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I90_XP_MP0 (XI1344_I90_XP_p1 I1344_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I90_XP_MP1 (I1344_P24_23 I1344_pn23 XI1344_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I89_XP_MP0 (XI1344_I89_XP_p1 I1344_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I89_XP_MP1 (I1344_P23_22 I1344_pn22 XI1344_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I154_XP_MP0 (XI1344_I154_XP_p1 I1344_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I154_XP_MP1 (I1344_P29_22 I1344_P25_22n XI1344_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I155_XP_MP0 (XI1390_I155_XP_p1 I1390_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I155_XP_MP1 (I1390_P30_23 I1390_P26_23n XI1390_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I90_XP_MP0 (XI1390_I90_XP_p1 I1390_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I90_XP_MP1 (I1390_P24_23 I1390_pn23 XI1390_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I89_XP_MP0 (XI1390_I89_XP_p1 I1390_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I89_XP_MP1 (I1390_P23_22 I1390_pn22 XI1390_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I154_XP_MP0 (XI1390_I154_XP_p1 I1390_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I154_XP_MP1 (I1390_P29_22 I1390_P25_22n XI1390_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I90_XP_MP0 (XI1436_I90_XP_p1 I1436_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I90_XP_MP1 (I1436_P24_23 I1436_pn23 XI1436_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I89_XP_MP0 (XI1436_I89_XP_p1 I1436_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I89_XP_MP1 (I1436_P23_22 I1436_pn22 XI1436_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I89_XP_MP0 (XI1482_I89_XP_p1 I1482_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I89_XP_MP1 (I1482_P23_22 I1482_pn22 XI1482_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I90_XP_MP0 (XI1482_I90_XP_p1 I1482_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I90_XP_MP1 (I1482_P24_23 I1482_pn23 XI1482_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I153_XP_MP0 (XI1482_I153_XP_p1 I1482_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I153_XP_MP1 (I1482_P28_21 I1482_P24_21n XI1482_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I89_XP_MP0 (XI1206_I89_XP_p1 I1206_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I89_XP_MP1 (I1206_P23_22 I1206_pn22 XI1206_I89_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I148_XP_MP0 (XI1206_I148_XP_p1 I1206_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I148_XP_MP1 (I1206_P23_16 I1206_P19_16n XI1206_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I150_XP_MP0 (XI1206_I150_XP_p1 I1206_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I150_XP_MP1 (I1206_P25_18 I1206_P21_18n XI1206_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I88_XP_MP0 (XI1206_I88_XP_p1 I1206_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I88_XP_MP1 (I1206_P22_21 I1206_pn21 XI1206_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I147_XP_MP0 (XI1206_I147_XP_p1 I1206_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I147_XP_MP1 (I1206_P22_15 I1206_P18_15n XI1206_I147_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I90_XP_MP0 (XI1252_I90_XP_p1 I1252_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I90_XP_MP1 (I1252_P24_23 I1252_pn23 XI1252_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I155_XP_MP0 (XI1252_I155_XP_p1 I1252_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I155_XP_MP1 (I1252_P30_23 I1252_P26_23n XI1252_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I91_XP_MP0 (XI1252_I91_XP_p1 I1252_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I91_XP_MP1 (I1252_P25_24 I1252_pn24 XI1252_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I154_XP_MP0 (XI1252_I154_XP_p1 I1252_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I154_XP_MP1 (I1252_P29_22 I1252_P25_22n XI1252_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I92_XP_MP0 (XI1298_I92_XP_p1 I1298_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I92_XP_MP1 (I1298_P26_25 I1298_pn25 XI1298_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I91_XP_MP0 (XI1298_I91_XP_p1 I1298_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I91_XP_MP1 (I1298_P25_24 I1298_pn24 XI1298_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I154_XP_MP0 (XI1298_I154_XP_p1 I1298_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I154_XP_MP1 (I1298_P29_22 I1298_P25_22n XI1298_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I92_XP_MP0 (XI1344_I92_XP_p1 I1344_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I92_XP_MP1 (I1344_P26_25 I1344_pn25 XI1344_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I91_XP_MP0 (XI1344_I91_XP_p1 I1344_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I91_XP_MP1 (I1344_P25_24 I1344_pn24 XI1344_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I156_XP_MP0 (XI1344_I156_XP_p1 I1344_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I156_XP_MP1 (I1344_P31_24 I1344_P27_24n XI1344_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I92_XP_MP0 (XI1390_I92_XP_p1 I1390_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I92_XP_MP1 (I1390_P26_25 I1390_pn25 XI1390_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I91_XP_MP0 (XI1390_I91_XP_p1 I1390_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I91_XP_MP1 (I1390_P25_24 I1390_pn24 XI1390_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I156_XP_MP0 (XI1390_I156_XP_p1 I1390_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I156_XP_MP1 (I1390_P31_24 I1390_P27_24n XI1390_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I92_XP_MP0 (XI1436_I92_XP_p1 I1436_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I92_XP_MP1 (I1436_P26_25 I1436_pn25 XI1436_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I155_XP_MP0 (XI1436_I155_XP_p1 I1436_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I155_XP_MP1 (I1436_P30_23 I1436_P26_23n XI1436_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I91_XP_MP0 (XI1436_I91_XP_p1 I1436_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I91_XP_MP1 (I1436_P25_24 I1436_pn24 XI1436_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I154_XP_MP0 (XI1436_I154_XP_p1 I1436_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I154_XP_MP1 (I1436_P29_22 I1436_P25_22n XI1436_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I152_XP_MP0 (XI1436_I152_XP_p1 I1436_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I152_XP_MP1 (I1436_P27_20 I1436_P23_20n XI1436_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I148_XP_MP0 (XI1482_I148_XP_p1 I1482_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I148_XP_MP1 (I1482_P23_16 I1482_P19_16n XI1482_I148_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I152_XP_MP0 (XI1482_I152_XP_p1 I1482_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I152_XP_MP1 (I1482_P27_20 I1482_P23_20n XI1482_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I154_XP_MP0 (XI1482_I154_XP_p1 I1482_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I154_XP_MP1 (I1482_P29_22 I1482_P25_22n XI1482_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I91_XP_MP0 (XI1482_I91_XP_p1 I1482_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I91_XP_MP1 (I1482_P25_24 I1482_pn24 XI1482_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I92_XP_MP0 (XI1482_I92_XP_p1 I1482_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I92_XP_MP1 (I1482_P26_25 I1482_pn25 XI1482_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I94_XP_MP0 (XI1482_I94_XP_p1 I1482_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I94_XP_MP1 (I1482_P28_27 I1482_pn27 XI1482_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I93_XP_MP0 (XI1206_I93_XP_p1 I1206_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I93_XP_MP1 (I1206_P27_26 I1206_pn26 XI1206_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I156_XP_MP0 (XI1206_I156_XP_p1 I1206_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I156_XP_MP1 (I1206_P31_24 I1206_P27_24n XI1206_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I91_XP_MP0 (XI1206_I91_XP_p1 I1206_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I91_XP_MP1 (I1206_P25_24 I1206_pn24 XI1206_I91_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I152_XP_MP0 (XI1206_I152_XP_p1 I1206_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I152_XP_MP1 (I1206_P27_20 I1206_P23_20n XI1206_I152_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I90_XP_MP0 (XI1206_I90_XP_p1 I1206_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I90_XP_MP1 (I1206_P24_23 I1206_pn23 XI1206_I90_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I92_XP_MP0 (XI1206_I92_XP_p1 I1206_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I92_XP_MP1 (I1206_P26_25 I1206_pn25 XI1206_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I151_XP_MP0 (XI1206_I151_XP_p1 I1206_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I151_XP_MP1 (I1206_P26_19 I1206_P22_19n XI1206_I151_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I92_XP_MP0 (XI1252_I92_XP_p1 I1252_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I92_XP_MP1 (I1252_P26_25 I1252_pn25 XI1252_I92_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I93_XP_MP0 (XI1252_I93_XP_p1 I1252_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I93_XP_MP1 (I1252_P27_26 I1252_pn26 XI1252_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I156_XP_MP0 (XI1252_I156_XP_p1 I1252_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I156_XP_MP1 (I1252_P31_24 I1252_P27_24n XI1252_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I94_XP_MP0 (XI1298_I94_XP_p1 I1298_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I94_XP_MP1 (I1298_P28_27 I1298_pn27 XI1298_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I93_XP_MP0 (XI1298_I93_XP_p1 I1298_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I93_XP_MP1 (I1298_P27_26 I1298_pn26 XI1298_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I156_XP_MP0 (XI1298_I156_XP_p1 I1298_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I156_XP_MP1 (I1298_P31_24 I1298_P27_24n XI1298_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I93_XP_MP0 (XI1344_I93_XP_p1 I1344_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I93_XP_MP1 (I1344_P27_26 I1344_pn26 XI1344_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I94_XP_MP0 (XI1390_I94_XP_p1 I1390_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I94_XP_MP1 (I1390_P28_27 I1390_pn27 XI1390_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I93_XP_MP0 (XI1390_I93_XP_p1 I1390_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I93_XP_MP1 (I1390_P27_26 I1390_pn26 XI1390_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I94_XP_MP0 (XI1436_I94_XP_p1 I1436_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I94_XP_MP1 (I1436_P28_27 I1436_pn27 XI1436_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I93_XP_MP0 (XI1436_I93_XP_p1 I1436_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I93_XP_MP1 (I1436_P27_26 I1436_pn26 XI1436_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I156_XP_MP0 (XI1436_I156_XP_p1 I1436_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I156_XP_MP1 (I1436_P31_24 I1436_P27_24n XI1436_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I156_XP_MP0 (XI1482_I156_XP_p1 I1482_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I156_XP_MP1 (I1482_P31_24 I1482_P27_24n XI1482_I156_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I93_XP_MP0 (XI1482_I93_XP_p1 I1482_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I93_XP_MP1 (I1482_P27_26 I1482_pn26 XI1482_I93_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I95_XP_MP0 (XI1206_I95_XP_p1 I1206_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I95_XP_MP1 (I1206_P29_28 I1206_pn28 XI1206_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I154_XP_MP0 (XI1206_I154_XP_p1 I1206_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I154_XP_MP1 (I1206_P29_22 I1206_P25_22n XI1206_I154_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I155_XP_MP0 (XI1206_I155_XP_p1 I1206_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I155_XP_MP1 (I1206_P30_23 I1206_P26_23n XI1206_I155_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I153_XP_MP0 (XI1206_I153_XP_p1 I1206_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I153_XP_MP1 (I1206_P28_21 I1206_P24_21n XI1206_I153_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I94_XP_MP0 (XI1252_I94_XP_p1 I1252_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I94_XP_MP1 (I1252_P28_27 I1252_pn27 XI1252_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I96_XP_MP0 (XI1252_I96_XP_p1 I1252_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I96_XP_MP1 (I1252_P30_29 I1252_pn29 XI1252_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I95_XP_MP0 (XI1252_I95_XP_p1 I1252_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I95_XP_MP1 (I1252_P29_28 I1252_pn28 XI1252_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I97_XP_MP0 (XI1252_I97_XP_p1 I1252_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I97_XP_MP1 (I1252_P31_30 I1252_pn30 XI1252_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I95_XP_MP0 (XI1298_I95_XP_p1 I1298_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I95_XP_MP1 (I1298_P29_28 I1298_pn28 XI1298_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I94_XP_MP0 (XI1344_I94_XP_p1 I1344_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I94_XP_MP1 (I1344_P28_27 I1344_pn27 XI1344_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I95_XP_MP0 (XI1344_I95_XP_p1 I1344_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I95_XP_MP1 (I1344_P29_28 I1344_pn28 XI1344_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I96_XP_MP0 (XI1344_I96_XP_p1 I1344_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I96_XP_MP1 (I1344_P30_29 I1344_pn29 XI1344_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I97_XP_MP0 (XI1344_I97_XP_p1 I1344_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I97_XP_MP1 (I1344_P31_30 I1344_pn30 XI1344_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I96_XP_MP0 (XI1390_I96_XP_p1 I1390_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I96_XP_MP1 (I1390_P30_29 I1390_pn29 XI1390_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I95_XP_MP0 (XI1390_I95_XP_p1 I1390_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I95_XP_MP1 (I1390_P29_28 I1390_pn28 XI1390_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I97_XP_MP0 (XI1390_I97_XP_p1 I1390_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I97_XP_MP1 (I1390_P31_30 I1390_pn30 XI1390_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I96_XP_MP0 (XI1436_I96_XP_p1 I1436_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I96_XP_MP1 (I1436_P30_29 I1436_pn29 XI1436_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I95_XP_MP0 (XI1436_I95_XP_p1 I1436_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I95_XP_MP1 (I1436_P29_28 I1436_pn28 XI1436_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I97_XP_MP0 (XI1436_I97_XP_p1 I1436_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I97_XP_MP1 (I1436_P31_30 I1436_pn30 XI1436_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I97_XP_MP0 (XI1482_I97_XP_p1 I1482_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I97_XP_MP1 (I1482_P31_30 I1482_pn30 XI1482_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I95_XP_MP0 (XI1482_I95_XP_p1 I1482_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I95_XP_MP1 (I1482_P29_28 I1482_pn28 XI1482_I95_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I96_XP_MP0 (XI1482_I96_XP_p1 I1482_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I96_XP_MP1 (I1482_P30_29 I1482_pn29 XI1482_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I97_XP_MP0 (XI1206_I97_XP_p1 I1206_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I97_XP_MP1 (I1206_P31_30 I1206_pn30 XI1206_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I96_XP_MP0 (XI1206_I96_XP_p1 I1206_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I96_XP_MP1 (I1206_P30_29 I1206_pn29 XI1206_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I94_XP_MP0 (XI1206_I94_XP_p1 I1206_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I94_XP_MP1 (I1206_P28_27 I1206_pn27 XI1206_I94_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I96_XP_MP0 (XI1298_I96_XP_p1 I1298_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I96_XP_MP1 (I1298_P30_29 I1298_pn29 XI1298_I96_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I97_XP_MP0 (XI1298_I97_XP_p1 I1298_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I97_XP_MP1 (I1298_P31_30 I1298_pn30 XI1298_I97_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2065_MP0 (dm31 dmn31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI658_MP0 (qu29_b0 qu29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI0_MP0 (A_31_b0 A_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2232_MP0 (nrk21 nrkn21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2235_MP0 (nrk22 nrkn22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2238_MP0 (nrk23 nrkn23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2241_MP0 (nrk24 nrkn24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2250_MP0 (nrk27 nrkn27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2247_MP0 (nrk26 nrkn26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2253_MP0 (nrk28 nrkn28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2256_MP0 (nrk29 nrkn29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2259_MP0 (nrk30 nrkn30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2061_MP0 (dm29 dmn29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2059_MP0 (dm28 dmn28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2063_MP0 (dm30 dmn30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI612_MP0 (qu30_b0 qu30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2229_MP0 (nrk20 nrkn20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2244_MP0 (nrk25 nrkn25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2057_MP0 (dm27 dmn27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1946_MP0 (qu1_b0 qu1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2226_MP0 (nrk19 nrkn19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2220_MP0 (nrk17 nrkn17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2055_MP0 (dm26 dmn26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2053_MP0 (dm25 dmn25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1991_MP0 (p31_32_b0 p31_32 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I191_MP0 (I1896_G6_0n I1896_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I193_MP0 (I654_G7_0n I654_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I193_MP0 (I608_G7_0n I608_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI566_MP0 (qu31_b0 qu31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2223_MP0 (nrk18 nrkn18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2214_MP0 (nrk15 nrkn15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2217_MP0 (nrk16 nrkn16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2051_MP0 (dm24 dmn24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2049_MP0 (dm23 dmn23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI704_MP0 (qu28_b0 qu28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2211_MP0 (nrk14 nrkn14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I193_MP0 (I2066_G7_0n I2066_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I191_MP0 (I2066_G6_0n I2066_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2045_MP0 (dm21 dmn21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2047_MP0 (dm22 dmn22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I191_MP0 (I1942_G6_0n I1942_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I193_MP0 (I1942_G7_0n I1942_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I159_MP0 (I1896_G2_0np I1896_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I187_MP0 (I1896_G4_0n I1896_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I189_MP0 (I654_G5_0n I654_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I191_MP0 (I654_G6_0n I654_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I189_MP0 (I608_G5_0n I608_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I191_MP0 (I608_G6_0n I608_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2205_MP0 (nrk12 nrkn12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2208_MP0 (nrk13 nrkn13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2041_MP0 (dm19 dmn19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2043_MP0 (dm20 dmn20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I193_MP0 (I1988_G7_0n I1988_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I189_MP0 (I1942_G5_0n I1942_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I189_MP0 (I1896_G5_0n I1896_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I161_MP0 (I654_G3_0np I654_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I187_MP0 (I654_G4_0n I654_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I191_MP0 (I562_G6_0n I562_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I189_MP0 (I562_G5_0n I562_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I193_MP0 (I562_G7_0n I562_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2202_MP0 (nrk11 nrkn11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I189_MP0 (I2066_G5_0n I2066_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2039_MP0 (dm18 dmn18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I191_MP0 (I1988_G6_0n I1988_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I187_MP0 (I608_G4_0n I608_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2199_MP0 (nrk10 nrkn10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I161_MP0 (I2066_G3_0np I2066_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I187_MP0 (I2066_G4_0n I2066_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2037_MP0 (dm17 dmn17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2035_MP0 (dm16 dmn16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I187_MP0 (I1942_G4_0n I1942_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I129_MP0 (I1896_G1_0n I1896_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I161_MP0 (I1896_G3_0np I1896_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I193_MP0 (I1896_G7_0n I1896_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1900_MP0 (qu2_b0 qu2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I161_MP0 (I608_G3_0np I608_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I161_MP0 (I562_G3_0np I562_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2196_MP0 (nrk9 nrkn9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I159_MP0 (I2066_G2_0np I2066_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2031_MP0 (dm14 dmn14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2033_MP0 (dm15 dmn15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I187_MP0 (I1988_G4_0n I1988_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I189_MP0 (I1988_G5_0n I1988_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I161_MP0 (I1942_G3_0np I1942_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1854_MP0 (qu3_b0 qu3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I193_MP0 (I700_G7_0n I700_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I129_MP0 (I654_G1_0n I654_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I159_MP0 (I654_G2_0np I654_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I159_MP0 (I608_G2_0np I608_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2193_MP0 (nrk8 nrkn8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2029_MP0 (dm13 dmn13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2027_MP0 (dm12 dmn12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I161_MP0 (I1988_G3_0np I1988_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I159_MP0 (I1942_G2_0np I1942_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I193_MP0 (I1850_G7_0n I1850_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I129_MP0 (I608_G1_0n I608_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I187_MP0 (I562_G4_0n I562_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I159_MP0 (I562_G2_0np I562_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I129_MP0 (I562_G1_0n I562_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2187_MP0 (nrk6 nrkn6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2190_MP0 (nrk7 nrkn7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I129_MP0 (I2066_G1_0n I2066_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2025_MP0 (dm11 dmn11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2023_MP0 (dm10 dmn10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I159_MP0 (I1988_G2_0np I1988_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I129_MP0 (I1942_G1_0n I1942_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I66_MP0 (I1896_G0_0n I1896_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I161_MP0 (I1850_G3_0np I1850_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I189_MP0 (I700_G5_0n I700_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I161_MP0 (I700_G3_0np I700_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2184_MP0 (nrk5 nrkn5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2021_MP0 (dm9 dmn9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2019_MP0 (dm8 dmn8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I129_MP0 (I1850_G1_0n I1850_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I189_MP0 (I1850_G5_0n I1850_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I66_MP0 (I608_G0_0n I608_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I66_MP0 (I562_G0_0n I562_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2181_MP0 (nrk4 nrkn4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2178_MP0 (nrk3 nrkn3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2175_MP0 (nrk2 nrkn2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI16_MP0 (B_31_b0 B_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I66_MP0 (I2066_G0_0n I2066_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2017_MP0 (dm7 dmn7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2015_MP0 (dm6 dmn6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I66_MP0 (I1988_G0_0n I1988_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I129_MP0 (I1988_G1_0n I1988_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I129_MP0 (I700_G1_0n I700_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I66_MP0 (I654_G0_0n I654_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI179_MP0 (nbk4 nbkn4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI192_MP0 (nbk5 nbkn5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI205_MP0 (nbk6 nbkn6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI218_MP0 (nbk7 nbkn7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI231_MP0 (nbk8 nbkn8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2172_MP0 (nrk1 nrkn1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2013_MP0 (dm5 dmn5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I66_MP0 (I1942_G0_0n I1942_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I66_MP0 (I1850_G0_0n I1850_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I159_MP0 (I1850_G2_0np I1850_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I187_MP0 (I1850_G4_0n I1850_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I191_MP0 (I1850_G6_0n I1850_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I191_MP0 (I700_G6_0n I700_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI654_I64_MP0 (I654_cinn qu30_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2167_MP0 (nqk30 nqkn30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2164_MP0 (nqk29 nqkn29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2293_MP0 (sqn sq_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI608_I64_MP0 (I608_cinn qu31_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI125_MP0 (nak30 nakn30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI182_MP0 (dd5_b0 dd5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI166_MP0 (nbk3 nbkn3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI195_MP0 (dd6_b0 dd6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI244_MP0 (nbk9 nbkn9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI309_MP0 (nbk14 nbkn14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI322_MP0 (nbk15 nbkn15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI26_MP0 (B_0_b0 B_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2011_MP0 (dm4 dmn4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2007_MP0 (dm2 dmn2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2009_MP0 (dm3 dmn3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2001_MP0 (Q_0 p31_32_b3_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2080_MP0 (nqk1 nqkn1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2083_MP0 (nqk2 nqkn2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I159_MP0 (I700_G2_0np I700_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI122_MP0 (nak29 nakn29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI562_I64_MP0 (I562_cinn VDD VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI140_MP0 (nbk1 nbkn1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI153_MP0 (nbk2 nbkn2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI156_MP0 (dd3_b0 dd3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI257_MP0 (nbk10 nbkn10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI270_MP0 (nbk11 nbkn11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI296_MP0 (nbk13 nbkn13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI299_MP0 (dd14_b0 dd14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI335_MP0 (nbk16 nbkn16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI348_MP0 (nbk17 nbkn17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI361_MP0 (nbk18 nbkn18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI374_MP0 (nbk19 nbkn19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI387_MP0 (nbk20 nbkn20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I64_MP0 (I2066_cinn VSS VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI400_MP0 (nbk21 nbkn21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2003_MP0 (dm0 dmn0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2005_MP0 (dm1 dmn1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1942_I64_MP0 (I1942_cinn qu2_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2086_MP0 (nqk3 nqkn3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I66_MP0 (I700_G0_0n I700_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I64_MP0 (I700_cinn qu29_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI119_MP0 (nak28 nakn28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI116_MP0 (nak27 nakn27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI113_MP0 (nak26 nakn26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI110_MP0 (nak25 nakn25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI107_MP0 (nak24 nakn24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI130_MP0 (dd1_b0 dd1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI169_MP0 (dd4_b0 dd4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI143_MP0 (dd2_b0 dd2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI208_MP0 (dd7_b0 dd7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI247_MP0 (dd10_b0 dd10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI260_MP0 (dd11_b0 dd11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI234_MP0 (dd9_b0 dd9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI283_MP0 (nbk12 nbkn12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI325_MP0 (dd16_b0 dd16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI413_MP0 (nbk22 nbkn22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI377_MP0 (dd20_b0 dd20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI390_MP0 (dd21_b0 dd21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1988_I64_MP0 (I1988_cinn qu1_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI38_MP0 (nak1 nakn1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1896_I64_MP0 (I1896_cinn qu3_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1850_I64_MP0 (I1850_cinn qu4_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2089_MP0 (nqk4 nqkn4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI700_I187_MP0 (I700_G4_0n I700_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2161_MP0 (nqk28 nqkn28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I64_MP0 (I746_cinn qu28_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I64_MP0 (I792_cinn qu27_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I64_MP0 (I838_cinn qu26_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI221_MP0 (dd8_b0 dd8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI273_MP0 (dd12_b0 dd12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI312_MP0 (dd15_b0 dd15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI286_MP0 (dd13_b0 dd13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2068_MP0 (sq_b0 sq VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI517_MP0 (nbk30 nbkn30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI338_MP0 (dd17_b0 dd17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI504_MP0 (nbk29 nbkn29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI351_MP0 (dd18_b0 dd18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI364_MP0 (dd19_b0 dd19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI426_MP0 (nbk23 nbkn23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI41_MP0 (nak2 nakn2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI44_MP0 (nak3 nakn3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI47_MP0 (nak4 nakn4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI50_MP0 (nak5 nakn5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I64_MP0 (I1804_cinn qu5_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2158_MP0 (nqk27 nqkn27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I66_MP0 (I792_G0_0n I792_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI494_MP0 (dd29_b0 dd29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI491_MP0 (nbk28 nbkn28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI439_MP0 (nbk24 nbkn24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI416_MP0 (dd23_b0 dd23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI403_MP0 (dd22_b0 dd22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2092_MP0 (nqk5 nqkn5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI750_MP0 (qu27_b0 qu27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI520_MP0 (dd31_b0 dd31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI507_MP0 (dd30_b0 dd30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI481_MP0 (dd28_b0 dd28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI478_MP0 (nbk27 nbkn27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI465_MP0 (nbk26 nbkn26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI452_MP0 (nbk25 nbkn25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I66_MP0 (I1712_G0_0n I1712_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I64_MP0 (I1712_cinn qu7_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I64_MP0 (I1758_cinn qu6_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I66_MP0 (I1804_G0_0n I1804_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I66_MP0 (I746_G0_0n I746_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I66_MP0 (I838_G0_0n I838_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I64_MP0 (I884_cinn qu25_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I66_MP0 (I884_G0_0n I884_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI468_MP0 (dd27_b0 dd27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI455_MP0 (dd26_b0 dd26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI442_MP0 (dd25_b0 dd25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I66_MP0 (I1758_G0_0n I1758_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI53_MP0 (nak6 nakn6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2095_MP0 (nqk6 nqkn6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I159_MP0 (I1804_G2_0np I1804_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I193_MP0 (I746_G7_0n I746_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I161_MP0 (I746_G3_0np I746_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I129_MP0 (I746_G1_0n I746_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I129_MP0 (I792_G1_0n I792_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I129_MP0 (I838_G1_0n I838_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I129_MP0 (I884_G1_0n I884_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI429_MP0 (dd24_b0 dd24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I129_MP0 (I1804_G1_0n I1804_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I187_MP0 (I1804_G4_0n I1804_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I159_MP0 (I838_G2_0np I838_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I187_MP0 (I1712_G4_0n I1712_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I129_MP0 (I1758_G1_0n I1758_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I189_MP0 (I746_G5_0n I746_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I159_MP0 (I792_G2_0np I792_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I187_MP0 (I838_G4_0n I838_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I159_MP0 (I884_G2_0np I884_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I159_MP0 (I1712_G2_0np I1712_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I129_MP0 (I1712_G1_0n I1712_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I159_MP0 (I1758_G2_0np I1758_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I161_MP0 (I1804_G3_0np I1804_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I191_MP0 (I1804_G6_0n I1804_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I187_MP0 (I746_G4_0n I746_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I159_MP0 (I746_G2_0np I746_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I161_MP0 (I792_G3_0np I792_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I187_MP0 (I792_G4_0n I792_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I161_MP0 (I838_G3_0np I838_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I189_MP0 (I838_G5_0n I838_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I191_MP0 (I1712_G6_0n I1712_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I161_MP0 (I1712_G3_0np I1712_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I187_MP0 (I1758_G4_0n I1758_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I161_MP0 (I1758_G3_0np I1758_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I191_MP0 (I884_G6_0n I884_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I187_MP0 (I884_G4_0n I884_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I189_MP0 (I884_G5_0n I884_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I189_MP0 (I1758_G5_0n I1758_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I189_MP0 (I1804_G5_0n I1804_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI746_I191_MP0 (I746_G6_0n I746_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I189_MP0 (I792_G5_0n I792_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I191_MP0 (I792_G6_0n I792_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I191_MP0 (I838_G6_0n I838_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I189_MP0 (I1712_G5_0n I1712_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1804_I193_MP0 (I1804_G7_0n I1804_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI838_I193_MP0 (I838_G7_0n I838_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I161_MP0 (I884_G3_0np I884_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I191_MP0 (I1758_G6_0n I1758_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1758_I193_MP0 (I1758_G7_0n I1758_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI842_MP0 (qu25_b0 qu25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1712_I193_MP0 (I1712_G7_0n I1712_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1808_MP0 (qu4_b0 qu4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI792_I193_MP0 (I792_G7_0n I792_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I189_MP0 (I1068_G5_0n I1068_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2155_MP0 (nqk26 nqkn26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI796_MP0 (qu26_b0 qu26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1762_MP0 (qu5_b0 qu5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I129_MP0 (I1068_G1_0n I1068_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2152_MP0 (nqk25 nqkn25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2149_MP0 (nqk24 nqkn24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI98_MP0 (nak21 nakn21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI101_MP0 (nak22 nakn22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI884_I193_MP0 (I884_G7_0n I884_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1716_MP0 (qu6_b0 qu6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2098_MP0 (nqk7 nqkn7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I193_MP0 (I1068_G7_0n I1068_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I161_MP0 (I1068_G3_0np I1068_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I64_MP0 (I976_cinn qu23_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI104_MP0 (nak23 nakn23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I64_MP0 (I1666_cinn qu8_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI56_MP0 (nak7 nakn7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI59_MP0 (nak8 nakn8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2101_MP0 (nqk8 nqkn8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2146_MP0 (nqk23 nqkn23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I64_MP0 (I1022_cinn qu22_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I64_MP0 (I930_cinn qu24_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I66_MP0 (I1666_G0_0n I1666_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1670_MP0 (qu7_b0 qu7 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I64_MP0 (I1620_cinn qu9_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I66_MP0 (I1574_G0_0n I1574_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I159_MP0 (I1068_G2_0np I1068_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I66_MP0 (I1068_G0_0n I1068_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I66_MP0 (I1022_G0_0n I1022_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI888_MP0 (qu24_b0 qu24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I66_MP0 (I930_G0_0n I930_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I66_MP0 (I1620_G0_0n I1620_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I64_MP0 (I1574_cinn qu10_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2104_MP0 (nqk9 nqkn9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I191_MP0 (I1068_G6_0n I1068_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI62_MP0 (nak9 nakn9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2107_MP0 (nqk10 nqkn10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I187_MP0 (I1574_G4_0n I1574_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I187_MP0 (I1068_G4_0n I1068_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I129_MP0 (I1022_G1_0n I1022_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I66_MP0 (I976_G0_0n I976_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I129_MP0 (I930_G1_0n I930_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I159_MP0 (I1666_G2_0np I1666_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I129_MP0 (I1666_G1_0n I1666_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I129_MP0 (I1574_G1_0n I1574_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I159_MP0 (I1574_G2_0np I1574_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I159_MP0 (I1022_G2_0np I1022_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I129_MP0 (I976_G1_0n I976_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI934_MP0 (qu23_b0 qu23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I187_MP0 (I1666_G4_0n I1666_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I161_MP0 (I1666_G3_0np I1666_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I129_MP0 (I1620_G1_0n I1620_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I159_MP0 (I1620_G2_0np I1620_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I161_MP0 (I1022_G3_0np I1022_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I187_MP0 (I1022_G4_0n I1022_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I187_MP0 (I930_G4_0n I930_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I161_MP0 (I930_G3_0np I930_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I161_MP0 (I1574_G3_0np I1574_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I159_MP0 (I976_G2_0np I976_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I159_MP0 (I930_G2_0np I930_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I189_MP0 (I1666_G5_0n I1666_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I161_MP0 (I1620_G3_0np I1620_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I187_MP0 (I1620_G4_0n I1620_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I189_MP0 (I1574_G5_0n I1574_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I191_MP0 (I1574_G6_0n I1574_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I189_MP0 (I1022_G5_0n I1022_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I193_MP0 (I930_G7_0n I930_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I189_MP0 (I930_G5_0n I930_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I191_MP0 (I1666_G6_0n I1666_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I189_MP0 (I1620_G5_0n I1620_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1072_MP0 (qu20_b0 qu20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I191_MP0 (I1022_G6_0n I1022_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I161_MP0 (I976_G3_0np I976_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I191_MP0 (I930_G6_0n I930_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I193_MP0 (I1666_G7_0n I1666_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I191_MP0 (I1620_G6_0n I1620_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I193_MP0 (I1574_G7_0n I1574_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1026_MP0 (qu21_b0 qu21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I193_MP0 (I1022_G7_0n I1022_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I187_MP0 (I976_G4_0n I976_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I189_MP0 (I976_G5_0n I976_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I193_MP0 (I1620_G7_0n I1620_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2143_MP0 (nqk22 nqkn22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I191_MP0 (I976_G6_0n I976_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I193_MP0 (I976_G7_0n I976_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1624_MP0 (qu8_b0 qu8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1578_MP0 (qu9_b0 qu9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I64_MP0 (I1068_cinn qu21_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2140_MP0 (nqk21 nqkn21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I191_MP0 (I1114_G6_0n I1114_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I187_MP0 (I1114_G4_0n I1114_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I159_MP0 (I1114_G2_0np I1114_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI65_MP0 (nak10 nakn10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I64_MP0 (I1528_cinn qu11_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1532_MP0 (qu10_b0 qu10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I66_MP0 (I1114_G0_0n I1114_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2137_MP0 (nqk20 nqkn20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI95_MP0 (nak20 nakn20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI92_MP0 (nak19 nakn19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI980_MP0 (qu22_b0 qu22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI77_MP0 (nak14 nakn14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI74_MP0 (nak13 nakn13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I64_MP0 (I1390_cinn qu14_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI71_MP0 (nak12 nakn12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I64_MP0 (I1436_cinn qu13_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI68_MP0 (nak11 nakn11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I64_MP0 (I1482_cinn qu12_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2110_MP0 (nqk11 nqkn11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I66_MP0 (I1528_G0_0n I1528_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I129_MP0 (I1114_G1_0n I1114_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I64_MP0 (I1114_cinn qu20_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI89_MP0 (nak18 nakn18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI86_MP0 (nak17 nakn17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI83_MP0 (nak16 nakn16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI80_MP0 (nak15 nakn15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I64_MP0 (I1344_cinn qu15_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2122_MP0 (nqk15 nqkn15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2119_MP0 (nqk14 nqkn14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2116_MP0 (nqk13 nqkn13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2113_MP0 (nqk12 nqkn12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I66_MP0 (I1482_G0_0n I1482_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I129_MP0 (I1528_G1_0n I1528_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I189_MP0 (I1114_G5_0n I1114_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I161_MP0 (I1114_G3_0np I1114_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I64_MP0 (I1160_cinn qu19_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2134_MP0 (nqk19 nqkn19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2131_MP0 (nqk18 nqkn18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I64_MP0 (I1206_cinn qu18_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2128_MP0 (nqk17 nqkn17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I64_MP0 (I1252_cinn qu17_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I66_MP0 (I1390_G0_0n I1390_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I66_MP0 (I1436_G0_0n I1436_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1118_MP0 (qu19_b0 qu19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I193_MP0 (I1114_G7_0n I1114_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2125_MP0 (nqk16 nqkn16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I66_MP0 (I1298_G0_0n I1298_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I64_MP0 (I1298_cinn qu16_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I66_MP0 (I1344_G0_0n I1344_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I187_MP0 (I1528_G4_0n I1528_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I66_MP0 (I1252_G0_0n I1252_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I129_MP0 (I1344_G1_0n I1344_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I159_MP0 (I1528_G2_0np I1528_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I161_MP0 (I1528_G3_0np I1528_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I66_MP0 (I1206_G0_0n I1206_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I129_MP0 (I1252_G1_0n I1252_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I129_MP0 (I1298_G1_0n I1298_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I129_MP0 (I1390_G1_0n I1390_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I129_MP0 (I1436_G1_0n I1436_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I129_MP0 (I1482_G1_0n I1482_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I189_MP0 (I1528_G5_0n I1528_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I159_MP0 (I1344_G2_0np I1344_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I159_MP0 (I1390_G2_0np I1390_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I159_MP0 (I1436_G2_0np I1436_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I193_MP0 (I1160_G7_0n I1160_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I161_MP0 (I1160_G3_0np I1160_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I129_MP0 (I1160_G1_0n I1160_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I159_MP0 (I1252_G2_0np I1252_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I159_MP0 (I1298_G2_0np I1298_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I187_MP0 (I1344_G4_0n I1344_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I161_MP0 (I1344_G3_0np I1344_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I191_MP0 (I1528_G6_0n I1528_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1164_MP0 (qu18_b0 qu18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I189_MP0 (I1160_G5_0n I1160_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I161_MP0 (I1252_G3_0np I1252_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I161_MP0 (I1298_G3_0np I1298_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I161_MP0 (I1390_G3_0np I1390_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I161_MP0 (I1436_G3_0np I1436_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I161_MP0 (I1482_G3_0np I1482_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I187_MP0 (I1482_G4_0n I1482_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I159_MP0 (I1482_G2_0np I1482_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I66_MP0 (I1160_G0_0n I1160_G0_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I187_MP0 (I1252_G4_0n I1252_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I187_MP0 (I1298_G4_0n I1298_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I187_MP0 (I1390_G4_0n I1390_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I187_MP0 (I1436_G4_0n I1436_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I193_MP0 (I1528_G7_0n I1528_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I187_MP0 (I1160_G4_0n I1160_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I189_MP0 (I1298_G5_0n I1298_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I189_MP0 (I1344_G5_0n I1344_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I189_MP0 (I1390_G5_0n I1390_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I159_MP0 (I1160_G2_0np I1160_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I129_MP0 (I1206_G1_0n I1206_G1_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I189_MP0 (I1252_G5_0n I1252_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I191_MP0 (I1298_G6_0n I1298_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I191_MP0 (I1344_G6_0n I1344_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I191_MP0 (I1390_G6_0n I1390_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I191_MP0 (I1436_G6_0n I1436_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I189_MP0 (I1436_G5_0n I1436_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I189_MP0 (I1482_G5_0n I1482_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I191_MP0 (I1482_G6_0n I1482_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I191_MP0 (I1160_G6_0n I1160_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I159_MP0 (I1206_G2_0np I1206_G2_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I191_MP0 (I1252_G6_0n I1252_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I161_MP0 (I1206_G3_0np I1206_G3_0n VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I187_MP0 (I1206_G4_0n I1206_G4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I193_MP0 (I1252_G7_0n I1252_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I193_MP0 (I1298_G7_0n I1298_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I193_MP0 (I1344_G7_0n I1344_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I193_MP0 (I1390_G7_0n I1390_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I193_MP0 (I1436_G7_0n I1436_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I189_MP0 (I1206_G5_0n I1206_G5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I193_MP0 (I1482_G7_0n I1482_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I193_MP0 (I1206_G7_0n I1206_G7_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I191_MP0 (I1206_G6_0n I1206_G6_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1210_MP0 (qu17_b0 qu17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1348_MP0 (qu14_b0 qu14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1394_MP0 (qu13_b0 qu13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1486_MP0 (qu11_b0 qu11 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1256_MP0 (qu16_b0 qu16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1302_MP0 (qu15_b0 qu15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1440_MP0 (qu12_b0 qu12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI653_MP1 (VDD qu30_b3_5 XI653_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI653_MP5 (b2_31 XI653_Bn XI653_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI653_MP4 (XI653_p1 XI653_An b2_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI653_MP2 (VDD dd31_b3_0 XI653_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI653_MP3 (XI653_p1 qu30_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI653_MP0 (VDD dd31_b3_0 XI653_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI610_MP1 (VDD c1_o XI610_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI610_MP5 (p1_32 XI610_Bn XI610_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI610_MP4 (XI610_p1 XI610_An p1_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI610_MP2 (VDD h1 XI610_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI610_MP3 (XI610_p1 c1_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI610_MP0 (VDD h1 XI610_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI607_MP1 (VDD qu31_b3_5 XI607_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI607_MP5 (b1_31 XI607_Bn XI607_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI607_MP4 (XI607_p1 XI607_An b1_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI607_MP2 (VDD dd31_b3_0 XI607_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI607_MP3 (XI607_p1 qu31_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI607_MP0 (VDD dd31_b3_0 XI607_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI606_MP1 (VDD qu31_b3_5 XI606_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI606_MP5 (b1_30 XI606_Bn XI606_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI606_MP4 (XI606_p1 XI606_An b1_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI606_MP2 (VDD dd30_b3_0 XI606_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI606_MP3 (XI606_p1 qu31_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI606_MP0 (VDD dd30_b3_0 XI606_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI609_MP1 (VDD qu31_b3_5 XI609_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI609_MP5 (h1 XI609_Bn XI609_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI609_MP4 (XI609_p1 XI609_An h1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI609_MP2 (VDD p0_31 XI609_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI609_MP3 (XI609_p1 qu31_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI609_MP0 (VDD p0_31 XI609_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI560_MP1 (VDD VDD XI560_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI560_MP5 (b0_30 XI560_Bn XI560_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI560_MP4 (XI560_p1 XI560_An b0_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI560_MP2 (VDD dd30_b3_0 XI560_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI560_MP3 (XI560_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI560_MP0 (VDD dd30_b3_0 XI560_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI561_MP1 (VDD VDD XI561_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI561_MP5 (b0_31 XI561_Bn XI561_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI561_MP4 (XI561_p1 XI561_An b0_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI561_MP2 (VDD dd31_b3_0 XI561_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI561_MP3 (XI561_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI561_MP0 (VDD dd31_b3_0 XI561_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI558_MP1 (VDD VDD XI558_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI558_MP5 (b0_28 XI558_Bn XI558_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI558_MP4 (XI558_p1 XI558_An b0_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI558_MP2 (VDD dd28_b3_0 XI558_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI558_MP3 (XI558_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI558_MP0 (VDD dd28_b3_0 XI558_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1985_MP1 (VDD qu1_b3_4 XI1985_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1985_MP5 (b31_29 XI1985_Bn XI1985_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1985_MP4 (XI1985_p1 XI1985_An b31_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1985_MP2 (VDD dd29_b3_5 XI1985_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1985_MP3 (XI1985_p1 qu1_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1985_MP0 (VDD dd29_b3_5 XI1985_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1939_MP1 (VDD qu2_b3_4 XI1939_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1939_MP5 (b30_29 XI1939_Bn XI1939_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1939_MP4 (XI1939_p1 XI1939_An b30_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1939_MP2 (VDD dd29_b3_5 XI1939_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1939_MP3 (XI1939_p1 qu2_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1939_MP0 (VDD dd29_b3_5 XI1939_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI699_MP1 (VDD qu29_b3_5 XI699_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI699_MP5 (b3_31 XI699_Bn XI699_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI699_MP4 (XI699_p1 XI699_An b3_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI699_MP2 (VDD dd31_b3_0 XI699_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI699_MP3 (XI699_p1 qu29_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI699_MP0 (VDD dd31_b3_0 XI699_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI656_MP1 (VDD c2_o XI656_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI656_MP5 (p2_32 XI656_Bn XI656_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI656_MP4 (XI656_p1 XI656_An p2_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI656_MP2 (VDD h2 XI656_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI656_MP3 (XI656_p1 c2_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI656_MP0 (VDD h2 XI656_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI650_MP1 (VDD qu30_b3_4 XI650_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI650_MP5 (b2_28 XI650_Bn XI650_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI650_MP4 (XI650_p1 XI650_An b2_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI650_MP2 (VDD dd28_b3_0 XI650_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI650_MP3 (XI650_p1 qu30_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI650_MP0 (VDD dd28_b3_0 XI650_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI651_MP1 (VDD qu30_b3_4 XI651_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI651_MP5 (b2_29 XI651_Bn XI651_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI651_MP4 (XI651_p1 XI651_An b2_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI651_MP2 (VDD dd29_b3_0 XI651_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI651_MP3 (XI651_p1 qu30_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI651_MP0 (VDD dd29_b3_0 XI651_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI648_MP1 (VDD qu30_b3_4 XI648_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI648_MP5 (b2_26 XI648_Bn XI648_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI648_MP4 (XI648_p1 XI648_An b2_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI648_MP2 (VDD dd26_b3_0 XI648_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI648_MP3 (XI648_p1 qu30_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI648_MP0 (VDD dd26_b3_0 XI648_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI655_MP1 (VDD qu30_b3_5 XI655_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI655_MP5 (h2 XI655_Bn XI655_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI655_MP4 (XI655_p1 XI655_An h2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI655_MP2 (VDD p1_31 XI655_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI655_MP3 (XI655_p1 qu30_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI655_MP0 (VDD p1_31 XI655_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI652_MP1 (VDD qu30_b3_5 XI652_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI652_MP5 (b2_30 XI652_Bn XI652_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI652_MP4 (XI652_p1 XI652_An b2_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI652_MP2 (VDD dd30_b3_0 XI652_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI652_MP3 (XI652_p1 qu30_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI652_MP0 (VDD dd30_b3_0 XI652_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI602_MP1 (VDD qu31_b3_4 XI602_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI602_MP5 (b1_26 XI602_Bn XI602_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI602_MP4 (XI602_p1 XI602_An b1_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI602_MP2 (VDD dd26_b3_0 XI602_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI602_MP3 (XI602_p1 qu31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI602_MP0 (VDD dd26_b3_0 XI602_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI604_MP1 (VDD qu31_b3_4 XI604_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI604_MP5 (b1_28 XI604_Bn XI604_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI604_MP4 (XI604_p1 XI604_An b1_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI604_MP2 (VDD dd28_b3_0 XI604_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI604_MP3 (XI604_p1 qu31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI604_MP0 (VDD dd28_b3_0 XI604_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI605_MP1 (VDD qu31_b3_4 XI605_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI605_MP5 (b1_29 XI605_Bn XI605_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI605_MP4 (XI605_p1 XI605_An b1_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI605_MP2 (VDD dd29_b3_0 XI605_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI605_MP3 (XI605_p1 qu31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI605_MP0 (VDD dd29_b3_0 XI605_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI559_MP1 (VDD VDD XI559_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI559_MP5 (b0_29 XI559_Bn XI559_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI559_MP4 (XI559_p1 XI559_An b0_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI559_MP2 (VDD dd29_b3_0 XI559_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI559_MP3 (XI559_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI559_MP0 (VDD dd29_b3_0 XI559_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1986_MP1 (VDD qu1_b3_5 XI1986_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1986_MP5 (b31_30 XI1986_Bn XI1986_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1986_MP4 (XI1986_p1 XI1986_An b31_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1986_MP2 (VDD dd30_b3_5 XI1986_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1986_MP3 (XI1986_p1 qu1_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1986_MP0 (VDD dd30_b3_5 XI1986_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1987_MP1 (VDD qu1_b3_5 XI1987_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1987_MP5 (b31_31 XI1987_Bn XI1987_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1987_MP4 (XI1987_p1 XI1987_An b31_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1987_MP2 (VDD dd31_b3_5 XI1987_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1987_MP3 (XI1987_p1 qu1_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1987_MP0 (VDD dd31_b3_5 XI1987_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1984_MP1 (VDD qu1_b3_4 XI1984_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1984_MP5 (b31_28 XI1984_Bn XI1984_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1984_MP4 (XI1984_p1 XI1984_An b31_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1984_MP2 (VDD dd28_b3_5 XI1984_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1984_MP3 (XI1984_p1 qu1_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1984_MP0 (VDD dd28_b3_5 XI1984_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1983_MP1 (VDD qu1_b3_4 XI1983_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1983_MP5 (b31_27 XI1983_Bn XI1983_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1983_MP4 (XI1983_p1 XI1983_An b31_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1983_MP2 (VDD dd27_b3_5 XI1983_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1983_MP3 (XI1983_p1 qu1_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1983_MP0 (VDD dd27_b3_5 XI1983_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1989_MP1 (VDD qu1_b3_5 XI1989_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1989_MP5 (h31 XI1989_Bn XI1989_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1989_MP4 (XI1989_p1 XI1989_An h31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1989_MP2 (VDD p30_31 XI1989_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1989_MP3 (XI1989_p1 qu1_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1989_MP0 (VDD p30_31 XI1989_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1940_MP1 (VDD qu2_b3_5 XI1940_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1940_MP5 (b30_30 XI1940_Bn XI1940_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1940_MP4 (XI1940_p1 XI1940_An b30_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1940_MP2 (VDD dd30_b3_5 XI1940_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1940_MP3 (XI1940_p1 qu2_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1940_MP0 (VDD dd30_b3_5 XI1940_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1941_MP1 (VDD qu2_b3_5 XI1941_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1941_MP5 (b30_31 XI1941_Bn XI1941_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1941_MP4 (XI1941_p1 XI1941_An b30_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1941_MP2 (VDD dd31_b3_5 XI1941_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1941_MP3 (XI1941_p1 qu2_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1941_MP0 (VDD dd31_b3_5 XI1941_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1943_MP1 (VDD qu2_b3_5 XI1943_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1943_MP5 (h30 XI1943_Bn XI1943_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1943_MP4 (XI1943_p1 XI1943_An h30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1943_MP2 (VDD p29_31 XI1943_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1943_MP3 (XI1943_p1 qu2_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1943_MP0 (VDD p29_31 XI1943_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1938_MP1 (VDD qu2_b3_4 XI1938_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1938_MP5 (b30_28 XI1938_Bn XI1938_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1938_MP4 (XI1938_p1 XI1938_An b30_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1938_MP2 (VDD dd28_b3_5 XI1938_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1938_MP3 (XI1938_p1 qu2_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1938_MP0 (VDD dd28_b3_5 XI1938_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1937_MP1 (VDD qu2_b3_4 XI1937_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1937_MP5 (b30_27 XI1937_Bn XI1937_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1937_MP4 (XI1937_p1 XI1937_An b30_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1937_MP2 (VDD dd27_b3_5 XI1937_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1937_MP3 (XI1937_p1 qu2_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1937_MP0 (VDD dd27_b3_5 XI1937_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1890_MP1 (VDD qu3_b3_4 XI1890_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1890_MP5 (b29_26 XI1890_Bn XI1890_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1890_MP4 (XI1890_p1 XI1890_An b29_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1890_MP2 (VDD dd26_b3_5 XI1890_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1890_MP3 (XI1890_p1 qu3_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1890_MP0 (VDD dd26_b3_5 XI1890_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1891_MP1 (VDD qu3_b3_4 XI1891_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1891_MP5 (b29_27 XI1891_Bn XI1891_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1891_MP4 (XI1891_p1 XI1891_An b29_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1891_MP2 (VDD dd27_b3_5 XI1891_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1891_MP3 (XI1891_p1 qu3_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1891_MP0 (VDD dd27_b3_5 XI1891_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1892_MP1 (VDD qu3_b3_4 XI1892_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1892_MP5 (b29_28 XI1892_Bn XI1892_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1892_MP4 (XI1892_p1 XI1892_An b29_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1892_MP2 (VDD dd28_b3_5 XI1892_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1892_MP3 (XI1892_p1 qu3_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1892_MP0 (VDD dd28_b3_5 XI1892_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1893_MP1 (VDD qu3_b3_4 XI1893_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1893_MP5 (b29_29 XI1893_Bn XI1893_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1893_MP4 (XI1893_p1 XI1893_An b29_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1893_MP2 (VDD dd29_b3_5 XI1893_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1893_MP3 (XI1893_p1 qu3_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1893_MP0 (VDD dd29_b3_5 XI1893_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI695_MP1 (VDD qu29_b3_4 XI695_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI695_MP5 (b3_27 XI695_Bn XI695_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI695_MP4 (XI695_p1 XI695_An b3_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI695_MP2 (VDD dd27_b3_0 XI695_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI695_MP3 (XI695_p1 qu29_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI695_MP0 (VDD dd27_b3_0 XI695_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI697_MP1 (VDD qu29_b3_4 XI697_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI697_MP5 (b3_29 XI697_Bn XI697_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI697_MP4 (XI697_p1 XI697_An b3_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI697_MP2 (VDD dd29_b3_0 XI697_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI697_MP3 (XI697_p1 qu29_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI697_MP0 (VDD dd29_b3_0 XI697_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI696_MP1 (VDD qu29_b3_4 XI696_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI696_MP5 (b3_28 XI696_Bn XI696_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI696_MP4 (XI696_p1 XI696_An b3_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI696_MP2 (VDD dd28_b3_0 XI696_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI696_MP3 (XI696_p1 qu29_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI696_MP0 (VDD dd28_b3_0 XI696_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI698_MP1 (VDD qu29_b3_5 XI698_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI698_MP5 (b3_30 XI698_Bn XI698_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI698_MP4 (XI698_p1 XI698_An b3_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI698_MP2 (VDD dd30_b3_0 XI698_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI698_MP3 (XI698_p1 qu29_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI698_MP0 (VDD dd30_b3_0 XI698_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI649_MP1 (VDD qu30_b3_4 XI649_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI649_MP5 (b2_27 XI649_Bn XI649_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI649_MP4 (XI649_p1 XI649_An b2_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI649_MP2 (VDD dd27_b3_0 XI649_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI649_MP3 (XI649_p1 qu30_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI649_MP0 (VDD dd27_b3_0 XI649_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI647_MP1 (VDD qu30_b3_4 XI647_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI647_MP5 (b2_25 XI647_Bn XI647_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI647_MP4 (XI647_p1 XI647_An b2_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI647_MP2 (VDD dd25_b3_0 XI647_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI647_MP3 (XI647_p1 qu30_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI647_MP0 (VDD dd25_b3_0 XI647_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI601_MP1 (VDD qu31_b3_4 XI601_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI601_MP5 (b1_25 XI601_Bn XI601_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI601_MP4 (XI601_p1 XI601_An b1_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI601_MP2 (VDD dd25_b3_0 XI601_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI601_MP3 (XI601_p1 qu31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI601_MP0 (VDD dd25_b3_0 XI601_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI603_MP1 (VDD qu31_b3_4 XI603_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI603_MP5 (b1_27 XI603_Bn XI603_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI603_MP4 (XI603_p1 XI603_An b1_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI603_MP2 (VDD dd27_b3_0 XI603_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI603_MP3 (XI603_p1 qu31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI603_MP0 (VDD dd27_b3_0 XI603_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI556_MP1 (VDD VDD XI556_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI556_MP5 (b0_26 XI556_Bn XI556_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI556_MP4 (XI556_p1 XI556_An b0_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI556_MP2 (VDD dd26_b3_0 XI556_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI556_MP3 (XI556_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI556_MP0 (VDD dd26_b3_0 XI556_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI557_MP1 (VDD VDD XI557_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI557_MP5 (b0_27 XI557_Bn XI557_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI557_MP4 (XI557_p1 XI557_An b0_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI557_MP2 (VDD dd27_b3_0 XI557_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI557_MP3 (XI557_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI557_MP0 (VDD dd27_b3_0 XI557_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI555_MP1 (VDD VDD XI555_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI555_MP5 (b0_25 XI555_Bn XI555_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI555_MP4 (XI555_p1 XI555_An b0_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI555_MP2 (VDD dd25_b3_0 XI555_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI555_MP3 (XI555_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI555_MP0 (VDD dd25_b3_0 XI555_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1990_MP1 (VDD c31_o XI1990_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1990_MP5 (p31_32 XI1990_Bn XI1990_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1990_MP4 (XI1990_p1 XI1990_An p31_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1990_MP2 (VDD h31 XI1990_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1990_MP3 (XI1990_p1 c31_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1990_MP0 (VDD h31 XI1990_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1982_MP1 (VDD qu1_b3_4 XI1982_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1982_MP5 (b31_26 XI1982_Bn XI1982_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1982_MP4 (XI1982_p1 XI1982_An b31_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1982_MP2 (VDD dd26_b3_5 XI1982_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1982_MP3 (XI1982_p1 qu1_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1982_MP0 (VDD dd26_b3_5 XI1982_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1944_MP1 (VDD c30_o XI1944_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1944_MP5 (p30_32 XI1944_Bn XI1944_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1944_MP4 (XI1944_p1 XI1944_An p30_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1944_MP2 (VDD h30 XI1944_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1944_MP3 (XI1944_p1 c30_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1944_MP0 (VDD h30 XI1944_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1935_MP1 (VDD qu2_b3_4 XI1935_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1935_MP5 (b30_25 XI1935_Bn XI1935_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1935_MP4 (XI1935_p1 XI1935_An b30_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1935_MP2 (VDD dd25_b3_5 XI1935_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1935_MP3 (XI1935_p1 qu2_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1935_MP0 (VDD dd25_b3_5 XI1935_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1936_MP1 (VDD qu2_b3_4 XI1936_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1936_MP5 (b30_26 XI1936_Bn XI1936_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1936_MP4 (XI1936_p1 XI1936_An b30_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1936_MP2 (VDD dd26_b3_5 XI1936_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1936_MP3 (XI1936_p1 qu2_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1936_MP0 (VDD dd26_b3_5 XI1936_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1889_MP1 (VDD qu3_b3_4 XI1889_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1889_MP5 (b29_25 XI1889_Bn XI1889_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1889_MP4 (XI1889_p1 XI1889_An b29_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1889_MP2 (VDD dd25_b3_5 XI1889_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1889_MP3 (XI1889_p1 qu3_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1889_MP0 (VDD dd25_b3_5 XI1889_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI692_MP1 (VDD qu29_b3_4 XI692_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI692_MP5 (b3_24 XI692_Bn XI692_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI692_MP4 (XI692_p1 XI692_An b3_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI692_MP2 (VDD dd24_b3_0 XI692_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI692_MP3 (XI692_p1 qu29_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI692_MP0 (VDD dd24_b3_0 XI692_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI694_MP1 (VDD qu29_b3_4 XI694_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI694_MP5 (b3_26 XI694_Bn XI694_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI694_MP4 (XI694_p1 XI694_An b3_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI694_MP2 (VDD dd26_b3_0 XI694_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI694_MP3 (XI694_p1 qu29_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI694_MP0 (VDD dd26_b3_0 XI694_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI693_MP1 (VDD qu29_b3_4 XI693_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI693_MP5 (b3_25 XI693_Bn XI693_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI693_MP4 (XI693_p1 XI693_An b3_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI693_MP2 (VDD dd25_b3_0 XI693_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI693_MP3 (XI693_p1 qu29_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI693_MP0 (VDD dd25_b3_0 XI693_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI701_MP1 (VDD qu29_b3_5 XI701_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI701_MP5 (h3 XI701_Bn XI701_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI701_MP4 (XI701_p1 XI701_An h3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI701_MP2 (VDD p2_31 XI701_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI701_MP3 (XI701_p1 qu29_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI701_MP0 (VDD p2_31 XI701_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI646_MP1 (VDD qu30_b3_4 XI646_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI646_MP5 (b2_24 XI646_Bn XI646_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI646_MP4 (XI646_p1 XI646_An b2_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI646_MP2 (VDD dd24_b3_0 XI646_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI646_MP3 (XI646_p1 qu30_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI646_MP0 (VDD dd24_b3_0 XI646_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI645_MP1 (VDD qu30_b3_3 XI645_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI645_MP5 (b2_23 XI645_Bn XI645_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI645_MP4 (XI645_p1 XI645_An b2_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI645_MP2 (VDD dd23_b3_0 XI645_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI645_MP3 (XI645_p1 qu30_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI645_MP0 (VDD dd23_b3_0 XI645_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI599_MP1 (VDD qu31_b3_3 XI599_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI599_MP5 (b1_23 XI599_Bn XI599_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI599_MP4 (XI599_p1 XI599_An b1_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI599_MP2 (VDD dd23_b3_0 XI599_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI599_MP3 (XI599_p1 qu31_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI599_MP0 (VDD dd23_b3_0 XI599_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI600_MP1 (VDD qu31_b3_4 XI600_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI600_MP5 (b1_24 XI600_Bn XI600_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI600_MP4 (XI600_p1 XI600_An b1_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI600_MP2 (VDD dd24_b3_0 XI600_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI600_MP3 (XI600_p1 qu31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI600_MP0 (VDD dd24_b3_0 XI600_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI553_MP1 (VDD VDD XI553_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI553_MP5 (b0_23 XI553_Bn XI553_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI553_MP4 (XI553_p1 XI553_An b0_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI553_MP2 (VDD dd23_b3_0 XI553_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI553_MP3 (XI553_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI553_MP0 (VDD dd23_b3_0 XI553_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI554_MP1 (VDD VDD XI554_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI554_MP5 (b0_24 XI554_Bn XI554_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI554_MP4 (XI554_p1 XI554_An b0_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI554_MP2 (VDD dd24_b3_0 XI554_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI554_MP3 (XI554_p1 VDD VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI554_MP0 (VDD dd24_b3_0 XI554_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI564_MP1 (VDD c0_o XI564_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI564_MP5 (p0_32 XI564_Bn XI564_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI564_MP4 (XI564_p1 XI564_An p0_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI564_MP2 (VDD h0 XI564_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI564_MP3 (XI564_p1 c0_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI564_MP0 (VDD h0 XI564_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I219_MP1 (VDD I2066_G15_0n XI2066_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI2066_I219_MP5 (ru16 XI2066_I219_Bn XI2066_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI2066_I219_MP4 (XI2066_I219_p1 XI2066_I219_An ru16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I219_MP2 (VDD I2066_pn16 XI2066_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI2066_I219_MP3 (XI2066_I219_p1 I2066_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI2066_I219_MP0 (VDD I2066_pn16 XI2066_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1980_MP1 (VDD qu1_b3_4 XI1980_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1980_MP5 (b31_24 XI1980_Bn XI1980_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1980_MP4 (XI1980_p1 XI1980_An b31_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1980_MP2 (VDD dd24_b3_5 XI1980_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1980_MP3 (XI1980_p1 qu1_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1980_MP0 (VDD dd24_b3_5 XI1980_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1981_MP1 (VDD qu1_b3_4 XI1981_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1981_MP5 (b31_25 XI1981_Bn XI1981_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1981_MP4 (XI1981_p1 XI1981_An b31_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1981_MP2 (VDD dd25_b3_5 XI1981_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1981_MP3 (XI1981_p1 qu1_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1981_MP0 (VDD dd25_b3_5 XI1981_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1934_MP1 (VDD qu2_b3_4 XI1934_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1934_MP5 (b30_24 XI1934_Bn XI1934_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1934_MP4 (XI1934_p1 XI1934_An b30_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1934_MP2 (VDD dd24_b3_5 XI1934_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1934_MP3 (XI1934_p1 qu2_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1934_MP0 (VDD dd24_b3_5 XI1934_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1888_MP1 (VDD qu3_b3_4 XI1888_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1888_MP5 (b29_24 XI1888_Bn XI1888_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1888_MP4 (XI1888_p1 XI1888_An b29_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1888_MP2 (VDD dd24_b3_5 XI1888_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1888_MP3 (XI1888_p1 qu3_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1888_MP0 (VDD dd24_b3_5 XI1888_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI690_MP1 (VDD qu29_b3_3 XI690_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI690_MP5 (b3_22 XI690_Bn XI690_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI690_MP4 (XI690_p1 XI690_An b3_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI690_MP2 (VDD dd22_b3_0 XI690_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI690_MP3 (XI690_p1 qu29_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI690_MP0 (VDD dd22_b3_0 XI690_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI702_MP1 (VDD c3_o XI702_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI702_MP5 (p3_32 XI702_Bn XI702_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI702_MP4 (XI702_p1 XI702_An p3_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI702_MP2 (VDD h3 XI702_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
