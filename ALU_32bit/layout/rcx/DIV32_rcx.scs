    I_MXI1043_MN4 (b11_7 XI1043_An XI1043_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1043_MN2 (XI1043_n1 dd7_b3_2 b11_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1043_MN3 (VSS qu21_b3_1 XI1043_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1043_MN0 (XI1043_An dd7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I207_MN1 (XI1022_I207_Bn I1022_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I207_MN5 (XI1022_I207_n2 XI1022_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I207_MN4 (p10_4 XI1022_I207_An XI1022_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I207_MN2 (XI1022_I207_n1 I1022_pn4 p10_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I207_MN3 (VSS I1022_G3_0n XI1022_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I207_MN0 (XI1022_I207_An I1022_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1037_MN1 (XI1037_Bn qu21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1037_MN5 (XI1037_n2 XI1037_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1037_MN4 (b11_1 XI1037_An XI1037_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1037_MN2 (XI1037_n1 dd1_b3_2 b11_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1037_MN3 (VSS qu21_b3_0 XI1037_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1037_MN0 (XI1037_An dd1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I206_MN1 (XI1022_I206_Bn I1022_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I206_MN5 (XI1022_I206_n2 XI1022_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I206_MN4 (p10_3 XI1022_I206_An XI1022_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I206_MN2 (XI1022_I206_n1 I1022_pn3 p10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I206_MN3 (VSS I1022_G2_0n XI1022_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I206_MN0 (XI1022_I206_An I1022_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI996_MN1 (XI996_Bn qu22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI996_MN5 (XI996_n2 XI996_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI996_MN4 (b10_6 XI996_An XI996_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI996_MN2 (XI996_n1 dd6_b3_1 b10_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI996_MN3 (VSS qu22_b3_1 XI996_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI996_MN0 (XI996_An dd6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI994_MN1 (XI994_Bn qu22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI994_MN5 (XI994_n2 XI994_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI994_MN4 (b10_4 XI994_An XI994_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI994_MN2 (XI994_n1 dd4_b3_1 b10_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI994_MN3 (VSS qu22_b3_0 XI994_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI994_MN0 (XI994_An dd4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI993_MN1 (XI993_Bn qu22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI993_MN5 (XI993_n2 XI993_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI993_MN4 (b10_3 XI993_An XI993_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI993_MN2 (XI993_n1 dd3_b3_1 b10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI993_MN3 (VSS qu22_b3_0 XI993_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI993_MN0 (XI993_An dd3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I206_MN1 (XI976_I206_Bn I976_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I206_MN5 (XI976_I206_n2 XI976_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I206_MN4 (p9_3 XI976_I206_An XI976_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I206_MN2 (XI976_I206_n1 I976_pn3 p9_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I206_MN3 (VSS I976_G2_0n XI976_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I206_MN0 (XI976_I206_An I976_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI950_MN1 (XI950_Bn qu23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI950_MN5 (XI950_n2 XI950_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI950_MN4 (b9_6 XI950_An XI950_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI950_MN2 (XI950_n1 dd6_b3_1 b9_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI950_MN3 (VSS qu23_b3_1 XI950_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI950_MN0 (XI950_An dd6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI905_MN1 (XI905_Bn qu24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI905_MN5 (XI905_n2 XI905_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI905_MN4 (b8_7 XI905_An XI905_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI905_MN2 (XI905_n1 dd7_b3_1 b8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI905_MN3 (VSS qu24_b3_1 XI905_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI905_MN0 (XI905_An dd7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI904_MN1 (XI904_Bn qu24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI904_MN5 (XI904_n2 XI904_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI904_MN4 (b8_6 XI904_An XI904_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI904_MN2 (XI904_n1 dd6_b3_1 b8_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI904_MN3 (VSS qu24_b3_1 XI904_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI904_MN0 (XI904_An dd6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI906_MN1 (XI906_Bn qu24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI906_MN5 (XI906_n2 XI906_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI906_MN4 (b8_8 XI906_An XI906_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI906_MN2 (XI906_n1 dd8_b3_1 b8_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI906_MN3 (VSS qu24_b3_1 XI906_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI906_MN0 (XI906_An dd8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I206_MN1 (XI930_I206_Bn I930_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I206_MN5 (XI930_I206_n2 XI930_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I206_MN4 (p8_3 XI930_I206_An XI930_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I206_MN2 (XI930_I206_n1 I930_pn3 p8_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I206_MN3 (VSS I930_G2_0n XI930_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I206_MN0 (XI930_I206_An I930_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I207_MN1 (XI930_I207_Bn I930_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I207_MN5 (XI930_I207_n2 XI930_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I207_MN4 (p8_4 XI930_I207_An XI930_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I207_MN2 (XI930_I207_n1 I930_pn4 p8_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I207_MN3 (VSS I930_G3_0n XI930_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I207_MN0 (XI930_I207_An I930_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I212_MN1 (XI1666_I212_Bn I1666_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I212_MN5 (XI1666_I212_n2 XI1666_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I212_MN4 (p24_9 XI1666_I212_An XI1666_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I212_MN2 (XI1666_I212_n1 I1666_pn9 p24_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I212_MN3 (VSS I1666_G8_0n XI1666_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I212_MN0 (XI1666_I212_An I1666_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I207_MN1 (XI1666_I207_Bn I1666_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I207_MN5 (XI1666_I207_n2 XI1666_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I207_MN4 (p24_4 XI1666_I207_An XI1666_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I207_MN2 (XI1666_I207_n1 I1666_pn4 p24_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I207_MN3 (VSS I1666_G3_0n XI1666_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I207_MN0 (XI1666_I207_An I1666_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1640_MN1 (XI1640_Bn qu8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1640_MN5 (XI1640_n2 XI1640_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1640_MN4 (b24_6 XI1640_An XI1640_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1640_MN2 (XI1640_n1 dd6_b3_4 b24_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1640_MN3 (VSS qu8_b3_1 XI1640_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1640_MN0 (XI1640_An dd6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I207_MN1 (XI1620_I207_Bn I1620_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I207_MN5 (XI1620_I207_n2 XI1620_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I207_MN4 (p23_4 XI1620_I207_An XI1620_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I207_MN2 (XI1620_I207_n1 I1620_pn4 p23_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I207_MN3 (VSS I1620_G3_0n XI1620_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I207_MN0 (XI1620_I207_An I1620_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I206_MN1 (XI1620_I206_Bn I1620_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I206_MN5 (XI1620_I206_n2 XI1620_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I206_MN4 (p23_3 XI1620_I206_An XI1620_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I206_MN2 (XI1620_I206_n1 I1620_pn3 p23_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I206_MN3 (VSS I1620_G2_0n XI1620_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I206_MN0 (XI1620_I206_An I1620_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1594_MN1 (XI1594_Bn qu9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1594_MN5 (XI1594_n2 XI1594_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1594_MN4 (b23_6 XI1594_An XI1594_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1594_MN2 (XI1594_n1 dd6_b3_4 b23_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1594_MN3 (VSS qu9_b3_1 XI1594_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1594_MN0 (XI1594_An dd6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1548_MN1 (XI1548_Bn qu10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1548_MN5 (XI1548_n2 XI1548_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1548_MN4 (b22_6 XI1548_An XI1548_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1548_MN2 (XI1548_n1 dd6_b3_4 b22_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1548_MN3 (VSS qu10_b3_1 XI1548_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1548_MN0 (XI1548_An dd6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I207_MN1 (XI1574_I207_Bn I1574_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I207_MN5 (XI1574_I207_n2 XI1574_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I207_MN4 (p22_4 XI1574_I207_An XI1574_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I207_MN2 (XI1574_I207_n1 I1574_pn4 p22_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I207_MN3 (VSS I1574_G3_0n XI1574_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I207_MN0 (XI1574_I207_An I1574_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1064_MN1 (XI1064_Bn qu21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1064_MN5 (XI1064_n2 XI1064_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1064_MN4 (b11_28 XI1064_An XI1064_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1064_MN2 (XI1064_n1 dd28_b3_2 b11_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1064_MN3 (VSS qu21_b3_4 XI1064_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1064_MN0 (XI1064_An dd28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I214_MN1 (XI1068_I214_Bn I1068_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I214_MN5 (XI1068_I214_n2 XI1068_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I214_MN4 (p11_11 XI1068_I214_An XI1068_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I214_MN2 (XI1068_I214_n1 I1068_pn11 p11_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I214_MN3 (VSS I1068_G10_0n XI1068_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I214_MN0 (XI1068_I214_An I1068_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI999_MN1 (XI999_Bn qu22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI999_MN5 (XI999_n2 XI999_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI999_MN4 (b10_9 XI999_An XI999_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI999_MN2 (XI999_n1 dd9_b3_1 b10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI999_MN3 (VSS qu22_b3_1 XI999_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI999_MN0 (XI999_An dd9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI997_MN1 (XI997_Bn qu22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI997_MN5 (XI997_n2 XI997_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI997_MN4 (b10_7 XI997_An XI997_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI997_MN2 (XI997_n1 dd7_b3_1 b10_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI997_MN3 (VSS qu22_b3_1 XI997_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI997_MN0 (XI997_An dd7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1000_MN1 (XI1000_Bn qu22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1000_MN5 (XI1000_n2 XI1000_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1000_MN4 (b10_10 XI1000_An XI1000_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1000_MN2 (XI1000_n1 dd10_b3_1 b10_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1000_MN3 (VSS qu22_b3_1 XI1000_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1000_MN0 (XI1000_An dd10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI998_MN1 (XI998_Bn qu22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI998_MN5 (XI998_n2 XI998_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI998_MN4 (b10_8 XI998_An XI998_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI998_MN2 (XI998_n1 dd8_b3_1 b10_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI998_MN3 (VSS qu22_b3_1 XI998_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI998_MN0 (XI998_An dd8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I207_MN1 (XI976_I207_Bn I976_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I207_MN5 (XI976_I207_n2 XI976_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I207_MN4 (p9_4 XI976_I207_An XI976_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I207_MN2 (XI976_I207_n1 I976_pn4 p9_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I207_MN3 (VSS I976_G3_0n XI976_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I207_MN0 (XI976_I207_An I976_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI951_MN1 (XI951_Bn qu23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI951_MN5 (XI951_n2 XI951_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI951_MN4 (b9_7 XI951_An XI951_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI951_MN2 (XI951_n1 dd7_b3_1 b9_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI951_MN3 (VSS qu23_b3_1 XI951_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI951_MN0 (XI951_An dd7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI952_MN1 (XI952_Bn qu23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI952_MN5 (XI952_n2 XI952_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI952_MN4 (b9_8 XI952_An XI952_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI952_MN2 (XI952_n1 dd8_b3_1 b9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI952_MN3 (VSS qu23_b3_1 XI952_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI952_MN0 (XI952_An dd8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI954_MN1 (XI954_Bn qu23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI954_MN5 (XI954_n2 XI954_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI954_MN4 (b9_10 XI954_An XI954_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI954_MN2 (XI954_n1 dd10_b3_1 b9_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI954_MN3 (VSS qu23_b3_1 XI954_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI954_MN0 (XI954_An dd10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI907_MN1 (XI907_Bn qu24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI907_MN5 (XI907_n2 XI907_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI907_MN4 (b8_9 XI907_An XI907_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI907_MN2 (XI907_n1 dd9_b3_1 b8_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI907_MN3 (VSS qu24_b3_1 XI907_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI907_MN0 (XI907_An dd9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI909_MN1 (XI909_Bn qu24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI909_MN5 (XI909_n2 XI909_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI909_MN4 (b8_11 XI909_An XI909_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI909_MN2 (XI909_n1 dd11_b3_1 b8_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI909_MN3 (VSS qu24_b3_1 XI909_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI909_MN0 (XI909_An dd11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI931_MN1 (XI931_Bn qu24_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI931_MN5 (XI931_n2 XI931_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI931_MN4 (h8 XI931_An XI931_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI931_MN2 (XI931_n1 p7_31 h8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI931_MN3 (VSS qu24_b3_5 XI931_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI931_MN0 (XI931_An p7_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI908_MN1 (XI908_Bn qu24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI908_MN5 (XI908_n2 XI908_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI908_MN4 (b8_10 XI908_An XI908_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI908_MN2 (XI908_n1 dd10_b3_1 b8_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI908_MN3 (VSS qu24_b3_1 XI908_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI908_MN0 (XI908_An dd10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1641_MN1 (XI1641_Bn qu8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1641_MN5 (XI1641_n2 XI1641_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1641_MN4 (b24_7 XI1641_An XI1641_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1641_MN2 (XI1641_n1 dd7_b3_4 b24_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1641_MN3 (VSS qu8_b3_1 XI1641_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1641_MN0 (XI1641_An dd7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1642_MN1 (XI1642_Bn qu8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1642_MN5 (XI1642_n2 XI1642_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1642_MN4 (b24_8 XI1642_An XI1642_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1642_MN2 (XI1642_n1 dd8_b3_4 b24_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1642_MN3 (VSS qu8_b3_1 XI1642_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1642_MN0 (XI1642_An dd8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1596_MN1 (XI1596_Bn qu9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1596_MN5 (XI1596_n2 XI1596_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1596_MN4 (b23_8 XI1596_An XI1596_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1596_MN2 (XI1596_n1 dd8_b3_4 b23_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1596_MN3 (VSS qu9_b3_1 XI1596_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1596_MN0 (XI1596_An dd8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1595_MN1 (XI1595_Bn qu9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1595_MN5 (XI1595_n2 XI1595_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1595_MN4 (b23_7 XI1595_An XI1595_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1595_MN2 (XI1595_n1 dd7_b3_4 b23_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1595_MN3 (VSS qu9_b3_1 XI1595_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1595_MN0 (XI1595_An dd7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1550_MN1 (XI1550_Bn qu10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1550_MN5 (XI1550_n2 XI1550_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1550_MN4 (b22_8 XI1550_An XI1550_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1550_MN2 (XI1550_n1 dd8_b3_4 b22_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1550_MN3 (VSS qu10_b3_1 XI1550_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1550_MN0 (XI1550_An dd8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1549_MN1 (XI1549_Bn qu10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1549_MN5 (XI1549_n2 XI1549_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1549_MN4 (b22_7 XI1549_An XI1549_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1549_MN2 (XI1549_n1 dd7_b3_4 b22_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1549_MN3 (VSS qu10_b3_1 XI1549_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1549_MN0 (XI1549_An dd7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1046_MN1 (XI1046_Bn qu21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1046_MN5 (XI1046_n2 XI1046_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1046_MN4 (b11_10 XI1046_An XI1046_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1046_MN2 (XI1046_n1 dd10_b3_2 b11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1046_MN3 (VSS qu21_b3_1 XI1046_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1046_MN0 (XI1046_An dd10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I212_MN1 (XI1022_I212_Bn I1022_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I212_MN5 (XI1022_I212_n2 XI1022_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I212_MN4 (p10_9 XI1022_I212_An XI1022_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I212_MN2 (XI1022_I212_n1 I1022_pn9 p10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I212_MN3 (VSS I1022_G8_0n XI1022_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I212_MN0 (XI1022_I212_An I1022_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1001_MN1 (XI1001_Bn qu22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1001_MN5 (XI1001_n2 XI1001_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1001_MN4 (b10_11 XI1001_An XI1001_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1001_MN2 (XI1001_n1 dd11_b3_1 b10_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1001_MN3 (VSS qu22_b3_1 XI1001_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1001_MN0 (XI1001_An dd11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI953_MN1 (XI953_Bn qu23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI953_MN5 (XI953_n2 XI953_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI953_MN4 (b9_9 XI953_An XI953_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI953_MN2 (XI953_n1 dd9_b3_1 b9_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI953_MN3 (VSS qu23_b3_1 XI953_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI953_MN0 (XI953_An dd9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI955_MN1 (XI955_Bn qu23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI955_MN5 (XI955_n2 XI955_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI955_MN4 (b9_11 XI955_An XI955_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI955_MN2 (XI955_n1 dd11_b3_1 b9_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI955_MN3 (VSS qu23_b3_1 XI955_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI955_MN0 (XI955_An dd11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI910_MN1 (XI910_Bn qu24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI910_MN5 (XI910_n2 XI910_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI910_MN4 (b8_12 XI910_An XI910_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI910_MN2 (XI910_n1 dd12_b3_1 b8_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI910_MN3 (VSS qu24_b3_2 XI910_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI910_MN0 (XI910_An dd12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I212_MN1 (XI930_I212_Bn I930_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I212_MN5 (XI930_I212_n2 XI930_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I212_MN4 (p8_9 XI930_I212_An XI930_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I212_MN2 (XI930_I212_n1 I930_pn9 p8_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I212_MN3 (VSS I930_G8_0n XI930_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I212_MN0 (XI930_I212_An I930_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I213_MN1 (XI1666_I213_Bn I1666_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I213_MN5 (XI1666_I213_n2 XI1666_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I213_MN4 (p24_10 XI1666_I213_An XI1666_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I213_MN2 (XI1666_I213_n1 I1666_pn10 p24_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I213_MN3 (VSS I1666_G9_0n XI1666_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I213_MN0 (XI1666_I213_An I1666_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1643_MN1 (XI1643_Bn qu8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1643_MN5 (XI1643_n2 XI1643_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1643_MN4 (b24_9 XI1643_An XI1643_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1643_MN2 (XI1643_n1 dd9_b3_4 b24_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1643_MN3 (VSS qu8_b3_1 XI1643_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1643_MN0 (XI1643_An dd9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1644_MN1 (XI1644_Bn qu8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1644_MN5 (XI1644_n2 XI1644_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1644_MN4 (b24_10 XI1644_An XI1644_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1644_MN2 (XI1644_n1 dd10_b3_4 b24_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1644_MN3 (VSS qu8_b3_1 XI1644_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1644_MN0 (XI1644_An dd10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1645_MN1 (XI1645_Bn qu8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1645_MN5 (XI1645_n2 XI1645_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1645_MN4 (b24_11 XI1645_An XI1645_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1645_MN2 (XI1645_n1 dd11_b3_4 b24_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1645_MN3 (VSS qu8_b3_1 XI1645_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1645_MN0 (XI1645_An dd11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I212_MN1 (XI1620_I212_Bn I1620_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I212_MN5 (XI1620_I212_n2 XI1620_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I212_MN4 (p23_9 XI1620_I212_An XI1620_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I212_MN2 (XI1620_I212_n1 I1620_pn9 p23_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I212_MN3 (VSS I1620_G8_0n XI1620_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I212_MN0 (XI1620_I212_An I1620_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1597_MN1 (XI1597_Bn qu9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1597_MN5 (XI1597_n2 XI1597_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1597_MN4 (b23_9 XI1597_An XI1597_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1597_MN2 (XI1597_n1 dd9_b3_4 b23_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1597_MN3 (VSS qu9_b3_1 XI1597_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1597_MN0 (XI1597_An dd9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1599_MN1 (XI1599_Bn qu9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1599_MN5 (XI1599_n2 XI1599_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1599_MN4 (b23_11 XI1599_An XI1599_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1599_MN2 (XI1599_n1 dd11_b3_4 b23_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1599_MN3 (VSS qu9_b3_1 XI1599_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1599_MN0 (XI1599_An dd11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1598_MN1 (XI1598_Bn qu9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1598_MN5 (XI1598_n2 XI1598_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1598_MN4 (b23_10 XI1598_An XI1598_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1598_MN2 (XI1598_n1 dd10_b3_4 b23_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1598_MN3 (VSS qu9_b3_1 XI1598_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1598_MN0 (XI1598_An dd10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1552_MN1 (XI1552_Bn qu10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1552_MN5 (XI1552_n2 XI1552_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1552_MN4 (b22_10 XI1552_An XI1552_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1552_MN2 (XI1552_n1 dd10_b3_4 b22_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1552_MN3 (VSS qu10_b3_1 XI1552_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1552_MN0 (XI1552_An dd10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1551_MN1 (XI1551_Bn qu10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1551_MN5 (XI1551_n2 XI1551_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1551_MN4 (b22_9 XI1551_An XI1551_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1551_MN2 (XI1551_n1 dd9_b3_4 b22_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1551_MN3 (VSS qu10_b3_1 XI1551_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1551_MN0 (XI1551_An dd9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I212_MN1 (XI1574_I212_Bn I1574_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I212_MN5 (XI1574_I212_n2 XI1574_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I212_MN4 (p22_9 XI1574_I212_An XI1574_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I212_MN2 (XI1574_I212_n1 I1574_pn9 p22_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I212_MN3 (VSS I1574_G8_0n XI1574_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I212_MN0 (XI1574_I212_An I1574_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I215_MN1 (XI1068_I215_Bn I1068_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I215_MN5 (XI1068_I215_n2 XI1068_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I215_MN4 (p11_12 XI1068_I215_An XI1068_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I215_MN2 (XI1068_I215_n1 I1068_pn12 p11_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I215_MN3 (VSS I1068_G11_0n XI1068_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I215_MN0 (XI1068_I215_An I1068_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I212_MN1 (XI1068_I212_Bn I1068_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I212_MN5 (XI1068_I212_n2 XI1068_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I212_MN4 (p11_9 XI1068_I212_An XI1068_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I212_MN2 (XI1068_I212_n1 I1068_pn9 p11_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I212_MN3 (VSS I1068_G8_0n XI1068_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I212_MN0 (XI1068_I212_An I1068_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1045_MN1 (XI1045_Bn qu21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1045_MN5 (XI1045_n2 XI1045_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1045_MN4 (b11_9 XI1045_An XI1045_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1045_MN2 (XI1045_n1 dd9_b3_2 b11_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1045_MN3 (VSS qu21_b3_1 XI1045_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1045_MN0 (XI1045_An dd9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1047_MN1 (XI1047_Bn qu21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1047_MN5 (XI1047_n2 XI1047_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1047_MN4 (b11_11 XI1047_An XI1047_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1047_MN2 (XI1047_n1 dd11_b3_2 b11_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1047_MN3 (VSS qu21_b3_1 XI1047_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1047_MN0 (XI1047_An dd11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I213_MN1 (XI1022_I213_Bn I1022_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I213_MN5 (XI1022_I213_n2 XI1022_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I213_MN4 (p10_10 XI1022_I213_An XI1022_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I213_MN2 (XI1022_I213_n1 I1022_pn10 p10_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I213_MN3 (VSS I1022_G9_0n XI1022_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I213_MN0 (XI1022_I213_An I1022_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1002_MN1 (XI1002_Bn qu22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1002_MN5 (XI1002_n2 XI1002_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1002_MN4 (b10_12 XI1002_An XI1002_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1002_MN2 (XI1002_n1 dd12_b3_1 b10_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1002_MN3 (VSS qu22_b3_2 XI1002_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1002_MN0 (XI1002_An dd12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I212_MN1 (XI976_I212_Bn I976_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I212_MN5 (XI976_I212_n2 XI976_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I212_MN4 (p9_9 XI976_I212_An XI976_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I212_MN2 (XI976_I212_n1 I976_pn9 p9_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I212_MN3 (VSS I976_G8_0n XI976_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I212_MN0 (XI976_I212_An I976_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I213_MN1 (XI976_I213_Bn I976_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I213_MN5 (XI976_I213_n2 XI976_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I213_MN4 (p9_10 XI976_I213_An XI976_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I213_MN2 (XI976_I213_n1 I976_pn10 p9_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I213_MN3 (VSS I976_G9_0n XI976_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I213_MN0 (XI976_I213_An I976_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI956_MN1 (XI956_Bn qu23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI956_MN5 (XI956_n2 XI956_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI956_MN4 (b9_12 XI956_An XI956_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI956_MN2 (XI956_n1 dd12_b3_1 b9_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI956_MN3 (VSS qu23_b3_2 XI956_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI956_MN0 (XI956_An dd12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI911_MN1 (XI911_Bn qu24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI911_MN5 (XI911_n2 XI911_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI911_MN4 (b8_13 XI911_An XI911_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI911_MN2 (XI911_n1 dd13_b3_1 b8_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI911_MN3 (VSS qu24_b3_2 XI911_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI911_MN0 (XI911_An dd13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI932_MN1 (XI932_Bn c8_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI932_MN5 (XI932_n2 XI932_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI932_MN4 (p8_32 XI932_An XI932_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI932_MN2 (XI932_n1 h8 p8_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI932_MN3 (VSS c8_o XI932_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI932_MN0 (XI932_An h8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I213_MN1 (XI930_I213_Bn I930_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I213_MN5 (XI930_I213_n2 XI930_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I213_MN4 (p8_10 XI930_I213_An XI930_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I213_MN2 (XI930_I213_n1 I930_pn10 p8_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I213_MN3 (VSS I930_G9_0n XI930_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I213_MN0 (XI930_I213_An I930_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I216_MN1 (XI1666_I216_Bn I1666_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I216_MN5 (XI1666_I216_n2 XI1666_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I216_MN4 (p24_13 XI1666_I216_An XI1666_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I216_MN2 (XI1666_I216_n1 I1666_pn13 p24_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I216_MN3 (VSS I1666_G12_0n XI1666_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I216_MN0 (XI1666_I216_An I1666_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I214_MN1 (XI1666_I214_Bn I1666_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I214_MN5 (XI1666_I214_n2 XI1666_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I214_MN4 (p24_11 XI1666_I214_An XI1666_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I214_MN2 (XI1666_I214_n1 I1666_pn11 p24_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I214_MN3 (VSS I1666_G10_0n XI1666_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I214_MN0 (XI1666_I214_An I1666_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I215_MN1 (XI1666_I215_Bn I1666_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I215_MN5 (XI1666_I215_n2 XI1666_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I215_MN4 (p24_12 XI1666_I215_An XI1666_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I215_MN2 (XI1666_I215_n1 I1666_pn12 p24_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I215_MN3 (VSS I1666_G11_0n XI1666_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I215_MN0 (XI1666_I215_An I1666_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1646_MN1 (XI1646_Bn qu8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1646_MN5 (XI1646_n2 XI1646_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1646_MN4 (b24_12 XI1646_An XI1646_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1646_MN2 (XI1646_n1 dd12_b3_4 b24_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1646_MN3 (VSS qu8_b3_2 XI1646_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1646_MN0 (XI1646_An dd12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I213_MN1 (XI1620_I213_Bn I1620_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I213_MN5 (XI1620_I213_n2 XI1620_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I213_MN4 (p23_10 XI1620_I213_An XI1620_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I213_MN2 (XI1620_I213_n1 I1620_pn10 p23_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I213_MN3 (VSS I1620_G9_0n XI1620_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I213_MN0 (XI1620_I213_An I1620_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I214_MN1 (XI1620_I214_Bn I1620_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I214_MN5 (XI1620_I214_n2 XI1620_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I214_MN4 (p23_11 XI1620_I214_An XI1620_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I214_MN2 (XI1620_I214_n1 I1620_pn11 p23_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I214_MN3 (VSS I1620_G10_0n XI1620_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I214_MN0 (XI1620_I214_An I1620_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1601_MN1 (XI1601_Bn qu9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1601_MN5 (XI1601_n2 XI1601_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1601_MN4 (b23_13 XI1601_An XI1601_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1601_MN2 (XI1601_n1 dd13_b3_4 b23_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1601_MN3 (VSS qu9_b3_2 XI1601_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1601_MN0 (XI1601_An dd13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1600_MN1 (XI1600_Bn qu9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1600_MN5 (XI1600_n2 XI1600_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1600_MN4 (b23_12 XI1600_An XI1600_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1600_MN2 (XI1600_n1 dd12_b3_4 b23_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1600_MN3 (VSS qu9_b3_2 XI1600_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1600_MN0 (XI1600_An dd12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1553_MN1 (XI1553_Bn qu10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1553_MN5 (XI1553_n2 XI1553_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1553_MN4 (b22_11 XI1553_An XI1553_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1553_MN2 (XI1553_n1 dd11_b3_4 b22_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1553_MN3 (VSS qu10_b3_1 XI1553_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1553_MN0 (XI1553_An dd11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1554_MN1 (XI1554_Bn qu10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1554_MN5 (XI1554_n2 XI1554_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1554_MN4 (b22_12 XI1554_An XI1554_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1554_MN2 (XI1554_n1 dd12_b3_4 b22_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1554_MN3 (VSS qu10_b3_2 XI1554_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1554_MN0 (XI1554_An dd12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I213_MN1 (XI1574_I213_Bn I1574_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I213_MN5 (XI1574_I213_n2 XI1574_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I213_MN4 (p22_10 XI1574_I213_An XI1574_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I213_MN2 (XI1574_I213_n1 I1574_pn10 p22_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I213_MN3 (VSS I1574_G9_0n XI1574_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I213_MN0 (XI1574_I213_An I1574_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I214_MN1 (XI1574_I214_Bn I1574_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I214_MN5 (XI1574_I214_n2 XI1574_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I214_MN4 (p22_11 XI1574_I214_An XI1574_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I214_MN2 (XI1574_I214_n1 I1574_pn11 p22_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I214_MN3 (VSS I1574_G10_0n XI1574_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I214_MN0 (XI1574_I214_An I1574_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1065_MN1 (XI1065_Bn qu21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1065_MN5 (XI1065_n2 XI1065_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1065_MN4 (b11_29 XI1065_An XI1065_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1065_MN2 (XI1065_n1 dd29_b3_2 b11_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1065_MN3 (VSS qu21_b3_4 XI1065_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1065_MN0 (XI1065_An dd29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1061_MN1 (XI1061_Bn qu21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1061_MN5 (XI1061_n2 XI1061_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1061_MN4 (b11_25 XI1061_An XI1061_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1061_MN2 (XI1061_n1 dd25_b3_2 b11_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1061_MN3 (VSS qu21_b3_4 XI1061_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1061_MN0 (XI1061_An dd25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I217_MN1 (XI1068_I217_Bn I1068_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I217_MN5 (XI1068_I217_n2 XI1068_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I217_MN4 (p11_14 XI1068_I217_An XI1068_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I217_MN2 (XI1068_I217_n1 I1068_pn14 p11_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I217_MN3 (VSS I1068_G13_0n XI1068_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I217_MN0 (XI1068_I217_An I1068_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I216_MN1 (XI1068_I216_Bn I1068_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I216_MN5 (XI1068_I216_n2 XI1068_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I216_MN4 (p11_13 XI1068_I216_An XI1068_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I216_MN2 (XI1068_I216_n1 I1068_pn13 p11_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I216_MN3 (VSS I1068_G12_0n XI1068_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I216_MN0 (XI1068_I216_An I1068_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1048_MN1 (XI1048_Bn qu21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1048_MN5 (XI1048_n2 XI1048_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1048_MN4 (b11_12 XI1048_An XI1048_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1048_MN2 (XI1048_n1 dd12_b3_2 b11_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1048_MN3 (VSS qu21_b3_2 XI1048_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1048_MN0 (XI1048_An dd12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I215_MN1 (XI1022_I215_Bn I1022_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I215_MN5 (XI1022_I215_n2 XI1022_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I215_MN4 (p10_12 XI1022_I215_An XI1022_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I215_MN2 (XI1022_I215_n1 I1022_pn12 p10_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I215_MN3 (VSS I1022_G11_0n XI1022_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I215_MN0 (XI1022_I215_An I1022_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I214_MN1 (XI1022_I214_Bn I1022_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I214_MN5 (XI1022_I214_n2 XI1022_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I214_MN4 (p10_11 XI1022_I214_An XI1022_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I214_MN2 (XI1022_I214_n1 I1022_pn11 p10_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I214_MN3 (VSS I1022_G10_0n XI1022_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I214_MN0 (XI1022_I214_An I1022_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1004_MN1 (XI1004_Bn qu22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1004_MN5 (XI1004_n2 XI1004_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1004_MN4 (b10_14 XI1004_An XI1004_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1004_MN2 (XI1004_n1 dd14_b3_1 b10_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1004_MN3 (VSS qu22_b3_2 XI1004_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1004_MN0 (XI1004_An dd14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1003_MN1 (XI1003_Bn qu22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1003_MN5 (XI1003_n2 XI1003_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1003_MN4 (b10_13 XI1003_An XI1003_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1003_MN2 (XI1003_n1 dd13_b3_1 b10_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1003_MN3 (VSS qu22_b3_2 XI1003_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1003_MN0 (XI1003_An dd13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I214_MN1 (XI976_I214_Bn I976_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I214_MN5 (XI976_I214_n2 XI976_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I214_MN4 (p9_11 XI976_I214_An XI976_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I214_MN2 (XI976_I214_n1 I976_pn11 p9_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I214_MN3 (VSS I976_G10_0n XI976_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I214_MN0 (XI976_I214_An I976_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI957_MN1 (XI957_Bn qu23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI957_MN5 (XI957_n2 XI957_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI957_MN4 (b9_13 XI957_An XI957_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI957_MN2 (XI957_n1 dd13_b3_1 b9_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI957_MN3 (VSS qu23_b3_2 XI957_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI957_MN0 (XI957_An dd13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI958_MN1 (XI958_Bn qu23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI958_MN5 (XI958_n2 XI958_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI958_MN4 (b9_14 XI958_An XI958_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI958_MN2 (XI958_n1 dd14_b3_1 b9_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI958_MN3 (VSS qu23_b3_2 XI958_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI958_MN0 (XI958_An dd14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI961_MN1 (XI961_Bn qu23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI961_MN5 (XI961_n2 XI961_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI961_MN4 (b9_17 XI961_An XI961_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI961_MN2 (XI961_n1 dd17_b3_1 b9_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI961_MN3 (VSS qu23_b3_2 XI961_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI961_MN0 (XI961_An dd17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI959_MN1 (XI959_Bn qu23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI959_MN5 (XI959_n2 XI959_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI959_MN4 (b9_15 XI959_An XI959_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI959_MN2 (XI959_n1 dd15_b3_1 b9_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI959_MN3 (VSS qu23_b3_2 XI959_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI959_MN0 (XI959_An dd15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI913_MN1 (XI913_Bn qu24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI913_MN5 (XI913_n2 XI913_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI913_MN4 (b8_15 XI913_An XI913_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI913_MN2 (XI913_n1 dd15_b3_1 b8_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI913_MN3 (VSS qu24_b3_2 XI913_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI913_MN0 (XI913_An dd15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI912_MN1 (XI912_Bn qu24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI912_MN5 (XI912_n2 XI912_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI912_MN4 (b8_14 XI912_An XI912_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI912_MN2 (XI912_n1 dd14_b3_1 b8_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI912_MN3 (VSS qu24_b3_2 XI912_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI912_MN0 (XI912_An dd14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI914_MN1 (XI914_Bn qu24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI914_MN5 (XI914_n2 XI914_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI914_MN4 (b8_16 XI914_An XI914_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI914_MN2 (XI914_n1 dd16_b3_1 b8_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI914_MN3 (VSS qu24_b3_2 XI914_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI914_MN0 (XI914_An dd16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I214_MN1 (XI930_I214_Bn I930_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I214_MN5 (XI930_I214_n2 XI930_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I214_MN4 (p8_11 XI930_I214_An XI930_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I214_MN2 (XI930_I214_n1 I930_pn11 p8_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I214_MN3 (VSS I930_G10_0n XI930_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I214_MN0 (XI930_I214_An I930_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1647_MN1 (XI1647_Bn qu8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1647_MN5 (XI1647_n2 XI1647_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1647_MN4 (b24_13 XI1647_An XI1647_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1647_MN2 (XI1647_n1 dd13_b3_4 b24_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1647_MN3 (VSS qu8_b3_2 XI1647_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1647_MN0 (XI1647_An dd13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1648_MN1 (XI1648_Bn qu8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1648_MN5 (XI1648_n2 XI1648_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1648_MN4 (b24_14 XI1648_An XI1648_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1648_MN2 (XI1648_n1 dd14_b3_4 b24_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1648_MN3 (VSS qu8_b3_2 XI1648_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1648_MN0 (XI1648_An dd14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1649_MN1 (XI1649_Bn qu8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1649_MN5 (XI1649_n2 XI1649_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1649_MN4 (b24_15 XI1649_An XI1649_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1649_MN2 (XI1649_n1 dd15_b3_4 b24_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1649_MN3 (VSS qu8_b3_2 XI1649_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1649_MN0 (XI1649_An dd15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I215_MN1 (XI1620_I215_Bn I1620_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I215_MN5 (XI1620_I215_n2 XI1620_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I215_MN4 (p23_12 XI1620_I215_An XI1620_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I215_MN2 (XI1620_I215_n1 I1620_pn12 p23_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I215_MN3 (VSS I1620_G11_0n XI1620_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I215_MN0 (XI1620_I215_An I1620_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1602_MN1 (XI1602_Bn qu9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1602_MN5 (XI1602_n2 XI1602_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1602_MN4 (b23_14 XI1602_An XI1602_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1602_MN2 (XI1602_n1 dd14_b3_4 b23_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1602_MN3 (VSS qu9_b3_2 XI1602_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1602_MN0 (XI1602_An dd14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1555_MN1 (XI1555_Bn qu10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1555_MN5 (XI1555_n2 XI1555_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1555_MN4 (b22_13 XI1555_An XI1555_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1555_MN2 (XI1555_n1 dd13_b3_4 b22_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1555_MN3 (VSS qu10_b3_2 XI1555_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1555_MN0 (XI1555_An dd13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I215_MN1 (XI1574_I215_Bn I1574_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I215_MN5 (XI1574_I215_n2 XI1574_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I215_MN4 (p22_12 XI1574_I215_An XI1574_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I215_MN2 (XI1574_I215_n1 I1574_pn12 p22_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I215_MN3 (VSS I1574_G11_0n XI1574_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I215_MN0 (XI1574_I215_An I1574_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1066_MN1 (XI1066_Bn qu21_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1066_MN5 (XI1066_n2 XI1066_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1066_MN4 (b11_30 XI1066_An XI1066_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1066_MN2 (XI1066_n1 dd30_b3_2 b11_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1066_MN3 (VSS qu21_b3_5 XI1066_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1066_MN0 (XI1066_An dd30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1060_MN1 (XI1060_Bn qu21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1060_MN5 (XI1060_n2 XI1060_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1060_MN4 (b11_24 XI1060_An XI1060_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1060_MN2 (XI1060_n1 dd24_b3_2 b11_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1060_MN3 (VSS qu21_b3_4 XI1060_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1060_MN0 (XI1060_An dd24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1055_MN1 (XI1055_Bn qu21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1055_MN5 (XI1055_n2 XI1055_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1055_MN4 (b11_19 XI1055_An XI1055_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1055_MN2 (XI1055_n1 dd19_b3_2 b11_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1055_MN3 (VSS qu21_b3_3 XI1055_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1055_MN0 (XI1055_An dd19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I218_MN1 (XI1068_I218_Bn I1068_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I218_MN5 (XI1068_I218_n2 XI1068_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I218_MN4 (p11_15 XI1068_I218_An XI1068_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I218_MN2 (XI1068_I218_n1 I1068_pn15 p11_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I218_MN3 (VSS I1068_G14_0n XI1068_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I218_MN0 (XI1068_I218_An I1068_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1051_MN1 (XI1051_Bn qu21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1051_MN5 (XI1051_n2 XI1051_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1051_MN4 (b11_15 XI1051_An XI1051_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1051_MN2 (XI1051_n1 dd15_b3_2 b11_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1051_MN3 (VSS qu21_b3_2 XI1051_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1051_MN0 (XI1051_An dd15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1050_MN1 (XI1050_Bn qu21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1050_MN5 (XI1050_n2 XI1050_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1050_MN4 (b11_14 XI1050_An XI1050_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1050_MN2 (XI1050_n1 dd14_b3_2 b11_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1050_MN3 (VSS qu21_b3_2 XI1050_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1050_MN0 (XI1050_An dd14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1049_MN1 (XI1049_Bn qu21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1049_MN5 (XI1049_n2 XI1049_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1049_MN4 (b11_13 XI1049_An XI1049_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1049_MN2 (XI1049_n1 dd13_b3_2 b11_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1049_MN3 (VSS qu21_b3_2 XI1049_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1049_MN0 (XI1049_An dd13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I217_MN1 (XI1022_I217_Bn I1022_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I217_MN5 (XI1022_I217_n2 XI1022_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I217_MN4 (p10_14 XI1022_I217_An XI1022_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I217_MN2 (XI1022_I217_n1 I1022_pn14 p10_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I217_MN3 (VSS I1022_G13_0n XI1022_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I217_MN0 (XI1022_I217_An I1022_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I216_MN1 (XI1022_I216_Bn I1022_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I216_MN5 (XI1022_I216_n2 XI1022_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I216_MN4 (p10_13 XI1022_I216_An XI1022_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I216_MN2 (XI1022_I216_n1 I1022_pn13 p10_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I216_MN3 (VSS I1022_G12_0n XI1022_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I216_MN0 (XI1022_I216_An I1022_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1006_MN1 (XI1006_Bn qu22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1006_MN5 (XI1006_n2 XI1006_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1006_MN4 (b10_16 XI1006_An XI1006_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1006_MN2 (XI1006_n1 dd16_b3_1 b10_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1006_MN3 (VSS qu22_b3_2 XI1006_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1006_MN0 (XI1006_An dd16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1005_MN1 (XI1005_Bn qu22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1005_MN5 (XI1005_n2 XI1005_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1005_MN4 (b10_15 XI1005_An XI1005_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1005_MN2 (XI1005_n1 dd15_b3_1 b10_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1005_MN3 (VSS qu22_b3_2 XI1005_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1005_MN0 (XI1005_An dd15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1007_MN1 (XI1007_Bn qu22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1007_MN5 (XI1007_n2 XI1007_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1007_MN4 (b10_17 XI1007_An XI1007_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1007_MN2 (XI1007_n1 dd17_b3_1 b10_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1007_MN3 (VSS qu22_b3_2 XI1007_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1007_MN0 (XI1007_An dd17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I215_MN1 (XI976_I215_Bn I976_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I215_MN5 (XI976_I215_n2 XI976_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I215_MN4 (p9_12 XI976_I215_An XI976_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I215_MN2 (XI976_I215_n1 I976_pn12 p9_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I215_MN3 (VSS I976_G11_0n XI976_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I215_MN0 (XI976_I215_An I976_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI960_MN1 (XI960_Bn qu23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI960_MN5 (XI960_n2 XI960_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI960_MN4 (b9_16 XI960_An XI960_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI960_MN2 (XI960_n1 dd16_b3_1 b9_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI960_MN3 (VSS qu23_b3_2 XI960_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI960_MN0 (XI960_An dd16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI915_MN1 (XI915_Bn qu24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI915_MN5 (XI915_n2 XI915_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI915_MN4 (b8_17 XI915_An XI915_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI915_MN2 (XI915_n1 dd17_b3_1 b8_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI915_MN3 (VSS qu24_b3_2 XI915_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI915_MN0 (XI915_An dd17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I216_MN1 (XI930_I216_Bn I930_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I216_MN5 (XI930_I216_n2 XI930_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I216_MN4 (p8_13 XI930_I216_An XI930_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I216_MN2 (XI930_I216_n1 I930_pn13 p8_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I216_MN3 (VSS I930_G12_0n XI930_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I216_MN0 (XI930_I216_An I930_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I215_MN1 (XI930_I215_Bn I930_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I215_MN5 (XI930_I215_n2 XI930_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I215_MN4 (p8_12 XI930_I215_An XI930_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I215_MN2 (XI930_I215_n1 I930_pn12 p8_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I215_MN3 (VSS I930_G11_0n XI930_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I215_MN0 (XI930_I215_An I930_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I218_MN1 (XI1666_I218_Bn I1666_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I218_MN5 (XI1666_I218_n2 XI1666_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I218_MN4 (p24_15 XI1666_I218_An XI1666_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I218_MN2 (XI1666_I218_n1 I1666_pn15 p24_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I218_MN3 (VSS I1666_G14_0n XI1666_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I218_MN0 (XI1666_I218_An I1666_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I217_MN1 (XI1666_I217_Bn I1666_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I217_MN5 (XI1666_I217_n2 XI1666_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I217_MN4 (p24_14 XI1666_I217_An XI1666_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I217_MN2 (XI1666_I217_n1 I1666_pn14 p24_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I217_MN3 (VSS I1666_G13_0n XI1666_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I217_MN0 (XI1666_I217_An I1666_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I219_MN1 (XI1666_I219_Bn I1666_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I219_MN5 (XI1666_I219_n2 XI1666_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I219_MN4 (p24_16 XI1666_I219_An XI1666_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I219_MN2 (XI1666_I219_n1 I1666_pn16 p24_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I219_MN3 (VSS I1666_G15_0n XI1666_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I219_MN0 (XI1666_I219_An I1666_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1650_MN1 (XI1650_Bn qu8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1650_MN5 (XI1650_n2 XI1650_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1650_MN4 (b24_16 XI1650_An XI1650_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1650_MN2 (XI1650_n1 dd16_b3_4 b24_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1650_MN3 (VSS qu8_b3_2 XI1650_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1650_MN0 (XI1650_An dd16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1651_MN1 (XI1651_Bn qu8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1651_MN5 (XI1651_n2 XI1651_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1651_MN4 (b24_17 XI1651_An XI1651_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1651_MN2 (XI1651_n1 dd17_b3_4 b24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1651_MN3 (VSS qu8_b3_2 XI1651_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1651_MN0 (XI1651_An dd17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I217_MN1 (XI1620_I217_Bn I1620_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I217_MN5 (XI1620_I217_n2 XI1620_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I217_MN4 (p23_14 XI1620_I217_An XI1620_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I217_MN2 (XI1620_I217_n1 I1620_pn14 p23_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I217_MN3 (VSS I1620_G13_0n XI1620_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I217_MN0 (XI1620_I217_An I1620_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I216_MN1 (XI1620_I216_Bn I1620_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I216_MN5 (XI1620_I216_n2 XI1620_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I216_MN4 (p23_13 XI1620_I216_An XI1620_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I216_MN2 (XI1620_I216_n1 I1620_pn13 p23_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I216_MN3 (VSS I1620_G12_0n XI1620_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I216_MN0 (XI1620_I216_An I1620_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1603_MN1 (XI1603_Bn qu9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1603_MN5 (XI1603_n2 XI1603_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1603_MN4 (b23_15 XI1603_An XI1603_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1603_MN2 (XI1603_n1 dd15_b3_4 b23_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1603_MN3 (VSS qu9_b3_2 XI1603_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1603_MN0 (XI1603_An dd15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1604_MN1 (XI1604_Bn qu9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1604_MN5 (XI1604_n2 XI1604_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1604_MN4 (b23_16 XI1604_An XI1604_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1604_MN2 (XI1604_n1 dd16_b3_4 b23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1604_MN3 (VSS qu9_b3_2 XI1604_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1604_MN0 (XI1604_An dd16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1557_MN1 (XI1557_Bn qu10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1557_MN5 (XI1557_n2 XI1557_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1557_MN4 (b22_15 XI1557_An XI1557_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1557_MN2 (XI1557_n1 dd15_b3_4 b22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1557_MN3 (VSS qu10_b3_2 XI1557_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1557_MN0 (XI1557_An dd15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1558_MN1 (XI1558_Bn qu10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1558_MN5 (XI1558_n2 XI1558_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1558_MN4 (b22_16 XI1558_An XI1558_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1558_MN2 (XI1558_n1 dd16_b3_4 b22_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1558_MN3 (VSS qu10_b3_2 XI1558_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1558_MN0 (XI1558_An dd16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1556_MN1 (XI1556_Bn qu10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1556_MN5 (XI1556_n2 XI1556_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1556_MN4 (b22_14 XI1556_An XI1556_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1556_MN2 (XI1556_n1 dd14_b3_4 b22_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1556_MN3 (VSS qu10_b3_2 XI1556_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1556_MN0 (XI1556_An dd14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I217_MN1 (XI1574_I217_Bn I1574_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I217_MN5 (XI1574_I217_n2 XI1574_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I217_MN4 (p22_14 XI1574_I217_An XI1574_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I217_MN2 (XI1574_I217_n1 I1574_pn14 p22_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I217_MN3 (VSS I1574_G13_0n XI1574_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I217_MN0 (XI1574_I217_An I1574_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I216_MN1 (XI1574_I216_Bn I1574_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I216_MN5 (XI1574_I216_n2 XI1574_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I216_MN4 (p22_13 XI1574_I216_An XI1574_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I216_MN2 (XI1574_I216_n1 I1574_pn13 p22_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I216_MN3 (VSS I1574_G12_0n XI1574_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I216_MN0 (XI1574_I216_An I1574_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1109_MN1 (XI1109_Bn qu20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1109_MN5 (XI1109_n2 XI1109_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1109_MN4 (b12_27 XI1109_An XI1109_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1109_MN2 (XI1109_n1 dd27_b3_2 b12_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1109_MN3 (VSS qu20_b3_4 XI1109_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1109_MN0 (XI1109_An dd27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1067_MN1 (XI1067_Bn qu21_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1067_MN5 (XI1067_n2 XI1067_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1067_MN4 (b11_31 XI1067_An XI1067_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1067_MN2 (XI1067_n1 dd31_b3_2 b11_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1067_MN3 (VSS qu21_b3_5 XI1067_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1067_MN0 (XI1067_An dd31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1108_MN1 (XI1108_Bn qu20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1108_MN5 (XI1108_n2 XI1108_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1108_MN4 (b12_26 XI1108_An XI1108_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1108_MN2 (XI1108_n1 dd26_b3_2 b12_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1108_MN3 (VSS qu20_b3_4 XI1108_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1108_MN0 (XI1108_An dd26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1059_MN1 (XI1059_Bn qu21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1059_MN5 (XI1059_n2 XI1059_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1059_MN4 (b11_23 XI1059_An XI1059_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1059_MN2 (XI1059_n1 dd23_b3_2 b11_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1059_MN3 (VSS qu21_b3_3 XI1059_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1059_MN0 (XI1059_An dd23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1057_MN1 (XI1057_Bn qu21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1057_MN5 (XI1057_n2 XI1057_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1057_MN4 (b11_21 XI1057_An XI1057_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1057_MN2 (XI1057_n1 dd21_b3_2 b11_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1057_MN3 (VSS qu21_b3_3 XI1057_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1057_MN0 (XI1057_An dd21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1058_MN1 (XI1058_Bn qu21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1058_MN5 (XI1058_n2 XI1058_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1058_MN4 (b11_22 XI1058_An XI1058_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1058_MN2 (XI1058_n1 dd22_b3_2 b11_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1058_MN3 (VSS qu21_b3_3 XI1058_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1058_MN0 (XI1058_An dd22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1101_MN1 (XI1101_Bn qu20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1101_MN5 (XI1101_n2 XI1101_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1101_MN4 (b12_19 XI1101_An XI1101_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1101_MN2 (XI1101_n1 dd19_b3_2 b12_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1101_MN3 (VSS qu20_b3_3 XI1101_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1101_MN0 (XI1101_An dd19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1054_MN1 (XI1054_Bn qu21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1054_MN5 (XI1054_n2 XI1054_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1054_MN4 (b11_18 XI1054_An XI1054_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1054_MN2 (XI1054_n1 dd18_b3_2 b11_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1054_MN3 (VSS qu21_b3_3 XI1054_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1054_MN0 (XI1054_An dd18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1056_MN1 (XI1056_Bn qu21_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1056_MN5 (XI1056_n2 XI1056_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1056_MN4 (b11_20 XI1056_An XI1056_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1056_MN2 (XI1056_n1 dd20_b3_2 b11_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1056_MN3 (VSS qu21_b3_3 XI1056_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1056_MN0 (XI1056_An dd20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1100_MN1 (XI1100_Bn qu20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1100_MN5 (XI1100_n2 XI1100_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1100_MN4 (b12_18 XI1100_An XI1100_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1100_MN2 (XI1100_n1 dd18_b3_2 b12_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1100_MN3 (VSS qu20_b3_3 XI1100_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1100_MN0 (XI1100_An dd18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I219_MN1 (XI1068_I219_Bn I1068_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I219_MN5 (XI1068_I219_n2 XI1068_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I219_MN4 (p11_16 XI1068_I219_An XI1068_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I219_MN2 (XI1068_I219_n1 I1068_pn16 p11_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I219_MN3 (VSS I1068_G15_0n XI1068_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I219_MN0 (XI1068_I219_An I1068_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1052_MN1 (XI1052_Bn qu21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1052_MN5 (XI1052_n2 XI1052_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1052_MN4 (b11_16 XI1052_An XI1052_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1052_MN2 (XI1052_n1 dd16_b3_2 b11_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1052_MN3 (VSS qu21_b3_2 XI1052_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1052_MN0 (XI1052_An dd16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1096_MN1 (XI1096_Bn qu20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1096_MN5 (XI1096_n2 XI1096_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1096_MN4 (b12_14 XI1096_An XI1096_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1096_MN2 (XI1096_n1 dd14_b3_2 b12_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1096_MN3 (VSS qu20_b3_2 XI1096_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1096_MN0 (XI1096_An dd14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1053_MN1 (XI1053_Bn qu21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1053_MN5 (XI1053_n2 XI1053_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1053_MN4 (b11_17 XI1053_An XI1053_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1053_MN2 (XI1053_n1 dd17_b3_2 b11_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1053_MN3 (VSS qu21_b3_2 XI1053_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1053_MN0 (XI1053_An dd17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1070_MN1 (XI1070_Bn c11_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1070_MN5 (XI1070_n2 XI1070_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1070_MN4 (p11_32 XI1070_An XI1070_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1070_MN2 (XI1070_n1 h11 p11_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1070_MN3 (VSS c11_o XI1070_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1070_MN0 (XI1070_An h11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I219_MN1 (XI1022_I219_Bn I1022_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I219_MN5 (XI1022_I219_n2 XI1022_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I219_MN4 (p10_16 XI1022_I219_An XI1022_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I219_MN2 (XI1022_I219_n1 I1022_pn16 p10_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I219_MN3 (VSS I1022_G15_0n XI1022_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I219_MN0 (XI1022_I219_An I1022_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I218_MN1 (XI1022_I218_Bn I1022_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I218_MN5 (XI1022_I218_n2 XI1022_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1022_I218_MN4 (p10_15 XI1022_I218_An XI1022_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I218_MN2 (XI1022_I218_n1 I1022_pn15 p10_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1022_I218_MN3 (VSS I1022_G14_0n XI1022_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I218_MN0 (XI1022_I218_An I1022_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I218_MN1 (XI976_I218_Bn I976_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I218_MN5 (XI976_I218_n2 XI976_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I218_MN4 (p9_15 XI976_I218_An XI976_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I218_MN2 (XI976_I218_n1 I976_pn15 p9_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I218_MN3 (VSS I976_G14_0n XI976_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I218_MN0 (XI976_I218_An I976_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I216_MN1 (XI976_I216_Bn I976_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I216_MN5 (XI976_I216_n2 XI976_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I216_MN4 (p9_13 XI976_I216_An XI976_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I216_MN2 (XI976_I216_n1 I976_pn13 p9_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I216_MN3 (VSS I976_G12_0n XI976_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I216_MN0 (XI976_I216_An I976_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I217_MN1 (XI976_I217_Bn I976_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I217_MN5 (XI976_I217_n2 XI976_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I217_MN4 (p9_14 XI976_I217_An XI976_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I217_MN2 (XI976_I217_n1 I976_pn14 p9_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I217_MN3 (VSS I976_G13_0n XI976_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I217_MN0 (XI976_I217_An I976_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I219_MN1 (XI930_I219_Bn I930_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I219_MN5 (XI930_I219_n2 XI930_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I219_MN4 (p8_16 XI930_I219_An XI930_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I219_MN2 (XI930_I219_n1 I930_pn16 p8_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I219_MN3 (VSS I930_G15_0n XI930_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I219_MN0 (XI930_I219_An I930_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I217_MN1 (XI930_I217_Bn I930_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I217_MN5 (XI930_I217_n2 XI930_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I217_MN4 (p8_14 XI930_I217_An XI930_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I217_MN2 (XI930_I217_n1 I930_pn14 p8_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I217_MN3 (VSS I930_G13_0n XI930_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I217_MN0 (XI930_I217_An I930_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1652_MN1 (XI1652_Bn qu8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1652_MN5 (XI1652_n2 XI1652_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1652_MN4 (b24_18 XI1652_An XI1652_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1652_MN2 (XI1652_n1 dd18_b3_4 b24_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1652_MN3 (VSS qu8_b3_3 XI1652_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1652_MN0 (XI1652_An dd18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I218_MN1 (XI1620_I218_Bn I1620_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I218_MN5 (XI1620_I218_n2 XI1620_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I218_MN4 (p23_15 XI1620_I218_An XI1620_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I218_MN2 (XI1620_I218_n1 I1620_pn15 p23_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I218_MN3 (VSS I1620_G14_0n XI1620_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I218_MN0 (XI1620_I218_An I1620_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1605_MN1 (XI1605_Bn qu9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1605_MN5 (XI1605_n2 XI1605_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1605_MN4 (b23_17 XI1605_An XI1605_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1605_MN2 (XI1605_n1 dd17_b3_4 b23_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1605_MN3 (VSS qu9_b3_2 XI1605_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1605_MN0 (XI1605_An dd17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1559_MN1 (XI1559_Bn qu10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1559_MN5 (XI1559_n2 XI1559_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1559_MN4 (b22_17 XI1559_An XI1559_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1559_MN2 (XI1559_n1 dd17_b3_4 b22_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1559_MN3 (VSS qu10_b3_2 XI1559_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1559_MN0 (XI1559_An dd17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I219_MN1 (XI1574_I219_Bn I1574_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I219_MN5 (XI1574_I219_n2 XI1574_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I219_MN4 (p22_16 XI1574_I219_An XI1574_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I219_MN2 (XI1574_I219_n1 I1574_pn16 p22_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I219_MN3 (VSS I1574_G15_0n XI1574_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I219_MN0 (XI1574_I219_An I1574_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I218_MN1 (XI1574_I218_Bn I1574_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I218_MN5 (XI1574_I218_n2 XI1574_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I218_MN4 (p22_15 XI1574_I218_An XI1574_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I218_MN2 (XI1574_I218_n1 I1574_pn15 p22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I218_MN3 (VSS I1574_G14_0n XI1574_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I218_MN0 (XI1574_I218_An I1574_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1110_MN1 (XI1110_Bn qu20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1110_MN5 (XI1110_n2 XI1110_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1110_MN4 (b12_28 XI1110_An XI1110_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1110_MN2 (XI1110_n1 dd28_b3_2 b12_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1110_MN3 (VSS qu20_b3_4 XI1110_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1110_MN0 (XI1110_An dd28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1107_MN1 (XI1107_Bn qu20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1107_MN5 (XI1107_n2 XI1107_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1107_MN4 (b12_25 XI1107_An XI1107_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1107_MN2 (XI1107_n1 dd25_b3_2 b12_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1107_MN3 (VSS qu20_b3_4 XI1107_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1107_MN0 (XI1107_An dd25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1103_MN1 (XI1103_Bn qu20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1103_MN5 (XI1103_n2 XI1103_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1103_MN4 (b12_21 XI1103_An XI1103_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1103_MN2 (XI1103_n1 dd21_b3_2 b12_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1103_MN3 (VSS qu20_b3_3 XI1103_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1103_MN0 (XI1103_An dd21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1104_MN1 (XI1104_Bn qu20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1104_MN5 (XI1104_n2 XI1104_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1104_MN4 (b12_22 XI1104_An XI1104_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1104_MN2 (XI1104_n1 dd22_b3_2 b12_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1104_MN3 (VSS qu20_b3_3 XI1104_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1104_MN0 (XI1104_An dd22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1094_MN1 (XI1094_Bn qu20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1094_MN5 (XI1094_n2 XI1094_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1094_MN4 (b12_12 XI1094_An XI1094_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1094_MN2 (XI1094_n1 dd12_b3_2 b12_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1094_MN3 (VSS qu20_b3_2 XI1094_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1094_MN0 (XI1094_An dd12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1098_MN1 (XI1098_Bn qu20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1098_MN5 (XI1098_n2 XI1098_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1098_MN4 (b12_16 XI1098_An XI1098_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1098_MN2 (XI1098_n1 dd16_b3_2 b12_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1098_MN3 (VSS qu20_b3_2 XI1098_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1098_MN0 (XI1098_An dd16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1097_MN1 (XI1097_Bn qu20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1097_MN5 (XI1097_n2 XI1097_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1097_MN4 (b12_15 XI1097_An XI1097_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1097_MN2 (XI1097_n1 dd15_b3_2 b12_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1097_MN3 (VSS qu20_b3_2 XI1097_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1097_MN0 (XI1097_An dd15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1095_MN1 (XI1095_Bn qu20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1095_MN5 (XI1095_n2 XI1095_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1095_MN4 (b12_13 XI1095_An XI1095_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1095_MN2 (XI1095_n1 dd13_b3_2 b12_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1095_MN3 (VSS qu20_b3_2 XI1095_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1095_MN0 (XI1095_An dd13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1069_MN1 (XI1069_Bn qu21_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1069_MN5 (XI1069_n2 XI1069_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1069_MN4 (h11 XI1069_An XI1069_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1069_MN2 (XI1069_n1 p10_31 h11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1069_MN3 (VSS qu21_b3_5 XI1069_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1069_MN0 (XI1069_An p10_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1009_MN1 (XI1009_Bn qu22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1009_MN5 (XI1009_n2 XI1009_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1009_MN4 (b10_19 XI1009_An XI1009_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1009_MN2 (XI1009_n1 dd19_b3_1 b10_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1009_MN3 (VSS qu22_b3_3 XI1009_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1009_MN0 (XI1009_An dd19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1008_MN1 (XI1008_Bn qu22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1008_MN5 (XI1008_n2 XI1008_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1008_MN4 (b10_18 XI1008_An XI1008_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1008_MN2 (XI1008_n1 dd18_b3_1 b10_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1008_MN3 (VSS qu22_b3_3 XI1008_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1008_MN0 (XI1008_An dd18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I219_MN1 (XI976_I219_Bn I976_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I219_MN5 (XI976_I219_n2 XI976_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI976_I219_MN4 (p9_16 XI976_I219_An XI976_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I219_MN2 (XI976_I219_n1 I976_pn16 p9_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI976_I219_MN3 (VSS I976_G15_0n XI976_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I219_MN0 (XI976_I219_An I976_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI963_MN1 (XI963_Bn qu23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI963_MN5 (XI963_n2 XI963_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI963_MN4 (b9_19 XI963_An XI963_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI963_MN2 (XI963_n1 dd19_b3_1 b9_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI963_MN3 (VSS qu23_b3_3 XI963_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI963_MN0 (XI963_An dd19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI962_MN1 (XI962_Bn qu23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI962_MN5 (XI962_n2 XI962_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI962_MN4 (b9_18 XI962_An XI962_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI962_MN2 (XI962_n1 dd18_b3_1 b9_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI962_MN3 (VSS qu23_b3_3 XI962_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI962_MN0 (XI962_An dd18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI916_MN1 (XI916_Bn qu24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI916_MN5 (XI916_n2 XI916_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI916_MN4 (b8_18 XI916_An XI916_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI916_MN2 (XI916_n1 dd18_b3_1 b8_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI916_MN3 (VSS qu24_b3_3 XI916_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI916_MN0 (XI916_An dd18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI917_MN1 (XI917_Bn qu24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI917_MN5 (XI917_n2 XI917_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI917_MN4 (b8_19 XI917_An XI917_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI917_MN2 (XI917_n1 dd19_b3_1 b8_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI917_MN3 (VSS qu24_b3_3 XI917_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI917_MN0 (XI917_An dd19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I218_MN1 (XI930_I218_Bn I930_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I218_MN5 (XI930_I218_n2 XI930_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI930_I218_MN4 (p8_15 XI930_I218_An XI930_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I218_MN2 (XI930_I218_n1 I930_pn15 p8_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI930_I218_MN3 (VSS I930_G14_0n XI930_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I218_MN0 (XI930_I218_An I930_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1653_MN1 (XI1653_Bn qu8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1653_MN5 (XI1653_n2 XI1653_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1653_MN4 (b24_19 XI1653_An XI1653_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1653_MN2 (XI1653_n1 dd19_b3_4 b24_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1653_MN3 (VSS qu8_b3_3 XI1653_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1653_MN0 (XI1653_An dd19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I219_MN1 (XI1620_I219_Bn I1620_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I219_MN5 (XI1620_I219_n2 XI1620_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1620_I219_MN4 (p23_16 XI1620_I219_An XI1620_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I219_MN2 (XI1620_I219_n1 I1620_pn16 p23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1620_I219_MN3 (VSS I1620_G15_0n XI1620_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I219_MN0 (XI1620_I219_An I1620_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1608_MN1 (XI1608_Bn qu9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1608_MN5 (XI1608_n2 XI1608_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1608_MN4 (b23_20 XI1608_An XI1608_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1608_MN2 (XI1608_n1 dd20_b3_4 b23_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1608_MN3 (VSS qu9_b3_3 XI1608_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1608_MN0 (XI1608_An dd20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1607_MN1 (XI1607_Bn qu9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1607_MN5 (XI1607_n2 XI1607_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1607_MN4 (b23_19 XI1607_An XI1607_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1607_MN2 (XI1607_n1 dd19_b3_4 b23_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1607_MN3 (VSS qu9_b3_3 XI1607_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1607_MN0 (XI1607_An dd19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1606_MN1 (XI1606_Bn qu9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1606_MN5 (XI1606_n2 XI1606_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1606_MN4 (b23_18 XI1606_An XI1606_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1606_MN2 (XI1606_n1 dd18_b3_4 b23_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1606_MN3 (VSS qu9_b3_3 XI1606_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1606_MN0 (XI1606_An dd18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1560_MN1 (XI1560_Bn qu10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1560_MN5 (XI1560_n2 XI1560_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1560_MN4 (b22_18 XI1560_An XI1560_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1560_MN2 (XI1560_n1 dd18_b3_4 b22_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1560_MN3 (VSS qu10_b3_3 XI1560_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1560_MN0 (XI1560_An dd18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1561_MN1 (XI1561_Bn qu10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1561_MN5 (XI1561_n2 XI1561_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1561_MN4 (b22_19 XI1561_An XI1561_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1561_MN2 (XI1561_n1 dd19_b3_4 b22_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1561_MN3 (VSS qu10_b3_3 XI1561_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1561_MN0 (XI1561_An dd19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1111_MN1 (XI1111_Bn qu20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1111_MN5 (XI1111_n2 XI1111_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1111_MN4 (b12_29 XI1111_An XI1111_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1111_MN2 (XI1111_n1 dd29_b3_2 b12_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1111_MN3 (VSS qu20_b3_4 XI1111_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1111_MN0 (XI1111_An dd29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1106_MN1 (XI1106_Bn qu20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1106_MN5 (XI1106_n2 XI1106_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1106_MN4 (b12_24 XI1106_An XI1106_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1106_MN2 (XI1106_n1 dd24_b3_2 b12_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1106_MN3 (VSS qu20_b3_4 XI1106_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1106_MN0 (XI1106_An dd24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1105_MN1 (XI1105_Bn qu20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1105_MN5 (XI1105_n2 XI1105_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1105_MN4 (b12_23 XI1105_An XI1105_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1105_MN2 (XI1105_n1 dd23_b3_2 b12_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1105_MN3 (VSS qu20_b3_3 XI1105_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1105_MN0 (XI1105_An dd23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1102_MN1 (XI1102_Bn qu20_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1102_MN5 (XI1102_n2 XI1102_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1102_MN4 (b12_20 XI1102_An XI1102_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1102_MN2 (XI1102_n1 dd20_b3_2 b12_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1102_MN3 (VSS qu20_b3_3 XI1102_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1102_MN0 (XI1102_An dd20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1099_MN1 (XI1099_Bn qu20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1099_MN5 (XI1099_n2 XI1099_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1099_MN4 (b12_17 XI1099_An XI1099_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1099_MN2 (XI1099_n1 dd17_b3_2 b12_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1099_MN3 (VSS qu20_b3_2 XI1099_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1099_MN0 (XI1099_An dd17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1090_MN1 (XI1090_Bn qu20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1090_MN5 (XI1090_n2 XI1090_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1090_MN4 (b12_8 XI1090_An XI1090_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1090_MN2 (XI1090_n1 dd8_b3_2 b12_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1090_MN3 (VSS qu20_b3_1 XI1090_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1090_MN0 (XI1090_An dd8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1010_MN1 (XI1010_Bn qu22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1010_MN5 (XI1010_n2 XI1010_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1010_MN4 (b10_20 XI1010_An XI1010_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1010_MN2 (XI1010_n1 dd20_b3_1 b10_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1010_MN3 (VSS qu22_b3_3 XI1010_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1010_MN0 (XI1010_An dd20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1011_MN1 (XI1011_Bn qu22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1011_MN5 (XI1011_n2 XI1011_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1011_MN4 (b10_21 XI1011_An XI1011_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1011_MN2 (XI1011_n1 dd21_b3_1 b10_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1011_MN3 (VSS qu22_b3_3 XI1011_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1011_MN0 (XI1011_An dd21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI964_MN1 (XI964_Bn qu23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI964_MN5 (XI964_n2 XI964_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI964_MN4 (b9_20 XI964_An XI964_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI964_MN2 (XI964_n1 dd20_b3_1 b9_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI964_MN3 (VSS qu23_b3_3 XI964_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI964_MN0 (XI964_An dd20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI965_MN1 (XI965_Bn qu23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI965_MN5 (XI965_n2 XI965_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI965_MN4 (b9_21 XI965_An XI965_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI965_MN2 (XI965_n1 dd21_b3_1 b9_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI965_MN3 (VSS qu23_b3_3 XI965_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI965_MN0 (XI965_An dd21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI918_MN1 (XI918_Bn qu24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI918_MN5 (XI918_n2 XI918_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI918_MN4 (b8_20 XI918_An XI918_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI918_MN2 (XI918_n1 dd20_b3_1 b8_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI918_MN3 (VSS qu24_b3_3 XI918_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI918_MN0 (XI918_An dd20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI919_MN1 (XI919_Bn qu24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI919_MN5 (XI919_n2 XI919_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI919_MN4 (b8_21 XI919_An XI919_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI919_MN2 (XI919_n1 dd21_b3_1 b8_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI919_MN3 (VSS qu24_b3_3 XI919_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI919_MN0 (XI919_An dd21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1655_MN1 (XI1655_Bn qu8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1655_MN5 (XI1655_n2 XI1655_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1655_MN4 (b24_21 XI1655_An XI1655_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1655_MN2 (XI1655_n1 dd21_b3_4 b24_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1655_MN3 (VSS qu8_b3_3 XI1655_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1655_MN0 (XI1655_An dd21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1654_MN1 (XI1654_Bn qu8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1654_MN5 (XI1654_n2 XI1654_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1654_MN4 (b24_20 XI1654_An XI1654_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1654_MN2 (XI1654_n1 dd20_b3_4 b24_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1654_MN3 (VSS qu8_b3_3 XI1654_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1654_MN0 (XI1654_An dd20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1609_MN1 (XI1609_Bn qu9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1609_MN5 (XI1609_n2 XI1609_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1609_MN4 (b23_21 XI1609_An XI1609_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1609_MN2 (XI1609_n1 dd21_b3_4 b23_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1609_MN3 (VSS qu9_b3_3 XI1609_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1609_MN0 (XI1609_An dd21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1563_MN1 (XI1563_Bn qu10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1563_MN5 (XI1563_n2 XI1563_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1563_MN4 (b22_21 XI1563_An XI1563_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1563_MN2 (XI1563_n1 dd21_b3_4 b22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1563_MN3 (VSS qu10_b3_3 XI1563_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1563_MN0 (XI1563_An dd21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1562_MN1 (XI1562_Bn qu10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1562_MN5 (XI1562_n2 XI1562_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1562_MN4 (b22_20 XI1562_An XI1562_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1562_MN2 (XI1562_n1 dd20_b3_4 b22_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1562_MN3 (VSS qu10_b3_3 XI1562_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1562_MN0 (XI1562_An dd20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1091_MN1 (XI1091_Bn qu20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1091_MN5 (XI1091_n2 XI1091_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1091_MN4 (b12_9 XI1091_An XI1091_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1091_MN2 (XI1091_n1 dd9_b3_2 b12_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1091_MN3 (VSS qu20_b3_1 XI1091_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1091_MN0 (XI1091_An dd9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1092_MN1 (XI1092_Bn qu20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1092_MN5 (XI1092_n2 XI1092_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1092_MN4 (b12_10 XI1092_An XI1092_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1092_MN2 (XI1092_n1 dd10_b3_2 b12_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1092_MN3 (VSS qu20_b3_1 XI1092_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1092_MN0 (XI1092_An dd10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1089_MN1 (XI1089_Bn qu20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1089_MN5 (XI1089_n2 XI1089_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1089_MN4 (b12_7 XI1089_An XI1089_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1089_MN2 (XI1089_n1 dd7_b3_2 b12_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1089_MN3 (VSS qu20_b3_1 XI1089_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1089_MN0 (XI1089_An dd7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1093_MN1 (XI1093_Bn qu20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1093_MN5 (XI1093_n2 XI1093_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1093_MN4 (b12_11 XI1093_An XI1093_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1093_MN2 (XI1093_n1 dd11_b3_2 b12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1093_MN3 (VSS qu20_b3_1 XI1093_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1093_MN0 (XI1093_An dd11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1012_MN1 (XI1012_Bn qu22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1012_MN5 (XI1012_n2 XI1012_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1012_MN4 (b10_22 XI1012_An XI1012_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1012_MN2 (XI1012_n1 dd22_b3_1 b10_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1012_MN3 (VSS qu22_b3_3 XI1012_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1012_MN0 (XI1012_An dd22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI966_MN1 (XI966_Bn qu23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI966_MN5 (XI966_n2 XI966_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI966_MN4 (b9_22 XI966_An XI966_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI966_MN2 (XI966_n1 dd22_b3_1 b9_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI966_MN3 (VSS qu23_b3_3 XI966_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI966_MN0 (XI966_An dd22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI920_MN1 (XI920_Bn qu24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI920_MN5 (XI920_n2 XI920_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI920_MN4 (b8_22 XI920_An XI920_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI920_MN2 (XI920_n1 dd22_b3_1 b8_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI920_MN3 (VSS qu24_b3_3 XI920_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI920_MN0 (XI920_An dd22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI921_MN1 (XI921_Bn qu24_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI921_MN5 (XI921_n2 XI921_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI921_MN4 (b8_23 XI921_An XI921_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI921_MN2 (XI921_n1 dd23_b3_1 b8_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI921_MN3 (VSS qu24_b3_3 XI921_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI921_MN0 (XI921_An dd23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1656_MN1 (XI1656_Bn qu8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1656_MN5 (XI1656_n2 XI1656_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1656_MN4 (b24_22 XI1656_An XI1656_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1656_MN2 (XI1656_n1 dd22_b3_4 b24_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1656_MN3 (VSS qu8_b3_3 XI1656_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1656_MN0 (XI1656_An dd22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1657_MN1 (XI1657_Bn qu8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1657_MN5 (XI1657_n2 XI1657_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1657_MN4 (b24_23 XI1657_An XI1657_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1657_MN2 (XI1657_n1 dd23_b3_4 b24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1657_MN3 (VSS qu8_b3_3 XI1657_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1657_MN0 (XI1657_An dd23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1611_MN1 (XI1611_Bn qu9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1611_MN5 (XI1611_n2 XI1611_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1611_MN4 (b23_23 XI1611_An XI1611_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1611_MN2 (XI1611_n1 dd23_b3_4 b23_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1611_MN3 (VSS qu9_b3_3 XI1611_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1611_MN0 (XI1611_An dd23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1610_MN1 (XI1610_Bn qu9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1610_MN5 (XI1610_n2 XI1610_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1610_MN4 (b23_22 XI1610_An XI1610_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1610_MN2 (XI1610_n1 dd22_b3_4 b23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1610_MN3 (VSS qu9_b3_3 XI1610_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1610_MN0 (XI1610_An dd22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1564_MN1 (XI1564_Bn qu10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1564_MN5 (XI1564_n2 XI1564_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1564_MN4 (b22_22 XI1564_An XI1564_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1564_MN2 (XI1564_n1 dd22_b3_4 b22_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1564_MN3 (VSS qu10_b3_3 XI1564_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1564_MN0 (XI1564_An dd22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1565_MN1 (XI1565_Bn qu10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1565_MN5 (XI1565_n2 XI1565_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1565_MN4 (b22_23 XI1565_An XI1565_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1565_MN2 (XI1565_n1 dd23_b3_4 b22_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1565_MN3 (VSS qu10_b3_3 XI1565_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1565_MN0 (XI1565_An dd23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1112_MN1 (XI1112_Bn qu20_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1112_MN5 (XI1112_n2 XI1112_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1112_MN4 (b12_30 XI1112_An XI1112_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1112_MN2 (XI1112_n1 dd30_b3_2 b12_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1112_MN3 (VSS qu20_b3_5 XI1112_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1112_MN0 (XI1112_An dd30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1088_MN1 (XI1088_Bn qu20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1088_MN5 (XI1088_n2 XI1088_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1088_MN4 (b12_6 XI1088_An XI1088_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1088_MN2 (XI1088_n1 dd6_b3_2 b12_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1088_MN3 (VSS qu20_b3_1 XI1088_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1088_MN0 (XI1088_An dd6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1087_MN1 (XI1087_Bn qu20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1087_MN5 (XI1087_n2 XI1087_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1087_MN4 (b12_5 XI1087_An XI1087_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1087_MN2 (XI1087_n1 dd5_b3_2 b12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1087_MN3 (VSS qu20_b3_0 XI1087_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1087_MN0 (XI1087_An dd5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1024_MN1 (XI1024_Bn c10_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1024_MN5 (XI1024_n2 XI1024_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1024_MN4 (p10_32 XI1024_An XI1024_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1024_MN2 (XI1024_n1 h10 p10_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1024_MN3 (VSS c10_o XI1024_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1024_MN0 (XI1024_An h10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1013_MN1 (XI1013_Bn qu22_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1013_MN5 (XI1013_n2 XI1013_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1013_MN4 (b10_23 XI1013_An XI1013_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1013_MN2 (XI1013_n1 dd23_b3_1 b10_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1013_MN3 (VSS qu22_b3_3 XI1013_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1013_MN0 (XI1013_An dd23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1014_MN1 (XI1014_Bn qu22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1014_MN5 (XI1014_n2 XI1014_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1014_MN4 (b10_24 XI1014_An XI1014_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1014_MN2 (XI1014_n1 dd24_b3_1 b10_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1014_MN3 (VSS qu22_b3_4 XI1014_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1014_MN0 (XI1014_An dd24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI967_MN1 (XI967_Bn qu23_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI967_MN5 (XI967_n2 XI967_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI967_MN4 (b9_23 XI967_An XI967_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI967_MN2 (XI967_n1 dd23_b3_1 b9_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI967_MN3 (VSS qu23_b3_3 XI967_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI967_MN0 (XI967_An dd23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI969_MN1 (XI969_Bn qu23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI969_MN5 (XI969_n2 XI969_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI969_MN4 (b9_25 XI969_An XI969_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI969_MN2 (XI969_n1 dd25_b3_1 b9_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI969_MN3 (VSS qu23_b3_4 XI969_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI969_MN0 (XI969_An dd25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI922_MN1 (XI922_Bn qu24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI922_MN5 (XI922_n2 XI922_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI922_MN4 (b8_24 XI922_An XI922_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI922_MN2 (XI922_n1 dd24_b3_1 b8_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI922_MN3 (VSS qu24_b3_4 XI922_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI922_MN0 (XI922_An dd24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1658_MN1 (XI1658_Bn qu8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1658_MN5 (XI1658_n2 XI1658_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1658_MN4 (b24_24 XI1658_An XI1658_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1658_MN2 (XI1658_n1 dd24_b3_4 b24_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1658_MN3 (VSS qu8_b3_4 XI1658_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1658_MN0 (XI1658_An dd24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1668_MN1 (XI1668_Bn c24_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1668_MN5 (XI1668_n2 XI1668_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1668_MN4 (p24_32 XI1668_An XI1668_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1668_MN2 (XI1668_n1 h24 p24_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1668_MN3 (VSS c24_o XI1668_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1668_MN0 (XI1668_An h24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1612_MN1 (XI1612_Bn qu9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1612_MN5 (XI1612_n2 XI1612_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1612_MN4 (b23_24 XI1612_An XI1612_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1612_MN2 (XI1612_n1 dd24_b3_4 b23_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1612_MN3 (VSS qu9_b3_4 XI1612_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1612_MN0 (XI1612_An dd24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1576_MN1 (XI1576_Bn c22_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1576_MN5 (XI1576_n2 XI1576_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1576_MN4 (p22_32 XI1576_An XI1576_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1576_MN2 (XI1576_n1 h22 p22_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1576_MN3 (VSS c22_o XI1576_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1576_MN0 (XI1576_An h22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1566_MN1 (XI1566_Bn qu10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1566_MN5 (XI1566_n2 XI1566_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1566_MN4 (b22_24 XI1566_An XI1566_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1566_MN2 (XI1566_n1 dd24_b3_4 b22_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1566_MN3 (VSS qu10_b3_4 XI1566_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1566_MN0 (XI1566_An dd24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1113_MN1 (XI1113_Bn qu20_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1113_MN5 (XI1113_n2 XI1113_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1113_MN4 (b12_31 XI1113_An XI1113_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1113_MN2 (XI1113_n1 dd31_b3_2 b12_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1113_MN3 (VSS qu20_b3_5 XI1113_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1113_MN0 (XI1113_An dd31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1085_MN1 (XI1085_Bn qu20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1085_MN5 (XI1085_n2 XI1085_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1085_MN4 (b12_3 XI1085_An XI1085_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1085_MN2 (XI1085_n1 dd3_b3_2 b12_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1085_MN3 (VSS qu20_b3_0 XI1085_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1085_MN0 (XI1085_An dd3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1086_MN1 (XI1086_Bn qu20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1086_MN5 (XI1086_n2 XI1086_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1086_MN4 (b12_4 XI1086_An XI1086_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1086_MN2 (XI1086_n1 dd4_b3_2 b12_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1086_MN3 (VSS qu20_b3_0 XI1086_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1086_MN0 (XI1086_An dd4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1036_MN1 (XI1036_Bn qu21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1036_MN5 (XI1036_n2 XI1036_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1036_MN4 (b11_0 XI1036_An XI1036_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1036_MN2 (XI1036_n1 B_0_b3_2 b11_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1036_MN3 (VSS qu21_b3_0 XI1036_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1036_MN0 (XI1036_An B_0_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1016_MN1 (XI1016_Bn qu22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1016_MN5 (XI1016_n2 XI1016_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1016_MN4 (b10_26 XI1016_An XI1016_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1016_MN2 (XI1016_n1 dd26_b3_1 b10_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1016_MN3 (VSS qu22_b3_4 XI1016_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1016_MN0 (XI1016_An dd26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1015_MN1 (XI1015_Bn qu22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1015_MN5 (XI1015_n2 XI1015_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1015_MN4 (b10_25 XI1015_An XI1015_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1015_MN2 (XI1015_n1 dd25_b3_1 b10_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1015_MN3 (VSS qu22_b3_4 XI1015_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1015_MN0 (XI1015_An dd25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI970_MN1 (XI970_Bn qu23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI970_MN5 (XI970_n2 XI970_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI970_MN4 (b9_26 XI970_An XI970_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI970_MN2 (XI970_n1 dd26_b3_1 b9_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI970_MN3 (VSS qu23_b3_4 XI970_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI970_MN0 (XI970_An dd26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI968_MN1 (XI968_Bn qu23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI968_MN5 (XI968_n2 XI968_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI968_MN4 (b9_24 XI968_An XI968_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI968_MN2 (XI968_n1 dd24_b3_1 b9_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI968_MN3 (VSS qu23_b3_4 XI968_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI968_MN0 (XI968_An dd24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI923_MN1 (XI923_Bn qu24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI923_MN5 (XI923_n2 XI923_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI923_MN4 (b8_25 XI923_An XI923_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI923_MN2 (XI923_n1 dd25_b3_1 b8_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI923_MN3 (VSS qu24_b3_4 XI923_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI923_MN0 (XI923_An dd25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI924_MN1 (XI924_Bn qu24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI924_MN5 (XI924_n2 XI924_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI924_MN4 (b8_26 XI924_An XI924_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI924_MN2 (XI924_n1 dd26_b3_1 b8_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI924_MN3 (VSS qu24_b3_4 XI924_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI924_MN0 (XI924_An dd26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1659_MN1 (XI1659_Bn qu8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1659_MN5 (XI1659_n2 XI1659_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1659_MN4 (b24_25 XI1659_An XI1659_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1659_MN2 (XI1659_n1 dd25_b3_4 b24_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1659_MN3 (VSS qu8_b3_4 XI1659_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1659_MN0 (XI1659_An dd25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1660_MN1 (XI1660_Bn qu8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1660_MN5 (XI1660_n2 XI1660_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1660_MN4 (b24_26 XI1660_An XI1660_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1660_MN2 (XI1660_n1 dd26_b3_4 b24_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1660_MN3 (VSS qu8_b3_4 XI1660_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1660_MN0 (XI1660_An dd26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1661_MN1 (XI1661_Bn qu8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1661_MN5 (XI1661_n2 XI1661_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1661_MN4 (b24_27 XI1661_An XI1661_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1661_MN2 (XI1661_n1 dd27_b3_4 b24_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1661_MN3 (VSS qu8_b3_4 XI1661_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1661_MN0 (XI1661_An dd27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1662_MN1 (XI1662_Bn qu8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1662_MN5 (XI1662_n2 XI1662_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1662_MN4 (b24_28 XI1662_An XI1662_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1662_MN2 (XI1662_n1 dd28_b3_4 b24_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1662_MN3 (VSS qu8_b3_4 XI1662_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1662_MN0 (XI1662_An dd28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1664_MN1 (XI1664_Bn qu8_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1664_MN5 (XI1664_n2 XI1664_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1664_MN4 (b24_30 XI1664_An XI1664_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1664_MN2 (XI1664_n1 dd30_b3_4 b24_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1664_MN3 (VSS qu8_b3_5 XI1664_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1664_MN0 (XI1664_An dd30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1665_MN1 (XI1665_Bn qu8_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1665_MN5 (XI1665_n2 XI1665_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1665_MN4 (b24_31 XI1665_An XI1665_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1665_MN2 (XI1665_n1 dd31_b3_4 b24_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1665_MN3 (VSS qu8_b3_5 XI1665_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1665_MN0 (XI1665_An dd31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1667_MN1 (XI1667_Bn qu8_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1667_MN5 (XI1667_n2 XI1667_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1667_MN4 (h24 XI1667_An XI1667_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1667_MN2 (XI1667_n1 p23_31 h24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1667_MN3 (VSS qu8_b3_5 XI1667_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1667_MN0 (XI1667_An p23_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1622_MN1 (XI1622_Bn c23_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1622_MN5 (XI1622_n2 XI1622_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1622_MN4 (p23_32 XI1622_An XI1622_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1622_MN2 (XI1622_n1 h23 p23_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1622_MN3 (VSS c23_o XI1622_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1622_MN0 (XI1622_An h23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1619_MN1 (XI1619_Bn qu9_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1619_MN5 (XI1619_n2 XI1619_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1619_MN4 (b23_31 XI1619_An XI1619_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1619_MN2 (XI1619_n1 dd31_b3_4 b23_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1619_MN3 (VSS qu9_b3_5 XI1619_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1619_MN0 (XI1619_An dd31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1618_MN1 (XI1618_Bn qu9_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1618_MN5 (XI1618_n2 XI1618_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1618_MN4 (b23_30 XI1618_An XI1618_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1618_MN2 (XI1618_n1 dd30_b3_4 b23_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1618_MN3 (VSS qu9_b3_5 XI1618_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1618_MN0 (XI1618_An dd30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1615_MN1 (XI1615_Bn qu9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1615_MN5 (XI1615_n2 XI1615_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1615_MN4 (b23_27 XI1615_An XI1615_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1615_MN2 (XI1615_n1 dd27_b3_4 b23_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1615_MN3 (VSS qu9_b3_4 XI1615_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1615_MN0 (XI1615_An dd27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1614_MN1 (XI1614_Bn qu9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1614_MN5 (XI1614_n2 XI1614_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1614_MN4 (b23_26 XI1614_An XI1614_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1614_MN2 (XI1614_n1 dd26_b3_4 b23_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1614_MN3 (VSS qu9_b3_4 XI1614_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1614_MN0 (XI1614_An dd26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1613_MN1 (XI1613_Bn qu9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1613_MN5 (XI1613_n2 XI1613_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1613_MN4 (b23_25 XI1613_An XI1613_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1613_MN2 (XI1613_n1 dd25_b3_4 b23_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1613_MN3 (VSS qu9_b3_4 XI1613_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1613_MN0 (XI1613_An dd25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1621_MN1 (XI1621_Bn qu9_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1621_MN5 (XI1621_n2 XI1621_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1621_MN4 (h23 XI1621_An XI1621_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1621_MN2 (XI1621_n1 p22_31 h23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1621_MN3 (VSS qu9_b3_5 XI1621_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1621_MN0 (XI1621_An p22_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1572_MN1 (XI1572_Bn qu10_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1572_MN5 (XI1572_n2 XI1572_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1572_MN4 (b22_30 XI1572_An XI1572_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1572_MN2 (XI1572_n1 dd30_b3_4 b22_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1572_MN3 (VSS qu10_b3_5 XI1572_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1572_MN0 (XI1572_An dd30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1575_MN1 (XI1575_Bn qu10_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1575_MN5 (XI1575_n2 XI1575_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1575_MN4 (h22 XI1575_An XI1575_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1575_MN2 (XI1575_n1 p21_31 h22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1575_MN3 (VSS qu10_b3_5 XI1575_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1575_MN0 (XI1575_An p21_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1567_MN1 (XI1567_Bn qu10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1567_MN5 (XI1567_n2 XI1567_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1567_MN4 (b22_25 XI1567_An XI1567_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1567_MN2 (XI1567_n1 dd25_b3_4 b22_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1567_MN3 (VSS qu10_b3_4 XI1567_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1567_MN0 (XI1567_An dd25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I218_MN1 (XI1114_I218_Bn I1114_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I218_MN5 (XI1114_I218_n2 XI1114_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I218_MN4 (p12_15 XI1114_I218_An XI1114_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I218_MN2 (XI1114_I218_n1 I1114_pn15 p12_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I218_MN3 (VSS I1114_G14_0n XI1114_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I218_MN0 (XI1114_I218_An I1114_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I216_MN1 (XI1114_I216_Bn I1114_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I216_MN5 (XI1114_I216_n2 XI1114_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I216_MN4 (p12_13 XI1114_I216_An XI1114_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I216_MN2 (XI1114_I216_n1 I1114_pn13 p12_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I216_MN3 (VSS I1114_G12_0n XI1114_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I216_MN0 (XI1114_I216_An I1114_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1084_MN1 (XI1084_Bn qu20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1084_MN5 (XI1084_n2 XI1084_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1084_MN4 (b12_2 XI1084_An XI1084_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1084_MN2 (XI1084_n1 dd2_b3_2 b12_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1084_MN3 (VSS qu20_b3_0 XI1084_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1084_MN0 (XI1084_An dd2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1017_MN1 (XI1017_Bn qu22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1017_MN5 (XI1017_n2 XI1017_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1017_MN4 (b10_27 XI1017_An XI1017_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1017_MN2 (XI1017_n1 dd27_b3_1 b10_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1017_MN3 (VSS qu22_b3_4 XI1017_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1017_MN0 (XI1017_An dd27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1018_MN1 (XI1018_Bn qu22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1018_MN5 (XI1018_n2 XI1018_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1018_MN4 (b10_28 XI1018_An XI1018_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1018_MN2 (XI1018_n1 dd28_b3_1 b10_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1018_MN3 (VSS qu22_b3_4 XI1018_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1018_MN0 (XI1018_An dd28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI929_MN1 (XI929_Bn qu24_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI929_MN5 (XI929_n2 XI929_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI929_MN4 (b8_31 XI929_An XI929_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI929_MN2 (XI929_n1 dd31_b3_1 b8_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI929_MN3 (VSS qu24_b3_5 XI929_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI929_MN0 (XI929_An dd31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI971_MN1 (XI971_Bn qu23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI971_MN5 (XI971_n2 XI971_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI971_MN4 (b9_27 XI971_An XI971_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI971_MN2 (XI971_n1 dd27_b3_1 b9_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI971_MN3 (VSS qu23_b3_4 XI971_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI971_MN0 (XI971_An dd27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI972_MN1 (XI972_Bn qu23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI972_MN5 (XI972_n2 XI972_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI972_MN4 (b9_28 XI972_An XI972_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI972_MN2 (XI972_n1 dd28_b3_1 b9_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI972_MN3 (VSS qu23_b3_4 XI972_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI972_MN0 (XI972_An dd28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI925_MN1 (XI925_Bn qu24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI925_MN5 (XI925_n2 XI925_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI925_MN4 (b8_27 XI925_An XI925_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI925_MN2 (XI925_n1 dd27_b3_1 b8_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI925_MN3 (VSS qu24_b3_4 XI925_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI925_MN0 (XI925_An dd27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI926_MN1 (XI926_Bn qu24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI926_MN5 (XI926_n2 XI926_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI926_MN4 (b8_28 XI926_An XI926_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI926_MN2 (XI926_n1 dd28_b3_1 b8_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI926_MN3 (VSS qu24_b3_4 XI926_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI926_MN0 (XI926_An dd28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1663_MN1 (XI1663_Bn qu8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1663_MN5 (XI1663_n2 XI1663_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1663_MN4 (b24_29 XI1663_An XI1663_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1663_MN2 (XI1663_n1 dd29_b3_4 b24_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1663_MN3 (VSS qu8_b3_4 XI1663_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1663_MN0 (XI1663_An dd29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1617_MN1 (XI1617_Bn qu9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1617_MN5 (XI1617_n2 XI1617_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1617_MN4 (b23_29 XI1617_An XI1617_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1617_MN2 (XI1617_n1 dd29_b3_4 b23_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1617_MN3 (VSS qu9_b3_4 XI1617_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1617_MN0 (XI1617_An dd29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1616_MN1 (XI1616_Bn qu9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1616_MN5 (XI1616_n2 XI1616_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1616_MN4 (b23_28 XI1616_An XI1616_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1616_MN2 (XI1616_n1 dd28_b3_4 b23_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1616_MN3 (VSS qu9_b3_4 XI1616_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1616_MN0 (XI1616_An dd28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1496_MN1 (XI1496_Bn qu11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1496_MN5 (XI1496_n2 XI1496_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1496_MN4 (b21_0 XI1496_An XI1496_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1496_MN2 (XI1496_n1 B_0_b3_3 b21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1496_MN3 (VSS qu11_b3_0 XI1496_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1496_MN0 (XI1496_An B_0_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1573_MN1 (XI1573_Bn qu10_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1573_MN5 (XI1573_n2 XI1573_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1573_MN4 (b22_31 XI1573_An XI1573_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1573_MN2 (XI1573_n1 dd31_b3_4 b22_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1573_MN3 (VSS qu10_b3_5 XI1573_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1573_MN0 (XI1573_An dd31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1568_MN1 (XI1568_Bn qu10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1568_MN5 (XI1568_n2 XI1568_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1568_MN4 (b22_26 XI1568_An XI1568_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1568_MN2 (XI1568_n1 dd26_b3_4 b22_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1568_MN3 (VSS qu10_b3_4 XI1568_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1568_MN0 (XI1568_An dd26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1569_MN1 (XI1569_Bn qu10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1569_MN5 (XI1569_n2 XI1569_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1569_MN4 (b22_27 XI1569_An XI1569_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1569_MN2 (XI1569_n1 dd27_b3_4 b22_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1569_MN3 (VSS qu10_b3_4 XI1569_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1569_MN0 (XI1569_An dd27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I214_MN1 (XI1114_I214_Bn I1114_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I214_MN5 (XI1114_I214_n2 XI1114_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I214_MN4 (p12_11 XI1114_I214_An XI1114_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I214_MN2 (XI1114_I214_n1 I1114_pn11 p12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I214_MN3 (VSS I1114_G10_0n XI1114_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I214_MN0 (XI1114_I214_An I1114_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I212_MN1 (XI1114_I212_Bn I1114_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I212_MN5 (XI1114_I212_n2 XI1114_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I212_MN4 (p12_9 XI1114_I212_An XI1114_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I212_MN2 (XI1114_I212_n1 I1114_pn9 p12_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I212_MN3 (VSS I1114_G8_0n XI1114_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I212_MN0 (XI1114_I212_An I1114_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1083_MN1 (XI1083_Bn qu20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1083_MN5 (XI1083_n2 XI1083_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1083_MN4 (b12_1 XI1083_An XI1083_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1083_MN2 (XI1083_n1 dd1_b3_2 b12_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1083_MN3 (VSS qu20_b3_0 XI1083_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1083_MN0 (XI1083_An dd1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1082_MN1 (XI1082_Bn qu20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1082_MN5 (XI1082_n2 XI1082_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1082_MN4 (b12_0 XI1082_An XI1082_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1082_MN2 (XI1082_n1 B_0_b3_2 b12_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1082_MN3 (VSS qu20_b3_0 XI1082_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1082_MN0 (XI1082_An B_0_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1023_MN1 (XI1023_Bn qu22_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1023_MN5 (XI1023_n2 XI1023_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1023_MN4 (h10 XI1023_An XI1023_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1023_MN2 (XI1023_n1 p9_31 h10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1023_MN3 (VSS qu22_b3_5 XI1023_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1023_MN0 (XI1023_An p9_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1021_MN1 (XI1021_Bn qu22_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1021_MN5 (XI1021_n2 XI1021_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1021_MN4 (b10_31 XI1021_An XI1021_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1021_MN2 (XI1021_n1 dd31_b3_1 b10_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1021_MN3 (VSS qu22_b3_5 XI1021_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1021_MN0 (XI1021_An dd31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1020_MN1 (XI1020_Bn qu22_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1020_MN5 (XI1020_n2 XI1020_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1020_MN4 (b10_30 XI1020_An XI1020_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1020_MN2 (XI1020_n1 dd30_b3_1 b10_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1020_MN3 (VSS qu22_b3_5 XI1020_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1020_MN0 (XI1020_An dd30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1019_MN1 (XI1019_Bn qu22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1019_MN5 (XI1019_n2 XI1019_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1019_MN4 (b10_29 XI1019_An XI1019_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1019_MN2 (XI1019_n1 dd29_b3_1 b10_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1019_MN3 (VSS qu22_b3_4 XI1019_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1019_MN0 (XI1019_An dd29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI975_MN1 (XI975_Bn qu23_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI975_MN5 (XI975_n2 XI975_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI975_MN4 (b9_31 XI975_An XI975_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI975_MN2 (XI975_n1 dd31_b3_1 b9_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI975_MN3 (VSS qu23_b3_5 XI975_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI975_MN0 (XI975_An dd31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI974_MN1 (XI974_Bn qu23_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI974_MN5 (XI974_n2 XI974_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI974_MN4 (b9_30 XI974_An XI974_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI974_MN2 (XI974_n1 dd30_b3_1 b9_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI974_MN3 (VSS qu23_b3_5 XI974_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI974_MN0 (XI974_An dd30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI928_MN1 (XI928_Bn qu24_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI928_MN5 (XI928_n2 XI928_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI928_MN4 (b8_30 XI928_An XI928_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI928_MN2 (XI928_n1 dd30_b3_1 b8_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI928_MN3 (VSS qu24_b3_5 XI928_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI928_MN0 (XI928_An dd30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI973_MN1 (XI973_Bn qu23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI973_MN5 (XI973_n2 XI973_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI973_MN4 (b9_29 XI973_An XI973_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI973_MN2 (XI973_n1 dd29_b3_1 b9_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI973_MN3 (VSS qu23_b3_4 XI973_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI973_MN0 (XI973_An dd29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI927_MN1 (XI927_Bn qu24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI927_MN5 (XI927_n2 XI927_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI927_MN4 (b8_29 XI927_An XI927_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI927_MN2 (XI927_n1 dd29_b3_1 b8_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI927_MN3 (VSS qu24_b3_4 XI927_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI927_MN0 (XI927_An dd29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1312_MN1 (XI1312_Bn qu15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1312_MN5 (XI1312_n2 XI1312_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1312_MN4 (b17_0 XI1312_An XI1312_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1312_MN2 (XI1312_n1 B_0_b3_3 b17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1312_MN3 (VSS qu15_b3_0 XI1312_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1312_MN0 (XI1312_An B_0_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1361_MN1 (XI1361_Bn qu14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1361_MN5 (XI1361_n2 XI1361_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1361_MN4 (b18_3 XI1361_An XI1361_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1361_MN2 (XI1361_n1 dd3_b3_3 b18_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1361_MN3 (VSS qu14_b3_0 XI1361_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1361_MN0 (XI1361_An dd3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1358_MN1 (XI1358_Bn qu14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1358_MN5 (XI1358_n2 XI1358_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1358_MN4 (b18_0 XI1358_An XI1358_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1358_MN2 (XI1358_n1 B_0_b3_3 b18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1358_MN3 (VSS qu14_b3_0 XI1358_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1358_MN0 (XI1358_An B_0_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1360_MN1 (XI1360_Bn qu14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1360_MN5 (XI1360_n2 XI1360_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1360_MN4 (b18_2 XI1360_An XI1360_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1360_MN2 (XI1360_n1 dd2_b3_3 b18_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1360_MN3 (VSS qu14_b3_0 XI1360_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1360_MN0 (XI1360_An dd2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1404_MN1 (XI1404_Bn qu13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1404_MN5 (XI1404_n2 XI1404_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1404_MN4 (b19_0 XI1404_An XI1404_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1404_MN2 (XI1404_n1 B_0_b3_3 b19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1404_MN3 (VSS qu13_b3_0 XI1404_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1404_MN0 (XI1404_An B_0_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1405_MN1 (XI1405_Bn qu13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1405_MN5 (XI1405_n2 XI1405_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1405_MN4 (b19_1 XI1405_An XI1405_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1405_MN2 (XI1405_n1 dd1_b3_3 b19_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1405_MN3 (VSS qu13_b3_0 XI1405_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1405_MN0 (XI1405_An dd1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1450_MN1 (XI1450_Bn qu12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1450_MN5 (XI1450_n2 XI1450_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1450_MN4 (b20_0 XI1450_An XI1450_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1450_MN2 (XI1450_n1 B_0_b3_3 b20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1450_MN3 (VSS qu12_b3_0 XI1450_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1450_MN0 (XI1450_An B_0_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1451_MN1 (XI1451_Bn qu12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1451_MN5 (XI1451_n2 XI1451_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1451_MN4 (b20_1 XI1451_An XI1451_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1451_MN2 (XI1451_n1 dd1_b3_3 b20_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1451_MN3 (VSS qu12_b3_0 XI1451_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1451_MN0 (XI1451_An dd1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1499_MN1 (XI1499_Bn qu11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1499_MN5 (XI1499_n2 XI1499_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1499_MN4 (b21_3 XI1499_An XI1499_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1499_MN2 (XI1499_n1 dd3_b3_3 b21_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1499_MN3 (VSS qu11_b3_0 XI1499_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1499_MN0 (XI1499_An dd3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1497_MN1 (XI1497_Bn qu11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1497_MN5 (XI1497_n2 XI1497_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1497_MN4 (b21_1 XI1497_An XI1497_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1497_MN2 (XI1497_n1 dd1_b3_3 b21_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1497_MN3 (VSS qu11_b3_0 XI1497_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1497_MN0 (XI1497_An dd1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1498_MN1 (XI1498_Bn qu11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1498_MN5 (XI1498_n2 XI1498_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1498_MN4 (b21_2 XI1498_An XI1498_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1498_MN2 (XI1498_n1 dd2_b3_3 b21_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1498_MN3 (VSS qu11_b3_0 XI1498_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1498_MN0 (XI1498_An dd2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I206_MN1 (XI1528_I206_Bn I1528_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I206_MN5 (XI1528_I206_n2 XI1528_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I206_MN4 (p21_3 XI1528_I206_An XI1528_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I206_MN2 (XI1528_I206_n1 I1528_pn3 p21_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I206_MN3 (VSS I1528_G2_0n XI1528_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I206_MN0 (XI1528_I206_An I1528_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1571_MN1 (XI1571_Bn qu10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1571_MN5 (XI1571_n2 XI1571_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1571_MN4 (b22_29 XI1571_An XI1571_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1571_MN2 (XI1571_n1 dd29_b3_4 b22_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1571_MN3 (VSS qu10_b3_4 XI1571_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1571_MN0 (XI1571_An dd29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1570_MN1 (XI1570_Bn qu10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1570_MN5 (XI1570_n2 XI1570_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1570_MN4 (b22_28 XI1570_An XI1570_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1570_MN2 (XI1570_n1 dd28_b3_4 b22_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1570_MN3 (VSS qu10_b3_4 XI1570_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1570_MN0 (XI1570_An dd28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I206_MN1 (XI1114_I206_Bn I1114_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I206_MN5 (XI1114_I206_n2 XI1114_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I206_MN4 (p12_3 XI1114_I206_An XI1114_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I206_MN2 (XI1114_I206_n1 I1114_pn3 p12_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I206_MN3 (VSS I1114_G2_0n XI1114_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I206_MN0 (XI1114_I206_An I1114_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1221_MN1 (XI1221_Bn qu17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1221_MN5 (XI1221_n2 XI1221_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1221_MN4 (b15_1 XI1221_An XI1221_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1221_MN2 (XI1221_n1 dd1_b3_2 b15_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1221_MN3 (VSS qu17_b3_0 XI1221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1221_MN0 (XI1221_An dd1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1220_MN1 (XI1220_Bn qu17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1220_MN5 (XI1220_n2 XI1220_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1220_MN4 (b15_0 XI1220_An XI1220_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1220_MN2 (XI1220_n1 B_0_b3_2 b15_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1220_MN3 (VSS qu17_b3_0 XI1220_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1220_MN0 (XI1220_An B_0_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI978_MN1 (XI978_Bn c9_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI978_MN5 (XI978_n2 XI978_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI978_MN4 (p9_32 XI978_An XI978_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI978_MN2 (XI978_n1 h9 p9_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI978_MN3 (VSS c9_o XI978_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI978_MN0 (XI978_An h9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI977_MN1 (XI977_Bn qu23_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI977_MN5 (XI977_n2 XI977_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI977_MN4 (h9 XI977_An XI977_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI977_MN2 (XI977_n1 p8_31 h9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI977_MN3 (VSS qu23_b3_5 XI977_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI977_MN0 (XI977_An p8_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1316_MN1 (XI1316_Bn qu15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1316_MN5 (XI1316_n2 XI1316_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1316_MN4 (b17_4 XI1316_An XI1316_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1316_MN2 (XI1316_n1 dd4_b3_3 b17_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1316_MN3 (VSS qu15_b3_0 XI1316_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1316_MN0 (XI1316_An dd4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1315_MN1 (XI1315_Bn qu15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1315_MN5 (XI1315_n2 XI1315_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1315_MN4 (b17_3 XI1315_An XI1315_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1315_MN2 (XI1315_n1 dd3_b3_3 b17_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1315_MN3 (VSS qu15_b3_0 XI1315_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1315_MN0 (XI1315_An dd3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1314_MN1 (XI1314_Bn qu15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1314_MN5 (XI1314_n2 XI1314_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1314_MN4 (b17_2 XI1314_An XI1314_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1314_MN2 (XI1314_n1 dd2_b3_3 b17_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1314_MN3 (VSS qu15_b3_0 XI1314_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1314_MN0 (XI1314_An dd2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1313_MN1 (XI1313_Bn qu15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1313_MN5 (XI1313_n2 XI1313_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1313_MN4 (b17_1 XI1313_An XI1313_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1313_MN2 (XI1313_n1 dd1_b3_3 b17_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1313_MN3 (VSS qu15_b3_0 XI1313_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1313_MN0 (XI1313_An dd1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1362_MN1 (XI1362_Bn qu14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1362_MN5 (XI1362_n2 XI1362_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1362_MN4 (b18_4 XI1362_An XI1362_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1362_MN2 (XI1362_n1 dd4_b3_3 b18_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1362_MN3 (VSS qu14_b3_0 XI1362_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1362_MN0 (XI1362_An dd4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1359_MN1 (XI1359_Bn qu14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1359_MN5 (XI1359_n2 XI1359_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1359_MN4 (b18_1 XI1359_An XI1359_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1359_MN2 (XI1359_n1 dd1_b3_3 b18_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1359_MN3 (VSS qu14_b3_0 XI1359_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1359_MN0 (XI1359_An dd1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1408_MN1 (XI1408_Bn qu13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1408_MN5 (XI1408_n2 XI1408_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1408_MN4 (b19_4 XI1408_An XI1408_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1408_MN2 (XI1408_n1 dd4_b3_3 b19_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1408_MN3 (VSS qu13_b3_0 XI1408_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1408_MN0 (XI1408_An dd4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1407_MN1 (XI1407_Bn qu13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1407_MN5 (XI1407_n2 XI1407_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1407_MN4 (b19_3 XI1407_An XI1407_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1407_MN2 (XI1407_n1 dd3_b3_3 b19_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1407_MN3 (VSS qu13_b3_0 XI1407_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1407_MN0 (XI1407_An dd3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1409_MN1 (XI1409_Bn qu13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1409_MN5 (XI1409_n2 XI1409_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1409_MN4 (b19_5 XI1409_An XI1409_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1409_MN2 (XI1409_n1 dd5_b3_3 b19_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1409_MN3 (VSS qu13_b3_0 XI1409_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1409_MN0 (XI1409_An dd5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1406_MN1 (XI1406_Bn qu13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1406_MN5 (XI1406_n2 XI1406_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1406_MN4 (b19_2 XI1406_An XI1406_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1406_MN2 (XI1406_n1 dd2_b3_3 b19_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1406_MN3 (VSS qu13_b3_0 XI1406_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1406_MN0 (XI1406_An dd2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1454_MN1 (XI1454_Bn qu12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1454_MN5 (XI1454_n2 XI1454_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1454_MN4 (b20_4 XI1454_An XI1454_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1454_MN2 (XI1454_n1 dd4_b3_3 b20_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1454_MN3 (VSS qu12_b3_0 XI1454_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1454_MN0 (XI1454_An dd4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1453_MN1 (XI1453_Bn qu12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1453_MN5 (XI1453_n2 XI1453_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1453_MN4 (b20_3 XI1453_An XI1453_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1453_MN2 (XI1453_n1 dd3_b3_3 b20_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1453_MN3 (VSS qu12_b3_0 XI1453_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1453_MN0 (XI1453_An dd3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1452_MN1 (XI1452_Bn qu12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1452_MN5 (XI1452_n2 XI1452_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1452_MN4 (b20_2 XI1452_An XI1452_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1452_MN2 (XI1452_n1 dd2_b3_3 b20_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1452_MN3 (VSS qu12_b3_0 XI1452_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1452_MN0 (XI1452_An dd2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1500_MN1 (XI1500_Bn qu11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1500_MN5 (XI1500_n2 XI1500_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1500_MN4 (b21_4 XI1500_An XI1500_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1500_MN2 (XI1500_n1 dd4_b3_3 b21_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1500_MN3 (VSS qu11_b3_0 XI1500_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1500_MN0 (XI1500_An dd4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I212_MN1 (XI1528_I212_Bn I1528_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I212_MN5 (XI1528_I212_n2 XI1528_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I212_MN4 (p21_9 XI1528_I212_An XI1528_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I212_MN2 (XI1528_I212_n1 I1528_pn9 p21_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I212_MN3 (VSS I1528_G8_0n XI1528_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I212_MN0 (XI1528_I212_An I1528_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I207_MN1 (XI1528_I207_Bn I1528_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I207_MN5 (XI1528_I207_n2 XI1528_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I207_MN4 (p21_4 XI1528_I207_An XI1528_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I207_MN2 (XI1528_I207_n1 I1528_pn4 p21_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I207_MN3 (VSS I1528_G3_0n XI1528_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I207_MN0 (XI1528_I207_An I1528_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1115_MN1 (XI1115_Bn qu20_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1115_MN5 (XI1115_n2 XI1115_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1115_MN4 (h12 XI1115_An XI1115_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1115_MN2 (XI1115_n1 p11_31 h12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1115_MN3 (VSS qu20_b3_5 XI1115_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1115_MN0 (XI1115_An p11_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I217_MN1 (XI1114_I217_Bn I1114_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I217_MN5 (XI1114_I217_n2 XI1114_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I217_MN4 (p12_14 XI1114_I217_An XI1114_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I217_MN2 (XI1114_I217_n1 I1114_pn14 p12_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I217_MN3 (VSS I1114_G13_0n XI1114_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I217_MN0 (XI1114_I217_An I1114_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I213_MN1 (XI1114_I213_Bn I1114_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I213_MN5 (XI1114_I213_n2 XI1114_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I213_MN4 (p12_10 XI1114_I213_An XI1114_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I213_MN2 (XI1114_I213_n1 I1114_pn10 p12_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I213_MN3 (VSS I1114_G9_0n XI1114_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I213_MN0 (XI1114_I213_An I1114_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I207_MN1 (XI1114_I207_Bn I1114_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I207_MN5 (XI1114_I207_n2 XI1114_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I207_MN4 (p12_4 XI1114_I207_An XI1114_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I207_MN2 (XI1114_I207_n1 I1114_pn4 p12_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I207_MN3 (VSS I1114_G3_0n XI1114_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I207_MN0 (XI1114_I207_An I1114_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1132_MN1 (XI1132_Bn qu19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1132_MN5 (XI1132_n2 XI1132_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1132_MN4 (b13_4 XI1132_An XI1132_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1132_MN2 (XI1132_n1 dd4_b3_2 b13_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1132_MN3 (VSS qu19_b3_0 XI1132_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1132_MN0 (XI1132_An dd4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1133_MN1 (XI1133_Bn qu19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1133_MN5 (XI1133_n2 XI1133_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1133_MN4 (b13_5 XI1133_An XI1133_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1133_MN2 (XI1133_n1 dd5_b3_2 b13_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1133_MN3 (VSS qu19_b3_0 XI1133_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1133_MN0 (XI1133_An dd5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1130_MN1 (XI1130_Bn qu19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1130_MN5 (XI1130_n2 XI1130_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1130_MN4 (b13_2 XI1130_An XI1130_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1130_MN2 (XI1130_n1 dd2_b3_2 b13_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1130_MN3 (VSS qu19_b3_0 XI1130_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1130_MN0 (XI1130_An dd2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1129_MN1 (XI1129_Bn qu19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1129_MN5 (XI1129_n2 XI1129_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1129_MN4 (b13_1 XI1129_An XI1129_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1129_MN2 (XI1129_n1 dd1_b3_2 b13_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1129_MN3 (VSS qu19_b3_0 XI1129_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1129_MN0 (XI1129_An dd1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1128_MN1 (XI1128_Bn qu19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1128_MN5 (XI1128_n2 XI1128_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1128_MN4 (b13_0 XI1128_An XI1128_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1128_MN2 (XI1128_n1 B_0_b3_2 b13_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1128_MN3 (VSS qu19_b3_0 XI1128_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1128_MN0 (XI1128_An B_0_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1177_MN1 (XI1177_Bn qu18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1177_MN5 (XI1177_n2 XI1177_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1177_MN4 (b14_3 XI1177_An XI1177_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1177_MN2 (XI1177_n1 dd3_b3_2 b14_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1177_MN3 (VSS qu18_b3_0 XI1177_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1177_MN0 (XI1177_An dd3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1174_MN1 (XI1174_Bn qu18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1174_MN5 (XI1174_n2 XI1174_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1174_MN4 (b14_0 XI1174_An XI1174_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1174_MN2 (XI1174_n1 B_0_b3_2 b14_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1174_MN3 (VSS qu18_b3_0 XI1174_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1174_MN0 (XI1174_An B_0_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1175_MN1 (XI1175_Bn qu18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1175_MN5 (XI1175_n2 XI1175_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1175_MN4 (b14_1 XI1175_An XI1175_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1175_MN2 (XI1175_n1 dd1_b3_2 b14_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1175_MN3 (VSS qu18_b3_0 XI1175_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1175_MN0 (XI1175_An dd1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1222_MN1 (XI1222_Bn qu17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1222_MN5 (XI1222_n2 XI1222_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1222_MN4 (b15_2 XI1222_An XI1222_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1222_MN2 (XI1222_n1 dd2_b3_2 b15_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1222_MN3 (VSS qu17_b3_0 XI1222_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1222_MN0 (XI1222_An dd2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1267_MN1 (XI1267_Bn qu16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1267_MN5 (XI1267_n2 XI1267_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1267_MN4 (b16_1 XI1267_An XI1267_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1267_MN2 (XI1267_n1 dd1_b3_2 b16_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1267_MN3 (VSS qu16_b3_0 XI1267_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1267_MN0 (XI1267_An dd1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1266_MN1 (XI1266_Bn qu16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1266_MN5 (XI1266_n2 XI1266_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1266_MN4 (b16_0 XI1266_An XI1266_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1266_MN2 (XI1266_n1 B_0_b3_2 b16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1266_MN3 (VSS qu16_b3_0 XI1266_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1266_MN0 (XI1266_An B_0_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1268_MN1 (XI1268_Bn qu16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1268_MN5 (XI1268_n2 XI1268_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1268_MN4 (b16_2 XI1268_An XI1268_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1268_MN2 (XI1268_n1 dd2_b3_2 b16_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1268_MN3 (VSS qu16_b3_0 XI1268_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1268_MN0 (XI1268_An dd2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I206_MN1 (XI1344_I206_Bn I1344_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I206_MN5 (XI1344_I206_n2 XI1344_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I206_MN4 (p17_3 XI1344_I206_An XI1344_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I206_MN2 (XI1344_I206_n1 I1344_pn3 p17_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I206_MN3 (VSS I1344_G2_0n XI1344_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I206_MN0 (XI1344_I206_An I1344_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1317_MN1 (XI1317_Bn qu15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1317_MN5 (XI1317_n2 XI1317_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1317_MN4 (b17_5 XI1317_An XI1317_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1317_MN2 (XI1317_n1 dd5_b3_3 b17_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1317_MN3 (VSS qu15_b3_0 XI1317_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1317_MN0 (XI1317_An dd5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1364_MN1 (XI1364_Bn qu14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1364_MN5 (XI1364_n2 XI1364_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1364_MN4 (b18_6 XI1364_An XI1364_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1364_MN2 (XI1364_n1 dd6_b3_3 b18_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1364_MN3 (VSS qu14_b3_1 XI1364_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1364_MN0 (XI1364_An dd6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1363_MN1 (XI1363_Bn qu14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1363_MN5 (XI1363_n2 XI1363_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1363_MN4 (b18_5 XI1363_An XI1363_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1363_MN2 (XI1363_n1 dd5_b3_3 b18_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1363_MN3 (VSS qu14_b3_0 XI1363_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1363_MN0 (XI1363_An dd5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I206_MN1 (XI1390_I206_Bn I1390_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I206_MN5 (XI1390_I206_n2 XI1390_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I206_MN4 (p18_3 XI1390_I206_An XI1390_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I206_MN2 (XI1390_I206_n1 I1390_pn3 p18_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I206_MN3 (VSS I1390_G2_0n XI1390_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I206_MN0 (XI1390_I206_An I1390_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1410_MN1 (XI1410_Bn qu13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1410_MN5 (XI1410_n2 XI1410_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1410_MN4 (b19_6 XI1410_An XI1410_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1410_MN2 (XI1410_n1 dd6_b3_3 b19_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1410_MN3 (VSS qu13_b3_1 XI1410_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1410_MN0 (XI1410_An dd6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I206_MN1 (XI1436_I206_Bn I1436_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I206_MN5 (XI1436_I206_n2 XI1436_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I206_MN4 (p19_3 XI1436_I206_An XI1436_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I206_MN2 (XI1436_I206_n1 I1436_pn3 p19_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I206_MN3 (VSS I1436_G2_0n XI1436_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I206_MN0 (XI1436_I206_An I1436_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1455_MN1 (XI1455_Bn qu12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1455_MN5 (XI1455_n2 XI1455_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1455_MN4 (b20_5 XI1455_An XI1455_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1455_MN2 (XI1455_n1 dd5_b3_3 b20_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1455_MN3 (VSS qu12_b3_0 XI1455_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1455_MN0 (XI1455_An dd5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1502_MN1 (XI1502_Bn qu11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1502_MN5 (XI1502_n2 XI1502_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1502_MN4 (b21_6 XI1502_An XI1502_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1502_MN2 (XI1502_n1 dd6_b3_3 b21_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1502_MN3 (VSS qu11_b3_1 XI1502_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1502_MN0 (XI1502_An dd6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1504_MN1 (XI1504_Bn qu11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1504_MN5 (XI1504_n2 XI1504_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1504_MN4 (b21_8 XI1504_An XI1504_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1504_MN2 (XI1504_n1 dd8_b3_3 b21_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1504_MN3 (VSS qu11_b3_1 XI1504_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1504_MN0 (XI1504_An dd8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1501_MN1 (XI1501_Bn qu11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1501_MN5 (XI1501_n2 XI1501_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1501_MN4 (b21_5 XI1501_An XI1501_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1501_MN2 (XI1501_n1 dd5_b3_3 b21_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1501_MN3 (VSS qu11_b3_0 XI1501_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1501_MN0 (XI1501_An dd5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I207_MN1 (XI1482_I207_Bn I1482_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I207_MN5 (XI1482_I207_n2 XI1482_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I207_MN4 (p20_4 XI1482_I207_An XI1482_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I207_MN2 (XI1482_I207_n1 I1482_pn4 p20_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I207_MN3 (VSS I1482_G3_0n XI1482_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I207_MN0 (XI1482_I207_An I1482_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I206_MN1 (XI1482_I206_Bn I1482_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I206_MN5 (XI1482_I206_n2 XI1482_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I206_MN4 (p20_3 XI1482_I206_An XI1482_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I206_MN2 (XI1482_I206_n1 I1482_pn3 p20_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I206_MN3 (VSS I1482_G2_0n XI1482_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I206_MN0 (XI1482_I206_An I1482_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I213_MN1 (XI1528_I213_Bn I1528_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I213_MN5 (XI1528_I213_n2 XI1528_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I213_MN4 (p21_10 XI1528_I213_An XI1528_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I213_MN2 (XI1528_I213_n1 I1528_pn10 p21_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I213_MN3 (VSS I1528_G9_0n XI1528_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I213_MN0 (XI1528_I213_An I1528_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1116_MN1 (XI1116_Bn c12_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1116_MN5 (XI1116_n2 XI1116_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1116_MN4 (p12_32 XI1116_An XI1116_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1116_MN2 (XI1116_n1 h12 p12_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1116_MN3 (VSS c12_o XI1116_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1116_MN0 (XI1116_An h12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1149_MN1 (XI1149_Bn qu19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1149_MN5 (XI1149_n2 XI1149_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1149_MN4 (b13_21 XI1149_An XI1149_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1149_MN2 (XI1149_n1 dd21_b3_2 b13_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1149_MN3 (VSS qu19_b3_3 XI1149_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1149_MN0 (XI1149_An dd21_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1148_MN1 (XI1148_Bn qu19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1148_MN5 (XI1148_n2 XI1148_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1148_MN4 (b13_20 XI1148_An XI1148_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1148_MN2 (XI1148_n1 dd20_b3_2 b13_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1148_MN3 (VSS qu19_b3_3 XI1148_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1148_MN0 (XI1148_An dd20_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1147_MN1 (XI1147_Bn qu19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1147_MN5 (XI1147_n2 XI1147_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1147_MN4 (b13_19 XI1147_An XI1147_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1147_MN2 (XI1147_n1 dd19_b3_2 b13_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1147_MN3 (VSS qu19_b3_3 XI1147_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1147_MN0 (XI1147_An dd19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I219_MN1 (XI1114_I219_Bn I1114_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I219_MN5 (XI1114_I219_n2 XI1114_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I219_MN4 (p12_16 XI1114_I219_An XI1114_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I219_MN2 (XI1114_I219_n1 I1114_pn16 p12_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I219_MN3 (VSS I1114_G15_0n XI1114_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I219_MN0 (XI1114_I219_An I1114_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I215_MN1 (XI1114_I215_Bn I1114_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I215_MN5 (XI1114_I215_n2 XI1114_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1114_I215_MN4 (p12_12 XI1114_I215_An XI1114_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I215_MN2 (XI1114_I215_n1 I1114_pn12 p12_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1114_I215_MN3 (VSS I1114_G11_0n XI1114_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I215_MN0 (XI1114_I215_An I1114_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1144_MN1 (XI1144_Bn qu19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1144_MN5 (XI1144_n2 XI1144_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1144_MN4 (b13_16 XI1144_An XI1144_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1144_MN2 (XI1144_n1 dd16_b3_2 b13_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1144_MN3 (VSS qu19_b3_2 XI1144_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1144_MN0 (XI1144_An dd16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1140_MN1 (XI1140_Bn qu19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1140_MN5 (XI1140_n2 XI1140_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1140_MN4 (b13_12 XI1140_An XI1140_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1140_MN2 (XI1140_n1 dd12_b3_2 b13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1140_MN3 (VSS qu19_b3_2 XI1140_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1140_MN0 (XI1140_An dd12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1143_MN1 (XI1143_Bn qu19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1143_MN5 (XI1143_n2 XI1143_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1143_MN4 (b13_15 XI1143_An XI1143_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1143_MN2 (XI1143_n1 dd15_b3_2 b13_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1143_MN3 (VSS qu19_b3_2 XI1143_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1143_MN0 (XI1143_An dd15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1141_MN1 (XI1141_Bn qu19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1141_MN5 (XI1141_n2 XI1141_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1141_MN4 (b13_13 XI1141_An XI1141_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1141_MN2 (XI1141_n1 dd13_b3_2 b13_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1141_MN3 (VSS qu19_b3_2 XI1141_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1141_MN0 (XI1141_An dd13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1135_MN1 (XI1135_Bn qu19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1135_MN5 (XI1135_n2 XI1135_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1135_MN4 (b13_7 XI1135_An XI1135_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1135_MN2 (XI1135_n1 dd7_b3_2 b13_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1135_MN3 (VSS qu19_b3_1 XI1135_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1135_MN0 (XI1135_An dd7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1134_MN1 (XI1134_Bn qu19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1134_MN5 (XI1134_n2 XI1134_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1134_MN4 (b13_6 XI1134_An XI1134_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1134_MN2 (XI1134_n1 dd6_b3_2 b13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1134_MN3 (VSS qu19_b3_1 XI1134_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1134_MN0 (XI1134_An dd6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1131_MN1 (XI1131_Bn qu19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1131_MN5 (XI1131_n2 XI1131_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1131_MN4 (b13_3 XI1131_An XI1131_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1131_MN2 (XI1131_n1 dd3_b3_2 b13_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1131_MN3 (VSS qu19_b3_0 XI1131_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1131_MN0 (XI1131_An dd3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1178_MN1 (XI1178_Bn qu18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1178_MN5 (XI1178_n2 XI1178_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1178_MN4 (b14_4 XI1178_An XI1178_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1178_MN2 (XI1178_n1 dd4_b3_2 b14_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1178_MN3 (VSS qu18_b3_0 XI1178_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1178_MN0 (XI1178_An dd4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1176_MN1 (XI1176_Bn qu18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1176_MN5 (XI1176_n2 XI1176_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1176_MN4 (b14_2 XI1176_An XI1176_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1176_MN2 (XI1176_n1 dd2_b3_2 b14_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1176_MN3 (VSS qu18_b3_0 XI1176_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1176_MN0 (XI1176_An dd2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1224_MN1 (XI1224_Bn qu17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1224_MN5 (XI1224_n2 XI1224_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1224_MN4 (b15_4 XI1224_An XI1224_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1224_MN2 (XI1224_n1 dd4_b3_2 b15_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1224_MN3 (VSS qu17_b3_0 XI1224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1224_MN0 (XI1224_An dd4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1223_MN1 (XI1223_Bn qu17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1223_MN5 (XI1223_n2 XI1223_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1223_MN4 (b15_3 XI1223_An XI1223_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1223_MN2 (XI1223_n1 dd3_b3_2 b15_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1223_MN3 (VSS qu17_b3_0 XI1223_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1223_MN0 (XI1223_An dd3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1271_MN1 (XI1271_Bn qu16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1271_MN5 (XI1271_n2 XI1271_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1271_MN4 (b16_5 XI1271_An XI1271_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1271_MN2 (XI1271_n1 dd5_b3_2 b16_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1271_MN3 (VSS qu16_b3_0 XI1271_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1271_MN0 (XI1271_An dd5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1270_MN1 (XI1270_Bn qu16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1270_MN5 (XI1270_n2 XI1270_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1270_MN4 (b16_4 XI1270_An XI1270_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1270_MN2 (XI1270_n1 dd4_b3_2 b16_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1270_MN3 (VSS qu16_b3_0 XI1270_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1270_MN0 (XI1270_An dd4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1269_MN1 (XI1269_Bn qu16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1269_MN5 (XI1269_n2 XI1269_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1269_MN4 (b16_3 XI1269_An XI1269_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1269_MN2 (XI1269_n1 dd3_b3_2 b16_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1269_MN3 (VSS qu16_b3_0 XI1269_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1269_MN0 (XI1269_An dd3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I206_MN1 (XI1298_I206_Bn I1298_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I206_MN5 (XI1298_I206_n2 XI1298_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I206_MN4 (p16_3 XI1298_I206_An XI1298_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I206_MN2 (XI1298_I206_n1 I1298_pn3 p16_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I206_MN3 (VSS I1298_G2_0n XI1298_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I206_MN0 (XI1298_I206_An I1298_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I207_MN1 (XI1298_I207_Bn I1298_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I207_MN5 (XI1298_I207_n2 XI1298_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I207_MN4 (p16_4 XI1298_I207_An XI1298_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I207_MN2 (XI1298_I207_n1 I1298_pn4 p16_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I207_MN3 (VSS I1298_G3_0n XI1298_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I207_MN0 (XI1298_I207_An I1298_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I207_MN1 (XI1344_I207_Bn I1344_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I207_MN5 (XI1344_I207_n2 XI1344_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I207_MN4 (p17_4 XI1344_I207_An XI1344_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I207_MN2 (XI1344_I207_n1 I1344_pn4 p17_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I207_MN3 (VSS I1344_G3_0n XI1344_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I207_MN0 (XI1344_I207_An I1344_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1318_MN1 (XI1318_Bn qu15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1318_MN5 (XI1318_n2 XI1318_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1318_MN4 (b17_6 XI1318_An XI1318_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1318_MN2 (XI1318_n1 dd6_b3_3 b17_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1318_MN3 (VSS qu15_b3_1 XI1318_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1318_MN0 (XI1318_An dd6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1319_MN1 (XI1319_Bn qu15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1319_MN5 (XI1319_n2 XI1319_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1319_MN4 (b17_7 XI1319_An XI1319_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1319_MN2 (XI1319_n1 dd7_b3_3 b17_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1319_MN3 (VSS qu15_b3_1 XI1319_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1319_MN0 (XI1319_An dd7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1365_MN1 (XI1365_Bn qu14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1365_MN5 (XI1365_n2 XI1365_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1365_MN4 (b18_7 XI1365_An XI1365_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1365_MN2 (XI1365_n1 dd7_b3_3 b18_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1365_MN3 (VSS qu14_b3_1 XI1365_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1365_MN0 (XI1365_An dd7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I207_MN1 (XI1390_I207_Bn I1390_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I207_MN5 (XI1390_I207_n2 XI1390_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I207_MN4 (p18_4 XI1390_I207_An XI1390_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I207_MN2 (XI1390_I207_n1 I1390_pn4 p18_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I207_MN3 (VSS I1390_G3_0n XI1390_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I207_MN0 (XI1390_I207_An I1390_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1411_MN1 (XI1411_Bn qu13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1411_MN5 (XI1411_n2 XI1411_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1411_MN4 (b19_7 XI1411_An XI1411_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1411_MN2 (XI1411_n1 dd7_b3_3 b19_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1411_MN3 (VSS qu13_b3_1 XI1411_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1411_MN0 (XI1411_An dd7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I207_MN1 (XI1436_I207_Bn I1436_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I207_MN5 (XI1436_I207_n2 XI1436_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I207_MN4 (p19_4 XI1436_I207_An XI1436_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I207_MN2 (XI1436_I207_n1 I1436_pn4 p19_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I207_MN3 (VSS I1436_G3_0n XI1436_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I207_MN0 (XI1436_I207_An I1436_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1458_MN1 (XI1458_Bn qu12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1458_MN5 (XI1458_n2 XI1458_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1458_MN4 (b20_8 XI1458_An XI1458_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1458_MN2 (XI1458_n1 dd8_b3_3 b20_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1458_MN3 (VSS qu12_b3_1 XI1458_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1458_MN0 (XI1458_An dd8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1456_MN1 (XI1456_Bn qu12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1456_MN5 (XI1456_n2 XI1456_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1456_MN4 (b20_6 XI1456_An XI1456_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1456_MN2 (XI1456_n1 dd6_b3_3 b20_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1456_MN3 (VSS qu12_b3_1 XI1456_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1456_MN0 (XI1456_An dd6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1457_MN1 (XI1457_Bn qu12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1457_MN5 (XI1457_n2 XI1457_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1457_MN4 (b20_7 XI1457_An XI1457_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1457_MN2 (XI1457_n1 dd7_b3_3 b20_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1457_MN3 (VSS qu12_b3_1 XI1457_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1457_MN0 (XI1457_An dd7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1503_MN1 (XI1503_Bn qu11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1503_MN5 (XI1503_n2 XI1503_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1503_MN4 (b21_7 XI1503_An XI1503_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1503_MN2 (XI1503_n1 dd7_b3_3 b21_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1503_MN3 (VSS qu11_b3_1 XI1503_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1503_MN0 (XI1503_An dd7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1505_MN1 (XI1505_Bn qu11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1505_MN5 (XI1505_n2 XI1505_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1505_MN4 (b21_9 XI1505_An XI1505_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1505_MN2 (XI1505_n1 dd9_b3_3 b21_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1505_MN3 (VSS qu11_b3_1 XI1505_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1505_MN0 (XI1505_An dd9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1161_MN1 (XI1161_Bn qu19_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1161_MN5 (XI1161_n2 XI1161_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1161_MN4 (h13 XI1161_An XI1161_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1161_MN2 (XI1161_n1 p12_31 h13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1161_MN3 (VSS qu19_b3_5 XI1161_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1161_MN0 (XI1161_An p12_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1151_MN1 (XI1151_Bn qu19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1151_MN5 (XI1151_n2 XI1151_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1151_MN4 (b13_23 XI1151_An XI1151_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1151_MN2 (XI1151_n1 dd23_b3_2 b13_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1151_MN3 (VSS qu19_b3_3 XI1151_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1151_MN0 (XI1151_An dd23_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1150_MN1 (XI1150_Bn qu19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1150_MN5 (XI1150_n2 XI1150_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1150_MN4 (b13_22 XI1150_An XI1150_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1150_MN2 (XI1150_n1 dd22_b3_2 b13_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1150_MN3 (VSS qu19_b3_3 XI1150_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1150_MN0 (XI1150_An dd22_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1146_MN1 (XI1146_Bn qu19_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1146_MN5 (XI1146_n2 XI1146_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1146_MN4 (b13_18 XI1146_An XI1146_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1146_MN2 (XI1146_n1 dd18_b3_2 b13_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1146_MN3 (VSS qu19_b3_3 XI1146_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1146_MN0 (XI1146_An dd18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1142_MN1 (XI1142_Bn qu19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1142_MN5 (XI1142_n2 XI1142_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1142_MN4 (b13_14 XI1142_An XI1142_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1142_MN2 (XI1142_n1 dd14_b3_2 b13_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1142_MN3 (VSS qu19_b3_2 XI1142_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1142_MN0 (XI1142_An dd14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1145_MN1 (XI1145_Bn qu19_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1145_MN5 (XI1145_n2 XI1145_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1145_MN4 (b13_17 XI1145_An XI1145_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1145_MN2 (XI1145_n1 dd17_b3_2 b13_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1145_MN3 (VSS qu19_b3_2 XI1145_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1145_MN0 (XI1145_An dd17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1139_MN1 (XI1139_Bn qu19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1139_MN5 (XI1139_n2 XI1139_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1139_MN4 (b13_11 XI1139_An XI1139_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1139_MN2 (XI1139_n1 dd11_b3_2 b13_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1139_MN3 (VSS qu19_b3_1 XI1139_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1139_MN0 (XI1139_An dd11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1179_MN1 (XI1179_Bn qu18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1179_MN5 (XI1179_n2 XI1179_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1179_MN4 (b14_5 XI1179_An XI1179_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1179_MN2 (XI1179_n1 dd5_b3_2 b14_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1179_MN3 (VSS qu18_b3_0 XI1179_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1179_MN0 (XI1179_An dd5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1226_MN1 (XI1226_Bn qu17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1226_MN5 (XI1226_n2 XI1226_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1226_MN4 (b15_6 XI1226_An XI1226_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1226_MN2 (XI1226_n1 dd6_b3_2 b15_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1226_MN3 (VSS qu17_b3_1 XI1226_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1226_MN0 (XI1226_An dd6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1225_MN1 (XI1225_Bn qu17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1225_MN5 (XI1225_n2 XI1225_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1225_MN4 (b15_5 XI1225_An XI1225_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1225_MN2 (XI1225_n1 dd5_b3_2 b15_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1225_MN3 (VSS qu17_b3_0 XI1225_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1225_MN0 (XI1225_An dd5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I206_MN1 (XI1252_I206_Bn I1252_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I206_MN5 (XI1252_I206_n2 XI1252_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I206_MN4 (p15_3 XI1252_I206_An XI1252_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I206_MN2 (XI1252_I206_n1 I1252_pn3 p15_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I206_MN3 (VSS I1252_G2_0n XI1252_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I206_MN0 (XI1252_I206_An I1252_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I207_MN1 (XI1252_I207_Bn I1252_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I207_MN5 (XI1252_I207_n2 XI1252_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I207_MN4 (p15_4 XI1252_I207_An XI1252_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I207_MN2 (XI1252_I207_n1 I1252_pn4 p15_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I207_MN3 (VSS I1252_G3_0n XI1252_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I207_MN0 (XI1252_I207_An I1252_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1273_MN1 (XI1273_Bn qu16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1273_MN5 (XI1273_n2 XI1273_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1273_MN4 (b16_7 XI1273_An XI1273_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1273_MN2 (XI1273_n1 dd7_b3_2 b16_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1273_MN3 (VSS qu16_b3_1 XI1273_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1273_MN0 (XI1273_An dd7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1272_MN1 (XI1272_Bn qu16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1272_MN5 (XI1272_n2 XI1272_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1272_MN4 (b16_6 XI1272_An XI1272_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1272_MN2 (XI1272_n1 dd6_b3_2 b16_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1272_MN3 (VSS qu16_b3_1 XI1272_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1272_MN0 (XI1272_An dd6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1320_MN1 (XI1320_Bn qu15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1320_MN5 (XI1320_n2 XI1320_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1320_MN4 (b17_8 XI1320_An XI1320_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1320_MN2 (XI1320_n1 dd8_b3_3 b17_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1320_MN3 (VSS qu15_b3_1 XI1320_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1320_MN0 (XI1320_An dd8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1321_MN1 (XI1321_Bn qu15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1321_MN5 (XI1321_n2 XI1321_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1321_MN4 (b17_9 XI1321_An XI1321_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1321_MN2 (XI1321_n1 dd9_b3_3 b17_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1321_MN3 (VSS qu15_b3_1 XI1321_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1321_MN0 (XI1321_An dd9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1366_MN1 (XI1366_Bn qu14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1366_MN5 (XI1366_n2 XI1366_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1366_MN4 (b18_8 XI1366_An XI1366_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1366_MN2 (XI1366_n1 dd8_b3_3 b18_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1366_MN3 (VSS qu14_b3_1 XI1366_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1366_MN0 (XI1366_An dd8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1368_MN1 (XI1368_Bn qu14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1368_MN5 (XI1368_n2 XI1368_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1368_MN4 (b18_10 XI1368_An XI1368_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1368_MN2 (XI1368_n1 dd10_b3_3 b18_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1368_MN3 (VSS qu14_b3_1 XI1368_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1368_MN0 (XI1368_An dd10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1367_MN1 (XI1367_Bn qu14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1367_MN5 (XI1367_n2 XI1367_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1367_MN4 (b18_9 XI1367_An XI1367_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1367_MN2 (XI1367_n1 dd9_b3_3 b18_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1367_MN3 (VSS qu14_b3_1 XI1367_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1367_MN0 (XI1367_An dd9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1412_MN1 (XI1412_Bn qu13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1412_MN5 (XI1412_n2 XI1412_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1412_MN4 (b19_8 XI1412_An XI1412_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1412_MN2 (XI1412_n1 dd8_b3_3 b19_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1412_MN3 (VSS qu13_b3_1 XI1412_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1412_MN0 (XI1412_An dd8_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1413_MN1 (XI1413_Bn qu13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1413_MN5 (XI1413_n2 XI1413_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1413_MN4 (b19_9 XI1413_An XI1413_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1413_MN2 (XI1413_n1 dd9_b3_3 b19_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1413_MN3 (VSS qu13_b3_1 XI1413_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1413_MN0 (XI1413_An dd9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1507_MN1 (XI1507_Bn qu11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1507_MN5 (XI1507_n2 XI1507_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1507_MN4 (b21_11 XI1507_An XI1507_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1507_MN2 (XI1507_n1 dd11_b3_3 b21_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1507_MN3 (VSS qu11_b3_1 XI1507_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1507_MN0 (XI1507_An dd11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1506_MN1 (XI1506_Bn qu11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1506_MN5 (XI1506_n2 XI1506_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1506_MN4 (b21_10 XI1506_An XI1506_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1506_MN2 (XI1506_n1 dd10_b3_3 b21_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1506_MN3 (VSS qu11_b3_1 XI1506_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1506_MN0 (XI1506_An dd10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1459_MN1 (XI1459_Bn qu12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1459_MN5 (XI1459_n2 XI1459_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1459_MN4 (b20_9 XI1459_An XI1459_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1459_MN2 (XI1459_n1 dd9_b3_3 b20_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1459_MN3 (VSS qu12_b3_1 XI1459_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1459_MN0 (XI1459_An dd9_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I214_MN1 (XI1528_I214_Bn I1528_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I214_MN5 (XI1528_I214_n2 XI1528_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I214_MN4 (p21_11 XI1528_I214_An XI1528_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I214_MN2 (XI1528_I214_n1 I1528_pn11 p21_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I214_MN3 (VSS I1528_G10_0n XI1528_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I214_MN0 (XI1528_I214_An I1528_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I216_MN1 (XI1528_I216_Bn I1528_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I216_MN5 (XI1528_I216_n2 XI1528_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I216_MN4 (p21_13 XI1528_I216_An XI1528_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I216_MN2 (XI1528_I216_n1 I1528_pn13 p21_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I216_MN3 (VSS I1528_G12_0n XI1528_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I216_MN0 (XI1528_I216_An I1528_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I215_MN1 (XI1528_I215_Bn I1528_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I215_MN5 (XI1528_I215_n2 XI1528_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I215_MN4 (p21_12 XI1528_I215_An XI1528_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I215_MN2 (XI1528_I215_n1 I1528_pn12 p21_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I215_MN3 (VSS I1528_G11_0n XI1528_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I215_MN0 (XI1528_I215_An I1528_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1158_MN1 (XI1158_Bn qu19_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1158_MN5 (XI1158_n2 XI1158_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1158_MN4 (b13_30 XI1158_An XI1158_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1158_MN2 (XI1158_n1 dd30_b3_2 b13_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1158_MN3 (VSS qu19_b3_5 XI1158_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1158_MN0 (XI1158_An dd30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1159_MN1 (XI1159_Bn qu19_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1159_MN5 (XI1159_n2 XI1159_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1159_MN4 (b13_31 XI1159_An XI1159_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1159_MN2 (XI1159_n1 dd31_b3_2 b13_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1159_MN3 (VSS qu19_b3_5 XI1159_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1159_MN0 (XI1159_An dd31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1137_MN1 (XI1137_Bn qu19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1137_MN5 (XI1137_n2 XI1137_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1137_MN4 (b13_9 XI1137_An XI1137_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1137_MN2 (XI1137_n1 dd9_b3_2 b13_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1137_MN3 (VSS qu19_b3_1 XI1137_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1137_MN0 (XI1137_An dd9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1138_MN1 (XI1138_Bn qu19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1138_MN5 (XI1138_n2 XI1138_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1138_MN4 (b13_10 XI1138_An XI1138_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1138_MN2 (XI1138_n1 dd10_b3_2 b13_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1138_MN3 (VSS qu19_b3_1 XI1138_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1138_MN0 (XI1138_An dd10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1136_MN1 (XI1136_Bn qu19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1136_MN5 (XI1136_n2 XI1136_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1136_MN4 (b13_8 XI1136_An XI1136_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1136_MN2 (XI1136_n1 dd8_b3_2 b13_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1136_MN3 (VSS qu19_b3_1 XI1136_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1136_MN0 (XI1136_An dd8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1185_MN1 (XI1185_Bn qu18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1185_MN5 (XI1185_n2 XI1185_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1185_MN4 (b14_11 XI1185_An XI1185_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1185_MN2 (XI1185_n1 dd11_b3_2 b14_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1185_MN3 (VSS qu18_b3_1 XI1185_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1185_MN0 (XI1185_An dd11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1182_MN1 (XI1182_Bn qu18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1182_MN5 (XI1182_n2 XI1182_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1182_MN4 (b14_8 XI1182_An XI1182_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1182_MN2 (XI1182_n1 dd8_b3_2 b14_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1182_MN3 (VSS qu18_b3_1 XI1182_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1182_MN0 (XI1182_An dd8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1180_MN1 (XI1180_Bn qu18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1180_MN5 (XI1180_n2 XI1180_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1180_MN4 (b14_6 XI1180_An XI1180_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1180_MN2 (XI1180_n1 dd6_b3_2 b14_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1180_MN3 (VSS qu18_b3_1 XI1180_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1180_MN0 (XI1180_An dd6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1181_MN1 (XI1181_Bn qu18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1181_MN5 (XI1181_n2 XI1181_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1181_MN4 (b14_7 XI1181_An XI1181_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1181_MN2 (XI1181_n1 dd7_b3_2 b14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1181_MN3 (VSS qu18_b3_1 XI1181_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1181_MN0 (XI1181_An dd7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I207_MN1 (XI1206_I207_Bn I1206_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I207_MN5 (XI1206_I207_n2 XI1206_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I207_MN4 (p14_4 XI1206_I207_An XI1206_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I207_MN2 (XI1206_I207_n1 I1206_pn4 p14_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I207_MN3 (VSS I1206_G3_0n XI1206_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I207_MN0 (XI1206_I207_An I1206_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I206_MN1 (XI1206_I206_Bn I1206_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I206_MN5 (XI1206_I206_n2 XI1206_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I206_MN4 (p14_3 XI1206_I206_An XI1206_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I206_MN2 (XI1206_I206_n1 I1206_pn3 p14_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I206_MN3 (VSS I1206_G2_0n XI1206_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I206_MN0 (XI1206_I206_An I1206_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1227_MN1 (XI1227_Bn qu17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1227_MN5 (XI1227_n2 XI1227_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1227_MN4 (b15_7 XI1227_An XI1227_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1227_MN2 (XI1227_n1 dd7_b3_2 b15_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1227_MN3 (VSS qu17_b3_1 XI1227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1227_MN0 (XI1227_An dd7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1231_MN1 (XI1231_Bn qu17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1231_MN5 (XI1231_n2 XI1231_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1231_MN4 (b15_11 XI1231_An XI1231_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1231_MN2 (XI1231_n1 dd11_b3_2 b15_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1231_MN3 (VSS qu17_b3_1 XI1231_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1231_MN0 (XI1231_An dd11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1228_MN1 (XI1228_Bn qu17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1228_MN5 (XI1228_n2 XI1228_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1228_MN4 (b15_8 XI1228_An XI1228_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1228_MN2 (XI1228_n1 dd8_b3_2 b15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1228_MN3 (VSS qu17_b3_1 XI1228_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1228_MN0 (XI1228_An dd8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1274_MN1 (XI1274_Bn qu16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1274_MN5 (XI1274_n2 XI1274_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1274_MN4 (b16_8 XI1274_An XI1274_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1274_MN2 (XI1274_n1 dd8_b3_2 b16_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1274_MN3 (VSS qu16_b3_1 XI1274_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1274_MN0 (XI1274_An dd8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1277_MN1 (XI1277_Bn qu16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1277_MN5 (XI1277_n2 XI1277_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1277_MN4 (b16_11 XI1277_An XI1277_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1277_MN2 (XI1277_n1 dd11_b3_2 b16_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1277_MN3 (VSS qu16_b3_1 XI1277_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1277_MN0 (XI1277_An dd11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1275_MN1 (XI1275_Bn qu16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1275_MN5 (XI1275_n2 XI1275_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1275_MN4 (b16_9 XI1275_An XI1275_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1275_MN2 (XI1275_n1 dd9_b3_2 b16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1275_MN3 (VSS qu16_b3_1 XI1275_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1275_MN0 (XI1275_An dd9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I212_MN1 (XI1298_I212_Bn I1298_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I212_MN5 (XI1298_I212_n2 XI1298_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I212_MN4 (p16_9 XI1298_I212_An XI1298_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I212_MN2 (XI1298_I212_n1 I1298_pn9 p16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I212_MN3 (VSS I1298_G8_0n XI1298_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I212_MN0 (XI1298_I212_An I1298_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I212_MN1 (XI1344_I212_Bn I1344_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I212_MN5 (XI1344_I212_n2 XI1344_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I212_MN4 (p17_9 XI1344_I212_An XI1344_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I212_MN2 (XI1344_I212_n1 I1344_pn9 p17_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I212_MN3 (VSS I1344_G8_0n XI1344_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I212_MN0 (XI1344_I212_An I1344_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1322_MN1 (XI1322_Bn qu15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1322_MN5 (XI1322_n2 XI1322_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1322_MN4 (b17_10 XI1322_An XI1322_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1322_MN2 (XI1322_n1 dd10_b3_3 b17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1322_MN3 (VSS qu15_b3_1 XI1322_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1322_MN0 (XI1322_An dd10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1323_MN1 (XI1323_Bn qu15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1323_MN5 (XI1323_n2 XI1323_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1323_MN4 (b17_11 XI1323_An XI1323_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1323_MN2 (XI1323_n1 dd11_b3_3 b17_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1323_MN3 (VSS qu15_b3_1 XI1323_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1323_MN0 (XI1323_An dd11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1369_MN1 (XI1369_Bn qu14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1369_MN5 (XI1369_n2 XI1369_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1369_MN4 (b18_11 XI1369_An XI1369_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1369_MN2 (XI1369_n1 dd11_b3_3 b18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1369_MN3 (VSS qu14_b3_1 XI1369_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1369_MN0 (XI1369_An dd11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I212_MN1 (XI1390_I212_Bn I1390_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I212_MN5 (XI1390_I212_n2 XI1390_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I212_MN4 (p18_9 XI1390_I212_An XI1390_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I212_MN2 (XI1390_I212_n1 I1390_pn9 p18_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I212_MN3 (VSS I1390_G8_0n XI1390_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I212_MN0 (XI1390_I212_An I1390_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1414_MN1 (XI1414_Bn qu13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1414_MN5 (XI1414_n2 XI1414_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1414_MN4 (b19_10 XI1414_An XI1414_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1414_MN2 (XI1414_n1 dd10_b3_3 b19_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1414_MN3 (VSS qu13_b3_1 XI1414_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1414_MN0 (XI1414_An dd10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1415_MN1 (XI1415_Bn qu13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1415_MN5 (XI1415_n2 XI1415_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1415_MN4 (b19_11 XI1415_An XI1415_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1415_MN2 (XI1415_n1 dd11_b3_3 b19_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1415_MN3 (VSS qu13_b3_1 XI1415_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1415_MN0 (XI1415_An dd11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I212_MN1 (XI1436_I212_Bn I1436_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I212_MN5 (XI1436_I212_n2 XI1436_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I212_MN4 (p19_9 XI1436_I212_An XI1436_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I212_MN2 (XI1436_I212_n1 I1436_pn9 p19_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I212_MN3 (VSS I1436_G8_0n XI1436_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I212_MN0 (XI1436_I212_An I1436_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1508_MN1 (XI1508_Bn qu11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1508_MN5 (XI1508_n2 XI1508_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1508_MN4 (b21_12 XI1508_An XI1508_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1508_MN2 (XI1508_n1 dd12_b3_3 b21_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1508_MN3 (VSS qu11_b3_2 XI1508_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1508_MN0 (XI1508_An dd12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1461_MN1 (XI1461_Bn qu12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1461_MN5 (XI1461_n2 XI1461_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1461_MN4 (b20_11 XI1461_An XI1461_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1461_MN2 (XI1461_n1 dd11_b3_3 b20_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1461_MN3 (VSS qu12_b3_1 XI1461_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1461_MN0 (XI1461_An dd11_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1460_MN1 (XI1460_Bn qu12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1460_MN5 (XI1460_n2 XI1460_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1460_MN4 (b20_10 XI1460_An XI1460_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1460_MN2 (XI1460_n1 dd10_b3_3 b20_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1460_MN3 (VSS qu12_b3_1 XI1460_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1460_MN0 (XI1460_An dd10_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I213_MN1 (XI1482_I213_Bn I1482_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I213_MN5 (XI1482_I213_n2 XI1482_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I213_MN4 (p20_10 XI1482_I213_An XI1482_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I213_MN2 (XI1482_I213_n1 I1482_pn10 p20_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I213_MN3 (VSS I1482_G9_0n XI1482_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I213_MN0 (XI1482_I213_An I1482_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I212_MN1 (XI1482_I212_Bn I1482_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I212_MN5 (XI1482_I212_n2 XI1482_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I212_MN4 (p20_9 XI1482_I212_An XI1482_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I212_MN2 (XI1482_I212_n1 I1482_pn9 p20_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I212_MN3 (VSS I1482_G8_0n XI1482_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I212_MN0 (XI1482_I212_An I1482_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I217_MN1 (XI1528_I217_Bn I1528_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I217_MN5 (XI1528_I217_n2 XI1528_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I217_MN4 (p21_14 XI1528_I217_An XI1528_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I217_MN2 (XI1528_I217_n1 I1528_pn14 p21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I217_MN3 (VSS I1528_G13_0n XI1528_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I217_MN0 (XI1528_I217_An I1528_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I207_MN1 (XI1160_I207_Bn I1160_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I207_MN5 (XI1160_I207_n2 XI1160_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I207_MN4 (p13_4 XI1160_I207_An XI1160_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I207_MN2 (XI1160_I207_n1 I1160_pn4 p13_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I207_MN3 (VSS I1160_G3_0n XI1160_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I207_MN0 (XI1160_I207_An I1160_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I206_MN1 (XI1160_I206_Bn I1160_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I206_MN5 (XI1160_I206_n2 XI1160_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I206_MN4 (p13_3 XI1160_I206_An XI1160_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I206_MN2 (XI1160_I206_n1 I1160_pn3 p13_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I206_MN3 (VSS I1160_G2_0n XI1160_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I206_MN0 (XI1160_I206_An I1160_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1183_MN1 (XI1183_Bn qu18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1183_MN5 (XI1183_n2 XI1183_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1183_MN4 (b14_9 XI1183_An XI1183_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1183_MN2 (XI1183_n1 dd9_b3_2 b14_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1183_MN3 (VSS qu18_b3_1 XI1183_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1183_MN0 (XI1183_An dd9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1184_MN1 (XI1184_Bn qu18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1184_MN5 (XI1184_n2 XI1184_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1184_MN4 (b14_10 XI1184_An XI1184_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1184_MN2 (XI1184_n1 dd10_b3_2 b14_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1184_MN3 (VSS qu18_b3_1 XI1184_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1184_MN0 (XI1184_An dd10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1229_MN1 (XI1229_Bn qu17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1229_MN5 (XI1229_n2 XI1229_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1229_MN4 (b15_9 XI1229_An XI1229_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1229_MN2 (XI1229_n1 dd9_b3_2 b15_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1229_MN3 (VSS qu17_b3_1 XI1229_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1229_MN0 (XI1229_An dd9_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1230_MN1 (XI1230_Bn qu17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1230_MN5 (XI1230_n2 XI1230_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1230_MN4 (b15_10 XI1230_An XI1230_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1230_MN2 (XI1230_n1 dd10_b3_2 b15_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1230_MN3 (VSS qu17_b3_1 XI1230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1230_MN0 (XI1230_An dd10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1276_MN1 (XI1276_Bn qu16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1276_MN5 (XI1276_n2 XI1276_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1276_MN4 (b16_10 XI1276_An XI1276_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1276_MN2 (XI1276_n1 dd10_b3_2 b16_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1276_MN3 (VSS qu16_b3_1 XI1276_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1276_MN0 (XI1276_An dd10_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I213_MN1 (XI1298_I213_Bn I1298_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I213_MN5 (XI1298_I213_n2 XI1298_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I213_MN4 (p16_10 XI1298_I213_An XI1298_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I213_MN2 (XI1298_I213_n1 I1298_pn10 p16_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I213_MN3 (VSS I1298_G9_0n XI1298_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I213_MN0 (XI1298_I213_An I1298_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I214_MN1 (XI1344_I214_Bn I1344_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I214_MN5 (XI1344_I214_n2 XI1344_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I214_MN4 (p17_11 XI1344_I214_An XI1344_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I214_MN2 (XI1344_I214_n1 I1344_pn11 p17_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I214_MN3 (VSS I1344_G10_0n XI1344_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I214_MN0 (XI1344_I214_An I1344_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I213_MN1 (XI1344_I213_Bn I1344_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I213_MN5 (XI1344_I213_n2 XI1344_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I213_MN4 (p17_10 XI1344_I213_An XI1344_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I213_MN2 (XI1344_I213_n1 I1344_pn10 p17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I213_MN3 (VSS I1344_G9_0n XI1344_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I213_MN0 (XI1344_I213_An I1344_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1370_MN1 (XI1370_Bn qu14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1370_MN5 (XI1370_n2 XI1370_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1370_MN4 (b18_12 XI1370_An XI1370_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1370_MN2 (XI1370_n1 dd12_b3_3 b18_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1370_MN3 (VSS qu14_b3_2 XI1370_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1370_MN0 (XI1370_An dd12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I214_MN1 (XI1390_I214_Bn I1390_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I214_MN5 (XI1390_I214_n2 XI1390_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I214_MN4 (p18_11 XI1390_I214_An XI1390_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I214_MN2 (XI1390_I214_n1 I1390_pn11 p18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I214_MN3 (VSS I1390_G10_0n XI1390_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I214_MN0 (XI1390_I214_An I1390_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I213_MN1 (XI1390_I213_Bn I1390_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I213_MN5 (XI1390_I213_n2 XI1390_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I213_MN4 (p18_10 XI1390_I213_An XI1390_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I213_MN2 (XI1390_I213_n1 I1390_pn10 p18_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I213_MN3 (VSS I1390_G9_0n XI1390_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I213_MN0 (XI1390_I213_An I1390_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I213_MN1 (XI1436_I213_Bn I1436_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I213_MN5 (XI1436_I213_n2 XI1436_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I213_MN4 (p19_10 XI1436_I213_An XI1436_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I213_MN2 (XI1436_I213_n1 I1436_pn10 p19_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I213_MN3 (VSS I1436_G9_0n XI1436_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I213_MN0 (XI1436_I213_An I1436_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1510_MN1 (XI1510_Bn qu11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1510_MN5 (XI1510_n2 XI1510_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1510_MN4 (b21_14 XI1510_An XI1510_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1510_MN2 (XI1510_n1 dd14_b3_3 b21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1510_MN3 (VSS qu11_b3_2 XI1510_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1510_MN0 (XI1510_An dd14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1509_MN1 (XI1509_Bn qu11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1509_MN5 (XI1509_n2 XI1509_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1509_MN4 (b21_13 XI1509_An XI1509_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1509_MN2 (XI1509_n1 dd13_b3_3 b21_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1509_MN3 (VSS qu11_b3_2 XI1509_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1509_MN0 (XI1509_An dd13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I215_MN1 (XI1482_I215_Bn I1482_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I215_MN5 (XI1482_I215_n2 XI1482_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I215_MN4 (p20_12 XI1482_I215_An XI1482_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I215_MN2 (XI1482_I215_n1 I1482_pn12 p20_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I215_MN3 (VSS I1482_G11_0n XI1482_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I215_MN0 (XI1482_I215_An I1482_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I218_MN1 (XI1528_I218_Bn I1528_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I218_MN5 (XI1528_I218_n2 XI1528_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I218_MN4 (p21_15 XI1528_I218_An XI1528_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I218_MN2 (XI1528_I218_n1 I1528_pn15 p21_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I218_MN3 (VSS I1528_G14_0n XI1528_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I218_MN0 (XI1528_I218_An I1528_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1162_MN1 (XI1162_Bn c13_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1162_MN5 (XI1162_n2 XI1162_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1162_MN4 (p13_32 XI1162_An XI1162_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1162_MN2 (XI1162_n1 h13 p13_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1162_MN3 (VSS c13_o XI1162_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1162_MN0 (XI1162_An h13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I219_MN1 (XI1160_I219_Bn I1160_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I219_MN5 (XI1160_I219_n2 XI1160_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I219_MN4 (p13_16 XI1160_I219_An XI1160_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I219_MN2 (XI1160_I219_n1 I1160_pn16 p13_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I219_MN3 (VSS I1160_G15_0n XI1160_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I219_MN0 (XI1160_I219_An I1160_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I212_MN1 (XI1252_I212_Bn I1252_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I212_MN5 (XI1252_I212_n2 XI1252_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I212_MN4 (p15_9 XI1252_I212_An XI1252_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I212_MN2 (XI1252_I212_n1 I1252_pn9 p15_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I212_MN3 (VSS I1252_G8_0n XI1252_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I212_MN0 (XI1252_I212_An I1252_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I213_MN1 (XI1252_I213_Bn I1252_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I213_MN5 (XI1252_I213_n2 XI1252_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I213_MN4 (p15_10 XI1252_I213_An XI1252_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I213_MN2 (XI1252_I213_n1 I1252_pn10 p15_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I213_MN3 (VSS I1252_G9_0n XI1252_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I213_MN0 (XI1252_I213_An I1252_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1278_MN1 (XI1278_Bn qu16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1278_MN5 (XI1278_n2 XI1278_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1278_MN4 (b16_12 XI1278_An XI1278_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1278_MN2 (XI1278_n1 dd12_b3_2 b16_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1278_MN3 (VSS qu16_b3_2 XI1278_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1278_MN0 (XI1278_An dd12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I214_MN1 (XI1298_I214_Bn I1298_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I214_MN5 (XI1298_I214_n2 XI1298_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I214_MN4 (p16_11 XI1298_I214_An XI1298_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I214_MN2 (XI1298_I214_n1 I1298_pn11 p16_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I214_MN3 (VSS I1298_G10_0n XI1298_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I214_MN0 (XI1298_I214_An I1298_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I215_MN1 (XI1298_I215_Bn I1298_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I215_MN5 (XI1298_I215_n2 XI1298_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I215_MN4 (p16_12 XI1298_I215_An XI1298_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I215_MN2 (XI1298_I215_n1 I1298_pn12 p16_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I215_MN3 (VSS I1298_G11_0n XI1298_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I215_MN0 (XI1298_I215_An I1298_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I215_MN1 (XI1344_I215_Bn I1344_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I215_MN5 (XI1344_I215_n2 XI1344_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I215_MN4 (p17_12 XI1344_I215_An XI1344_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I215_MN2 (XI1344_I215_n1 I1344_pn12 p17_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I215_MN3 (VSS I1344_G11_0n XI1344_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I215_MN0 (XI1344_I215_An I1344_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1325_MN1 (XI1325_Bn qu15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1325_MN5 (XI1325_n2 XI1325_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1325_MN4 (b17_13 XI1325_An XI1325_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1325_MN2 (XI1325_n1 dd13_b3_3 b17_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1325_MN3 (VSS qu15_b3_2 XI1325_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1325_MN0 (XI1325_An dd13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1324_MN1 (XI1324_Bn qu15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1324_MN5 (XI1324_n2 XI1324_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1324_MN4 (b17_12 XI1324_An XI1324_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1324_MN2 (XI1324_n1 dd12_b3_3 b17_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1324_MN3 (VSS qu15_b3_2 XI1324_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1324_MN0 (XI1324_An dd12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1371_MN1 (XI1371_Bn qu14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1371_MN5 (XI1371_n2 XI1371_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1371_MN4 (b18_13 XI1371_An XI1371_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1371_MN2 (XI1371_n1 dd13_b3_3 b18_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1371_MN3 (VSS qu14_b3_2 XI1371_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1371_MN0 (XI1371_An dd13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I215_MN1 (XI1390_I215_Bn I1390_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I215_MN5 (XI1390_I215_n2 XI1390_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I215_MN4 (p18_12 XI1390_I215_An XI1390_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I215_MN2 (XI1390_I215_n1 I1390_pn12 p18_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I215_MN3 (VSS I1390_G11_0n XI1390_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I215_MN0 (XI1390_I215_An I1390_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1416_MN1 (XI1416_Bn qu13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1416_MN5 (XI1416_n2 XI1416_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1416_MN4 (b19_12 XI1416_An XI1416_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1416_MN2 (XI1416_n1 dd12_b3_3 b19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1416_MN3 (VSS qu13_b3_2 XI1416_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1416_MN0 (XI1416_An dd12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1417_MN1 (XI1417_Bn qu13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1417_MN5 (XI1417_n2 XI1417_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1417_MN4 (b19_13 XI1417_An XI1417_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1417_MN2 (XI1417_n1 dd13_b3_3 b19_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1417_MN3 (VSS qu13_b3_2 XI1417_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1417_MN0 (XI1417_An dd13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I214_MN1 (XI1436_I214_Bn I1436_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I214_MN5 (XI1436_I214_n2 XI1436_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I214_MN4 (p19_11 XI1436_I214_An XI1436_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I214_MN2 (XI1436_I214_n1 I1436_pn11 p19_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I214_MN3 (VSS I1436_G10_0n XI1436_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I214_MN0 (XI1436_I214_An I1436_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I215_MN1 (XI1436_I215_Bn I1436_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I215_MN5 (XI1436_I215_n2 XI1436_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I215_MN4 (p19_12 XI1436_I215_An XI1436_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I215_MN2 (XI1436_I215_n1 I1436_pn12 p19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I215_MN3 (VSS I1436_G11_0n XI1436_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I215_MN0 (XI1436_I215_An I1436_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1462_MN1 (XI1462_Bn qu12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1462_MN5 (XI1462_n2 XI1462_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1462_MN4 (b20_12 XI1462_An XI1462_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1462_MN2 (XI1462_n1 dd12_b3_3 b20_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1462_MN3 (VSS qu12_b3_2 XI1462_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1462_MN0 (XI1462_An dd12_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1511_MN1 (XI1511_Bn qu11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1511_MN5 (XI1511_n2 XI1511_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1511_MN4 (b21_15 XI1511_An XI1511_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1511_MN2 (XI1511_n1 dd15_b3_3 b21_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1511_MN3 (VSS qu11_b3_2 XI1511_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1511_MN0 (XI1511_An dd15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1463_MN1 (XI1463_Bn qu12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1463_MN5 (XI1463_n2 XI1463_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1463_MN4 (b20_13 XI1463_An XI1463_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1463_MN2 (XI1463_n1 dd13_b3_3 b20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1463_MN3 (VSS qu12_b3_2 XI1463_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1463_MN0 (XI1463_An dd13_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I214_MN1 (XI1482_I214_Bn I1482_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I214_MN5 (XI1482_I214_n2 XI1482_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I214_MN4 (p20_11 XI1482_I214_An XI1482_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I214_MN2 (XI1482_I214_n1 I1482_pn11 p20_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I214_MN3 (VSS I1482_G10_0n XI1482_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I214_MN0 (XI1482_I214_An I1482_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I217_MN1 (XI1160_I217_Bn I1160_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I217_MN5 (XI1160_I217_n2 XI1160_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I217_MN4 (p13_14 XI1160_I217_An XI1160_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I217_MN2 (XI1160_I217_n1 I1160_pn14 p13_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I217_MN3 (VSS I1160_G13_0n XI1160_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I217_MN0 (XI1160_I217_An I1160_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I215_MN1 (XI1160_I215_Bn I1160_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I215_MN5 (XI1160_I215_n2 XI1160_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I215_MN4 (p13_12 XI1160_I215_An XI1160_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I215_MN2 (XI1160_I215_n1 I1160_pn12 p13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I215_MN3 (VSS I1160_G11_0n XI1160_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I215_MN0 (XI1160_I215_An I1160_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I213_MN1 (XI1160_I213_Bn I1160_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I213_MN5 (XI1160_I213_n2 XI1160_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I213_MN4 (p13_10 XI1160_I213_An XI1160_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I213_MN2 (XI1160_I213_n1 I1160_pn10 p13_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I213_MN3 (VSS I1160_G9_0n XI1160_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I213_MN0 (XI1160_I213_An I1160_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I212_MN1 (XI1206_I212_Bn I1206_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I212_MN5 (XI1206_I212_n2 XI1206_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I212_MN4 (p14_9 XI1206_I212_An XI1206_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I212_MN2 (XI1206_I212_n1 I1206_pn9 p14_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I212_MN3 (VSS I1206_G8_0n XI1206_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I212_MN0 (XI1206_I212_An I1206_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1232_MN1 (XI1232_Bn qu17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1232_MN5 (XI1232_n2 XI1232_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1232_MN4 (b15_12 XI1232_An XI1232_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1232_MN2 (XI1232_n1 dd12_b3_2 b15_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1232_MN3 (VSS qu17_b3_2 XI1232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1232_MN0 (XI1232_An dd12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1233_MN1 (XI1233_Bn qu17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1233_MN5 (XI1233_n2 XI1233_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1233_MN4 (b15_13 XI1233_An XI1233_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1233_MN2 (XI1233_n1 dd13_b3_2 b15_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1233_MN3 (VSS qu17_b3_2 XI1233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1233_MN0 (XI1233_An dd13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I214_MN1 (XI1252_I214_Bn I1252_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I214_MN5 (XI1252_I214_n2 XI1252_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I214_MN4 (p15_11 XI1252_I214_An XI1252_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I214_MN2 (XI1252_I214_n1 I1252_pn11 p15_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I214_MN3 (VSS I1252_G10_0n XI1252_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I214_MN0 (XI1252_I214_An I1252_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I215_MN1 (XI1252_I215_Bn I1252_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I215_MN5 (XI1252_I215_n2 XI1252_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I215_MN4 (p15_12 XI1252_I215_An XI1252_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I215_MN2 (XI1252_I215_n1 I1252_pn12 p15_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I215_MN3 (VSS I1252_G11_0n XI1252_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I215_MN0 (XI1252_I215_An I1252_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1279_MN1 (XI1279_Bn qu16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1279_MN5 (XI1279_n2 XI1279_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1279_MN4 (b16_13 XI1279_An XI1279_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1279_MN2 (XI1279_n1 dd13_b3_2 b16_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1279_MN3 (VSS qu16_b3_2 XI1279_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1279_MN0 (XI1279_An dd13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I216_MN1 (XI1344_I216_Bn I1344_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I216_MN5 (XI1344_I216_n2 XI1344_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I216_MN4 (p17_13 XI1344_I216_An XI1344_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I216_MN2 (XI1344_I216_n1 I1344_pn13 p17_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I216_MN3 (VSS I1344_G12_0n XI1344_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I216_MN0 (XI1344_I216_An I1344_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1326_MN1 (XI1326_Bn qu15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1326_MN5 (XI1326_n2 XI1326_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1326_MN4 (b17_14 XI1326_An XI1326_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1326_MN2 (XI1326_n1 dd14_b3_3 b17_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1326_MN3 (VSS qu15_b3_2 XI1326_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1326_MN0 (XI1326_An dd14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1372_MN1 (XI1372_Bn qu14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1372_MN5 (XI1372_n2 XI1372_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1372_MN4 (b18_14 XI1372_An XI1372_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1372_MN2 (XI1372_n1 dd14_b3_3 b18_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1372_MN3 (VSS qu14_b3_2 XI1372_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1372_MN0 (XI1372_An dd14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1373_MN1 (XI1373_Bn qu14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1373_MN5 (XI1373_n2 XI1373_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1373_MN4 (b18_15 XI1373_An XI1373_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1373_MN2 (XI1373_n1 dd15_b3_3 b18_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1373_MN3 (VSS qu14_b3_2 XI1373_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1373_MN0 (XI1373_An dd15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I216_MN1 (XI1390_I216_Bn I1390_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I216_MN5 (XI1390_I216_n2 XI1390_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I216_MN4 (p18_13 XI1390_I216_An XI1390_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I216_MN2 (XI1390_I216_n1 I1390_pn13 p18_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I216_MN3 (VSS I1390_G12_0n XI1390_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I216_MN0 (XI1390_I216_An I1390_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1418_MN1 (XI1418_Bn qu13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1418_MN5 (XI1418_n2 XI1418_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1418_MN4 (b19_14 XI1418_An XI1418_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1418_MN2 (XI1418_n1 dd14_b3_3 b19_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1418_MN3 (VSS qu13_b3_2 XI1418_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1418_MN0 (XI1418_An dd14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I216_MN1 (XI1436_I216_Bn I1436_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I216_MN5 (XI1436_I216_n2 XI1436_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I216_MN4 (p19_13 XI1436_I216_An XI1436_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I216_MN2 (XI1436_I216_n1 I1436_pn13 p19_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I216_MN3 (VSS I1436_G12_0n XI1436_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I216_MN0 (XI1436_I216_An I1436_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1512_MN1 (XI1512_Bn qu11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1512_MN5 (XI1512_n2 XI1512_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1512_MN4 (b21_16 XI1512_An XI1512_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1512_MN2 (XI1512_n1 dd16_b3_3 b21_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1512_MN3 (VSS qu11_b3_2 XI1512_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1512_MN0 (XI1512_An dd16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1513_MN1 (XI1513_Bn qu11_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1513_MN5 (XI1513_n2 XI1513_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1513_MN4 (b21_17 XI1513_An XI1513_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1513_MN2 (XI1513_n1 dd17_b3_3 b21_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1513_MN3 (VSS qu11_b3_2 XI1513_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1513_MN0 (XI1513_An dd17_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1464_MN1 (XI1464_Bn qu12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1464_MN5 (XI1464_n2 XI1464_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1464_MN4 (b20_14 XI1464_An XI1464_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1464_MN2 (XI1464_n1 dd14_b3_3 b20_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1464_MN3 (VSS qu12_b3_2 XI1464_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1464_MN0 (XI1464_An dd14_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I216_MN1 (XI1482_I216_Bn I1482_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I216_MN5 (XI1482_I216_n2 XI1482_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I216_MN4 (p20_13 XI1482_I216_An XI1482_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I216_MN2 (XI1482_I216_n1 I1482_pn13 p20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I216_MN3 (VSS I1482_G12_0n XI1482_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I216_MN0 (XI1482_I216_An I1482_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I219_MN1 (XI1528_I219_Bn I1528_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I219_MN5 (XI1528_I219_n2 XI1528_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I219_MN4 (p21_16 XI1528_I219_An XI1528_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I219_MN2 (XI1528_I219_n1 I1528_pn16 p21_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I219_MN3 (VSS I1528_G15_0n XI1528_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I219_MN0 (XI1528_I219_An I1528_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I212_MN1 (XI1160_I212_Bn I1160_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I212_MN5 (XI1160_I212_n2 XI1160_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I212_MN4 (p13_9 XI1160_I212_An XI1160_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I212_MN2 (XI1160_I212_n1 I1160_pn9 p13_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I212_MN3 (VSS I1160_G8_0n XI1160_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I212_MN0 (XI1160_I212_An I1160_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1187_MN1 (XI1187_Bn qu18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1187_MN5 (XI1187_n2 XI1187_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1187_MN4 (b14_13 XI1187_An XI1187_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1187_MN2 (XI1187_n1 dd13_b3_2 b14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1187_MN3 (VSS qu18_b3_2 XI1187_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1187_MN0 (XI1187_An dd13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I214_MN1 (XI1206_I214_Bn I1206_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I214_MN5 (XI1206_I214_n2 XI1206_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I214_MN4 (p14_11 XI1206_I214_An XI1206_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I214_MN2 (XI1206_I214_n1 I1206_pn11 p14_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I214_MN3 (VSS I1206_G10_0n XI1206_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I214_MN0 (XI1206_I214_An I1206_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1234_MN1 (XI1234_Bn qu17_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1234_MN5 (XI1234_n2 XI1234_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1234_MN4 (b15_14 XI1234_An XI1234_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1234_MN2 (XI1234_n1 dd14_b3_2 b15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1234_MN3 (VSS qu17_b3_2 XI1234_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1234_MN0 (XI1234_An dd14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I216_MN1 (XI1252_I216_Bn I1252_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I216_MN5 (XI1252_I216_n2 XI1252_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I216_MN4 (p15_13 XI1252_I216_An XI1252_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I216_MN2 (XI1252_I216_n1 I1252_pn13 p15_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I216_MN3 (VSS I1252_G12_0n XI1252_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I216_MN0 (XI1252_I216_An I1252_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1280_MN1 (XI1280_Bn qu16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1280_MN5 (XI1280_n2 XI1280_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1280_MN4 (b16_14 XI1280_An XI1280_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1280_MN2 (XI1280_n1 dd14_b3_2 b16_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1280_MN3 (VSS qu16_b3_2 XI1280_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1280_MN0 (XI1280_An dd14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1281_MN1 (XI1281_Bn qu16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1281_MN5 (XI1281_n2 XI1281_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1281_MN4 (b16_15 XI1281_An XI1281_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1281_MN2 (XI1281_n1 dd15_b3_2 b16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1281_MN3 (VSS qu16_b3_2 XI1281_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1281_MN0 (XI1281_An dd15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I216_MN1 (XI1298_I216_Bn I1298_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I216_MN5 (XI1298_I216_n2 XI1298_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I216_MN4 (p16_13 XI1298_I216_An XI1298_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I216_MN2 (XI1298_I216_n1 I1298_pn13 p16_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I216_MN3 (VSS I1298_G12_0n XI1298_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I216_MN0 (XI1298_I216_An I1298_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I217_MN1 (XI1298_I217_Bn I1298_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I217_MN5 (XI1298_I217_n2 XI1298_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I217_MN4 (p16_14 XI1298_I217_An XI1298_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I217_MN2 (XI1298_I217_n1 I1298_pn14 p16_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I217_MN3 (VSS I1298_G13_0n XI1298_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I217_MN0 (XI1298_I217_An I1298_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1327_MN1 (XI1327_Bn qu15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1327_MN5 (XI1327_n2 XI1327_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1327_MN4 (b17_15 XI1327_An XI1327_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1327_MN2 (XI1327_n1 dd15_b3_3 b17_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1327_MN3 (VSS qu15_b3_2 XI1327_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1327_MN0 (XI1327_An dd15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I217_MN1 (XI1344_I217_Bn I1344_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I217_MN5 (XI1344_I217_n2 XI1344_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I217_MN4 (p17_14 XI1344_I217_An XI1344_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I217_MN2 (XI1344_I217_n1 I1344_pn14 p17_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I217_MN3 (VSS I1344_G13_0n XI1344_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I217_MN0 (XI1344_I217_An I1344_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1328_MN1 (XI1328_Bn qu15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1328_MN5 (XI1328_n2 XI1328_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1328_MN4 (b17_16 XI1328_An XI1328_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1328_MN2 (XI1328_n1 dd16_b3_3 b17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1328_MN3 (VSS qu15_b3_2 XI1328_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1328_MN0 (XI1328_An dd16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1374_MN1 (XI1374_Bn qu14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1374_MN5 (XI1374_n2 XI1374_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1374_MN4 (b18_16 XI1374_An XI1374_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1374_MN2 (XI1374_n1 dd16_b3_3 b18_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1374_MN3 (VSS qu14_b3_2 XI1374_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1374_MN0 (XI1374_An dd16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I217_MN1 (XI1390_I217_Bn I1390_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I217_MN5 (XI1390_I217_n2 XI1390_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I217_MN4 (p18_14 XI1390_I217_An XI1390_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I217_MN2 (XI1390_I217_n1 I1390_pn14 p18_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I217_MN3 (VSS I1390_G13_0n XI1390_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I217_MN0 (XI1390_I217_An I1390_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1419_MN1 (XI1419_Bn qu13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1419_MN5 (XI1419_n2 XI1419_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1419_MN4 (b19_15 XI1419_An XI1419_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1419_MN2 (XI1419_n1 dd15_b3_3 b19_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1419_MN3 (VSS qu13_b3_2 XI1419_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1419_MN0 (XI1419_An dd15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1420_MN1 (XI1420_Bn qu13_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1420_MN5 (XI1420_n2 XI1420_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1420_MN4 (b19_16 XI1420_An XI1420_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1420_MN2 (XI1420_n1 dd16_b3_3 b19_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1420_MN3 (VSS qu13_b3_2 XI1420_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1420_MN0 (XI1420_An dd16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I217_MN1 (XI1436_I217_Bn I1436_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I217_MN5 (XI1436_I217_n2 XI1436_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I217_MN4 (p19_14 XI1436_I217_An XI1436_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I217_MN2 (XI1436_I217_n1 I1436_pn14 p19_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I217_MN3 (VSS I1436_G13_0n XI1436_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I217_MN0 (XI1436_I217_An I1436_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1466_MN1 (XI1466_Bn qu12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1466_MN5 (XI1466_n2 XI1466_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1466_MN4 (b20_16 XI1466_An XI1466_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1466_MN2 (XI1466_n1 dd16_b3_3 b20_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1466_MN3 (VSS qu12_b3_2 XI1466_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1466_MN0 (XI1466_An dd16_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1465_MN1 (XI1465_Bn qu12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1465_MN5 (XI1465_n2 XI1465_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1465_MN4 (b20_15 XI1465_An XI1465_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1465_MN2 (XI1465_n1 dd15_b3_3 b20_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1465_MN3 (VSS qu12_b3_2 XI1465_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1465_MN0 (XI1465_An dd15_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I217_MN1 (XI1482_I217_Bn I1482_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I217_MN5 (XI1482_I217_n2 XI1482_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I217_MN4 (p20_14 XI1482_I217_An XI1482_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I217_MN2 (XI1482_I217_n1 I1482_pn14 p20_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I217_MN3 (VSS I1482_G13_0n XI1482_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I217_MN0 (XI1482_I217_An I1482_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I218_MN1 (XI1482_I218_Bn I1482_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I218_MN5 (XI1482_I218_n2 XI1482_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I218_MN4 (p20_15 XI1482_I218_An XI1482_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I218_MN2 (XI1482_I218_n1 I1482_pn15 p20_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I218_MN3 (VSS I1482_G14_0n XI1482_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I218_MN0 (XI1482_I218_An I1482_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1152_MN1 (XI1152_Bn qu19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1152_MN5 (XI1152_n2 XI1152_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1152_MN4 (b13_24 XI1152_An XI1152_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1152_MN2 (XI1152_n1 dd24_b3_2 b13_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1152_MN3 (VSS qu19_b3_4 XI1152_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1152_MN0 (XI1152_An dd24_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I214_MN1 (XI1160_I214_Bn I1160_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I214_MN5 (XI1160_I214_n2 XI1160_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I214_MN4 (p13_11 XI1160_I214_An XI1160_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I214_MN2 (XI1160_I214_n1 I1160_pn11 p13_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I214_MN3 (VSS I1160_G10_0n XI1160_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I214_MN0 (XI1160_I214_An I1160_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1190_MN1 (XI1190_Bn qu18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1190_MN5 (XI1190_n2 XI1190_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1190_MN4 (b14_16 XI1190_An XI1190_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1190_MN2 (XI1190_n1 dd16_b3_2 b14_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1190_MN3 (VSS qu18_b3_2 XI1190_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1190_MN0 (XI1190_An dd16_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1188_MN1 (XI1188_Bn qu18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1188_MN5 (XI1188_n2 XI1188_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1188_MN4 (b14_14 XI1188_An XI1188_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1188_MN2 (XI1188_n1 dd14_b3_2 b14_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1188_MN3 (VSS qu18_b3_2 XI1188_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1188_MN0 (XI1188_An dd14_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1189_MN1 (XI1189_Bn qu18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1189_MN5 (XI1189_n2 XI1189_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1189_MN4 (b14_15 XI1189_An XI1189_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1189_MN2 (XI1189_n1 dd15_b3_2 b14_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1189_MN3 (VSS qu18_b3_2 XI1189_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1189_MN0 (XI1189_An dd15_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1186_MN1 (XI1186_Bn qu18_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1186_MN5 (XI1186_n2 XI1186_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1186_MN4 (b14_12 XI1186_An XI1186_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1186_MN2 (XI1186_n1 dd12_b3_2 b14_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1186_MN3 (VSS qu18_b3_2 XI1186_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1186_MN0 (XI1186_An dd12_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I215_MN1 (XI1206_I215_Bn I1206_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I215_MN5 (XI1206_I215_n2 XI1206_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I215_MN4 (p14_12 XI1206_I215_An XI1206_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I215_MN2 (XI1206_I215_n1 I1206_pn12 p14_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I215_MN3 (VSS I1206_G11_0n XI1206_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I215_MN0 (XI1206_I215_An I1206_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I213_MN1 (XI1206_I213_Bn I1206_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
