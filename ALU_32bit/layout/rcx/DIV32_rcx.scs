    I_MXI1574_I98_XG_MN1 (VSS I1574_G0_0 XI1574_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I100_XG_MN2 (I1574_G4_1n I1574_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I100_XG_MN0 (XI1574_I100_XG_n1 I1574_P4_3 I1574_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I100_XG_MN1 (VSS I1574_G2_1 XI1574_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I123_XG_MN2 (I1068_G27_24n I1068_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I123_XG_MN0 (XI1068_I123_XG_n1 I1068_P27_26 I1068_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I123_XG_MN1 (VSS I1068_G25_24 XI1068_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I121_XG_MN2 (I1068_G25_22n I1068_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I121_XG_MN0 (XI1068_I121_XG_n1 I1068_P25_24 I1068_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I121_XG_MN1 (VSS I1068_G23_22 XI1068_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I119_XG_MN2 (I1068_G23_20n I1068_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I119_XG_MN0 (XI1068_I119_XG_n1 I1068_P23_22 I1068_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I119_XG_MN1 (VSS I1068_G21_20 XI1068_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I117_XG_MN2 (I1068_G21_18n I1068_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I117_XG_MN0 (XI1068_I117_XG_n1 I1068_P21_20 I1068_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I117_XG_MN1 (VSS I1068_G19_18 XI1068_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I115_XG_MN2 (I1068_G19_16n I1068_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I115_XG_MN0 (XI1068_I115_XG_n1 I1068_P19_18 I1068_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I115_XG_MN1 (VSS I1068_G17_16 XI1068_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I169_XG_MN2 (I1068_G18_3n I1068_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I169_XG_MN0 (XI1068_I169_XG_n1 I1068_P18_11 I1068_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I169_XG_MN1 (VSS I1068_G10_3 XI1068_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I160_XG_MN2 (I1068_G10_0n I1068_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I160_XG_MN0 (XI1068_I160_XG_n1 I1068_P10_3 I1068_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I160_XG_MN1 (VSS I1068_G2_0np XI1068_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I106_XG_MN2 (I1068_G10_7n I1068_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I106_XG_MN0 (XI1068_I106_XG_n1 I1068_P10_9 I1068_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I106_XG_MN1 (VSS I1068_G8_7 XI1068_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I104_XG_MN2 (I1068_G8_5n I1068_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I104_XG_MN0 (XI1068_I104_XG_n1 I1068_P8_7 I1068_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I104_XG_MN1 (VSS I1068_G6_5 XI1068_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I102_XG_MN2 (I1068_G6_3n I1068_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I102_XG_MN0 (XI1068_I102_XG_n1 I1068_P6_5 I1068_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I102_XG_MN1 (VSS I1068_G4_3 XI1068_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I100_XG_MN2 (I1068_G4_1n I1068_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I100_XG_MN0 (XI1068_I100_XG_n1 I1068_P4_3 I1068_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I100_XG_MN1 (VSS I1068_G2_1 XI1068_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I98_XG_MN2 (I1068_G2_0n I1068_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I98_XG_MN0 (XI1068_I98_XG_n1 I1068_P2_1 I1068_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I98_XG_MN1 (VSS I1068_G0_0 XI1068_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I99_XG_MN2 (I1022_G3_0n I1022_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I99_XG_MN0 (XI1022_I99_XG_n1 I1022_P3_2 I1022_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I99_XG_MN1 (VSS I1022_G1_0 XI1022_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2144_MN2 (nqkn23 nqk22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2144_MN0 (XI2144_n1 sq_b3_4 nqkn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2144_MN1 (VSS qu22_b3_5 XI2144_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I98_XG_MN2 (I1022_G2_0n I1022_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I98_XG_MN0 (XI1022_I98_XG_n1 I1022_P2_1 I1022_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I98_XG_MN1 (VSS I1022_G0_0 XI1022_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I100_XG_MN2 (I1022_G4_1n I1022_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I100_XG_MN0 (XI1022_I100_XG_n1 I1022_P4_3 I1022_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I100_XG_MN1 (VSS I1022_G2_1 XI1022_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I103_XG_MN2 (I930_G7_4n I930_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I103_XG_MN0 (XI930_I103_XG_n1 I930_P7_6 I930_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I103_XG_MN1 (VSS I930_G5_4 XI930_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I99_XG_MN2 (I930_G3_0n I930_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I99_XG_MN0 (XI930_I99_XG_n1 I930_P3_2 I930_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I99_XG_MN1 (VSS I930_G1_0 XI930_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I101_XG_MN2 (I930_G5_2n I930_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I101_XG_MN0 (XI930_I101_XG_n1 I930_P5_4 I930_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I101_XG_MN1 (VSS I930_G3_2 XI930_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I100_XG_MN2 (I1666_G4_1n I1666_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I100_XG_MN0 (XI1666_I100_XG_n1 I1666_P4_3 I1666_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I100_XG_MN1 (VSS I1666_G2_1 XI1666_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I99_XG_MN2 (I1666_G3_0n I1666_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I99_XG_MN0 (XI1666_I99_XG_n1 I1666_P3_2 I1666_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I99_XG_MN1 (VSS I1666_G1_0 XI1666_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I99_XG_MN2 (I1620_G3_0n I1620_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I99_XG_MN0 (XI1620_I99_XG_n1 I1620_P3_2 I1620_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I99_XG_MN1 (VSS I1620_G1_0 XI1620_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I98_XG_MN2 (I1620_G2_0n I1620_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I98_XG_MN0 (XI1620_I98_XG_n1 I1620_P2_1 I1620_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I98_XG_MN1 (VSS I1620_G0_0 XI1620_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I100_XG_MN2 (I1620_G4_1n I1620_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I100_XG_MN0 (XI1620_I100_XG_n1 I1620_P4_3 I1620_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I100_XG_MN1 (VSS I1620_G2_1 XI1620_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2105_MN2 (nqkn10 nqk9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2105_MN0 (XI2105_n1 sq_b3_1 nqkn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2105_MN1 (VSS qu9_b3_5 XI2105_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I99_XG_MN2 (I1574_G3_0n I1574_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I99_XG_MN0 (XI1574_I99_XG_n1 I1574_P3_2 I1574_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I99_XG_MN1 (VSS I1574_G1_0 XI1574_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I102_XG_MN2 (I1574_G6_3n I1574_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I102_XG_MN0 (XI1574_I102_XG_n1 I1574_P6_5 I1574_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I102_XG_MN1 (VSS I1574_G4_3 XI1574_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I104_XG_MN2 (I1574_G8_5n I1574_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I104_XG_MN0 (XI1574_I104_XG_n1 I1574_P8_7 I1574_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I104_XG_MN1 (VSS I1574_G6_5 XI1574_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I157_XG_MN2 (I1574_G8_0n I1574_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I157_XG_MN0 (XI1574_I157_XG_n1 I1574_P8_1 I1574_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I157_XG_MN1 (VSS I1574_G0_0 XI1574_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I167_XG_MN2 (I1574_G16_1n I1574_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I167_XG_MN0 (XI1574_I167_XG_n1 I1574_P16_9 I1574_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I167_XG_MN1 (VSS I1574_G8_1 XI1574_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I181_XG_MN2 (I1068_G30_15n I1068_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I181_XG_MN0 (XI1068_I181_XG_n1 I1068_P30_23 I1068_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I181_XG_MN1 (VSS I1068_G22_15 XI1068_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I177_XG_MN2 (I1068_G26_11n I1068_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I177_XG_MN0 (XI1068_I177_XG_n1 I1068_P26_19 I1068_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I177_XG_MN1 (VSS I1068_G18_11 XI1068_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I173_XG_MN2 (I1068_G22_7n I1068_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I173_XG_MN0 (XI1068_I173_XG_n1 I1068_P22_15 I1068_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I173_XG_MN1 (VSS I1068_G14_7 XI1068_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I165_XG_MN2 (I1068_G14_0n I1068_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I165_XG_MN0 (XI1068_I165_XG_n1 I1068_P14_7 I1068_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I165_XG_MN1 (VSS I1068_G6_0 XI1068_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I101_XG_MN2 (I1022_G5_2n I1022_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I101_XG_MN0 (XI1022_I101_XG_n1 I1022_P5_4 I1022_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I101_XG_MN1 (VSS I1022_G3_2 XI1022_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I102_XG_MN2 (I1022_G6_3n I1022_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I102_XG_MN0 (XI1022_I102_XG_n1 I1022_P6_5 I1022_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I102_XG_MN1 (VSS I1022_G4_3 XI1022_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I98_XG_MN2 (I976_G2_0n I976_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I98_XG_MN0 (XI976_I98_XG_n1 I976_P2_1 I976_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I98_XG_MN1 (VSS I976_G0_0 XI976_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I100_XG_MN2 (I976_G4_1n I976_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I100_XG_MN0 (XI976_I100_XG_n1 I976_P4_3 I976_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I100_XG_MN1 (VSS I976_G2_1 XI976_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I99_XG_MN2 (I976_G3_0n I976_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I99_XG_MN0 (XI976_I99_XG_n1 I976_P3_2 I976_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I99_XG_MN1 (VSS I976_G1_0 XI976_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I101_XG_MN2 (I976_G5_2n I976_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I101_XG_MN0 (XI976_I101_XG_n1 I976_P5_4 I976_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I101_XG_MN1 (VSS I976_G3_2 XI976_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I98_XG_MN2 (I930_G2_0n I930_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I98_XG_MN0 (XI930_I98_XG_n1 I930_P2_1 I930_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I98_XG_MN1 (VSS I930_G0_0 XI930_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I100_XG_MN2 (I930_G4_1n I930_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I100_XG_MN0 (XI930_I100_XG_n1 I930_P4_3 I930_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I100_XG_MN1 (VSS I930_G2_1 XI930_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I102_XG_MN2 (I930_G6_3n I930_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I102_XG_MN0 (XI930_I102_XG_n1 I930_P6_5 I930_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I102_XG_MN1 (VSS I930_G4_3 XI930_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I104_XG_MN2 (I930_G8_5n I930_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I104_XG_MN0 (XI930_I104_XG_n1 I930_P8_7 I930_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I104_XG_MN1 (VSS I930_G6_5 XI930_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I167_XG_MN2 (I1666_G16_1n I1666_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I167_XG_MN0 (XI1666_I167_XG_n1 I1666_P16_9 I1666_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I167_XG_MN1 (VSS I1666_G8_1 XI1666_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I157_XG_MN2 (I1666_G8_0n I1666_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I157_XG_MN0 (XI1666_I157_XG_n1 I1666_P8_1 I1666_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I157_XG_MN1 (VSS I1666_G0_0 XI1666_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I104_XG_MN2 (I1666_G8_5n I1666_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I104_XG_MN0 (XI1666_I104_XG_n1 I1666_P8_7 I1666_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I104_XG_MN1 (VSS I1666_G6_5 XI1666_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I102_XG_MN2 (I1666_G6_3n I1666_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I102_XG_MN0 (XI1666_I102_XG_n1 I1666_P6_5 I1666_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I102_XG_MN1 (VSS I1666_G4_3 XI1666_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I103_XG_MN2 (I1666_G7_4n I1666_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I103_XG_MN0 (XI1666_I103_XG_n1 I1666_P7_6 I1666_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I103_XG_MN1 (VSS I1666_G5_4 XI1666_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I101_XG_MN2 (I1666_G5_2n I1666_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I101_XG_MN0 (XI1666_I101_XG_n1 I1666_P5_4 I1666_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I101_XG_MN1 (VSS I1666_G3_2 XI1666_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I101_XG_MN2 (I1620_G5_2n I1620_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I101_XG_MN0 (XI1620_I101_XG_n1 I1620_P5_4 I1620_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I101_XG_MN1 (VSS I1620_G3_2 XI1620_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I102_XG_MN2 (I1620_G6_3n I1620_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I102_XG_MN0 (XI1620_I102_XG_n1 I1620_P6_5 I1620_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I102_XG_MN1 (VSS I1620_G4_3 XI1620_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI63_MN2 (nakn10 nak9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI63_MN0 (XI63_n1 A_31_b3_1 nakn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI63_MN1 (VSS A_9 XI63_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2108_MN2 (nqkn11 nqk10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2108_MN0 (XI2108_n1 sq_b3_1 nqkn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2108_MN1 (VSS qu10_b3_5 XI2108_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I101_XG_MN2 (I1574_G5_2n I1574_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I101_XG_MN0 (XI1574_I101_XG_n1 I1574_P5_4 I1574_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I101_XG_MN1 (VSS I1574_G3_2 XI1574_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I103_XG_MN2 (I1574_G7_4n I1574_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I103_XG_MN0 (XI1574_I103_XG_n1 I1574_P7_6 I1574_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I103_XG_MN1 (VSS I1574_G5_4 XI1574_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I163_XG_MN2 (I1574_G12_0n I1574_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I163_XG_MN0 (XI1574_I163_XG_n1 I1574_P12_5 I1574_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I163_XG_MN1 (VSS I1574_G4_0 XI1574_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I126_XG_MN2 (I1068_G30_27n I1068_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I126_XG_MN0 (XI1068_I126_XG_n1 I1068_P30_29 I1068_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I126_XG_MN1 (VSS I1068_G28_27 XI1068_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I124_XG_MN2 (I1068_G28_25n I1068_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I124_XG_MN0 (XI1068_I124_XG_n1 I1068_P28_27 I1068_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I124_XG_MN1 (VSS I1068_G26_25 XI1068_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I122_XG_MN2 (I1068_G26_23n I1068_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I122_XG_MN0 (XI1068_I122_XG_n1 I1068_P26_25 I1068_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I122_XG_MN1 (VSS I1068_G24_23 XI1068_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I120_XG_MN2 (I1068_G24_21n I1068_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I120_XG_MN0 (XI1068_I120_XG_n1 I1068_P24_23 I1068_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I120_XG_MN1 (VSS I1068_G22_21 XI1068_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I118_XG_MN2 (I1068_G22_19n I1068_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I118_XG_MN0 (XI1068_I118_XG_n1 I1068_P22_21 I1068_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I118_XG_MN1 (VSS I1068_G20_19 XI1068_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I179_XG_MN2 (I1068_G28_13n I1068_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I179_XG_MN0 (XI1068_I179_XG_n1 I1068_P28_21 I1068_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I179_XG_MN1 (VSS I1068_G20_13 XI1068_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I171_XG_MN2 (I1068_G20_5n I1068_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I171_XG_MN0 (XI1068_I171_XG_n1 I1068_P20_13 I1068_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I171_XG_MN1 (VSS I1068_G12_5 XI1068_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I175_XG_MN2 (I1068_G24_9n I1068_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I175_XG_MN0 (XI1068_I175_XG_n1 I1068_P24_17 I1068_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I175_XG_MN1 (VSS I1068_G16_9 XI1068_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I163_XG_MN2 (I1068_G12_0n I1068_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I163_XG_MN0 (XI1068_I163_XG_n1 I1068_P12_5 I1068_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I163_XG_MN1 (VSS I1068_G4_0 XI1068_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I108_XG_MN2 (I1068_G12_9n I1068_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I108_XG_MN0 (XI1068_I108_XG_n1 I1068_P12_11 I1068_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I108_XG_MN1 (VSS I1068_G10_9 XI1068_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I167_XG_MN2 (I1068_G16_1n I1068_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I167_XG_MN0 (XI1068_I167_XG_n1 I1068_P16_9 I1068_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I167_XG_MN1 (VSS I1068_G8_1 XI1068_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I157_XG_MN2 (I1068_G8_0n I1068_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I157_XG_MN0 (XI1068_I157_XG_n1 I1068_P8_1 I1068_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I157_XG_MN1 (VSS I1068_G0_0 XI1068_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I158_XG_MN2 (I1022_G9_0n I1022_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I158_XG_MN0 (XI1022_I158_XG_n1 I1022_P9_2 I1022_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I158_XG_MN1 (VSS I1022_G1_0 XI1022_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I103_XG_MN2 (I1022_G7_4n I1022_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I103_XG_MN0 (XI1022_I103_XG_n1 I1022_P7_6 I1022_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I103_XG_MN1 (VSS I1022_G5_4 XI1022_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I105_XG_MN2 (I1022_G9_6n I1022_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I105_XG_MN0 (XI1022_I105_XG_n1 I1022_P9_8 I1022_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I105_XG_MN1 (VSS I1022_G7_6 XI1022_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I157_XG_MN2 (I1022_G8_0n I1022_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I157_XG_MN0 (XI1022_I157_XG_n1 I1022_P8_1 I1022_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I157_XG_MN1 (VSS I1022_G0_0 XI1022_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I167_XG_MN2 (I1022_G16_1n I1022_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I167_XG_MN0 (XI1022_I167_XG_n1 I1022_P16_9 I1022_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I167_XG_MN1 (VSS I1022_G8_1 XI1022_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I104_XG_MN2 (I1022_G8_5n I1022_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I104_XG_MN0 (XI1022_I104_XG_n1 I1022_P8_7 I1022_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I104_XG_MN1 (VSS I1022_G6_5 XI1022_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I104_XG_MN2 (I976_G8_5n I976_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I104_XG_MN0 (XI976_I104_XG_n1 I976_P8_7 I976_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I104_XG_MN1 (VSS I976_G6_5 XI976_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I102_XG_MN2 (I976_G6_3n I976_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I102_XG_MN0 (XI976_I102_XG_n1 I976_P6_5 I976_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I102_XG_MN1 (VSS I976_G4_3 XI976_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I103_XG_MN2 (I976_G7_4n I976_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I103_XG_MN0 (XI976_I103_XG_n1 I976_P7_6 I976_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I103_XG_MN1 (VSS I976_G5_4 XI976_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I157_XG_MN2 (I930_G8_0n I930_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I157_XG_MN0 (XI930_I157_XG_n1 I930_P8_1 I930_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I157_XG_MN1 (VSS I930_G0_0 XI930_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I167_XG_MN2 (I930_G16_1n I930_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I167_XG_MN0 (XI930_I167_XG_n1 I930_P16_9 I930_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I167_XG_MN1 (VSS I930_G8_1 XI930_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I106_XG_MN2 (I930_G10_7n I930_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I106_XG_MN0 (XI930_I106_XG_n1 I930_P10_9 I930_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I106_XG_MN1 (VSS I930_G8_7 XI930_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I105_XG_MN2 (I930_G9_6n I930_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I105_XG_MN0 (XI930_I105_XG_n1 I930_P9_8 I930_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I105_XG_MN1 (VSS I930_G7_6 XI930_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I175_XG_MN2 (I1666_G24_9n I1666_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I175_XG_MN0 (XI1666_I175_XG_n1 I1666_P24_17 I1666_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I175_XG_MN1 (VSS I1666_G16_9 XI1666_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I169_XG_MN2 (I1666_G18_3n I1666_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I169_XG_MN0 (XI1666_I169_XG_n1 I1666_P18_11 I1666_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I169_XG_MN1 (VSS I1666_G10_3 XI1666_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I160_XG_MN2 (I1666_G10_0n I1666_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I160_XG_MN0 (XI1666_I160_XG_n1 I1666_P10_3 I1666_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I160_XG_MN1 (VSS I1666_G2_0np XI1666_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I106_XG_MN2 (I1666_G10_7n I1666_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I106_XG_MN0 (XI1666_I106_XG_n1 I1666_P10_9 I1666_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I106_XG_MN1 (VSS I1666_G8_7 XI1666_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I158_XG_MN2 (I1666_G9_0n I1666_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I158_XG_MN0 (XI1666_I158_XG_n1 I1666_P9_2 I1666_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I158_XG_MN1 (VSS I1666_G1_0 XI1666_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I105_XG_MN2 (I1666_G9_6n I1666_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I105_XG_MN0 (XI1666_I105_XG_n1 I1666_P9_8 I1666_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I105_XG_MN1 (VSS I1666_G7_6 XI1666_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I103_XG_MN2 (I1620_G7_4n I1620_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I103_XG_MN0 (XI1620_I103_XG_n1 I1620_P7_6 I1620_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I103_XG_MN1 (VSS I1620_G5_4 XI1620_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I157_XG_MN2 (I1620_G8_0n I1620_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I157_XG_MN0 (XI1620_I157_XG_n1 I1620_P8_1 I1620_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I157_XG_MN1 (VSS I1620_G0_0 XI1620_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I104_XG_MN2 (I1620_G8_5n I1620_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I104_XG_MN0 (XI1620_I104_XG_n1 I1620_P8_7 I1620_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I104_XG_MN1 (VSS I1620_G6_5 XI1620_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I106_XG_MN2 (I1620_G10_7n I1620_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I106_XG_MN0 (XI1620_I106_XG_n1 I1620_P10_9 I1620_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I106_XG_MN1 (VSS I1620_G8_7 XI1620_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I158_XG_MN2 (I1574_G9_0n I1574_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I158_XG_MN0 (XI1574_I158_XG_n1 I1574_P9_2 I1574_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I158_XG_MN1 (VSS I1574_G1_0 XI1574_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I105_XG_MN2 (I1574_G9_6n I1574_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I105_XG_MN0 (XI1574_I105_XG_n1 I1574_P9_8 I1574_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I105_XG_MN1 (VSS I1574_G7_6 XI1574_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I106_XG_MN2 (I1574_G10_7n I1574_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I106_XG_MN0 (XI1574_I106_XG_n1 I1574_P10_9 I1574_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I106_XG_MN1 (VSS I1574_G8_7 XI1574_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I108_XG_MN2 (I1574_G12_9n I1574_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I108_XG_MN0 (XI1574_I108_XG_n1 I1574_P12_11 I1574_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I108_XG_MN1 (VSS I1574_G10_9 XI1574_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I160_XG_MN2 (I1574_G10_0n I1574_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I160_XG_MN0 (XI1574_I160_XG_n1 I1574_P10_3 I1574_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I160_XG_MN1 (VSS I1574_G2_0np XI1574_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I171_XG_MN2 (I1574_G20_5n I1574_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I171_XG_MN0 (XI1574_I171_XG_n1 I1574_P20_13 I1574_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I171_XG_MN1 (VSS I1574_G12_5 XI1574_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I116_XG_MN2 (I1068_G20_17n I1068_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I116_XG_MN0 (XI1068_I116_XG_n1 I1068_P20_19 I1068_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I116_XG_MN1 (VSS I1068_G18_17 XI1068_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I114_XG_MN2 (I1068_G18_15n I1068_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I114_XG_MN0 (XI1068_I114_XG_n1 I1068_P18_17 I1068_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I114_XG_MN1 (VSS I1068_G16_15 XI1068_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I112_XG_MN2 (I1068_G16_13n I1068_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I112_XG_MN0 (XI1068_I112_XG_n1 I1068_P16_15 I1068_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I112_XG_MN1 (VSS I1068_G14_13 XI1068_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I110_XG_MN2 (I1068_G14_11n I1068_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I110_XG_MN0 (XI1068_I110_XG_n1 I1068_P14_13 I1068_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I110_XG_MN1 (VSS I1068_G12_11 XI1068_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I168_XG_MN2 (I1022_G17_2n I1022_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I168_XG_MN0 (XI1022_I168_XG_n1 I1022_P17_10 I1022_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I168_XG_MN1 (VSS I1022_G9_2 XI1022_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I107_XG_MN2 (I1022_G11_8n I1022_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I107_XG_MN0 (XI1022_I107_XG_n1 I1022_P11_10 I1022_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I107_XG_MN1 (VSS I1022_G9_8 XI1022_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I160_XG_MN2 (I1022_G10_0n I1022_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I160_XG_MN0 (XI1022_I160_XG_n1 I1022_P10_3 I1022_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I160_XG_MN1 (VSS I1022_G2_0np XI1022_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I175_XG_MN2 (I1022_G24_9n I1022_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I175_XG_MN0 (XI1022_I175_XG_n1 I1022_P24_17 I1022_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I175_XG_MN1 (VSS I1022_G16_9 XI1022_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I106_XG_MN2 (I1022_G10_7n I1022_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I106_XG_MN0 (XI1022_I106_XG_n1 I1022_P10_9 I1022_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I106_XG_MN1 (VSS I1022_G8_7 XI1022_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I157_XG_MN2 (I976_G8_0n I976_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I157_XG_MN0 (XI976_I157_XG_n1 I976_P8_1 I976_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I157_XG_MN1 (VSS I976_G0_0 XI976_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I175_XG_MN2 (I930_G24_9n I930_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I175_XG_MN0 (XI930_I175_XG_n1 I930_P24_17 I930_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I175_XG_MN1 (VSS I930_G16_9 XI930_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I108_XG_MN2 (I930_G12_9n I930_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I108_XG_MN0 (XI930_I108_XG_n1 I930_P12_11 I930_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I108_XG_MN1 (VSS I930_G10_9 XI930_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I158_XG_MN2 (I930_G9_0n I930_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I158_XG_MN0 (XI930_I158_XG_n1 I930_P9_2 I930_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I158_XG_MN1 (VSS I930_G1_0 XI930_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I171_XG_MN2 (I1666_G20_5n I1666_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I171_XG_MN0 (XI1666_I171_XG_n1 I1666_P20_13 I1666_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I171_XG_MN1 (VSS I1666_G12_5 XI1666_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I163_XG_MN2 (I1666_G12_0n I1666_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I163_XG_MN0 (XI1666_I163_XG_n1 I1666_P12_5 I1666_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I163_XG_MN1 (VSS I1666_G4_0 XI1666_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I108_XG_MN2 (I1666_G12_9n I1666_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I108_XG_MN0 (XI1666_I108_XG_n1 I1666_P12_11 I1666_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I108_XG_MN1 (VSS I1666_G10_9 XI1666_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I168_XG_MN2 (I1666_G17_2n I1666_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I168_XG_MN0 (XI1666_I168_XG_n1 I1666_P17_10 I1666_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I168_XG_MN1 (VSS I1666_G9_2 XI1666_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I162_XG_MN2 (I1666_G11_0n I1666_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I162_XG_MN0 (XI1666_I162_XG_n1 I1666_P11_4 I1666_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I162_XG_MN1 (VSS I1666_G3_0np XI1666_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I107_XG_MN2 (I1666_G11_8n I1666_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I107_XG_MN0 (XI1666_I107_XG_n1 I1666_P11_10 I1666_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I107_XG_MN1 (VSS I1666_G9_8 XI1666_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I158_XG_MN2 (I1620_G9_0n I1620_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I158_XG_MN0 (XI1620_I158_XG_n1 I1620_P9_2 I1620_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I158_XG_MN1 (VSS I1620_G1_0 XI1620_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I105_XG_MN2 (I1620_G9_6n I1620_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I105_XG_MN0 (XI1620_I105_XG_n1 I1620_P9_8 I1620_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I105_XG_MN1 (VSS I1620_G7_6 XI1620_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I160_XG_MN2 (I1620_G10_0n I1620_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I160_XG_MN0 (XI1620_I160_XG_n1 I1620_P10_3 I1620_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I160_XG_MN1 (VSS I1620_G2_0np XI1620_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I167_XG_MN2 (I1620_G16_1n I1620_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I167_XG_MN0 (XI1620_I167_XG_n1 I1620_P16_9 I1620_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I167_XG_MN1 (VSS I1620_G8_1 XI1620_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I168_XG_MN2 (I1574_G17_2n I1574_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I168_XG_MN0 (XI1574_I168_XG_n1 I1574_P17_10 I1574_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I168_XG_MN1 (VSS I1574_G9_2 XI1574_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I107_XG_MN2 (I1574_G11_8n I1574_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I107_XG_MN0 (XI1574_I107_XG_n1 I1574_P11_10 I1574_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I107_XG_MN1 (VSS I1574_G9_8 XI1574_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I169_XG_MN2 (I1574_G18_3n I1574_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I169_XG_MN0 (XI1574_I169_XG_n1 I1574_P18_11 I1574_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I169_XG_MN1 (VSS I1574_G10_3 XI1574_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I175_XG_MN2 (I1574_G24_9n I1574_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I175_XG_MN0 (XI1574_I175_XG_n1 I1574_P24_17 I1574_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I175_XG_MN1 (VSS I1574_G16_9 XI1574_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I162_XG_MN2 (I1022_G11_0n I1022_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I162_XG_MN0 (XI1022_I162_XG_n1 I1022_P11_4 I1022_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I162_XG_MN1 (VSS I1022_G3_0np XI1022_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I109_XG_MN2 (I1022_G13_10n I1022_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I109_XG_MN0 (XI1022_I109_XG_n1 I1022_P13_12 I1022_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I109_XG_MN1 (VSS I1022_G11_10 XI1022_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I163_XG_MN2 (I1022_G12_0n I1022_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I163_XG_MN0 (XI1022_I163_XG_n1 I1022_P12_5 I1022_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I163_XG_MN1 (VSS I1022_G4_0 XI1022_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I169_XG_MN2 (I1022_G18_3n I1022_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I169_XG_MN0 (XI1022_I169_XG_n1 I1022_P18_11 I1022_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I169_XG_MN1 (VSS I1022_G10_3 XI1022_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I108_XG_MN2 (I1022_G12_9n I1022_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I108_XG_MN0 (XI1022_I108_XG_n1 I1022_P12_11 I1022_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I108_XG_MN1 (VSS I1022_G10_9 XI1022_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I167_XG_MN2 (I976_G16_1n I976_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I167_XG_MN0 (XI976_I167_XG_n1 I976_P16_9 I976_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I167_XG_MN1 (VSS I976_G8_1 XI976_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I106_XG_MN2 (I976_G10_7n I976_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I106_XG_MN0 (XI976_I106_XG_n1 I976_P10_9 I976_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I106_XG_MN1 (VSS I976_G8_7 XI976_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I158_XG_MN2 (I976_G9_0n I976_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I158_XG_MN0 (XI976_I158_XG_n1 I976_P9_2 I976_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I158_XG_MN1 (VSS I976_G1_0 XI976_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I105_XG_MN2 (I976_G9_6n I976_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I105_XG_MN0 (XI976_I105_XG_n1 I976_P9_8 I976_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I105_XG_MN1 (VSS I976_G7_6 XI976_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I163_XG_MN2 (I930_G12_0n I930_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I163_XG_MN0 (XI930_I163_XG_n1 I930_P12_5 I930_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I163_XG_MN1 (VSS I930_G4_0 XI930_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I171_XG_MN2 (I930_G20_5n I930_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I171_XG_MN0 (XI930_I171_XG_n1 I930_P20_13 I930_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I171_XG_MN1 (VSS I930_G12_5 XI930_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I107_XG_MN2 (I930_G11_8n I930_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I107_XG_MN0 (XI930_I107_XG_n1 I930_P11_10 I930_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I107_XG_MN1 (VSS I930_G9_8 XI930_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I109_XG_MN2 (I930_G13_10n I930_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I109_XG_MN0 (XI930_I109_XG_n1 I930_P13_12 I930_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I109_XG_MN1 (VSS I930_G11_10 XI930_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I162_XG_MN2 (I930_G11_0n I930_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I162_XG_MN0 (XI930_I162_XG_n1 I930_P11_4 I930_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I162_XG_MN1 (VSS I930_G3_0np XI930_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I168_XG_MN2 (I930_G17_2n I930_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I168_XG_MN0 (XI930_I168_XG_n1 I930_P17_10 I930_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I168_XG_MN1 (VSS I930_G9_2 XI930_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I110_XG_MN2 (I1666_G14_11n I1666_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I110_XG_MN0 (XI1666_I110_XG_n1 I1666_P14_13 I1666_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I110_XG_MN1 (VSS I1666_G12_11 XI1666_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I170_XG_MN2 (I1666_G19_4n I1666_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I170_XG_MN0 (XI1666_I170_XG_n1 I1666_P19_12 I1666_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I170_XG_MN1 (VSS I1666_G11_4 XI1666_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I109_XG_MN2 (I1666_G13_10n I1666_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I109_XG_MN0 (XI1666_I109_XG_n1 I1666_P13_12 I1666_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I109_XG_MN1 (VSS I1666_G11_10 XI1666_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I107_XG_MN2 (I1620_G11_8n I1620_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I107_XG_MN0 (XI1620_I107_XG_n1 I1620_P11_10 I1620_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I107_XG_MN1 (VSS I1620_G9_8 XI1620_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I168_XG_MN2 (I1620_G17_2n I1620_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I168_XG_MN0 (XI1620_I168_XG_n1 I1620_P17_10 I1620_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I168_XG_MN1 (VSS I1620_G9_2 XI1620_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I169_XG_MN2 (I1620_G18_3n I1620_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I169_XG_MN0 (XI1620_I169_XG_n1 I1620_P18_11 I1620_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I169_XG_MN1 (VSS I1620_G10_3 XI1620_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I175_XG_MN2 (I1620_G24_9n I1620_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I175_XG_MN0 (XI1620_I175_XG_n1 I1620_P24_17 I1620_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I175_XG_MN1 (VSS I1620_G16_9 XI1620_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I108_XG_MN2 (I1620_G12_9n I1620_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I108_XG_MN0 (XI1620_I108_XG_n1 I1620_P12_11 I1620_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I108_XG_MN1 (VSS I1620_G10_9 XI1620_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I162_XG_MN2 (I1574_G11_0n I1574_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I162_XG_MN0 (XI1574_I162_XG_n1 I1574_P11_4 I1574_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I162_XG_MN1 (VSS I1574_G3_0np XI1574_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I170_XG_MN2 (I1574_G19_4n I1574_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I170_XG_MN0 (XI1574_I170_XG_n1 I1574_P19_12 I1574_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I170_XG_MN1 (VSS I1574_G11_4 XI1574_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I109_XG_MN2 (I1574_G13_10n I1574_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I109_XG_MN0 (XI1574_I109_XG_n1 I1574_P13_12 I1574_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I109_XG_MN1 (VSS I1574_G11_10 XI1574_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I110_XG_MN2 (I1574_G14_11n I1574_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I110_XG_MN0 (XI1574_I110_XG_n1 I1574_P14_13 I1574_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I110_XG_MN1 (VSS I1574_G12_11 XI1574_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I177_XG_MN2 (I1574_G26_11n I1574_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I177_XG_MN0 (XI1574_I177_XG_n1 I1574_P26_19 I1574_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I177_XG_MN1 (VSS I1574_G18_11 XI1574_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I164_XG_MN2 (I1022_G13_0n I1022_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I164_XG_MN0 (XI1022_I164_XG_n1 I1022_P13_6 I1022_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I164_XG_MN1 (VSS I1022_G5_0 XI1022_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I176_XG_MN2 (I1022_G25_10n I1022_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I176_XG_MN0 (XI1022_I176_XG_n1 I1022_P25_18 I1022_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I176_XG_MN1 (VSS I1022_G17_10 XI1022_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I170_XG_MN2 (I1022_G19_4n I1022_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I170_XG_MN0 (XI1022_I170_XG_n1 I1022_P19_12 I1022_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I170_XG_MN1 (VSS I1022_G11_4 XI1022_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I171_XG_MN2 (I1022_G20_5n I1022_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I171_XG_MN0 (XI1022_I171_XG_n1 I1022_P20_13 I1022_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I171_XG_MN1 (VSS I1022_G12_5 XI1022_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I110_XG_MN2 (I1022_G14_11n I1022_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I110_XG_MN0 (XI1022_I110_XG_n1 I1022_P14_13 I1022_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I110_XG_MN1 (VSS I1022_G12_11 XI1022_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I160_XG_MN2 (I976_G10_0n I976_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I160_XG_MN0 (XI976_I160_XG_n1 I976_P10_3 I976_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I160_XG_MN1 (VSS I976_G2_0np XI976_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I108_XG_MN2 (I976_G12_9n I976_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I108_XG_MN0 (XI976_I108_XG_n1 I976_P12_11 I976_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I108_XG_MN1 (VSS I976_G10_9 XI976_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I168_XG_MN2 (I976_G17_2n I976_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I168_XG_MN0 (XI976_I168_XG_n1 I976_P17_10 I976_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I168_XG_MN1 (VSS I976_G9_2 XI976_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I107_XG_MN2 (I976_G11_8n I976_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I107_XG_MN0 (XI976_I107_XG_n1 I976_P11_10 I976_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I107_XG_MN1 (VSS I976_G9_8 XI976_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I112_XG_MN2 (I930_G16_13n I930_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I112_XG_MN0 (XI930_I112_XG_n1 I930_P16_15 I930_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I112_XG_MN1 (VSS I930_G14_13 XI930_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I110_XG_MN2 (I930_G14_11n I930_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I110_XG_MN0 (XI930_I110_XG_n1 I930_P14_13 I930_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I110_XG_MN1 (VSS I930_G12_11 XI930_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I160_XG_MN2 (I930_G10_0n I930_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I160_XG_MN0 (XI930_I160_XG_n1 I930_P10_3 I930_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I160_XG_MN1 (VSS I930_G2_0np XI930_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I111_XG_MN2 (I930_G15_12n I930_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I111_XG_MN0 (XI930_I111_XG_n1 I930_P15_14 I930_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I111_XG_MN1 (VSS I930_G13_12 XI930_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I170_XG_MN2 (I930_G19_4n I930_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I170_XG_MN0 (XI930_I170_XG_n1 I930_P19_12 I930_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I170_XG_MN1 (VSS I930_G11_4 XI930_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I179_XG_MN2 (I1666_G28_13n I1666_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I179_XG_MN0 (XI1666_I179_XG_n1 I1666_P28_21 I1666_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I179_XG_MN1 (VSS I1666_G20_13 XI1666_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I177_XG_MN2 (I1666_G26_11n I1666_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I177_XG_MN0 (XI1666_I177_XG_n1 I1666_P26_19 I1666_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I177_XG_MN1 (VSS I1666_G18_11 XI1666_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I165_XG_MN2 (I1666_G14_0n I1666_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I165_XG_MN0 (XI1666_I165_XG_n1 I1666_P14_7 I1666_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I165_XG_MN1 (VSS I1666_G6_0 XI1666_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I112_XG_MN2 (I1666_G16_13n I1666_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I112_XG_MN0 (XI1666_I112_XG_n1 I1666_P16_15 I1666_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I112_XG_MN1 (VSS I1666_G14_13 XI1666_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I176_XG_MN2 (I1666_G25_10n I1666_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I176_XG_MN0 (XI1666_I176_XG_n1 I1666_P25_18 I1666_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I176_XG_MN1 (VSS I1666_G17_10 XI1666_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I164_XG_MN2 (I1666_G13_0n I1666_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I164_XG_MN0 (XI1666_I164_XG_n1 I1666_P13_6 I1666_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I164_XG_MN1 (VSS I1666_G5_0 XI1666_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I113_XG_MN2 (I1666_G17_14n I1666_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I113_XG_MN0 (XI1666_I113_XG_n1 I1666_P17_16 I1666_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I113_XG_MN1 (VSS I1666_G15_14 XI1666_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I111_XG_MN2 (I1666_G15_12n I1666_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I111_XG_MN0 (XI1666_I111_XG_n1 I1666_P15_14 I1666_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I111_XG_MN1 (VSS I1666_G13_12 XI1666_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I162_XG_MN2 (I1620_G11_0n I1620_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I162_XG_MN0 (XI1620_I162_XG_n1 I1620_P11_4 I1620_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I162_XG_MN1 (VSS I1620_G3_0np XI1620_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I109_XG_MN2 (I1620_G13_10n I1620_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I109_XG_MN0 (XI1620_I109_XG_n1 I1620_P13_12 I1620_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I109_XG_MN1 (VSS I1620_G11_10 XI1620_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I111_XG_MN2 (I1620_G15_12n I1620_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I111_XG_MN0 (XI1620_I111_XG_n1 I1620_P15_14 I1620_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I111_XG_MN1 (VSS I1620_G13_12 XI1620_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I163_XG_MN2 (I1620_G12_0n I1620_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I163_XG_MN0 (XI1620_I163_XG_n1 I1620_P12_5 I1620_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I163_XG_MN1 (VSS I1620_G4_0 XI1620_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I110_XG_MN2 (I1620_G14_11n I1620_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I110_XG_MN0 (XI1620_I110_XG_n1 I1620_P14_13 I1620_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I110_XG_MN1 (VSS I1620_G12_11 XI1620_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I112_XG_MN2 (I1620_G16_13n I1620_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I112_XG_MN0 (XI1620_I112_XG_n1 I1620_P16_15 I1620_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I112_XG_MN1 (VSS I1620_G14_13 XI1620_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I164_XG_MN2 (I1574_G13_0n I1574_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I164_XG_MN0 (XI1574_I164_XG_n1 I1574_P13_6 I1574_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I164_XG_MN1 (VSS I1574_G5_0 XI1574_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I176_XG_MN2 (I1574_G25_10n I1574_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I176_XG_MN0 (XI1574_I176_XG_n1 I1574_P25_18 I1574_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I176_XG_MN1 (VSS I1574_G17_10 XI1574_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I111_XG_MN2 (I1574_G15_12n I1574_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I111_XG_MN0 (XI1574_I111_XG_n1 I1574_P15_14 I1574_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I111_XG_MN1 (VSS I1574_G13_12 XI1574_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I112_XG_MN2 (I1574_G16_13n I1574_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I112_XG_MN0 (XI1574_I112_XG_n1 I1574_P16_15 I1574_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I112_XG_MN1 (VSS I1574_G14_13 XI1574_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I165_XG_MN2 (I1574_G14_0n I1574_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I165_XG_MN0 (XI1574_I165_XG_n1 I1574_P14_7 I1574_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I165_XG_MN1 (VSS I1574_G6_0 XI1574_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I172_XG_MN2 (I1022_G21_6n I1022_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I172_XG_MN0 (XI1022_I172_XG_n1 I1022_P21_14 I1022_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I172_XG_MN1 (VSS I1022_G13_6 XI1022_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I113_XG_MN2 (I1022_G17_14n I1022_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I113_XG_MN0 (XI1022_I113_XG_n1 I1022_P17_16 I1022_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I113_XG_MN1 (VSS I1022_G15_14 XI1022_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I111_XG_MN2 (I1022_G15_12n I1022_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I111_XG_MN0 (XI1022_I111_XG_n1 I1022_P15_14 I1022_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I111_XG_MN1 (VSS I1022_G13_12 XI1022_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I112_XG_MN2 (I1022_G16_13n I1022_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I112_XG_MN0 (XI1022_I112_XG_n1 I1022_P16_15 I1022_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I112_XG_MN1 (VSS I1022_G14_13 XI1022_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I163_XG_MN2 (I976_G12_0n I976_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I163_XG_MN0 (XI976_I163_XG_n1 I976_P12_5 I976_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I163_XG_MN1 (VSS I976_G4_0 XI976_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I109_XG_MN2 (I976_G13_10n I976_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I109_XG_MN0 (XI976_I109_XG_n1 I976_P13_12 I976_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I109_XG_MN1 (VSS I976_G11_10 XI976_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I111_XG_MN2 (I976_G15_12n I976_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I111_XG_MN0 (XI976_I111_XG_n1 I976_P15_14 I976_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I111_XG_MN1 (VSS I976_G13_12 XI976_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I114_XG_MN2 (I930_G18_15n I930_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I114_XG_MN0 (XI930_I114_XG_n1 I930_P18_17 I930_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I114_XG_MN1 (VSS I930_G16_15 XI930_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I169_XG_MN2 (I930_G18_3n I930_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I169_XG_MN0 (XI930_I169_XG_n1 I930_P18_11 I930_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I169_XG_MN1 (VSS I930_G10_3 XI930_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I113_XG_MN2 (I930_G17_14n I930_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I113_XG_MN0 (XI930_I113_XG_n1 I930_P17_16 I930_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I113_XG_MN1 (VSS I930_G15_14 XI930_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I166_XG_MN2 (I930_G15_0n I930_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I166_XG_MN0 (XI930_I166_XG_n1 I930_P15_8 I930_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I166_XG_MN1 (VSS I930_G7_0 XI930_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I176_XG_MN2 (I930_G25_10n I930_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I176_XG_MN0 (XI930_I176_XG_n1 I930_P25_18 I930_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I176_XG_MN1 (VSS I930_G17_10 XI930_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I164_XG_MN2 (I930_G13_0n I930_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I164_XG_MN0 (XI930_I164_XG_n1 I930_P13_6 I930_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I164_XG_MN1 (VSS I930_G5_0 XI930_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I173_XG_MN2 (I1666_G22_7n I1666_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I173_XG_MN0 (XI1666_I173_XG_n1 I1666_P22_15 I1666_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I173_XG_MN1 (VSS I1666_G14_7 XI1666_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I116_XG_MN2 (I1666_G20_17n I1666_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I116_XG_MN0 (XI1666_I116_XG_n1 I1666_P20_19 I1666_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I116_XG_MN1 (VSS I1666_G18_17 XI1666_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I114_XG_MN2 (I1666_G18_15n I1666_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I114_XG_MN0 (XI1666_I114_XG_n1 I1666_P18_17 I1666_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I114_XG_MN1 (VSS I1666_G16_15 XI1666_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I172_XG_MN2 (I1666_G21_6n I1666_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I172_XG_MN0 (XI1666_I172_XG_n1 I1666_P21_14 I1666_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I172_XG_MN1 (VSS I1666_G13_6 XI1666_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I115_XG_MN2 (I1666_G19_16n I1666_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I115_XG_MN0 (XI1666_I115_XG_n1 I1666_P19_18 I1666_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I115_XG_MN1 (VSS I1666_G17_16 XI1666_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I170_XG_MN2 (I1620_G19_4n I1620_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I170_XG_MN0 (XI1620_I170_XG_n1 I1620_P19_12 I1620_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I170_XG_MN1 (VSS I1620_G11_4 XI1620_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I164_XG_MN2 (I1620_G13_0n I1620_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I164_XG_MN0 (XI1620_I164_XG_n1 I1620_P13_6 I1620_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I164_XG_MN1 (VSS I1620_G5_0 XI1620_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I113_XG_MN2 (I1620_G17_14n I1620_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I113_XG_MN0 (XI1620_I113_XG_n1 I1620_P17_16 I1620_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I113_XG_MN1 (VSS I1620_G15_14 XI1620_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I165_XG_MN2 (I1620_G14_0n I1620_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I165_XG_MN0 (XI1620_I165_XG_n1 I1620_P14_7 I1620_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I165_XG_MN1 (VSS I1620_G6_0 XI1620_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I171_XG_MN2 (I1620_G20_5n I1620_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I171_XG_MN0 (XI1620_I171_XG_n1 I1620_P20_13 I1620_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I171_XG_MN1 (VSS I1620_G12_5 XI1620_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I114_XG_MN2 (I1620_G18_15n I1620_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I114_XG_MN0 (XI1620_I114_XG_n1 I1620_P18_17 I1620_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I114_XG_MN1 (VSS I1620_G16_15 XI1620_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I172_XG_MN2 (I1574_G21_6n I1574_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I172_XG_MN0 (XI1574_I172_XG_n1 I1574_P21_14 I1574_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I172_XG_MN1 (VSS I1574_G13_6 XI1574_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I113_XG_MN2 (I1574_G17_14n I1574_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I113_XG_MN0 (XI1574_I113_XG_n1 I1574_P17_16 I1574_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I113_XG_MN1 (VSS I1574_G15_14 XI1574_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I114_XG_MN2 (I1574_G18_15n I1574_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I114_XG_MN0 (XI1574_I114_XG_n1 I1574_P18_17 I1574_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I114_XG_MN1 (VSS I1574_G16_15 XI1574_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I173_XG_MN2 (I1574_G22_7n I1574_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I173_XG_MN0 (XI1574_I173_XG_n1 I1574_P22_15 I1574_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I173_XG_MN1 (VSS I1574_G14_7 XI1574_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I179_XG_MN2 (I1574_G28_13n I1574_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I179_XG_MN0 (XI1574_I179_XG_n1 I1574_P28_21 I1574_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I179_XG_MN1 (VSS I1574_G20_13 XI1574_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I180_XG_MN2 (I1022_G29_14n I1022_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I180_XG_MN0 (XI1022_I180_XG_n1 I1022_P29_22 I1022_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I180_XG_MN1 (VSS I1022_G21_14 XI1022_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I115_XG_MN2 (I1022_G19_16n I1022_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I115_XG_MN0 (XI1022_I115_XG_n1 I1022_P19_18 I1022_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I115_XG_MN1 (VSS I1022_G17_16 XI1022_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I165_XG_MN2 (I1022_G14_0n I1022_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I165_XG_MN0 (XI1022_I165_XG_n1 I1022_P14_7 I1022_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I165_XG_MN1 (VSS I1022_G6_0 XI1022_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I177_XG_MN2 (I1022_G26_11n I1022_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I177_XG_MN0 (XI1022_I177_XG_n1 I1022_P26_19 I1022_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I177_XG_MN1 (VSS I1022_G18_11 XI1022_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I116_XG_MN2 (I1022_G20_17n I1022_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I116_XG_MN0 (XI1022_I116_XG_n1 I1022_P20_19 I1022_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I116_XG_MN1 (VSS I1022_G18_17 XI1022_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I114_XG_MN2 (I1022_G18_15n I1022_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I114_XG_MN0 (XI1022_I114_XG_n1 I1022_P18_17 I1022_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I114_XG_MN1 (VSS I1022_G16_15 XI1022_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I169_XG_MN2 (I976_G18_3n I976_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I169_XG_MN0 (XI976_I169_XG_n1 I976_P18_11 I976_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I169_XG_MN1 (VSS I976_G10_3 XI976_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I110_XG_MN2 (I976_G14_11n I976_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I110_XG_MN0 (XI976_I110_XG_n1 I976_P14_13 I976_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I110_XG_MN1 (VSS I976_G12_11 XI976_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I112_XG_MN2 (I976_G16_13n I976_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I112_XG_MN0 (XI976_I112_XG_n1 I976_P16_15 I976_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I112_XG_MN1 (VSS I976_G14_13 XI976_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I162_XG_MN2 (I976_G11_0n I976_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I162_XG_MN0 (XI976_I162_XG_n1 I976_P11_4 I976_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I162_XG_MN1 (VSS I976_G3_0np XI976_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I113_XG_MN2 (I976_G17_14n I976_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I113_XG_MN0 (XI976_I113_XG_n1 I976_P17_16 I976_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I113_XG_MN1 (VSS I976_G15_14 XI976_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I116_XG_MN2 (I930_G20_17n I930_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I116_XG_MN0 (XI930_I116_XG_n1 I930_P20_19 I930_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I116_XG_MN1 (VSS I930_G18_17 XI930_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I173_XG_MN2 (I930_G22_7n I930_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I173_XG_MN0 (XI930_I173_XG_n1 I930_P22_15 I930_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I173_XG_MN1 (VSS I930_G14_7 XI930_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I165_XG_MN2 (I930_G14_0n I930_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I165_XG_MN0 (XI930_I165_XG_n1 I930_P14_7 I930_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I165_XG_MN1 (VSS I930_G6_0 XI930_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I177_XG_MN2 (I930_G26_11n I930_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I177_XG_MN0 (XI930_I177_XG_n1 I930_P26_19 I930_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I177_XG_MN1 (VSS I930_G18_11 XI930_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I115_XG_MN2 (I930_G19_16n I930_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I115_XG_MN0 (XI930_I115_XG_n1 I930_P19_18 I930_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I115_XG_MN1 (VSS I930_G17_16 XI930_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I174_XG_MN2 (I930_G23_8n I930_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I174_XG_MN0 (XI930_I174_XG_n1 I930_P23_16 I930_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I174_XG_MN1 (VSS I930_G15_8 XI930_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I172_XG_MN2 (I930_G21_6n I930_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I172_XG_MN0 (XI930_I172_XG_n1 I930_P21_14 I930_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I172_XG_MN1 (VSS I930_G13_6 XI930_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I118_XG_MN2 (I1666_G22_19n I1666_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I118_XG_MN0 (XI1666_I118_XG_n1 I1666_P22_21 I1666_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I118_XG_MN1 (VSS I1666_G20_19 XI1666_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I180_XG_MN2 (I1666_G29_14n I1666_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I180_XG_MN0 (XI1666_I180_XG_n1 I1666_P29_22 I1666_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I180_XG_MN1 (VSS I1666_G21_14 XI1666_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I117_XG_MN2 (I1666_G21_18n I1666_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I117_XG_MN0 (XI1666_I117_XG_n1 I1666_P21_20 I1666_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I117_XG_MN1 (VSS I1666_G19_18 XI1666_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I166_XG_MN2 (I1666_G15_0n I1666_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I166_XG_MN0 (XI1666_I166_XG_n1 I1666_P15_8 I1666_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I166_XG_MN1 (VSS I1666_G7_0 XI1666_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I172_XG_MN2 (I1620_G21_6n I1620_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I172_XG_MN0 (XI1620_I172_XG_n1 I1620_P21_14 I1620_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I172_XG_MN1 (VSS I1620_G13_6 XI1620_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I115_XG_MN2 (I1620_G19_16n I1620_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I115_XG_MN0 (XI1620_I115_XG_n1 I1620_P19_18 I1620_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I115_XG_MN1 (VSS I1620_G17_16 XI1620_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I177_XG_MN2 (I1620_G26_11n I1620_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I177_XG_MN0 (XI1620_I177_XG_n1 I1620_P26_19 I1620_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I177_XG_MN1 (VSS I1620_G18_11 XI1620_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I116_XG_MN2 (I1620_G20_17n I1620_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I116_XG_MN0 (XI1620_I116_XG_n1 I1620_P20_19 I1620_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I116_XG_MN1 (VSS I1620_G18_17 XI1620_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I166_XG_MN2 (I1574_G15_0n I1574_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I166_XG_MN0 (XI1574_I166_XG_n1 I1574_P15_8 I1574_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I166_XG_MN1 (VSS I1574_G7_0 XI1574_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I117_XG_MN2 (I1574_G21_18n I1574_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I117_XG_MN0 (XI1574_I117_XG_n1 I1574_P21_20 I1574_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I117_XG_MN1 (VSS I1574_G19_18 XI1574_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I115_XG_MN2 (I1574_G19_16n I1574_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I115_XG_MN0 (XI1574_I115_XG_n1 I1574_P19_18 I1574_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I115_XG_MN1 (VSS I1574_G17_16 XI1574_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I116_XG_MN2 (I1574_G20_17n I1574_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I116_XG_MN0 (XI1574_I116_XG_n1 I1574_P20_19 I1574_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I116_XG_MN1 (VSS I1574_G18_17 XI1574_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I166_XG_MN2 (I1022_G15_0n I1022_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I166_XG_MN0 (XI1022_I166_XG_n1 I1022_P15_8 I1022_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I166_XG_MN1 (VSS I1022_G7_0 XI1022_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I178_XG_MN2 (I1022_G27_12n I1022_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I178_XG_MN0 (XI1022_I178_XG_n1 I1022_P27_20 I1022_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I178_XG_MN1 (VSS I1022_G19_12 XI1022_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I117_XG_MN2 (I1022_G21_18n I1022_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I117_XG_MN0 (XI1022_I117_XG_n1 I1022_P21_20 I1022_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I117_XG_MN1 (VSS I1022_G19_18 XI1022_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I173_XG_MN2 (I1022_G22_7n I1022_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I173_XG_MN0 (XI1022_I173_XG_n1 I1022_P22_15 I1022_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I173_XG_MN1 (VSS I1022_G14_7 XI1022_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I118_XG_MN2 (I1022_G22_19n I1022_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I118_XG_MN0 (XI1022_I118_XG_n1 I1022_P22_21 I1022_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I118_XG_MN1 (VSS I1022_G20_19 XI1022_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I114_XG_MN2 (I976_G18_15n I976_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I114_XG_MN0 (XI976_I114_XG_n1 I976_P18_17 I976_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I114_XG_MN1 (VSS I976_G16_15 XI976_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I164_XG_MN2 (I976_G13_0n I976_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I164_XG_MN0 (XI976_I164_XG_n1 I976_P13_6 I976_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I164_XG_MN1 (VSS I976_G5_0 XI976_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I170_XG_MN2 (I976_G19_4n I976_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I170_XG_MN0 (XI976_I170_XG_n1 I976_P19_12 I976_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I170_XG_MN1 (VSS I976_G11_4 XI976_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I176_XG_MN2 (I976_G25_10n I976_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I176_XG_MN0 (XI976_I176_XG_n1 I976_P25_18 I976_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I176_XG_MN1 (VSS I976_G17_10 XI976_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I115_XG_MN2 (I976_G19_16n I976_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I115_XG_MN0 (XI976_I115_XG_n1 I976_P19_18 I976_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I115_XG_MN1 (VSS I976_G17_16 XI976_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I118_XG_MN2 (I930_G22_19n I930_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I118_XG_MN0 (XI930_I118_XG_n1 I930_P22_21 I930_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I118_XG_MN1 (VSS I930_G20_19 XI930_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I117_XG_MN2 (I930_G21_18n I930_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I117_XG_MN0 (XI930_I117_XG_n1 I930_P21_20 I930_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I117_XG_MN1 (VSS I930_G19_18 XI930_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I182_XG_MN2 (I930_G31_16n I930_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I182_XG_MN0 (XI930_I182_XG_n1 I930_P31_24 I930_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I182_XG_MN1 (VSS I930_G23_16 XI930_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I178_XG_MN2 (I930_G27_12n I930_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I178_XG_MN0 (XI930_I178_XG_n1 I930_P27_20 I930_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I178_XG_MN1 (VSS I930_G19_12 XI930_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I120_XG_MN2 (I1666_G24_21n I1666_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I120_XG_MN0 (XI1666_I120_XG_n1 I1666_P24_23 I1666_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I120_XG_MN1 (VSS I1666_G22_21 XI1666_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I181_XG_MN2 (I1666_G30_15n I1666_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I181_XG_MN0 (XI1666_I181_XG_n1 I1666_P30_23 I1666_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I181_XG_MN1 (VSS I1666_G22_15 XI1666_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I178_XG_MN2 (I1666_G27_12n I1666_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I178_XG_MN0 (XI1666_I178_XG_n1 I1666_P27_20 I1666_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I178_XG_MN1 (VSS I1666_G19_12 XI1666_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I174_XG_MN2 (I1666_G23_8n I1666_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I174_XG_MN0 (XI1666_I174_XG_n1 I1666_P23_16 I1666_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I174_XG_MN1 (VSS I1666_G15_8 XI1666_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I166_XG_MN2 (I1620_G15_0n I1620_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I166_XG_MN0 (XI1620_I166_XG_n1 I1620_P15_8 I1620_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I166_XG_MN1 (VSS I1620_G7_0 XI1620_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I176_XG_MN2 (I1620_G25_10n I1620_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I176_XG_MN0 (XI1620_I176_XG_n1 I1620_P25_18 I1620_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I176_XG_MN1 (VSS I1620_G17_10 XI1620_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I117_XG_MN2 (I1620_G21_18n I1620_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I117_XG_MN0 (XI1620_I117_XG_n1 I1620_P21_20 I1620_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I117_XG_MN1 (VSS I1620_G19_18 XI1620_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I173_XG_MN2 (I1620_G22_7n I1620_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I173_XG_MN0 (XI1620_I173_XG_n1 I1620_P22_15 I1620_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I173_XG_MN1 (VSS I1620_G14_7 XI1620_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I179_XG_MN2 (I1620_G28_13n I1620_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I179_XG_MN0 (XI1620_I179_XG_n1 I1620_P28_21 I1620_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I179_XG_MN1 (VSS I1620_G20_13 XI1620_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I118_XG_MN2 (I1620_G22_19n I1620_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I118_XG_MN0 (XI1620_I118_XG_n1 I1620_P22_21 I1620_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I118_XG_MN1 (VSS I1620_G20_19 XI1620_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I174_XG_MN2 (I1574_G23_8n I1574_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I174_XG_MN0 (XI1574_I174_XG_n1 I1574_P23_16 I1574_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I174_XG_MN1 (VSS I1574_G15_8 XI1574_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I180_XG_MN2 (I1574_G29_14n I1574_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I180_XG_MN0 (XI1574_I180_XG_n1 I1574_P29_22 I1574_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I180_XG_MN1 (VSS I1574_G21_14 XI1574_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I118_XG_MN2 (I1574_G22_19n I1574_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I118_XG_MN0 (XI1574_I118_XG_n1 I1574_P22_21 I1574_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I118_XG_MN1 (VSS I1574_G20_19 XI1574_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I181_XG_MN2 (I1574_G30_15n I1574_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I181_XG_MN0 (XI1574_I181_XG_n1 I1574_P30_23 I1574_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I181_XG_MN1 (VSS I1574_G22_15 XI1574_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I120_XG_MN2 (I1574_G24_21n I1574_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I120_XG_MN0 (XI1574_I120_XG_n1 I1574_P24_23 I1574_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I120_XG_MN1 (VSS I1574_G22_21 XI1574_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I118_XG_MN2 (I1114_G22_19n I1114_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I118_XG_MN0 (XI1114_I118_XG_n1 I1114_P22_21 I1114_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I118_XG_MN1 (VSS I1114_G20_19 XI1114_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I116_XG_MN2 (I1114_G20_17n I1114_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I116_XG_MN0 (XI1114_I116_XG_n1 I1114_P20_19 I1114_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I116_XG_MN1 (VSS I1114_G18_17 XI1114_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I114_XG_MN2 (I1114_G18_15n I1114_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I114_XG_MN0 (XI1114_I114_XG_n1 I1114_P18_17 I1114_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I114_XG_MN1 (VSS I1114_G16_15 XI1114_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I112_XG_MN2 (I1114_G16_13n I1114_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I112_XG_MN0 (XI1114_I112_XG_n1 I1114_P16_15 I1114_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I112_XG_MN1 (VSS I1114_G14_13 XI1114_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I174_XG_MN2 (I1022_G23_8n I1022_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I174_XG_MN0 (XI1022_I174_XG_n1 I1022_P23_16 I1022_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I174_XG_MN1 (VSS I1022_G15_8 XI1022_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I119_XG_MN2 (I1022_G23_20n I1022_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I119_XG_MN0 (XI1022_I119_XG_n1 I1022_P23_22 I1022_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I119_XG_MN1 (VSS I1022_G21_20 XI1022_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I121_XG_MN2 (I1022_G25_22n I1022_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I121_XG_MN0 (XI1022_I121_XG_n1 I1022_P25_24 I1022_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I121_XG_MN1 (VSS I1022_G23_22 XI1022_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I179_XG_MN2 (I1022_G28_13n I1022_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I179_XG_MN0 (XI1022_I179_XG_n1 I1022_P28_21 I1022_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I179_XG_MN1 (VSS I1022_G20_13 XI1022_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I120_XG_MN2 (I1022_G24_21n I1022_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I120_XG_MN0 (XI1022_I120_XG_n1 I1022_P24_23 I1022_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I120_XG_MN1 (VSS I1022_G22_21 XI1022_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I171_XG_MN2 (I976_G20_5n I976_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I171_XG_MN0 (XI976_I171_XG_n1 I976_P20_13 I976_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I171_XG_MN1 (VSS I976_G12_5 XI976_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I175_XG_MN2 (I976_G24_9n I976_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I175_XG_MN0 (XI976_I175_XG_n1 I976_P24_17 I976_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I175_XG_MN1 (VSS I976_G16_9 XI976_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I116_XG_MN2 (I976_G20_17n I976_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I116_XG_MN0 (XI976_I116_XG_n1 I976_P20_19 I976_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I116_XG_MN1 (VSS I976_G18_17 XI976_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I172_XG_MN2 (I976_G21_6n I976_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I172_XG_MN0 (XI976_I172_XG_n1 I976_P21_14 I976_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I172_XG_MN1 (VSS I976_G13_6 XI976_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I117_XG_MN2 (I976_G21_18n I976_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I117_XG_MN0 (XI976_I117_XG_n1 I976_P21_20 I976_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I117_XG_MN1 (VSS I976_G19_18 XI976_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I179_XG_MN2 (I930_G28_13n I930_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I179_XG_MN0 (XI930_I179_XG_n1 I930_P28_21 I930_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I179_XG_MN1 (VSS I930_G20_13 XI930_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I119_XG_MN2 (I930_G23_20n I930_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I119_XG_MN0 (XI930_I119_XG_n1 I930_P23_22 I930_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I119_XG_MN1 (VSS I930_G21_20 XI930_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I180_XG_MN2 (I930_G29_14n I930_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I180_XG_MN0 (XI930_I180_XG_n1 I930_P29_22 I930_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I180_XG_MN1 (VSS I930_G21_14 XI930_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I122_XG_MN2 (I1666_G26_23n I1666_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I122_XG_MN0 (XI1666_I122_XG_n1 I1666_P26_25 I1666_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I122_XG_MN1 (VSS I1666_G24_23 XI1666_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I124_XG_MN2 (I1666_G28_25n I1666_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I124_XG_MN0 (XI1666_I124_XG_n1 I1666_P28_27 I1666_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I124_XG_MN1 (VSS I1666_G26_25 XI1666_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I126_XG_MN2 (I1666_G30_27n I1666_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I126_XG_MN0 (XI1666_I126_XG_n1 I1666_P30_29 I1666_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I126_XG_MN1 (VSS I1666_G28_27 XI1666_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I123_XG_MN2 (I1666_G27_24n I1666_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I123_XG_MN0 (XI1666_I123_XG_n1 I1666_P27_26 I1666_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I123_XG_MN1 (VSS I1666_G25_24 XI1666_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I121_XG_MN2 (I1666_G25_22n I1666_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I121_XG_MN0 (XI1666_I121_XG_n1 I1666_P25_24 I1666_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I121_XG_MN1 (VSS I1666_G23_22 XI1666_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I119_XG_MN2 (I1666_G23_20n I1666_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I119_XG_MN0 (XI1666_I119_XG_n1 I1666_P23_22 I1666_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I119_XG_MN1 (VSS I1666_G21_20 XI1666_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I174_XG_MN2 (I1620_G23_8n I1620_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I174_XG_MN0 (XI1620_I174_XG_n1 I1620_P23_16 I1620_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I174_XG_MN1 (VSS I1620_G15_8 XI1620_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I180_XG_MN2 (I1620_G29_14n I1620_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I180_XG_MN0 (XI1620_I180_XG_n1 I1620_P29_22 I1620_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I180_XG_MN1 (VSS I1620_G21_14 XI1620_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I119_XG_MN2 (I1620_G23_20n I1620_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I119_XG_MN0 (XI1620_I119_XG_n1 I1620_P23_22 I1620_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I119_XG_MN1 (VSS I1620_G21_20 XI1620_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I120_XG_MN2 (I1620_G24_21n I1620_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I120_XG_MN0 (XI1620_I120_XG_n1 I1620_P24_23 I1620_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I120_XG_MN1 (VSS I1620_G22_21 XI1620_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I178_XG_MN2 (I1574_G27_12n I1574_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I178_XG_MN0 (XI1574_I178_XG_n1 I1574_P27_20 I1574_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I178_XG_MN1 (VSS I1574_G19_12 XI1574_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I119_XG_MN2 (I1574_G23_20n I1574_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I119_XG_MN0 (XI1574_I119_XG_n1 I1574_P23_22 I1574_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I119_XG_MN1 (VSS I1574_G21_20 XI1574_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I122_XG_MN2 (I1574_G26_23n I1574_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I122_XG_MN0 (XI1574_I122_XG_n1 I1574_P26_25 I1574_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I122_XG_MN1 (VSS I1574_G24_23 XI1574_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I126_XG_MN2 (I1114_G30_27n I1114_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I126_XG_MN0 (XI1114_I126_XG_n1 I1114_P30_29 I1114_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I126_XG_MN1 (VSS I1114_G28_27 XI1114_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I124_XG_MN2 (I1114_G28_25n I1114_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I124_XG_MN0 (XI1114_I124_XG_n1 I1114_P28_27 I1114_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I124_XG_MN1 (VSS I1114_G26_25 XI1114_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I122_XG_MN2 (I1114_G26_23n I1114_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I122_XG_MN0 (XI1114_I122_XG_n1 I1114_P26_25 I1114_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I122_XG_MN1 (VSS I1114_G24_23 XI1114_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I120_XG_MN2 (I1114_G24_21n I1114_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I120_XG_MN0 (XI1114_I120_XG_n1 I1114_P24_23 I1114_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I120_XG_MN1 (VSS I1114_G22_21 XI1114_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I177_XG_MN2 (I1114_G26_11n I1114_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I177_XG_MN0 (XI1114_I177_XG_n1 I1114_P26_19 I1114_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I177_XG_MN1 (VSS I1114_G18_11 XI1114_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I110_XG_MN2 (I1114_G14_11n I1114_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I110_XG_MN0 (XI1114_I110_XG_n1 I1114_P14_13 I1114_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I110_XG_MN1 (VSS I1114_G12_11 XI1114_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I108_XG_MN2 (I1114_G12_9n I1114_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I108_XG_MN0 (XI1114_I108_XG_n1 I1114_P12_11 I1114_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I108_XG_MN1 (VSS I1114_G10_9 XI1114_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I106_XG_MN2 (I1114_G10_7n I1114_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I106_XG_MN0 (XI1114_I106_XG_n1 I1114_P10_9 I1114_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I106_XG_MN1 (VSS I1114_G8_7 XI1114_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I182_XG_MN2 (I1022_G31_16n I1022_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I182_XG_MN0 (XI1022_I182_XG_n1 I1022_P31_24 I1022_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I182_XG_MN1 (VSS I1022_G23_16 XI1022_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I123_XG_MN2 (I1022_G27_24n I1022_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I123_XG_MN0 (XI1022_I123_XG_n1 I1022_P27_26 I1022_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I123_XG_MN1 (VSS I1022_G25_24 XI1022_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I181_XG_MN2 (I1022_G30_15n I1022_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I181_XG_MN0 (XI1022_I181_XG_n1 I1022_P30_23 I1022_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I181_XG_MN1 (VSS I1022_G22_15 XI1022_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I122_XG_MN2 (I1022_G26_23n I1022_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I122_XG_MN0 (XI1022_I122_XG_n1 I1022_P26_25 I1022_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I122_XG_MN1 (VSS I1022_G24_23 XI1022_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I173_XG_MN2 (I976_G22_7n I976_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I173_XG_MN0 (XI976_I173_XG_n1 I976_P22_15 I976_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I173_XG_MN1 (VSS I976_G14_7 XI976_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I165_XG_MN2 (I976_G14_0n I976_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I165_XG_MN0 (XI976_I165_XG_n1 I976_P14_7 I976_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I165_XG_MN1 (VSS I976_G6_0 XI976_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I118_XG_MN2 (I976_G22_19n I976_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I118_XG_MN0 (XI976_I118_XG_n1 I976_P22_21 I976_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I118_XG_MN1 (VSS I976_G20_19 XI976_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I166_XG_MN2 (I976_G15_0n I976_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I166_XG_MN0 (XI976_I166_XG_n1 I976_P15_8 I976_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I166_XG_MN1 (VSS I976_G7_0 XI976_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I174_XG_MN2 (I976_G23_8n I976_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I174_XG_MN0 (XI976_I174_XG_n1 I976_P23_16 I976_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I174_XG_MN1 (VSS I976_G15_8 XI976_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I120_XG_MN2 (I930_G24_21n I930_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I120_XG_MN0 (XI930_I120_XG_n1 I930_P24_23 I930_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I120_XG_MN1 (VSS I930_G22_21 XI930_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I122_XG_MN2 (I930_G26_23n I930_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I122_XG_MN0 (XI930_I122_XG_n1 I930_P26_25 I930_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I122_XG_MN1 (VSS I930_G24_23 XI930_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I123_XG_MN2 (I930_G27_24n I930_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I123_XG_MN0 (XI930_I123_XG_n1 I930_P27_26 I930_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I123_XG_MN1 (VSS I930_G25_24 XI930_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I121_XG_MN2 (I930_G25_22n I930_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I121_XG_MN0 (XI930_I121_XG_n1 I930_P25_24 I930_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I121_XG_MN1 (VSS I930_G23_22 XI930_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I125_XG_MN2 (I1666_G29_26n I1666_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I125_XG_MN0 (XI1666_I125_XG_n1 I1666_P29_28 I1666_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I125_XG_MN1 (VSS I1666_G27_26 XI1666_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I182_XG_MN2 (I1666_G31_16n I1666_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I182_XG_MN0 (XI1666_I182_XG_n1 I1666_P31_24 I1666_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I182_XG_MN1 (VSS I1666_G23_16 XI1666_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I178_XG_MN2 (I1620_G27_12n I1620_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I178_XG_MN0 (XI1620_I178_XG_n1 I1620_P27_20 I1620_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I178_XG_MN1 (VSS I1620_G19_12 XI1620_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I182_XG_MN2 (I1620_G31_16n I1620_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I182_XG_MN0 (XI1620_I182_XG_n1 I1620_P31_24 I1620_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I182_XG_MN1 (VSS I1620_G23_16 XI1620_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I123_XG_MN2 (I1620_G27_24n I1620_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I123_XG_MN0 (XI1620_I123_XG_n1 I1620_P27_26 I1620_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I123_XG_MN1 (VSS I1620_G25_24 XI1620_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I121_XG_MN2 (I1620_G25_22n I1620_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I121_XG_MN0 (XI1620_I121_XG_n1 I1620_P25_24 I1620_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I121_XG_MN1 (VSS I1620_G23_22 XI1620_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I181_XG_MN2 (I1620_G30_15n I1620_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I181_XG_MN0 (XI1620_I181_XG_n1 I1620_P30_23 I1620_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I181_XG_MN1 (VSS I1620_G22_15 XI1620_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I124_XG_MN2 (I1620_G28_25n I1620_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I124_XG_MN0 (XI1620_I124_XG_n1 I1620_P28_27 I1620_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I124_XG_MN1 (VSS I1620_G26_25 XI1620_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I122_XG_MN2 (I1620_G26_23n I1620_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I122_XG_MN0 (XI1620_I122_XG_n1 I1620_P26_25 I1620_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I122_XG_MN1 (VSS I1620_G24_23 XI1620_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I182_XG_MN2 (I1574_G31_16n I1574_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I182_XG_MN0 (XI1574_I182_XG_n1 I1574_P31_24 I1574_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I182_XG_MN1 (VSS I1574_G23_16 XI1574_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I123_XG_MN2 (I1574_G27_24n I1574_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I123_XG_MN0 (XI1574_I123_XG_n1 I1574_P27_26 I1574_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I123_XG_MN1 (VSS I1574_G25_24 XI1574_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I121_XG_MN2 (I1574_G25_22n I1574_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I121_XG_MN0 (XI1574_I121_XG_n1 I1574_P25_24 I1574_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I121_XG_MN1 (VSS I1574_G23_22 XI1574_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I124_XG_MN2 (I1574_G28_25n I1574_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I124_XG_MN0 (XI1574_I124_XG_n1 I1574_P28_27 I1574_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I124_XG_MN1 (VSS I1574_G26_25 XI1574_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I181_XG_MN2 (I1114_G30_15n I1114_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I181_XG_MN0 (XI1114_I181_XG_n1 I1114_P30_23 I1114_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I181_XG_MN1 (VSS I1114_G22_15 XI1114_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I179_XG_MN2 (I1114_G28_13n I1114_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I179_XG_MN0 (XI1114_I179_XG_n1 I1114_P28_21 I1114_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I179_XG_MN1 (VSS I1114_G20_13 XI1114_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I173_XG_MN2 (I1114_G22_7n I1114_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I173_XG_MN0 (XI1114_I173_XG_n1 I1114_P22_15 I1114_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I173_XG_MN1 (VSS I1114_G14_7 XI1114_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I165_XG_MN2 (I1114_G14_0n I1114_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I165_XG_MN0 (XI1114_I165_XG_n1 I1114_P14_7 I1114_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I165_XG_MN1 (VSS I1114_G6_0 XI1114_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I171_XG_MN2 (I1114_G20_5n I1114_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I171_XG_MN0 (XI1114_I171_XG_n1 I1114_P20_13 I1114_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I171_XG_MN1 (VSS I1114_G12_5 XI1114_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I175_XG_MN2 (I1114_G24_9n I1114_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I175_XG_MN0 (XI1114_I175_XG_n1 I1114_P24_17 I1114_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I175_XG_MN1 (VSS I1114_G16_9 XI1114_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I163_XG_MN2 (I1114_G12_0n I1114_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I163_XG_MN0 (XI1114_I163_XG_n1 I1114_P12_5 I1114_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I163_XG_MN1 (VSS I1114_G4_0 XI1114_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I169_XG_MN2 (I1114_G18_3n I1114_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I169_XG_MN0 (XI1114_I169_XG_n1 I1114_P18_11 I1114_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I169_XG_MN1 (VSS I1114_G10_3 XI1114_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I104_XG_MN2 (I1114_G8_5n I1114_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I104_XG_MN0 (XI1114_I104_XG_n1 I1114_P8_7 I1114_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I104_XG_MN1 (VSS I1114_G6_5 XI1114_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I102_XG_MN2 (I1114_G6_3n I1114_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I102_XG_MN0 (XI1114_I102_XG_n1 I1114_P6_5 I1114_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I102_XG_MN1 (VSS I1114_G4_3 XI1114_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2141_MN2 (nqkn22 nqk21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2141_MN0 (XI2141_n1 sq_b3_3 nqkn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2141_MN1 (VSS qu21_b3_5 XI2141_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I125_XG_MN2 (I1022_G29_26n I1022_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I125_XG_MN0 (XI1022_I125_XG_n1 I1022_P29_28 I1022_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I125_XG_MN1 (VSS I1022_G27_26 XI1022_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I127_XG_MN2 (I1022_G31_28n I1022_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I127_XG_MN0 (XI1022_I127_XG_n1 I1022_P31_30 I1022_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I127_XG_MN1 (VSS I1022_G29_28 XI1022_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I126_XG_MN2 (I1022_G30_27n I1022_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I126_XG_MN0 (XI1022_I126_XG_n1 I1022_P30_29 I1022_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I126_XG_MN1 (VSS I1022_G28_27 XI1022_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1022_I124_XG_MN2 (I1022_G28_25n I1022_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I124_XG_MN0 (XI1022_I124_XG_n1 I1022_P28_27 I1022_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1022_I124_XG_MN1 (VSS I1022_G26_25 XI1022_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I177_XG_MN2 (I976_G26_11n I976_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I177_XG_MN0 (XI976_I177_XG_n1 I976_P26_19 I976_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I177_XG_MN1 (VSS I976_G18_11 XI976_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I120_XG_MN2 (I976_G24_21n I976_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I120_XG_MN0 (XI976_I120_XG_n1 I976_P24_23 I976_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I120_XG_MN1 (VSS I976_G22_21 XI976_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I178_XG_MN2 (I976_G27_12n I976_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I178_XG_MN0 (XI976_I178_XG_n1 I976_P27_20 I976_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I178_XG_MN1 (VSS I976_G19_12 XI976_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I119_XG_MN2 (I976_G23_20n I976_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I119_XG_MN0 (XI976_I119_XG_n1 I976_P23_22 I976_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I119_XG_MN1 (VSS I976_G21_20 XI976_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I181_XG_MN2 (I930_G30_15n I930_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I181_XG_MN0 (XI930_I181_XG_n1 I930_P30_23 I930_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I181_XG_MN1 (VSS I930_G22_15 XI930_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I124_XG_MN2 (I930_G28_25n I930_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I124_XG_MN0 (XI930_I124_XG_n1 I930_P28_27 I930_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I124_XG_MN1 (VSS I930_G26_25 XI930_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I125_XG_MN2 (I930_G29_26n I930_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I125_XG_MN0 (XI930_I125_XG_n1 I930_P29_28 I930_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I125_XG_MN1 (VSS I930_G27_26 XI930_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I127_XG_MN2 (I1666_G31_28n I1666_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I127_XG_MN0 (XI1666_I127_XG_n1 I1666_P31_30 I1666_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I127_XG_MN1 (VSS I1666_G29_28 XI1666_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I125_XG_MN2 (I1620_G29_26n I1620_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I125_XG_MN0 (XI1620_I125_XG_n1 I1620_P29_28 I1620_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I125_XG_MN1 (VSS I1620_G27_26 XI1620_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I126_XG_MN2 (I1620_G30_27n I1620_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I126_XG_MN0 (XI1620_I126_XG_n1 I1620_P30_29 I1620_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I126_XG_MN1 (VSS I1620_G28_27 XI1620_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I127_XG_MN2 (I1574_G31_28n I1574_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I127_XG_MN0 (XI1574_I127_XG_n1 I1574_P31_30 I1574_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I127_XG_MN1 (VSS I1574_G29_28 XI1574_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I125_XG_MN2 (I1574_G29_26n I1574_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I125_XG_MN0 (XI1574_I125_XG_n1 I1574_P29_28 I1574_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I125_XG_MN1 (VSS I1574_G27_26 XI1574_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I126_XG_MN2 (I1574_G30_27n I1574_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I126_XG_MN0 (XI1574_I126_XG_n1 I1574_P30_29 I1574_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1574_I126_XG_MN1 (VSS I1574_G28_27 XI1574_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I119_XG_MN2 (I1114_G23_20n I1114_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I119_XG_MN0 (XI1114_I119_XG_n1 I1114_P23_22 I1114_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I119_XG_MN1 (VSS I1114_G21_20 XI1114_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I160_XG_MN2 (I1114_G10_0n I1114_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I160_XG_MN0 (XI1114_I160_XG_n1 I1114_P10_3 I1114_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I160_XG_MN1 (VSS I1114_G2_0np XI1114_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I167_XG_MN2 (I1114_G16_1n I1114_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I167_XG_MN0 (XI1114_I167_XG_n1 I1114_P16_9 I1114_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I167_XG_MN1 (VSS I1114_G8_1 XI1114_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I100_XG_MN2 (I1114_G4_1n I1114_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I100_XG_MN0 (XI1114_I100_XG_n1 I1114_P4_3 I1114_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I100_XG_MN1 (VSS I1114_G2_1 XI1114_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2138_MN2 (nqkn21 nqk20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2138_MN0 (XI2138_n1 sq_b3_3 nqkn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2138_MN1 (VSS qu20_b3_5 XI2138_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI96_MN2 (nakn21 nak20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI96_MN0 (XI96_n1 A_31_b3_3 nakn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI96_MN1 (VSS A_20 XI96_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I179_XG_MN2 (I976_G28_13n I976_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I179_XG_MN0 (XI976_I179_XG_n1 I976_P28_21 I976_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I179_XG_MN1 (VSS I976_G20_13 XI976_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I124_XG_MN2 (I976_G28_25n I976_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I124_XG_MN0 (XI976_I124_XG_n1 I976_P28_27 I976_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I124_XG_MN1 (VSS I976_G26_25 XI976_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I122_XG_MN2 (I976_G26_23n I976_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I122_XG_MN0 (XI976_I122_XG_n1 I976_P26_25 I976_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I122_XG_MN1 (VSS I976_G24_23 XI976_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I180_XG_MN2 (I976_G29_14n I976_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I180_XG_MN0 (XI976_I180_XG_n1 I976_P29_22 I976_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I180_XG_MN1 (VSS I976_G21_14 XI976_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I123_XG_MN2 (I976_G27_24n I976_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I123_XG_MN0 (XI976_I123_XG_n1 I976_P27_26 I976_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I123_XG_MN1 (VSS I976_G25_24 XI976_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I121_XG_MN2 (I976_G25_22n I976_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I121_XG_MN0 (XI976_I121_XG_n1 I976_P25_24 I976_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I121_XG_MN1 (VSS I976_G23_22 XI976_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I126_XG_MN2 (I930_G30_27n I930_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I126_XG_MN0 (XI930_I126_XG_n1 I930_P30_29 I930_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I126_XG_MN1 (VSS I930_G28_27 XI930_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1620_I127_XG_MN2 (I1620_G31_28n I1620_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I127_XG_MN0 (XI1620_I127_XG_n1 I1620_P31_30 I1620_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1620_I127_XG_MN1 (VSS I1620_G29_28 XI1620_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI66_MN2 (nakn11 nak10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI66_MN0 (XI66_n1 A_31_b3_1 nakn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI66_MN1 (VSS A_10 XI66_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I127_XG_MN2 (I1114_G31_28n I1114_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I127_XG_MN0 (XI1114_I127_XG_n1 I1114_P31_30 I1114_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I127_XG_MN1 (VSS I1114_G29_28 XI1114_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I125_XG_MN2 (I1114_G29_26n I1114_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I125_XG_MN0 (XI1114_I125_XG_n1 I1114_P29_28 I1114_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I125_XG_MN1 (VSS I1114_G27_26 XI1114_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I123_XG_MN2 (I1114_G27_24n I1114_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I123_XG_MN0 (XI1114_I123_XG_n1 I1114_P27_26 I1114_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I123_XG_MN1 (VSS I1114_G25_24 XI1114_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I121_XG_MN2 (I1114_G25_22n I1114_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I121_XG_MN0 (XI1114_I121_XG_n1 I1114_P25_24 I1114_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I121_XG_MN1 (VSS I1114_G23_22 XI1114_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I117_XG_MN2 (I1114_G21_18n I1114_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I117_XG_MN0 (XI1114_I117_XG_n1 I1114_P21_20 I1114_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I117_XG_MN1 (VSS I1114_G19_18 XI1114_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I176_XG_MN2 (I1114_G25_10n I1114_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I176_XG_MN0 (XI1114_I176_XG_n1 I1114_P25_18 I1114_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I176_XG_MN1 (VSS I1114_G17_10 XI1114_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I115_XG_MN2 (I1114_G19_16n I1114_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I115_XG_MN0 (XI1114_I115_XG_n1 I1114_P19_18 I1114_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I115_XG_MN1 (VSS I1114_G17_16 XI1114_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I113_XG_MN2 (I1114_G17_14n I1114_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I113_XG_MN0 (XI1114_I113_XG_n1 I1114_P17_16 I1114_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I113_XG_MN1 (VSS I1114_G15_14 XI1114_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I111_XG_MN2 (I1114_G15_12n I1114_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I111_XG_MN0 (XI1114_I111_XG_n1 I1114_P15_14 I1114_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I111_XG_MN1 (VSS I1114_G13_12 XI1114_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I109_XG_MN2 (I1114_G13_10n I1114_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I109_XG_MN0 (XI1114_I109_XG_n1 I1114_P13_12 I1114_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I109_XG_MN1 (VSS I1114_G11_10 XI1114_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I107_XG_MN2 (I1114_G11_8n I1114_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I107_XG_MN0 (XI1114_I107_XG_n1 I1114_P11_10 I1114_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I107_XG_MN1 (VSS I1114_G9_8 XI1114_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I105_XG_MN2 (I1114_G9_6n I1114_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I105_XG_MN0 (XI1114_I105_XG_n1 I1114_P9_8 I1114_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I105_XG_MN1 (VSS I1114_G7_6 XI1114_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I157_XG_MN2 (I1114_G8_0n I1114_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I157_XG_MN0 (XI1114_I157_XG_n1 I1114_P8_1 I1114_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I157_XG_MN1 (VSS I1114_G0_0 XI1114_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I98_XG_MN2 (I1114_G2_0n I1114_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I98_XG_MN0 (XI1114_I98_XG_n1 I1114_P2_1 I1114_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I98_XG_MN1 (VSS I1114_G0_0 XI1114_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI93_MN2 (nakn20 nak19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI93_MN0 (XI93_n1 A_31_b3_3 nakn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI93_MN1 (VSS A_19 XI93_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I181_XG_MN2 (I976_G30_15n I976_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I181_XG_MN0 (XI976_I181_XG_n1 I976_P30_23 I976_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I181_XG_MN1 (VSS I976_G22_15 XI976_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I182_XG_MN2 (I976_G31_16n I976_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I182_XG_MN0 (XI976_I182_XG_n1 I976_P31_24 I976_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I182_XG_MN1 (VSS I976_G23_16 XI976_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I127_XG_MN2 (I976_G31_28n I976_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I127_XG_MN0 (XI976_I127_XG_n1 I976_P31_30 I976_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I127_XG_MN1 (VSS I976_G29_28 XI976_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I125_XG_MN2 (I976_G29_26n I976_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I125_XG_MN0 (XI976_I125_XG_n1 I976_P29_28 I976_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I125_XG_MN1 (VSS I976_G27_26 XI976_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI930_I127_XG_MN2 (I930_G31_28n I930_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I127_XG_MN0 (XI930_I127_XG_n1 I930_P31_30 I930_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI930_I127_XG_MN1 (VSS I930_G29_28 XI930_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI78_MN2 (nakn15 nak14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI78_MN0 (XI78_n1 A_31_b3_2 nakn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI78_MN1 (VSS A_14 XI78_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI75_MN2 (nakn14 nak13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI75_MN0 (XI75_n1 A_31_b3_2 nakn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI75_MN1 (VSS A_13 XI75_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI72_MN2 (nakn13 nak12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI72_MN0 (XI72_n1 A_31_b3_2 nakn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI72_MN1 (VSS A_12 XI72_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI69_MN2 (nakn12 nak11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI69_MN0 (XI69_n1 A_31_b3_1 nakn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI69_MN1 (VSS A_11 XI69_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2111_MN2 (nqkn12 nqk11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2111_MN0 (XI2111_n1 sq_b3_2 nqkn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2111_MN1 (VSS qu11_b3_5 XI2111_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I180_XG_MN2 (I1114_G29_14n I1114_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I180_XG_MN0 (XI1114_I180_XG_n1 I1114_P29_22 I1114_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I180_XG_MN1 (VSS I1114_G21_14 XI1114_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I172_XG_MN2 (I1114_G21_6n I1114_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I172_XG_MN0 (XI1114_I172_XG_n1 I1114_P21_14 I1114_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I172_XG_MN1 (VSS I1114_G13_6 XI1114_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I164_XG_MN2 (I1114_G13_0n I1114_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I164_XG_MN0 (XI1114_I164_XG_n1 I1114_P13_6 I1114_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I164_XG_MN1 (VSS I1114_G5_0 XI1114_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I168_XG_MN2 (I1114_G17_2n I1114_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I168_XG_MN0 (XI1114_I168_XG_n1 I1114_P17_10 I1114_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I168_XG_MN1 (VSS I1114_G9_2 XI1114_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I158_XG_MN2 (I1114_G9_0n I1114_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I158_XG_MN0 (XI1114_I158_XG_n1 I1114_P9_2 I1114_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I158_XG_MN1 (VSS I1114_G1_0 XI1114_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I103_XG_MN2 (I1114_G7_4n I1114_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I103_XG_MN0 (XI1114_I103_XG_n1 I1114_P7_6 I1114_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I103_XG_MN1 (VSS I1114_G5_4 XI1114_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I101_XG_MN2 (I1114_G5_2n I1114_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I101_XG_MN0 (XI1114_I101_XG_n1 I1114_P5_4 I1114_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I101_XG_MN1 (VSS I1114_G3_2 XI1114_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I99_XG_MN2 (I1114_G3_0n I1114_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I99_XG_MN0 (XI1114_I99_XG_n1 I1114_P3_2 I1114_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I99_XG_MN1 (VSS I1114_G1_0 XI1114_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI90_MN2 (nakn19 nak18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI90_MN0 (XI90_n1 A_31_b3_3 nakn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI90_MN1 (VSS A_18 XI90_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI87_MN2 (nakn18 nak17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI87_MN0 (XI87_n1 A_31_b3_2 nakn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI87_MN1 (VSS A_17 XI87_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI84_MN2 (nakn17 nak16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI84_MN0 (XI84_n1 A_31_b3_2 nakn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI84_MN1 (VSS A_16 XI84_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI976_I126_XG_MN2 (I976_G30_27n I976_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I126_XG_MN0 (XI976_I126_XG_n1 I976_P30_29 I976_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI976_I126_XG_MN1 (VSS I976_G28_27 XI976_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI81_MN2 (nakn16 nak15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI81_MN0 (XI81_n1 A_31_b3_2 nakn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI81_MN1 (VSS A_15 XI81_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2123_MN2 (nqkn16 nqk15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2123_MN0 (XI2123_n1 sq_b3_2 nqkn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2123_MN1 (VSS qu15_b3_5 XI2123_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2120_MN2 (nqkn15 nqk14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2120_MN0 (XI2120_n1 sq_b3_2 nqkn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2120_MN1 (VSS qu14_b3_5 XI2120_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2117_MN2 (nqkn14 nqk13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2117_MN0 (XI2117_n1 sq_b3_2 nqkn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2117_MN1 (VSS qu13_b3_5 XI2117_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2114_MN2 (nqkn13 nqk12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2114_MN0 (XI2114_n1 sq_b3_2 nqkn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2114_MN1 (VSS qu12_b3_5 XI2114_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I98_XG_MN2 (I1528_G2_0n I1528_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I98_XG_MN0 (XI1528_I98_XG_n1 I1528_P2_1 I1528_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I98_XG_MN1 (VSS I1528_G0_0 XI1528_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I100_XG_MN2 (I1528_G4_1n I1528_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I100_XG_MN0 (XI1528_I100_XG_n1 I1528_P4_3 I1528_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I100_XG_MN1 (VSS I1528_G2_1 XI1528_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I157_XG_MN2 (I1528_G8_0n I1528_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I157_XG_MN0 (XI1528_I157_XG_n1 I1528_P8_1 I1528_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I157_XG_MN1 (VSS I1528_G0_0 XI1528_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I99_XG_MN2 (I1528_G3_0n I1528_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I99_XG_MN0 (XI1528_I99_XG_n1 I1528_P3_2 I1528_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I99_XG_MN1 (VSS I1528_G1_0 XI1528_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I101_XG_MN2 (I1528_G5_2n I1528_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I101_XG_MN0 (XI1528_I101_XG_n1 I1528_P5_4 I1528_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I101_XG_MN1 (VSS I1528_G3_2 XI1528_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I182_XG_MN2 (I1114_G31_16n I1114_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I182_XG_MN0 (XI1114_I182_XG_n1 I1114_P31_24 I1114_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I182_XG_MN1 (VSS I1114_G23_16 XI1114_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I178_XG_MN2 (I1114_G27_12n I1114_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I178_XG_MN0 (XI1114_I178_XG_n1 I1114_P27_20 I1114_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I178_XG_MN1 (VSS I1114_G19_12 XI1114_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I174_XG_MN2 (I1114_G23_8n I1114_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I174_XG_MN0 (XI1114_I174_XG_n1 I1114_P23_16 I1114_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I174_XG_MN1 (VSS I1114_G15_8 XI1114_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I166_XG_MN2 (I1114_G15_0n I1114_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I166_XG_MN0 (XI1114_I166_XG_n1 I1114_P15_8 I1114_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I166_XG_MN1 (VSS I1114_G7_0 XI1114_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I170_XG_MN2 (I1114_G19_4n I1114_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I170_XG_MN0 (XI1114_I170_XG_n1 I1114_P19_12 I1114_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I170_XG_MN1 (VSS I1114_G11_4 XI1114_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1114_I162_XG_MN2 (I1114_G11_0n I1114_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I162_XG_MN0 (XI1114_I162_XG_n1 I1114_P11_4 I1114_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1114_I162_XG_MN1 (VSS I1114_G3_0np XI1114_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2135_MN2 (nqkn20 nqk19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2135_MN0 (XI2135_n1 sq_b3_3 nqkn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2135_MN1 (VSS qu19_b3_5 XI2135_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2132_MN2 (nqkn19 nqk18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2132_MN0 (XI2132_n1 sq_b3_3 nqkn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2132_MN1 (VSS qu18_b3_5 XI2132_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2129_MN2 (nqkn18 nqk17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2129_MN0 (XI2129_n1 sq_b3_3 nqkn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2129_MN1 (VSS qu17_b3_5 XI2129_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I98_XG_MN2 (I1390_G2_0n I1390_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I98_XG_MN0 (XI1390_I98_XG_n1 I1390_P2_1 I1390_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I98_XG_MN1 (VSS I1390_G0_0 XI1390_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I98_XG_MN2 (I1436_G2_0n I1436_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I98_XG_MN0 (XI1436_I98_XG_n1 I1436_P2_1 I1436_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I98_XG_MN1 (VSS I1436_G0_0 XI1436_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I99_XG_MN2 (I1482_G3_0n I1482_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I99_XG_MN0 (XI1482_I99_XG_n1 I1482_P3_2 I1482_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I99_XG_MN1 (VSS I1482_G1_0 XI1482_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I102_XG_MN2 (I1528_G6_3n I1528_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I102_XG_MN0 (XI1528_I102_XG_n1 I1528_P6_5 I1528_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I102_XG_MN1 (VSS I1528_G4_3 XI1528_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I167_XG_MN2 (I1528_G16_1n I1528_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I167_XG_MN0 (XI1528_I167_XG_n1 I1528_P16_9 I1528_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I167_XG_MN1 (VSS I1528_G8_1 XI1528_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I175_XG_MN2 (I1528_G24_9n I1528_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I175_XG_MN0 (XI1528_I175_XG_n1 I1528_P24_17 I1528_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I175_XG_MN1 (VSS I1528_G16_9 XI1528_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I103_XG_MN2 (I1528_G7_4n I1528_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I103_XG_MN0 (XI1528_I103_XG_n1 I1528_P7_6 I1528_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I103_XG_MN1 (VSS I1528_G5_4 XI1528_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I158_XG_MN2 (I1528_G9_0n I1528_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I158_XG_MN0 (XI1528_I158_XG_n1 I1528_P9_2 I1528_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I158_XG_MN1 (VSS I1528_G1_0 XI1528_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I168_XG_MN2 (I1528_G17_2n I1528_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I168_XG_MN0 (XI1528_I168_XG_n1 I1528_P17_10 I1528_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I168_XG_MN1 (VSS I1528_G9_2 XI1528_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2126_MN2 (nqkn17 nqk16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2126_MN0 (XI2126_n1 sq_b3_3 nqkn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2126_MN1 (VSS qu16_b3_5 XI2126_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I100_XG_MN2 (I1298_G4_1n I1298_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I100_XG_MN0 (XI1298_I100_XG_n1 I1298_P4_3 I1298_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I100_XG_MN1 (VSS I1298_G2_1 XI1298_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I98_XG_MN2 (I1298_G2_0n I1298_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I98_XG_MN0 (XI1298_I98_XG_n1 I1298_P2_1 I1298_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I98_XG_MN1 (VSS I1298_G0_0 XI1298_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I99_XG_MN2 (I1298_G3_0n I1298_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I99_XG_MN0 (XI1298_I99_XG_n1 I1298_P3_2 I1298_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I99_XG_MN1 (VSS I1298_G1_0 XI1298_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I102_XG_MN2 (I1344_G6_3n I1344_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I102_XG_MN0 (XI1344_I102_XG_n1 I1344_P6_5 I1344_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I102_XG_MN1 (VSS I1344_G4_3 XI1344_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I100_XG_MN2 (I1344_G4_1n I1344_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I100_XG_MN0 (XI1344_I100_XG_n1 I1344_P4_3 I1344_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I100_XG_MN1 (VSS I1344_G2_1 XI1344_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I98_XG_MN2 (I1344_G2_0n I1344_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I98_XG_MN0 (XI1344_I98_XG_n1 I1344_P2_1 I1344_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I98_XG_MN1 (VSS I1344_G0_0 XI1344_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I101_XG_MN2 (I1344_G5_2n I1344_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I101_XG_MN0 (XI1344_I101_XG_n1 I1344_P5_4 I1344_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I101_XG_MN1 (VSS I1344_G3_2 XI1344_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I99_XG_MN2 (I1344_G3_0n I1344_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I99_XG_MN0 (XI1344_I99_XG_n1 I1344_P3_2 I1344_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I99_XG_MN1 (VSS I1344_G1_0 XI1344_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I102_XG_MN2 (I1390_G6_3n I1390_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I102_XG_MN0 (XI1390_I102_XG_n1 I1390_P6_5 I1390_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I102_XG_MN1 (VSS I1390_G4_3 XI1390_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I100_XG_MN2 (I1390_G4_1n I1390_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I100_XG_MN0 (XI1390_I100_XG_n1 I1390_P4_3 I1390_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I100_XG_MN1 (VSS I1390_G2_1 XI1390_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I99_XG_MN2 (I1390_G3_0n I1390_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I99_XG_MN0 (XI1390_I99_XG_n1 I1390_P3_2 I1390_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I99_XG_MN1 (VSS I1390_G1_0 XI1390_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I101_XG_MN2 (I1390_G5_2n I1390_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I101_XG_MN0 (XI1390_I101_XG_n1 I1390_P5_4 I1390_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I101_XG_MN1 (VSS I1390_G3_2 XI1390_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I100_XG_MN2 (I1436_G4_1n I1436_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I100_XG_MN0 (XI1436_I100_XG_n1 I1436_P4_3 I1436_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I100_XG_MN1 (VSS I1436_G2_1 XI1436_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I99_XG_MN2 (I1436_G3_0n I1436_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I99_XG_MN0 (XI1436_I99_XG_n1 I1436_P3_2 I1436_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I99_XG_MN1 (VSS I1436_G1_0 XI1436_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I101_XG_MN2 (I1436_G5_2n I1436_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I101_XG_MN0 (XI1436_I101_XG_n1 I1436_P5_4 I1436_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I101_XG_MN1 (VSS I1436_G3_2 XI1436_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I101_XG_MN2 (I1482_G5_2n I1482_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I101_XG_MN0 (XI1482_I101_XG_n1 I1482_P5_4 I1482_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I101_XG_MN1 (VSS I1482_G3_2 XI1482_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I98_XG_MN2 (I1482_G2_0n I1482_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I98_XG_MN0 (XI1482_I98_XG_n1 I1482_P2_1 I1482_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I98_XG_MN1 (VSS I1482_G0_0 XI1482_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I100_XG_MN2 (I1482_G4_1n I1482_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I100_XG_MN0 (XI1482_I100_XG_n1 I1482_P4_3 I1482_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I100_XG_MN1 (VSS I1482_G2_1 XI1482_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I104_XG_MN2 (I1528_G8_5n I1528_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I104_XG_MN0 (XI1528_I104_XG_n1 I1528_P8_7 I1528_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I104_XG_MN1 (VSS I1528_G6_5 XI1528_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I163_XG_MN2 (I1528_G12_0n I1528_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I163_XG_MN0 (XI1528_I163_XG_n1 I1528_P12_5 I1528_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I163_XG_MN1 (VSS I1528_G4_0 XI1528_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I171_XG_MN2 (I1528_G20_5n I1528_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I171_XG_MN0 (XI1528_I171_XG_n1 I1528_P20_13 I1528_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I171_XG_MN1 (VSS I1528_G12_5 XI1528_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I105_XG_MN2 (I1528_G9_6n I1528_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I105_XG_MN0 (XI1528_I105_XG_n1 I1528_P9_8 I1528_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I105_XG_MN1 (VSS I1528_G7_6 XI1528_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I100_XG_MN2 (I1252_G4_1n I1252_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I100_XG_MN0 (XI1252_I100_XG_n1 I1252_P4_3 I1252_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I100_XG_MN1 (VSS I1252_G2_1 XI1252_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I98_XG_MN2 (I1252_G2_0n I1252_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I98_XG_MN0 (XI1252_I98_XG_n1 I1252_P2_1 I1252_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I98_XG_MN1 (VSS I1252_G0_0 XI1252_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I99_XG_MN2 (I1252_G3_0n I1252_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I99_XG_MN0 (XI1252_I99_XG_n1 I1252_P3_2 I1252_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I99_XG_MN1 (VSS I1252_G1_0 XI1252_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I102_XG_MN2 (I1298_G6_3n I1298_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I102_XG_MN0 (XI1298_I102_XG_n1 I1298_P6_5 I1298_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I102_XG_MN1 (VSS I1298_G4_3 XI1298_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I101_XG_MN2 (I1298_G5_2n I1298_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I101_XG_MN0 (XI1298_I101_XG_n1 I1298_P5_4 I1298_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I101_XG_MN1 (VSS I1298_G3_2 XI1298_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I104_XG_MN2 (I1344_G8_5n I1344_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I104_XG_MN0 (XI1344_I104_XG_n1 I1344_P8_7 I1344_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I104_XG_MN1 (VSS I1344_G6_5 XI1344_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I157_XG_MN2 (I1344_G8_0n I1344_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I157_XG_MN0 (XI1344_I157_XG_n1 I1344_P8_1 I1344_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I157_XG_MN1 (VSS I1344_G0_0 XI1344_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I103_XG_MN2 (I1344_G7_4n I1344_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I103_XG_MN0 (XI1344_I103_XG_n1 I1344_P7_6 I1344_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I103_XG_MN1 (VSS I1344_G5_4 XI1344_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I105_XG_MN2 (I1344_G9_6n I1344_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I105_XG_MN0 (XI1344_I105_XG_n1 I1344_P9_8 I1344_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I105_XG_MN1 (VSS I1344_G7_6 XI1344_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I104_XG_MN2 (I1390_G8_5n I1390_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I104_XG_MN0 (XI1390_I104_XG_n1 I1390_P8_7 I1390_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I104_XG_MN1 (VSS I1390_G6_5 XI1390_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I157_XG_MN2 (I1390_G8_0n I1390_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I157_XG_MN0 (XI1390_I157_XG_n1 I1390_P8_1 I1390_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I157_XG_MN1 (VSS I1390_G0_0 XI1390_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I103_XG_MN2 (I1390_G7_4n I1390_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I103_XG_MN0 (XI1390_I103_XG_n1 I1390_P7_6 I1390_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I103_XG_MN1 (VSS I1390_G5_4 XI1390_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I102_XG_MN2 (I1436_G6_3n I1436_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I102_XG_MN0 (XI1436_I102_XG_n1 I1436_P6_5 I1436_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I102_XG_MN1 (VSS I1436_G4_3 XI1436_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I104_XG_MN2 (I1436_G8_5n I1436_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I104_XG_MN0 (XI1436_I104_XG_n1 I1436_P8_7 I1436_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I104_XG_MN1 (VSS I1436_G6_5 XI1436_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I157_XG_MN2 (I1436_G8_0n I1436_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I157_XG_MN0 (XI1436_I157_XG_n1 I1436_P8_1 I1436_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I157_XG_MN1 (VSS I1436_G0_0 XI1436_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I103_XG_MN2 (I1436_G7_4n I1436_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I103_XG_MN0 (XI1436_I103_XG_n1 I1436_P7_6 I1436_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I103_XG_MN1 (VSS I1436_G5_4 XI1436_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I103_XG_MN2 (I1482_G7_4n I1482_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I103_XG_MN0 (XI1482_I103_XG_n1 I1482_P7_6 I1482_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I103_XG_MN1 (VSS I1482_G5_4 XI1482_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I102_XG_MN2 (I1482_G6_3n I1482_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I102_XG_MN0 (XI1482_I102_XG_n1 I1482_P6_5 I1482_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I102_XG_MN1 (VSS I1482_G4_3 XI1482_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I106_XG_MN2 (I1528_G10_7n I1528_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I106_XG_MN0 (XI1528_I106_XG_n1 I1528_P10_9 I1528_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I106_XG_MN1 (VSS I1528_G8_7 XI1528_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I108_XG_MN2 (I1528_G12_9n I1528_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I108_XG_MN0 (XI1528_I108_XG_n1 I1528_P12_11 I1528_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I108_XG_MN1 (VSS I1528_G10_9 XI1528_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I160_XG_MN2 (I1528_G10_0n I1528_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I160_XG_MN0 (XI1528_I160_XG_n1 I1528_P10_3 I1528_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I160_XG_MN1 (VSS I1528_G2_0np XI1528_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I107_XG_MN2 (I1528_G11_8n I1528_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I107_XG_MN0 (XI1528_I107_XG_n1 I1528_P11_10 I1528_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I107_XG_MN1 (VSS I1528_G9_8 XI1528_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I162_XG_MN2 (I1528_G11_0n I1528_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I162_XG_MN0 (XI1528_I162_XG_n1 I1528_P11_4 I1528_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I162_XG_MN1 (VSS I1528_G3_0np XI1528_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I176_XG_MN2 (I1528_G25_10n I1528_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I176_XG_MN0 (XI1528_I176_XG_n1 I1528_P25_18 I1528_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I176_XG_MN1 (VSS I1528_G17_10 XI1528_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I99_XG_MN2 (I1206_G3_0n I1206_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I99_XG_MN0 (XI1206_I99_XG_n1 I1206_P3_2 I1206_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I99_XG_MN1 (VSS I1206_G1_0 XI1206_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I98_XG_MN2 (I1206_G2_0n I1206_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I98_XG_MN0 (XI1206_I98_XG_n1 I1206_P2_1 I1206_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I98_XG_MN1 (VSS I1206_G0_0 XI1206_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I102_XG_MN2 (I1252_G6_3n I1252_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I102_XG_MN0 (XI1252_I102_XG_n1 I1252_P6_5 I1252_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I102_XG_MN1 (VSS I1252_G4_3 XI1252_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I103_XG_MN2 (I1252_G7_4n I1252_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I103_XG_MN0 (XI1252_I103_XG_n1 I1252_P7_6 I1252_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I103_XG_MN1 (VSS I1252_G5_4 XI1252_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I101_XG_MN2 (I1252_G5_2n I1252_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I101_XG_MN0 (XI1252_I101_XG_n1 I1252_P5_4 I1252_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I101_XG_MN1 (VSS I1252_G3_2 XI1252_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I104_XG_MN2 (I1298_G8_5n I1298_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I104_XG_MN0 (XI1298_I104_XG_n1 I1298_P8_7 I1298_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I104_XG_MN1 (VSS I1298_G6_5 XI1298_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I157_XG_MN2 (I1298_G8_0n I1298_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I157_XG_MN0 (XI1298_I157_XG_n1 I1298_P8_1 I1298_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I157_XG_MN1 (VSS I1298_G0_0 XI1298_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I103_XG_MN2 (I1298_G7_4n I1298_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I103_XG_MN0 (XI1298_I103_XG_n1 I1298_P7_6 I1298_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I103_XG_MN1 (VSS I1298_G5_4 XI1298_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I106_XG_MN2 (I1344_G10_7n I1344_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I106_XG_MN0 (XI1344_I106_XG_n1 I1344_P10_9 I1344_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I106_XG_MN1 (VSS I1344_G8_7 XI1344_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I167_XG_MN2 (I1344_G16_1n I1344_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I167_XG_MN0 (XI1344_I167_XG_n1 I1344_P16_9 I1344_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I167_XG_MN1 (VSS I1344_G8_1 XI1344_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I158_XG_MN2 (I1344_G9_0n I1344_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I158_XG_MN0 (XI1344_I158_XG_n1 I1344_P9_2 I1344_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I158_XG_MN1 (VSS I1344_G1_0 XI1344_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I167_XG_MN2 (I1390_G16_1n I1390_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I167_XG_MN0 (XI1390_I167_XG_n1 I1390_P16_9 I1390_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I167_XG_MN1 (VSS I1390_G8_1 XI1390_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I105_XG_MN2 (I1390_G9_6n I1390_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I105_XG_MN0 (XI1390_I105_XG_n1 I1390_P9_8 I1390_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I105_XG_MN1 (VSS I1390_G7_6 XI1390_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I158_XG_MN2 (I1390_G9_0n I1390_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I158_XG_MN0 (XI1390_I158_XG_n1 I1390_P9_2 I1390_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I158_XG_MN1 (VSS I1390_G1_0 XI1390_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I167_XG_MN2 (I1436_G16_1n I1436_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I167_XG_MN0 (XI1436_I167_XG_n1 I1436_P16_9 I1436_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I167_XG_MN1 (VSS I1436_G8_1 XI1436_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I104_XG_MN2 (I1482_G8_5n I1482_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I104_XG_MN0 (XI1482_I104_XG_n1 I1482_P8_7 I1482_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I104_XG_MN1 (VSS I1482_G6_5 XI1482_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I157_XG_MN2 (I1482_G8_0n I1482_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I157_XG_MN0 (XI1482_I157_XG_n1 I1482_P8_1 I1482_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I157_XG_MN1 (VSS I1482_G0_0 XI1482_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I169_XG_MN2 (I1528_G18_3n I1528_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I169_XG_MN0 (XI1528_I169_XG_n1 I1528_P18_11 I1528_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I169_XG_MN1 (VSS I1528_G10_3 XI1528_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I109_XG_MN2 (I1528_G13_10n I1528_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I109_XG_MN0 (XI1528_I109_XG_n1 I1528_P13_12 I1528_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I109_XG_MN1 (VSS I1528_G11_10 XI1528_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I170_XG_MN2 (I1528_G19_4n I1528_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I170_XG_MN0 (XI1528_I170_XG_n1 I1528_P19_12 I1528_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I170_XG_MN1 (VSS I1528_G11_4 XI1528_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I164_XG_MN2 (I1528_G13_0n I1528_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I164_XG_MN0 (XI1528_I164_XG_n1 I1528_P13_6 I1528_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I164_XG_MN1 (VSS I1528_G5_0 XI1528_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I119_XG_MN2 (I1160_G23_20n I1160_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I119_XG_MN0 (XI1160_I119_XG_n1 I1160_P23_22 I1160_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I119_XG_MN1 (VSS I1160_G21_20 XI1160_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I174_XG_MN2 (I1160_G23_8n I1160_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I174_XG_MN0 (XI1160_I174_XG_n1 I1160_P23_16 I1160_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I174_XG_MN1 (VSS I1160_G15_8 XI1160_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I117_XG_MN2 (I1160_G21_18n I1160_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I117_XG_MN0 (XI1160_I117_XG_n1 I1160_P21_20 I1160_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I117_XG_MN1 (VSS I1160_G19_18 XI1160_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I166_XG_MN2 (I1160_G15_0n I1160_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I166_XG_MN0 (XI1160_I166_XG_n1 I1160_P15_8 I1160_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I166_XG_MN1 (VSS I1160_G7_0 XI1160_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I115_XG_MN2 (I1160_G19_16n I1160_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I115_XG_MN0 (XI1160_I115_XG_n1 I1160_P19_18 I1160_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I115_XG_MN1 (VSS I1160_G17_16 XI1160_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I113_XG_MN2 (I1160_G17_14n I1160_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I113_XG_MN0 (XI1160_I113_XG_n1 I1160_P17_16 I1160_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I113_XG_MN1 (VSS I1160_G15_14 XI1160_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I111_XG_MN2 (I1160_G15_12n I1160_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I111_XG_MN0 (XI1160_I111_XG_n1 I1160_P15_14 I1160_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I111_XG_MN1 (VSS I1160_G13_12 XI1160_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I109_XG_MN2 (I1160_G13_10n I1160_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I109_XG_MN0 (XI1160_I109_XG_n1 I1160_P13_12 I1160_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I109_XG_MN1 (VSS I1160_G11_10 XI1160_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I107_XG_MN2 (I1160_G11_8n I1160_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I107_XG_MN0 (XI1160_I107_XG_n1 I1160_P11_10 I1160_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I107_XG_MN1 (VSS I1160_G9_8 XI1160_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I105_XG_MN2 (I1160_G9_6n I1160_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I105_XG_MN0 (XI1160_I105_XG_n1 I1160_P9_8 I1160_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I105_XG_MN1 (VSS I1160_G7_6 XI1160_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I103_XG_MN2 (I1160_G7_4n I1160_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I103_XG_MN0 (XI1160_I103_XG_n1 I1160_P7_6 I1160_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I103_XG_MN1 (VSS I1160_G5_4 XI1160_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I101_XG_MN2 (I1160_G5_2n I1160_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I101_XG_MN0 (XI1160_I101_XG_n1 I1160_P5_4 I1160_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I101_XG_MN1 (VSS I1160_G3_2 XI1160_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I99_XG_MN2 (I1160_G3_0n I1160_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I99_XG_MN0 (XI1160_I99_XG_n1 I1160_P3_2 I1160_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I99_XG_MN1 (VSS I1160_G1_0 XI1160_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I100_XG_MN2 (I1206_G4_1n I1206_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I100_XG_MN0 (XI1206_I100_XG_n1 I1206_P4_3 I1206_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I100_XG_MN1 (VSS I1206_G2_1 XI1206_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I104_XG_MN2 (I1252_G8_5n I1252_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I104_XG_MN0 (XI1252_I104_XG_n1 I1252_P8_7 I1252_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I104_XG_MN1 (VSS I1252_G6_5 XI1252_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I157_XG_MN2 (I1252_G8_0n I1252_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I157_XG_MN0 (XI1252_I157_XG_n1 I1252_P8_1 I1252_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I157_XG_MN1 (VSS I1252_G0_0 XI1252_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I105_XG_MN2 (I1252_G9_6n I1252_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I105_XG_MN0 (XI1252_I105_XG_n1 I1252_P9_8 I1252_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I105_XG_MN1 (VSS I1252_G7_6 XI1252_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I158_XG_MN2 (I1252_G9_0n I1252_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I158_XG_MN0 (XI1252_I158_XG_n1 I1252_P9_2 I1252_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I158_XG_MN1 (VSS I1252_G1_0 XI1252_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I167_XG_MN2 (I1298_G16_1n I1298_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I167_XG_MN0 (XI1298_I167_XG_n1 I1298_P16_9 I1298_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I167_XG_MN1 (VSS I1298_G8_1 XI1298_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I105_XG_MN2 (I1298_G9_6n I1298_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I105_XG_MN0 (XI1298_I105_XG_n1 I1298_P9_8 I1298_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I105_XG_MN1 (VSS I1298_G7_6 XI1298_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I158_XG_MN2 (I1298_G9_0n I1298_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I158_XG_MN0 (XI1298_I158_XG_n1 I1298_P9_2 I1298_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I158_XG_MN1 (VSS I1298_G1_0 XI1298_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I160_XG_MN2 (I1344_G10_0n I1344_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I160_XG_MN0 (XI1344_I160_XG_n1 I1344_P10_3 I1344_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I160_XG_MN1 (VSS I1344_G2_0np XI1344_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I108_XG_MN2 (I1344_G12_9n I1344_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I108_XG_MN0 (XI1344_I108_XG_n1 I1344_P12_11 I1344_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I108_XG_MN1 (VSS I1344_G10_9 XI1344_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I107_XG_MN2 (I1344_G11_8n I1344_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I107_XG_MN0 (XI1344_I107_XG_n1 I1344_P11_10 I1344_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I107_XG_MN1 (VSS I1344_G9_8 XI1344_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I168_XG_MN2 (I1344_G17_2n I1344_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I168_XG_MN0 (XI1344_I168_XG_n1 I1344_P17_10 I1344_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I168_XG_MN1 (VSS I1344_G9_2 XI1344_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I106_XG_MN2 (I1390_G10_7n I1390_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I106_XG_MN0 (XI1390_I106_XG_n1 I1390_P10_9 I1390_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I106_XG_MN1 (VSS I1390_G8_7 XI1390_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I160_XG_MN2 (I1390_G10_0n I1390_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I160_XG_MN0 (XI1390_I160_XG_n1 I1390_P10_3 I1390_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I160_XG_MN1 (VSS I1390_G2_0np XI1390_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I168_XG_MN2 (I1390_G17_2n I1390_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I168_XG_MN0 (XI1390_I168_XG_n1 I1390_P17_10 I1390_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I168_XG_MN1 (VSS I1390_G9_2 XI1390_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I106_XG_MN2 (I1436_G10_7n I1436_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I106_XG_MN0 (XI1436_I106_XG_n1 I1436_P10_9 I1436_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I106_XG_MN1 (VSS I1436_G8_7 XI1436_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I160_XG_MN2 (I1436_G10_0n I1436_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I160_XG_MN0 (XI1436_I160_XG_n1 I1436_P10_3 I1436_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I160_XG_MN1 (VSS I1436_G2_0np XI1436_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I105_XG_MN2 (I1436_G9_6n I1436_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I105_XG_MN0 (XI1436_I105_XG_n1 I1436_P9_8 I1436_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I105_XG_MN1 (VSS I1436_G7_6 XI1436_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I158_XG_MN2 (I1436_G9_0n I1436_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I158_XG_MN0 (XI1436_I158_XG_n1 I1436_P9_2 I1436_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I158_XG_MN1 (VSS I1436_G1_0 XI1436_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I105_XG_MN2 (I1482_G9_6n I1482_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I105_XG_MN0 (XI1482_I105_XG_n1 I1482_P9_8 I1482_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I105_XG_MN1 (VSS I1482_G7_6 XI1482_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I158_XG_MN2 (I1482_G9_0n I1482_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I158_XG_MN0 (XI1482_I158_XG_n1 I1482_P9_2 I1482_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I158_XG_MN1 (VSS I1482_G1_0 XI1482_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I106_XG_MN2 (I1482_G10_7n I1482_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I106_XG_MN0 (XI1482_I106_XG_n1 I1482_P10_9 I1482_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I106_XG_MN1 (VSS I1482_G8_7 XI1482_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I167_XG_MN2 (I1482_G16_1n I1482_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I167_XG_MN0 (XI1482_I167_XG_n1 I1482_P16_9 I1482_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I167_XG_MN1 (VSS I1482_G8_1 XI1482_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I110_XG_MN2 (I1528_G14_11n I1528_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I110_XG_MN0 (XI1528_I110_XG_n1 I1528_P14_13 I1528_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I110_XG_MN1 (VSS I1528_G12_11 XI1528_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I177_XG_MN2 (I1528_G26_11n I1528_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I177_XG_MN0 (XI1528_I177_XG_n1 I1528_P26_19 I1528_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I177_XG_MN1 (VSS I1528_G18_11 XI1528_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I172_XG_MN2 (I1528_G21_6n I1528_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I172_XG_MN0 (XI1528_I172_XG_n1 I1528_P21_14 I1528_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I172_XG_MN1 (VSS I1528_G13_6 XI1528_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I182_XG_MN2 (I1160_G31_16n I1160_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I182_XG_MN0 (XI1160_I182_XG_n1 I1160_P31_24 I1160_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I182_XG_MN1 (VSS I1160_G23_16 XI1160_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I178_XG_MN2 (I1160_G27_12n I1160_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I178_XG_MN0 (XI1160_I178_XG_n1 I1160_P27_20 I1160_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I178_XG_MN1 (VSS I1160_G19_12 XI1160_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I176_XG_MN2 (I1160_G25_10n I1160_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I176_XG_MN0 (XI1160_I176_XG_n1 I1160_P25_18 I1160_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I176_XG_MN1 (VSS I1160_G17_10 XI1160_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I170_XG_MN2 (I1160_G19_4n I1160_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I170_XG_MN0 (XI1160_I170_XG_n1 I1160_P19_12 I1160_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I170_XG_MN1 (VSS I1160_G11_4 XI1160_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I168_XG_MN2 (I1160_G17_2n I1160_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I168_XG_MN0 (XI1160_I168_XG_n1 I1160_P17_10 I1160_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I168_XG_MN1 (VSS I1160_G9_2 XI1160_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I162_XG_MN2 (I1160_G11_0n I1160_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I162_XG_MN0 (XI1160_I162_XG_n1 I1160_P11_4 I1160_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I162_XG_MN1 (VSS I1160_G3_0np XI1160_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I158_XG_MN2 (I1160_G9_0n I1160_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I158_XG_MN0 (XI1160_I158_XG_n1 I1160_P9_2 I1160_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I158_XG_MN1 (VSS I1160_G1_0 XI1160_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I102_XG_MN2 (I1160_G6_3n I1160_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I102_XG_MN0 (XI1160_I102_XG_n1 I1160_P6_5 I1160_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I102_XG_MN1 (VSS I1160_G4_3 XI1160_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I100_XG_MN2 (I1160_G4_1n I1160_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I100_XG_MN0 (XI1160_I100_XG_n1 I1160_P4_3 I1160_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I100_XG_MN1 (VSS I1160_G2_1 XI1160_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I98_XG_MN2 (I1160_G2_0n I1160_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I98_XG_MN0 (XI1160_I98_XG_n1 I1160_P2_1 I1160_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I98_XG_MN1 (VSS I1160_G0_0 XI1160_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I106_XG_MN2 (I1252_G10_7n I1252_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I106_XG_MN0 (XI1252_I106_XG_n1 I1252_P10_9 I1252_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I106_XG_MN1 (VSS I1252_G8_7 XI1252_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I169_XG_MN2 (I1252_G18_3n I1252_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I169_XG_MN0 (XI1252_I169_XG_n1 I1252_P18_11 I1252_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I169_XG_MN1 (VSS I1252_G10_3 XI1252_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I160_XG_MN2 (I1252_G10_0n I1252_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I160_XG_MN0 (XI1252_I160_XG_n1 I1252_P10_3 I1252_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I160_XG_MN1 (VSS I1252_G2_0np XI1252_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I167_XG_MN2 (I1252_G16_1n I1252_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I167_XG_MN0 (XI1252_I167_XG_n1 I1252_P16_9 I1252_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I167_XG_MN1 (VSS I1252_G8_1 XI1252_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I168_XG_MN2 (I1252_G17_2n I1252_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I168_XG_MN0 (XI1252_I168_XG_n1 I1252_P17_10 I1252_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I168_XG_MN1 (VSS I1252_G9_2 XI1252_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I106_XG_MN2 (I1298_G10_7n I1298_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I106_XG_MN0 (XI1298_I106_XG_n1 I1298_P10_9 I1298_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I106_XG_MN1 (VSS I1298_G8_7 XI1298_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I160_XG_MN2 (I1298_G10_0n I1298_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I160_XG_MN0 (XI1298_I160_XG_n1 I1298_P10_3 I1298_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I160_XG_MN1 (VSS I1298_G2_0np XI1298_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I107_XG_MN2 (I1298_G11_8n I1298_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I107_XG_MN0 (XI1298_I107_XG_n1 I1298_P11_10 I1298_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I107_XG_MN1 (VSS I1298_G9_8 XI1298_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I168_XG_MN2 (I1298_G17_2n I1298_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I168_XG_MN0 (XI1298_I168_XG_n1 I1298_P17_10 I1298_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I168_XG_MN1 (VSS I1298_G9_2 XI1298_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I175_XG_MN2 (I1344_G24_9n I1344_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I175_XG_MN0 (XI1344_I175_XG_n1 I1344_P24_17 I1344_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I175_XG_MN1 (VSS I1344_G16_9 XI1344_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I163_XG_MN2 (I1344_G12_0n I1344_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I163_XG_MN0 (XI1344_I163_XG_n1 I1344_P12_5 I1344_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I163_XG_MN1 (VSS I1344_G4_0 XI1344_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I170_XG_MN2 (I1344_G19_4n I1344_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I170_XG_MN0 (XI1344_I170_XG_n1 I1344_P19_12 I1344_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I170_XG_MN1 (VSS I1344_G11_4 XI1344_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I162_XG_MN2 (I1344_G11_0n I1344_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I162_XG_MN0 (XI1344_I162_XG_n1 I1344_P11_4 I1344_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I162_XG_MN1 (VSS I1344_G3_0np XI1344_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I108_XG_MN2 (I1390_G12_9n I1390_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I108_XG_MN0 (XI1390_I108_XG_n1 I1390_P12_11 I1390_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I108_XG_MN1 (VSS I1390_G10_9 XI1390_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I169_XG_MN2 (I1390_G18_3n I1390_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I169_XG_MN0 (XI1390_I169_XG_n1 I1390_P18_11 I1390_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I169_XG_MN1 (VSS I1390_G10_3 XI1390_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I109_XG_MN2 (I1390_G13_10n I1390_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I109_XG_MN0 (XI1390_I109_XG_n1 I1390_P13_12 I1390_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I109_XG_MN1 (VSS I1390_G11_10 XI1390_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I107_XG_MN2 (I1390_G11_8n I1390_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I107_XG_MN0 (XI1390_I107_XG_n1 I1390_P11_10 I1390_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I107_XG_MN1 (VSS I1390_G9_8 XI1390_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I108_XG_MN2 (I1436_G12_9n I1436_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I108_XG_MN0 (XI1436_I108_XG_n1 I1436_P12_11 I1436_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I108_XG_MN1 (VSS I1436_G10_9 XI1436_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I169_XG_MN2 (I1436_G18_3n I1436_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I169_XG_MN0 (XI1436_I169_XG_n1 I1436_P18_11 I1436_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I169_XG_MN1 (VSS I1436_G10_3 XI1436_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I107_XG_MN2 (I1436_G11_8n I1436_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I107_XG_MN0 (XI1436_I107_XG_n1 I1436_P11_10 I1436_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I107_XG_MN1 (VSS I1436_G9_8 XI1436_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I168_XG_MN2 (I1436_G17_2n I1436_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I168_XG_MN0 (XI1436_I168_XG_n1 I1436_P17_10 I1436_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I168_XG_MN1 (VSS I1436_G9_2 XI1436_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I107_XG_MN2 (I1482_G11_8n I1482_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I107_XG_MN0 (XI1482_I107_XG_n1 I1482_P11_10 I1482_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I107_XG_MN1 (VSS I1482_G9_8 XI1482_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I108_XG_MN2 (I1482_G12_9n I1482_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I108_XG_MN0 (XI1482_I108_XG_n1 I1482_P12_11 I1482_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I108_XG_MN1 (VSS I1482_G10_9 XI1482_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I112_XG_MN2 (I1528_G16_13n I1528_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I112_XG_MN0 (XI1528_I112_XG_n1 I1528_P16_15 I1528_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I112_XG_MN1 (VSS I1528_G14_13 XI1528_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I165_XG_MN2 (I1528_G14_0n I1528_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I165_XG_MN0 (XI1528_I165_XG_n1 I1528_P14_7 I1528_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I165_XG_MN1 (VSS I1528_G6_0 XI1528_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I179_XG_MN2 (I1528_G28_13n I1528_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I179_XG_MN0 (XI1528_I179_XG_n1 I1528_P28_21 I1528_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I179_XG_MN1 (VSS I1528_G20_13 XI1528_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I111_XG_MN2 (I1528_G15_12n I1528_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I111_XG_MN0 (XI1528_I111_XG_n1 I1528_P15_14 I1528_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I111_XG_MN1 (VSS I1528_G13_12 XI1528_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I178_XG_MN2 (I1528_G27_12n I1528_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I178_XG_MN0 (XI1528_I178_XG_n1 I1528_P27_20 I1528_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I178_XG_MN1 (VSS I1528_G19_12 XI1528_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I127_XG_MN2 (I1160_G31_28n I1160_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I127_XG_MN0 (XI1160_I127_XG_n1 I1160_P31_30 I1160_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I127_XG_MN1 (VSS I1160_G29_28 XI1160_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I121_XG_MN2 (I1160_G25_22n I1160_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I121_XG_MN0 (XI1160_I121_XG_n1 I1160_P25_24 I1160_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I121_XG_MN1 (VSS I1160_G23_22 XI1160_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I180_XG_MN2 (I1160_G29_14n I1160_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I180_XG_MN0 (XI1160_I180_XG_n1 I1160_P29_22 I1160_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I180_XG_MN1 (VSS I1160_G21_14 XI1160_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I172_XG_MN2 (I1160_G21_6n I1160_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I172_XG_MN0 (XI1160_I172_XG_n1 I1160_P21_14 I1160_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I172_XG_MN1 (VSS I1160_G13_6 XI1160_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I164_XG_MN2 (I1160_G13_0n I1160_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I164_XG_MN0 (XI1160_I164_XG_n1 I1160_P13_6 I1160_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I164_XG_MN1 (VSS I1160_G5_0 XI1160_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I110_XG_MN2 (I1160_G14_11n I1160_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I110_XG_MN0 (XI1160_I110_XG_n1 I1160_P14_13 I1160_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I110_XG_MN1 (VSS I1160_G12_11 XI1160_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I108_XG_MN2 (I1160_G12_9n I1160_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I108_XG_MN0 (XI1160_I108_XG_n1 I1160_P12_11 I1160_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I108_XG_MN1 (VSS I1160_G10_9 XI1160_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I106_XG_MN2 (I1160_G10_7n I1160_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I106_XG_MN0 (XI1160_I106_XG_n1 I1160_P10_9 I1160_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I106_XG_MN1 (VSS I1160_G8_7 XI1160_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I104_XG_MN2 (I1160_G8_5n I1160_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I104_XG_MN0 (XI1160_I104_XG_n1 I1160_P8_7 I1160_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I104_XG_MN1 (VSS I1160_G6_5 XI1160_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I101_XG_MN2 (I1206_G5_2n I1206_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I101_XG_MN0 (XI1206_I101_XG_n1 I1206_P5_4 I1206_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I101_XG_MN1 (VSS I1206_G3_2 XI1206_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I102_XG_MN2 (I1206_G6_3n I1206_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I102_XG_MN0 (XI1206_I102_XG_n1 I1206_P6_5 I1206_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I102_XG_MN1 (VSS I1206_G4_3 XI1206_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I108_XG_MN2 (I1252_G12_9n I1252_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I108_XG_MN0 (XI1252_I108_XG_n1 I1252_P12_11 I1252_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I108_XG_MN1 (VSS I1252_G10_9 XI1252_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I107_XG_MN2 (I1252_G11_8n I1252_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I107_XG_MN0 (XI1252_I107_XG_n1 I1252_P11_10 I1252_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I107_XG_MN1 (VSS I1252_G9_8 XI1252_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I162_XG_MN2 (I1252_G11_0n I1252_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I162_XG_MN0 (XI1252_I162_XG_n1 I1252_P11_4 I1252_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I162_XG_MN1 (VSS I1252_G3_0np XI1252_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I108_XG_MN2 (I1298_G12_9n I1298_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I108_XG_MN0 (XI1298_I108_XG_n1 I1298_P12_11 I1298_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I108_XG_MN1 (VSS I1298_G10_9 XI1298_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I175_XG_MN2 (I1298_G24_9n I1298_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I175_XG_MN0 (XI1298_I175_XG_n1 I1298_P24_17 I1298_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I175_XG_MN1 (VSS I1298_G16_9 XI1298_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I169_XG_MN2 (I1298_G18_3n I1298_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I169_XG_MN0 (XI1298_I169_XG_n1 I1298_P18_11 I1298_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I169_XG_MN1 (VSS I1298_G10_3 XI1298_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I109_XG_MN2 (I1298_G13_10n I1298_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I109_XG_MN0 (XI1298_I109_XG_n1 I1298_P13_12 I1298_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I109_XG_MN1 (VSS I1298_G11_10 XI1298_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I162_XG_MN2 (I1298_G11_0n I1298_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I162_XG_MN0 (XI1298_I162_XG_n1 I1298_P11_4 I1298_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I162_XG_MN1 (VSS I1298_G3_0np XI1298_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I169_XG_MN2 (I1344_G18_3n I1344_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I169_XG_MN0 (XI1344_I169_XG_n1 I1344_P18_11 I1344_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I169_XG_MN1 (VSS I1344_G10_3 XI1344_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I171_XG_MN2 (I1344_G20_5n I1344_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I171_XG_MN0 (XI1344_I171_XG_n1 I1344_P20_13 I1344_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I171_XG_MN1 (VSS I1344_G12_5 XI1344_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I110_XG_MN2 (I1344_G14_11n I1344_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I110_XG_MN0 (XI1344_I110_XG_n1 I1344_P14_13 I1344_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I110_XG_MN1 (VSS I1344_G12_11 XI1344_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I109_XG_MN2 (I1344_G13_10n I1344_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I109_XG_MN0 (XI1344_I109_XG_n1 I1344_P13_12 I1344_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I109_XG_MN1 (VSS I1344_G11_10 XI1344_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I110_XG_MN2 (I1390_G14_11n I1390_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I110_XG_MN0 (XI1390_I110_XG_n1 I1390_P14_13 I1390_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I110_XG_MN1 (VSS I1390_G12_11 XI1390_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I175_XG_MN2 (I1390_G24_9n I1390_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I175_XG_MN0 (XI1390_I175_XG_n1 I1390_P24_17 I1390_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I175_XG_MN1 (VSS I1390_G16_9 XI1390_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I163_XG_MN2 (I1390_G12_0n I1390_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I163_XG_MN0 (XI1390_I163_XG_n1 I1390_P12_5 I1390_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I163_XG_MN1 (VSS I1390_G4_0 XI1390_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I170_XG_MN2 (I1390_G19_4n I1390_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I170_XG_MN0 (XI1390_I170_XG_n1 I1390_P19_12 I1390_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I170_XG_MN1 (VSS I1390_G11_4 XI1390_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I162_XG_MN2 (I1390_G11_0n I1390_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I162_XG_MN0 (XI1390_I162_XG_n1 I1390_P11_4 I1390_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I162_XG_MN1 (VSS I1390_G3_0np XI1390_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I175_XG_MN2 (I1436_G24_9n I1436_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I175_XG_MN0 (XI1436_I175_XG_n1 I1436_P24_17 I1436_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I175_XG_MN1 (VSS I1436_G16_9 XI1436_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I163_XG_MN2 (I1436_G12_0n I1436_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I163_XG_MN0 (XI1436_I163_XG_n1 I1436_P12_5 I1436_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I163_XG_MN1 (VSS I1436_G4_0 XI1436_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I109_XG_MN2 (I1436_G13_10n I1436_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I109_XG_MN0 (XI1436_I109_XG_n1 I1436_P13_12 I1436_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I109_XG_MN1 (VSS I1436_G11_10 XI1436_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I162_XG_MN2 (I1436_G11_0n I1436_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I162_XG_MN0 (XI1436_I162_XG_n1 I1436_P11_4 I1436_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I162_XG_MN1 (VSS I1436_G3_0np XI1436_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I109_XG_MN2 (I1482_G13_10n I1482_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I109_XG_MN0 (XI1482_I109_XG_n1 I1482_P13_12 I1482_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I109_XG_MN1 (VSS I1482_G11_10 XI1482_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I162_XG_MN2 (I1482_G11_0n I1482_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I162_XG_MN0 (XI1482_I162_XG_n1 I1482_P11_4 I1482_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I162_XG_MN1 (VSS I1482_G3_0np XI1482_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I168_XG_MN2 (I1482_G17_2n I1482_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I168_XG_MN0 (XI1482_I168_XG_n1 I1482_P17_10 I1482_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I168_XG_MN1 (VSS I1482_G9_2 XI1482_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I110_XG_MN2 (I1482_G14_11n I1482_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I110_XG_MN0 (XI1482_I110_XG_n1 I1482_P14_13 I1482_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I110_XG_MN1 (VSS I1482_G12_11 XI1482_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I163_XG_MN2 (I1482_G12_0n I1482_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I163_XG_MN0 (XI1482_I163_XG_n1 I1482_P12_5 I1482_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I163_XG_MN1 (VSS I1482_G4_0 XI1482_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I160_XG_MN2 (I1482_G10_0n I1482_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I160_XG_MN0 (XI1482_I160_XG_n1 I1482_P10_3 I1482_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I160_XG_MN1 (VSS I1482_G2_0np XI1482_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I114_XG_MN2 (I1528_G18_15n I1528_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I114_XG_MN0 (XI1528_I114_XG_n1 I1528_P18_17 I1528_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I114_XG_MN1 (VSS I1528_G16_15 XI1528_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I116_XG_MN2 (I1528_G20_17n I1528_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I116_XG_MN0 (XI1528_I116_XG_n1 I1528_P20_19 I1528_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I116_XG_MN1 (VSS I1528_G18_17 XI1528_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I173_XG_MN2 (I1528_G22_7n I1528_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I173_XG_MN0 (XI1528_I173_XG_n1 I1528_P22_15 I1528_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I173_XG_MN1 (VSS I1528_G14_7 XI1528_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I166_XG_MN2 (I1528_G15_0n I1528_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I166_XG_MN0 (XI1528_I166_XG_n1 I1528_P15_8 I1528_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I166_XG_MN1 (VSS I1528_G7_0 XI1528_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I113_XG_MN2 (I1528_G17_14n I1528_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I113_XG_MN0 (XI1528_I113_XG_n1 I1528_P17_16 I1528_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I113_XG_MN1 (VSS I1528_G15_14 XI1528_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I180_XG_MN2 (I1528_G29_14n I1528_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I180_XG_MN0 (XI1528_I180_XG_n1 I1528_P29_22 I1528_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I180_XG_MN1 (VSS I1528_G21_14 XI1528_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I125_XG_MN2 (I1160_G29_26n I1160_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I125_XG_MN0 (XI1160_I125_XG_n1 I1160_P29_28 I1160_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I125_XG_MN1 (VSS I1160_G27_26 XI1160_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I123_XG_MN2 (I1160_G27_24n I1160_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I123_XG_MN0 (XI1160_I123_XG_n1 I1160_P27_26 I1160_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I123_XG_MN1 (VSS I1160_G25_24 XI1160_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I118_XG_MN2 (I1160_G22_19n I1160_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I118_XG_MN0 (XI1160_I118_XG_n1 I1160_P22_21 I1160_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I118_XG_MN1 (VSS I1160_G20_19 XI1160_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I116_XG_MN2 (I1160_G20_17n I1160_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I116_XG_MN0 (XI1160_I116_XG_n1 I1160_P20_19 I1160_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I116_XG_MN1 (VSS I1160_G18_17 XI1160_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I114_XG_MN2 (I1160_G18_15n I1160_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I114_XG_MN0 (XI1160_I114_XG_n1 I1160_P18_17 I1160_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I114_XG_MN1 (VSS I1160_G16_15 XI1160_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I112_XG_MN2 (I1160_G16_13n I1160_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I112_XG_MN0 (XI1160_I112_XG_n1 I1160_P16_15 I1160_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I112_XG_MN1 (VSS I1160_G14_13 XI1160_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I167_XG_MN2 (I1160_G16_1n I1160_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I167_XG_MN0 (XI1160_I167_XG_n1 I1160_P16_9 I1160_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I167_XG_MN1 (VSS I1160_G8_1 XI1160_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I157_XG_MN2 (I1160_G8_0n I1160_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I157_XG_MN0 (XI1160_I157_XG_n1 I1160_P8_1 I1160_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I157_XG_MN1 (VSS I1160_G0_0 XI1160_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I103_XG_MN2 (I1206_G7_4n I1206_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I103_XG_MN0 (XI1206_I103_XG_n1 I1206_P7_6 I1206_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I103_XG_MN1 (VSS I1206_G5_4 XI1206_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I104_XG_MN2 (I1206_G8_5n I1206_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I104_XG_MN0 (XI1206_I104_XG_n1 I1206_P8_7 I1206_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I104_XG_MN1 (VSS I1206_G6_5 XI1206_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I157_XG_MN2 (I1206_G8_0n I1206_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I157_XG_MN0 (XI1206_I157_XG_n1 I1206_P8_1 I1206_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I157_XG_MN1 (VSS I1206_G0_0 XI1206_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I175_XG_MN2 (I1252_G24_9n I1252_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I175_XG_MN0 (XI1252_I175_XG_n1 I1252_P24_17 I1252_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I175_XG_MN1 (VSS I1252_G16_9 XI1252_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I163_XG_MN2 (I1252_G12_0n I1252_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I163_XG_MN0 (XI1252_I163_XG_n1 I1252_P12_5 I1252_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I163_XG_MN1 (VSS I1252_G4_0 XI1252_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I109_XG_MN2 (I1252_G13_10n I1252_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I109_XG_MN0 (XI1252_I109_XG_n1 I1252_P13_12 I1252_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I109_XG_MN1 (VSS I1252_G11_10 XI1252_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I170_XG_MN2 (I1252_G19_4n I1252_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I170_XG_MN0 (XI1252_I170_XG_n1 I1252_P19_12 I1252_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I170_XG_MN1 (VSS I1252_G11_4 XI1252_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I112_XG_MN2 (I1298_G16_13n I1298_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I112_XG_MN0 (XI1298_I112_XG_n1 I1298_P16_15 I1298_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I112_XG_MN1 (VSS I1298_G14_13 XI1298_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I110_XG_MN2 (I1298_G14_11n I1298_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I110_XG_MN0 (XI1298_I110_XG_n1 I1298_P14_13 I1298_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I110_XG_MN1 (VSS I1298_G12_11 XI1298_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I163_XG_MN2 (I1298_G12_0n I1298_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I163_XG_MN0 (XI1298_I163_XG_n1 I1298_P12_5 I1298_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I163_XG_MN1 (VSS I1298_G4_0 XI1298_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I111_XG_MN2 (I1298_G15_12n I1298_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I111_XG_MN0 (XI1298_I111_XG_n1 I1298_P15_14 I1298_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I111_XG_MN1 (VSS I1298_G13_12 XI1298_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I170_XG_MN2 (I1298_G19_4n I1298_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I170_XG_MN0 (XI1298_I170_XG_n1 I1298_P19_12 I1298_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I170_XG_MN1 (VSS I1298_G11_4 XI1298_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I177_XG_MN2 (I1344_G26_11n I1344_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I177_XG_MN0 (XI1344_I177_XG_n1 I1344_P26_19 I1344_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I177_XG_MN1 (VSS I1344_G18_11 XI1344_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I112_XG_MN2 (I1344_G16_13n I1344_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I112_XG_MN0 (XI1344_I112_XG_n1 I1344_P16_15 I1344_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I112_XG_MN1 (VSS I1344_G14_13 XI1344_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I111_XG_MN2 (I1344_G15_12n I1344_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I111_XG_MN0 (XI1344_I111_XG_n1 I1344_P15_14 I1344_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I111_XG_MN1 (VSS I1344_G13_12 XI1344_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I176_XG_MN2 (I1344_G25_10n I1344_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I176_XG_MN0 (XI1344_I176_XG_n1 I1344_P25_18 I1344_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I176_XG_MN1 (VSS I1344_G17_10 XI1344_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I112_XG_MN2 (I1390_G16_13n I1390_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I112_XG_MN0 (XI1390_I112_XG_n1 I1390_P16_15 I1390_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I112_XG_MN1 (VSS I1390_G14_13 XI1390_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I171_XG_MN2 (I1390_G20_5n I1390_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I171_XG_MN0 (XI1390_I171_XG_n1 I1390_P20_13 I1390_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I171_XG_MN1 (VSS I1390_G12_5 XI1390_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I111_XG_MN2 (I1390_G15_12n I1390_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I111_XG_MN0 (XI1390_I111_XG_n1 I1390_P15_14 I1390_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I111_XG_MN1 (VSS I1390_G13_12 XI1390_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I176_XG_MN2 (I1390_G25_10n I1390_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I176_XG_MN0 (XI1390_I176_XG_n1 I1390_P25_18 I1390_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I176_XG_MN1 (VSS I1390_G17_10 XI1390_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I110_XG_MN2 (I1436_G14_11n I1436_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I110_XG_MN0 (XI1436_I110_XG_n1 I1436_P14_13 I1436_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I110_XG_MN1 (VSS I1436_G12_11 XI1436_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I112_XG_MN2 (I1436_G16_13n I1436_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I112_XG_MN0 (XI1436_I112_XG_n1 I1436_P16_15 I1436_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I112_XG_MN1 (VSS I1436_G14_13 XI1436_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I171_XG_MN2 (I1436_G20_5n I1436_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I171_XG_MN0 (XI1436_I171_XG_n1 I1436_P20_13 I1436_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I171_XG_MN1 (VSS I1436_G12_5 XI1436_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I111_XG_MN2 (I1436_G15_12n I1436_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I111_XG_MN0 (XI1436_I111_XG_n1 I1436_P15_14 I1436_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I111_XG_MN1 (VSS I1436_G13_12 XI1436_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I170_XG_MN2 (I1436_G19_4n I1436_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I170_XG_MN0 (XI1436_I170_XG_n1 I1436_P19_12 I1436_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I170_XG_MN1 (VSS I1436_G11_4 XI1436_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I111_XG_MN2 (I1482_G15_12n I1482_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I111_XG_MN0 (XI1482_I111_XG_n1 I1482_P15_14 I1482_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I111_XG_MN1 (VSS I1482_G13_12 XI1482_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I169_XG_MN2 (I1482_G18_3n I1482_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I169_XG_MN0 (XI1482_I169_XG_n1 I1482_P18_11 I1482_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I169_XG_MN1 (VSS I1482_G10_3 XI1482_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I115_XG_MN2 (I1528_G19_16n I1528_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I115_XG_MN0 (XI1528_I115_XG_n1 I1528_P19_18 I1528_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I115_XG_MN1 (VSS I1528_G17_16 XI1528_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I117_XG_MN2 (I1528_G21_18n I1528_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I117_XG_MN0 (XI1528_I117_XG_n1 I1528_P21_20 I1528_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I117_XG_MN1 (VSS I1528_G19_18 XI1528_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I174_XG_MN2 (I1528_G23_8n I1528_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I174_XG_MN0 (XI1528_I174_XG_n1 I1528_P23_16 I1528_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I174_XG_MN1 (VSS I1528_G15_8 XI1528_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I120_XG_MN2 (I1160_G24_21n I1160_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I120_XG_MN0 (XI1160_I120_XG_n1 I1160_P24_23 I1160_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I120_XG_MN1 (VSS I1160_G22_21 XI1160_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I179_XG_MN2 (I1160_G28_13n I1160_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I179_XG_MN0 (XI1160_I179_XG_n1 I1160_P28_21 I1160_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I179_XG_MN1 (VSS I1160_G20_13 XI1160_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I175_XG_MN2 (I1160_G24_9n I1160_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I175_XG_MN0 (XI1160_I175_XG_n1 I1160_P24_17 I1160_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I175_XG_MN1 (VSS I1160_G16_9 XI1160_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I171_XG_MN2 (I1160_G20_5n I1160_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I171_XG_MN0 (XI1160_I171_XG_n1 I1160_P20_13 I1160_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I171_XG_MN1 (VSS I1160_G12_5 XI1160_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I163_XG_MN2 (I1160_G12_0n I1160_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I163_XG_MN0 (XI1160_I163_XG_n1 I1160_P12_5 I1160_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I163_XG_MN1 (VSS I1160_G4_0 XI1160_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I105_XG_MN2 (I1206_G9_6n I1206_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I105_XG_MN0 (XI1206_I105_XG_n1 I1206_P9_8 I1206_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I105_XG_MN1 (VSS I1206_G7_6 XI1206_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I106_XG_MN2 (I1206_G10_7n I1206_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I106_XG_MN0 (XI1206_I106_XG_n1 I1206_P10_9 I1206_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I106_XG_MN1 (VSS I1206_G8_7 XI1206_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I167_XG_MN2 (I1206_G16_1n I1206_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I167_XG_MN0 (XI1206_I167_XG_n1 I1206_P16_9 I1206_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I167_XG_MN1 (VSS I1206_G8_1 XI1206_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I112_XG_MN2 (I1252_G16_13n I1252_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I112_XG_MN0 (XI1252_I112_XG_n1 I1252_P16_15 I1252_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I112_XG_MN1 (VSS I1252_G14_13 XI1252_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I110_XG_MN2 (I1252_G14_11n I1252_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I110_XG_MN0 (XI1252_I110_XG_n1 I1252_P14_13 I1252_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I110_XG_MN1 (VSS I1252_G12_11 XI1252_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I171_XG_MN2 (I1252_G20_5n I1252_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I171_XG_MN0 (XI1252_I171_XG_n1 I1252_P20_13 I1252_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I171_XG_MN1 (VSS I1252_G12_5 XI1252_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I111_XG_MN2 (I1252_G15_12n I1252_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I111_XG_MN0 (XI1252_I111_XG_n1 I1252_P15_14 I1252_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I111_XG_MN1 (VSS I1252_G13_12 XI1252_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I176_XG_MN2 (I1252_G25_10n I1252_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I176_XG_MN0 (XI1252_I176_XG_n1 I1252_P25_18 I1252_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I176_XG_MN1 (VSS I1252_G17_10 XI1252_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I114_XG_MN2 (I1298_G18_15n I1298_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I114_XG_MN0 (XI1298_I114_XG_n1 I1298_P18_17 I1298_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I114_XG_MN1 (VSS I1298_G16_15 XI1298_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I171_XG_MN2 (I1298_G20_5n I1298_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I171_XG_MN0 (XI1298_I171_XG_n1 I1298_P20_13 I1298_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I171_XG_MN1 (VSS I1298_G12_5 XI1298_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I165_XG_MN2 (I1298_G14_0n I1298_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I165_XG_MN0 (XI1298_I165_XG_n1 I1298_P14_7 I1298_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I165_XG_MN1 (VSS I1298_G6_0 XI1298_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I113_XG_MN2 (I1298_G17_14n I1298_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I113_XG_MN0 (XI1298_I113_XG_n1 I1298_P17_16 I1298_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I113_XG_MN1 (VSS I1298_G15_14 XI1298_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I164_XG_MN2 (I1298_G13_0n I1298_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I164_XG_MN0 (XI1298_I164_XG_n1 I1298_P13_6 I1298_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I164_XG_MN1 (VSS I1298_G5_0 XI1298_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I165_XG_MN2 (I1344_G14_0n I1344_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I165_XG_MN0 (XI1344_I165_XG_n1 I1344_P14_7 I1344_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I165_XG_MN1 (VSS I1344_G6_0 XI1344_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I114_XG_MN2 (I1344_G18_15n I1344_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I114_XG_MN0 (XI1344_I114_XG_n1 I1344_P18_17 I1344_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I114_XG_MN1 (VSS I1344_G16_15 XI1344_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I113_XG_MN2 (I1344_G17_14n I1344_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I113_XG_MN0 (XI1344_I113_XG_n1 I1344_P17_16 I1344_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I113_XG_MN1 (VSS I1344_G15_14 XI1344_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I164_XG_MN2 (I1344_G13_0n I1344_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I164_XG_MN0 (XI1344_I164_XG_n1 I1344_P13_6 I1344_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I164_XG_MN1 (VSS I1344_G5_0 XI1344_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I114_XG_MN2 (I1390_G18_15n I1390_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I114_XG_MN0 (XI1390_I114_XG_n1 I1390_P18_17 I1390_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I114_XG_MN1 (VSS I1390_G16_15 XI1390_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I177_XG_MN2 (I1390_G26_11n I1390_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I177_XG_MN0 (XI1390_I177_XG_n1 I1390_P26_19 I1390_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I177_XG_MN1 (VSS I1390_G18_11 XI1390_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I165_XG_MN2 (I1390_G14_0n I1390_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I165_XG_MN0 (XI1390_I165_XG_n1 I1390_P14_7 I1390_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I165_XG_MN1 (VSS I1390_G6_0 XI1390_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I113_XG_MN2 (I1390_G17_14n I1390_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I113_XG_MN0 (XI1390_I113_XG_n1 I1390_P17_16 I1390_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I113_XG_MN1 (VSS I1390_G15_14 XI1390_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I164_XG_MN2 (I1390_G13_0n I1390_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I164_XG_MN0 (XI1390_I164_XG_n1 I1390_P13_6 I1390_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I164_XG_MN1 (VSS I1390_G5_0 XI1390_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I114_XG_MN2 (I1436_G18_15n I1436_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I114_XG_MN0 (XI1436_I114_XG_n1 I1436_P18_17 I1436_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I114_XG_MN1 (VSS I1436_G16_15 XI1436_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I165_XG_MN2 (I1436_G14_0n I1436_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I165_XG_MN0 (XI1436_I165_XG_n1 I1436_P14_7 I1436_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I165_XG_MN1 (VSS I1436_G6_0 XI1436_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I113_XG_MN2 (I1436_G17_14n I1436_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I113_XG_MN0 (XI1436_I113_XG_n1 I1436_P17_16 I1436_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I113_XG_MN1 (VSS I1436_G15_14 XI1436_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I164_XG_MN2 (I1436_G13_0n I1436_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I164_XG_MN0 (XI1436_I164_XG_n1 I1436_P13_6 I1436_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I164_XG_MN1 (VSS I1436_G5_0 XI1436_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I113_XG_MN2 (I1482_G17_14n I1482_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I113_XG_MN0 (XI1482_I113_XG_n1 I1482_P17_16 I1482_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I113_XG_MN1 (VSS I1482_G15_14 XI1482_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I112_XG_MN2 (I1482_G16_13n I1482_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I112_XG_MN0 (XI1482_I112_XG_n1 I1482_P16_15 I1482_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I112_XG_MN1 (VSS I1482_G14_13 XI1482_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I171_XG_MN2 (I1482_G20_5n I1482_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I171_XG_MN0 (XI1482_I171_XG_n1 I1482_P20_13 I1482_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I171_XG_MN1 (VSS I1482_G12_5 XI1482_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I118_XG_MN2 (I1528_G22_19n I1528_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I118_XG_MN0 (XI1528_I118_XG_n1 I1528_P22_21 I1528_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I118_XG_MN1 (VSS I1528_G20_19 XI1528_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I181_XG_MN2 (I1528_G30_15n I1528_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I181_XG_MN0 (XI1528_I181_XG_n1 I1528_P30_23 I1528_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I181_XG_MN1 (VSS I1528_G22_15 XI1528_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I126_XG_MN2 (I1160_G30_27n I1160_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I126_XG_MN0 (XI1160_I126_XG_n1 I1160_P30_29 I1160_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I126_XG_MN1 (VSS I1160_G28_27 XI1160_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I124_XG_MN2 (I1160_G28_25n I1160_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I124_XG_MN0 (XI1160_I124_XG_n1 I1160_P28_27 I1160_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I124_XG_MN1 (VSS I1160_G26_25 XI1160_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I122_XG_MN2 (I1160_G26_23n I1160_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I122_XG_MN0 (XI1160_I122_XG_n1 I1160_P26_25 I1160_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I122_XG_MN1 (VSS I1160_G24_23 XI1160_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I177_XG_MN2 (I1160_G26_11n I1160_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I177_XG_MN0 (XI1160_I177_XG_n1 I1160_P26_19 I1160_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I177_XG_MN1 (VSS I1160_G18_11 XI1160_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I169_XG_MN2 (I1160_G18_3n I1160_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I169_XG_MN0 (XI1160_I169_XG_n1 I1160_P18_11 I1160_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I169_XG_MN1 (VSS I1160_G10_3 XI1160_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I160_XG_MN2 (I1160_G10_0n I1160_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I160_XG_MN0 (XI1160_I160_XG_n1 I1160_P10_3 I1160_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I160_XG_MN1 (VSS I1160_G2_0np XI1160_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I109_XG_MN2 (I1206_G13_10n I1206_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I109_XG_MN0 (XI1206_I109_XG_n1 I1206_P13_12 I1206_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I109_XG_MN1 (VSS I1206_G11_10 XI1206_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I107_XG_MN2 (I1206_G11_8n I1206_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I107_XG_MN0 (XI1206_I107_XG_n1 I1206_P11_10 I1206_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I107_XG_MN1 (VSS I1206_G9_8 XI1206_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I158_XG_MN2 (I1206_G9_0n I1206_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I158_XG_MN0 (XI1206_I158_XG_n1 I1206_P9_2 I1206_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I158_XG_MN1 (VSS I1206_G1_0 XI1206_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I110_XG_MN2 (I1206_G14_11n I1206_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I110_XG_MN0 (XI1206_I110_XG_n1 I1206_P14_13 I1206_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I110_XG_MN1 (VSS I1206_G12_11 XI1206_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I108_XG_MN2 (I1206_G12_9n I1206_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I108_XG_MN0 (XI1206_I108_XG_n1 I1206_P12_11 I1206_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I108_XG_MN1 (VSS I1206_G10_9 XI1206_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I163_XG_MN2 (I1206_G12_0n I1206_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I163_XG_MN0 (XI1206_I163_XG_n1 I1206_P12_5 I1206_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I163_XG_MN1 (VSS I1206_G4_0 XI1206_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I114_XG_MN2 (I1252_G18_15n I1252_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I114_XG_MN0 (XI1252_I114_XG_n1 I1252_P18_17 I1252_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I114_XG_MN1 (VSS I1252_G16_15 XI1252_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I165_XG_MN2 (I1252_G14_0n I1252_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I165_XG_MN0 (XI1252_I165_XG_n1 I1252_P14_7 I1252_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I165_XG_MN1 (VSS I1252_G6_0 XI1252_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I113_XG_MN2 (I1252_G17_14n I1252_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I113_XG_MN0 (XI1252_I113_XG_n1 I1252_P17_16 I1252_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I113_XG_MN1 (VSS I1252_G15_14 XI1252_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I164_XG_MN2 (I1252_G13_0n I1252_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I164_XG_MN0 (XI1252_I164_XG_n1 I1252_P13_6 I1252_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I164_XG_MN1 (VSS I1252_G5_0 XI1252_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I116_XG_MN2 (I1298_G20_17n I1298_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I116_XG_MN0 (XI1298_I116_XG_n1 I1298_P20_19 I1298_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I116_XG_MN1 (VSS I1298_G18_17 XI1298_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I177_XG_MN2 (I1298_G26_11n I1298_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I177_XG_MN0 (XI1298_I177_XG_n1 I1298_P26_19 I1298_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I177_XG_MN1 (VSS I1298_G18_11 XI1298_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I115_XG_MN2 (I1298_G19_16n I1298_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I115_XG_MN0 (XI1298_I115_XG_n1 I1298_P19_18 I1298_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I115_XG_MN1 (VSS I1298_G17_16 XI1298_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I172_XG_MN2 (I1298_G21_6n I1298_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I172_XG_MN0 (XI1298_I172_XG_n1 I1298_P21_14 I1298_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I172_XG_MN1 (VSS I1298_G13_6 XI1298_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I173_XG_MN2 (I1344_G22_7n I1344_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I173_XG_MN0 (XI1344_I173_XG_n1 I1344_P22_15 I1344_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I173_XG_MN1 (VSS I1344_G14_7 XI1344_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I116_XG_MN2 (I1344_G20_17n I1344_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I116_XG_MN0 (XI1344_I116_XG_n1 I1344_P20_19 I1344_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I116_XG_MN1 (VSS I1344_G18_17 XI1344_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I115_XG_MN2 (I1344_G19_16n I1344_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I115_XG_MN0 (XI1344_I115_XG_n1 I1344_P19_18 I1344_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I115_XG_MN1 (VSS I1344_G17_16 XI1344_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I172_XG_MN2 (I1344_G21_6n I1344_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I172_XG_MN0 (XI1344_I172_XG_n1 I1344_P21_14 I1344_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I172_XG_MN1 (VSS I1344_G13_6 XI1344_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I116_XG_MN2 (I1390_G20_17n I1390_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I116_XG_MN0 (XI1390_I116_XG_n1 I1390_P20_19 I1390_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I116_XG_MN1 (VSS I1390_G18_17 XI1390_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I173_XG_MN2 (I1390_G22_7n I1390_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I173_XG_MN0 (XI1390_I173_XG_n1 I1390_P22_15 I1390_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I173_XG_MN1 (VSS I1390_G14_7 XI1390_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I115_XG_MN2 (I1390_G19_16n I1390_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I115_XG_MN0 (XI1390_I115_XG_n1 I1390_P19_18 I1390_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I115_XG_MN1 (VSS I1390_G17_16 XI1390_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I117_XG_MN2 (I1390_G21_18n I1390_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I117_XG_MN0 (XI1390_I117_XG_n1 I1390_P21_20 I1390_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I117_XG_MN1 (VSS I1390_G19_18 XI1390_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I172_XG_MN2 (I1390_G21_6n I1390_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I172_XG_MN0 (XI1390_I172_XG_n1 I1390_P21_14 I1390_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I172_XG_MN1 (VSS I1390_G13_6 XI1390_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I116_XG_MN2 (I1436_G20_17n I1436_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I116_XG_MN0 (XI1436_I116_XG_n1 I1436_P20_19 I1436_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I116_XG_MN1 (VSS I1436_G18_17 XI1436_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I177_XG_MN2 (I1436_G26_11n I1436_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I177_XG_MN0 (XI1436_I177_XG_n1 I1436_P26_19 I1436_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I177_XG_MN1 (VSS I1436_G18_11 XI1436_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I115_XG_MN2 (I1436_G19_16n I1436_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I115_XG_MN0 (XI1436_I115_XG_n1 I1436_P19_18 I1436_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I115_XG_MN1 (VSS I1436_G17_16 XI1436_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I164_XG_MN2 (I1482_G13_0n I1482_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I164_XG_MN0 (XI1482_I164_XG_n1 I1482_P13_6 I1482_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I164_XG_MN1 (VSS I1482_G5_0 XI1482_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I114_XG_MN2 (I1482_G18_15n I1482_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I114_XG_MN0 (XI1482_I114_XG_n1 I1482_P18_17 I1482_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I114_XG_MN1 (VSS I1482_G16_15 XI1482_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I175_XG_MN2 (I1482_G24_9n I1482_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I175_XG_MN0 (XI1482_I175_XG_n1 I1482_P24_17 I1482_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I175_XG_MN1 (VSS I1482_G16_9 XI1482_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I177_XG_MN2 (I1482_G26_11n I1482_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I177_XG_MN0 (XI1482_I177_XG_n1 I1482_P26_19 I1482_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I177_XG_MN1 (VSS I1482_G18_11 XI1482_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I165_XG_MN2 (I1482_G14_0n I1482_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I165_XG_MN0 (XI1482_I165_XG_n1 I1482_P14_7 I1482_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I165_XG_MN1 (VSS I1482_G6_0 XI1482_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I120_XG_MN2 (I1528_G24_21n I1528_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I120_XG_MN0 (XI1528_I120_XG_n1 I1528_P24_23 I1528_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I120_XG_MN1 (VSS I1528_G22_21 XI1528_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I119_XG_MN2 (I1528_G23_20n I1528_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I119_XG_MN0 (XI1528_I119_XG_n1 I1528_P23_22 I1528_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I119_XG_MN1 (VSS I1528_G21_20 XI1528_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I182_XG_MN2 (I1528_G31_16n I1528_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I182_XG_MN0 (XI1528_I182_XG_n1 I1528_P31_24 I1528_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I182_XG_MN1 (VSS I1528_G23_16 XI1528_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I181_XG_MN2 (I1160_G30_15n I1160_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I181_XG_MN0 (XI1160_I181_XG_n1 I1160_P30_23 I1160_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I181_XG_MN1 (VSS I1160_G22_15 XI1160_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I173_XG_MN2 (I1160_G22_7n I1160_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I173_XG_MN0 (XI1160_I173_XG_n1 I1160_P22_15 I1160_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I173_XG_MN1 (VSS I1160_G14_7 XI1160_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I165_XG_MN2 (I1160_G14_0n I1160_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I165_XG_MN0 (XI1160_I165_XG_n1 I1160_P14_7 I1160_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1160_I165_XG_MN1 (VSS I1160_G6_0 XI1160_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I111_XG_MN2 (I1206_G15_12n I1206_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I111_XG_MN0 (XI1206_I111_XG_n1 I1206_P15_14 I1206_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I111_XG_MN1 (VSS I1206_G13_12 XI1206_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I168_XG_MN2 (I1206_G17_2n I1206_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I168_XG_MN0 (XI1206_I168_XG_n1 I1206_P17_10 I1206_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I168_XG_MN1 (VSS I1206_G9_2 XI1206_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I112_XG_MN2 (I1206_G16_13n I1206_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I112_XG_MN0 (XI1206_I112_XG_n1 I1206_P16_15 I1206_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I112_XG_MN1 (VSS I1206_G14_13 XI1206_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I160_XG_MN2 (I1206_G10_0n I1206_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I160_XG_MN0 (XI1206_I160_XG_n1 I1206_P10_3 I1206_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I160_XG_MN1 (VSS I1206_G2_0np XI1206_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I116_XG_MN2 (I1252_G20_17n I1252_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I116_XG_MN0 (XI1252_I116_XG_n1 I1252_P20_19 I1252_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I116_XG_MN1 (VSS I1252_G18_17 XI1252_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I177_XG_MN2 (I1252_G26_11n I1252_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I177_XG_MN0 (XI1252_I177_XG_n1 I1252_P26_19 I1252_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I177_XG_MN1 (VSS I1252_G18_11 XI1252_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I115_XG_MN2 (I1252_G19_16n I1252_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I115_XG_MN0 (XI1252_I115_XG_n1 I1252_P19_18 I1252_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I115_XG_MN1 (VSS I1252_G17_16 XI1252_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I172_XG_MN2 (I1252_G21_6n I1252_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I172_XG_MN0 (XI1252_I172_XG_n1 I1252_P21_14 I1252_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I172_XG_MN1 (VSS I1252_G13_6 XI1252_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I173_XG_MN2 (I1298_G22_7n I1298_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I173_XG_MN0 (XI1298_I173_XG_n1 I1298_P22_15 I1298_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I173_XG_MN1 (VSS I1298_G14_7 XI1298_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I176_XG_MN2 (I1298_G25_10n I1298_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I176_XG_MN0 (XI1298_I176_XG_n1 I1298_P25_18 I1298_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I176_XG_MN1 (VSS I1298_G17_10 XI1298_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I118_XG_MN2 (I1344_G22_19n I1344_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I118_XG_MN0 (XI1344_I118_XG_n1 I1344_P22_21 I1344_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I118_XG_MN1 (VSS I1344_G20_19 XI1344_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I117_XG_MN2 (I1344_G21_18n I1344_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I117_XG_MN0 (XI1344_I117_XG_n1 I1344_P21_20 I1344_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I117_XG_MN1 (VSS I1344_G19_18 XI1344_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I178_XG_MN2 (I1344_G27_12n I1344_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I178_XG_MN0 (XI1344_I178_XG_n1 I1344_P27_20 I1344_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I178_XG_MN1 (VSS I1344_G19_12 XI1344_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I166_XG_MN2 (I1344_G15_0n I1344_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I166_XG_MN0 (XI1344_I166_XG_n1 I1344_P15_8 I1344_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I166_XG_MN1 (VSS I1344_G7_0 XI1344_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I118_XG_MN2 (I1390_G22_19n I1390_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I118_XG_MN0 (XI1390_I118_XG_n1 I1390_P22_21 I1390_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I118_XG_MN1 (VSS I1390_G20_19 XI1390_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I178_XG_MN2 (I1390_G27_12n I1390_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I178_XG_MN0 (XI1390_I178_XG_n1 I1390_P27_20 I1390_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I178_XG_MN1 (VSS I1390_G19_12 XI1390_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I166_XG_MN2 (I1390_G15_0n I1390_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I166_XG_MN0 (XI1390_I166_XG_n1 I1390_P15_8 I1390_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I166_XG_MN1 (VSS I1390_G7_0 XI1390_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I173_XG_MN2 (I1436_G22_7n I1436_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I173_XG_MN0 (XI1436_I173_XG_n1 I1436_P22_15 I1436_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I173_XG_MN1 (VSS I1436_G14_7 XI1436_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I172_XG_MN2 (I1436_G21_6n I1436_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I172_XG_MN0 (XI1436_I172_XG_n1 I1436_P21_14 I1436_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I172_XG_MN1 (VSS I1436_G13_6 XI1436_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I115_XG_MN2 (I1482_G19_16n I1482_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I115_XG_MN0 (XI1482_I115_XG_n1 I1482_P19_18 I1482_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I115_XG_MN1 (VSS I1482_G17_16 XI1482_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I170_XG_MN2 (I1482_G19_4n I1482_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I170_XG_MN0 (XI1482_I170_XG_n1 I1482_P19_12 I1482_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I170_XG_MN1 (VSS I1482_G11_4 XI1482_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I172_XG_MN2 (I1482_G21_6n I1482_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I172_XG_MN0 (XI1482_I172_XG_n1 I1482_P21_14 I1482_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I172_XG_MN1 (VSS I1482_G13_6 XI1482_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I116_XG_MN2 (I1482_G20_17n I1482_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I116_XG_MN0 (XI1482_I116_XG_n1 I1482_P20_19 I1482_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I116_XG_MN1 (VSS I1482_G18_17 XI1482_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I173_XG_MN2 (I1482_G22_7n I1482_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I173_XG_MN0 (XI1482_I173_XG_n1 I1482_P22_15 I1482_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I173_XG_MN1 (VSS I1482_G14_7 XI1482_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I122_XG_MN2 (I1528_G26_23n I1528_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I122_XG_MN0 (XI1528_I122_XG_n1 I1528_P26_25 I1528_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I122_XG_MN1 (VSS I1528_G24_23 XI1528_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I121_XG_MN2 (I1528_G25_22n I1528_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I121_XG_MN0 (XI1528_I121_XG_n1 I1528_P25_24 I1528_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I121_XG_MN1 (VSS I1528_G23_22 XI1528_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I113_XG_MN2 (I1206_G17_14n I1206_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I113_XG_MN0 (XI1206_I113_XG_n1 I1206_P17_16 I1206_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I113_XG_MN1 (VSS I1206_G15_14 XI1206_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I170_XG_MN2 (I1206_G19_4n I1206_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I170_XG_MN0 (XI1206_I170_XG_n1 I1206_P19_12 I1206_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I170_XG_MN1 (VSS I1206_G11_4 XI1206_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I162_XG_MN2 (I1206_G11_0n I1206_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I162_XG_MN0 (XI1206_I162_XG_n1 I1206_P11_4 I1206_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I162_XG_MN1 (VSS I1206_G3_0np XI1206_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I114_XG_MN2 (I1206_G18_15n I1206_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I114_XG_MN0 (XI1206_I114_XG_n1 I1206_P18_17 I1206_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I114_XG_MN1 (VSS I1206_G16_15 XI1206_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I171_XG_MN2 (I1206_G20_5n I1206_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I171_XG_MN0 (XI1206_I171_XG_n1 I1206_P20_13 I1206_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I171_XG_MN1 (VSS I1206_G12_5 XI1206_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I169_XG_MN2 (I1206_G18_3n I1206_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I169_XG_MN0 (XI1206_I169_XG_n1 I1206_P18_11 I1206_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I169_XG_MN1 (VSS I1206_G10_3 XI1206_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I118_XG_MN2 (I1252_G22_19n I1252_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I118_XG_MN0 (XI1252_I118_XG_n1 I1252_P22_21 I1252_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I118_XG_MN1 (VSS I1252_G20_19 XI1252_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I173_XG_MN2 (I1252_G22_7n I1252_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I173_XG_MN0 (XI1252_I173_XG_n1 I1252_P22_15 I1252_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I173_XG_MN1 (VSS I1252_G14_7 XI1252_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I117_XG_MN2 (I1252_G21_18n I1252_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I117_XG_MN0 (XI1252_I117_XG_n1 I1252_P21_20 I1252_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I117_XG_MN1 (VSS I1252_G19_18 XI1252_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I178_XG_MN2 (I1252_G27_12n I1252_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I178_XG_MN0 (XI1252_I178_XG_n1 I1252_P27_20 I1252_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I178_XG_MN1 (VSS I1252_G19_12 XI1252_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I166_XG_MN2 (I1252_G15_0n I1252_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I166_XG_MN0 (XI1252_I166_XG_n1 I1252_P15_8 I1252_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I166_XG_MN1 (VSS I1252_G7_0 XI1252_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I118_XG_MN2 (I1298_G22_19n I1298_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I118_XG_MN0 (XI1298_I118_XG_n1 I1298_P22_21 I1298_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I118_XG_MN1 (VSS I1298_G20_19 XI1298_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I179_XG_MN2 (I1298_G28_13n I1298_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I179_XG_MN0 (XI1298_I179_XG_n1 I1298_P28_21 I1298_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I179_XG_MN1 (VSS I1298_G20_13 XI1298_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I117_XG_MN2 (I1298_G21_18n I1298_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I117_XG_MN0 (XI1298_I117_XG_n1 I1298_P21_20 I1298_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I117_XG_MN1 (VSS I1298_G19_18 XI1298_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I166_XG_MN2 (I1298_G15_0n I1298_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I166_XG_MN0 (XI1298_I166_XG_n1 I1298_P15_8 I1298_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I166_XG_MN1 (VSS I1298_G7_0 XI1298_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I181_XG_MN2 (I1344_G30_15n I1344_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I181_XG_MN0 (XI1344_I181_XG_n1 I1344_P30_23 I1344_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I181_XG_MN1 (VSS I1344_G22_15 XI1344_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I179_XG_MN2 (I1344_G28_13n I1344_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I179_XG_MN0 (XI1344_I179_XG_n1 I1344_P28_21 I1344_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I179_XG_MN1 (VSS I1344_G20_13 XI1344_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I120_XG_MN2 (I1344_G24_21n I1344_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I120_XG_MN0 (XI1344_I120_XG_n1 I1344_P24_23 I1344_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I120_XG_MN1 (VSS I1344_G22_21 XI1344_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I174_XG_MN2 (I1344_G23_8n I1344_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I174_XG_MN0 (XI1344_I174_XG_n1 I1344_P23_16 I1344_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I174_XG_MN1 (VSS I1344_G15_8 XI1344_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I120_XG_MN2 (I1390_G24_21n I1390_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I120_XG_MN0 (XI1390_I120_XG_n1 I1390_P24_23 I1390_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I120_XG_MN1 (VSS I1390_G22_21 XI1390_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I179_XG_MN2 (I1390_G28_13n I1390_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I179_XG_MN0 (XI1390_I179_XG_n1 I1390_P28_21 I1390_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I179_XG_MN1 (VSS I1390_G20_13 XI1390_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I119_XG_MN2 (I1390_G23_20n I1390_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I119_XG_MN0 (XI1390_I119_XG_n1 I1390_P23_22 I1390_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I119_XG_MN1 (VSS I1390_G21_20 XI1390_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I174_XG_MN2 (I1390_G23_8n I1390_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I174_XG_MN0 (XI1390_I174_XG_n1 I1390_P23_16 I1390_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I174_XG_MN1 (VSS I1390_G15_8 XI1390_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I118_XG_MN2 (I1436_G22_19n I1436_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I118_XG_MN0 (XI1436_I118_XG_n1 I1436_P22_21 I1436_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I118_XG_MN1 (VSS I1436_G20_19 XI1436_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I179_XG_MN2 (I1436_G28_13n I1436_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I179_XG_MN0 (XI1436_I179_XG_n1 I1436_P28_21 I1436_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I179_XG_MN1 (VSS I1436_G20_13 XI1436_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I117_XG_MN2 (I1436_G21_18n I1436_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I117_XG_MN0 (XI1436_I117_XG_n1 I1436_P21_20 I1436_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I117_XG_MN1 (VSS I1436_G19_18 XI1436_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I176_XG_MN2 (I1436_G25_10n I1436_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I176_XG_MN0 (XI1436_I176_XG_n1 I1436_P25_18 I1436_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I176_XG_MN1 (VSS I1436_G17_10 XI1436_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I166_XG_MN2 (I1436_G15_0n I1436_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I166_XG_MN0 (XI1436_I166_XG_n1 I1436_P15_8 I1436_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I166_XG_MN1 (VSS I1436_G7_0 XI1436_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I117_XG_MN2 (I1482_G21_18n I1482_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I117_XG_MN0 (XI1482_I117_XG_n1 I1482_P21_20 I1482_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I117_XG_MN1 (VSS I1482_G19_18 XI1482_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I166_XG_MN2 (I1482_G15_0n I1482_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I166_XG_MN0 (XI1482_I166_XG_n1 I1482_P15_8 I1482_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I166_XG_MN1 (VSS I1482_G7_0 XI1482_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I176_XG_MN2 (I1482_G25_10n I1482_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I176_XG_MN0 (XI1482_I176_XG_n1 I1482_P25_18 I1482_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I176_XG_MN1 (VSS I1482_G17_10 XI1482_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I118_XG_MN2 (I1482_G22_19n I1482_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I118_XG_MN0 (XI1482_I118_XG_n1 I1482_P22_21 I1482_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I118_XG_MN1 (VSS I1482_G20_19 XI1482_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I179_XG_MN2 (I1482_G28_13n I1482_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I179_XG_MN0 (XI1482_I179_XG_n1 I1482_P28_21 I1482_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I179_XG_MN1 (VSS I1482_G20_13 XI1482_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I181_XG_MN2 (I1482_G30_15n I1482_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I181_XG_MN0 (XI1482_I181_XG_n1 I1482_P30_23 I1482_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I181_XG_MN1 (VSS I1482_G22_15 XI1482_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I124_XG_MN2 (I1528_G28_25n I1528_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I124_XG_MN0 (XI1528_I124_XG_n1 I1528_P28_27 I1528_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I124_XG_MN1 (VSS I1528_G26_25 XI1528_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I126_XG_MN2 (I1528_G30_27n I1528_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I126_XG_MN0 (XI1528_I126_XG_n1 I1528_P30_29 I1528_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I126_XG_MN1 (VSS I1528_G28_27 XI1528_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I123_XG_MN2 (I1528_G27_24n I1528_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I123_XG_MN0 (XI1528_I123_XG_n1 I1528_P27_26 I1528_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I123_XG_MN1 (VSS I1528_G25_24 XI1528_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I125_XG_MN2 (I1528_G29_26n I1528_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I125_XG_MN0 (XI1528_I125_XG_n1 I1528_P29_28 I1528_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I125_XG_MN1 (VSS I1528_G27_26 XI1528_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I115_XG_MN2 (I1206_G19_16n I1206_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I115_XG_MN0 (XI1206_I115_XG_n1 I1206_P19_18 I1206_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I115_XG_MN1 (VSS I1206_G17_16 XI1206_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I166_XG_MN2 (I1206_G15_0n I1206_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I166_XG_MN0 (XI1206_I166_XG_n1 I1206_P15_8 I1206_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I166_XG_MN1 (VSS I1206_G7_0 XI1206_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I164_XG_MN2 (I1206_G13_0n I1206_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I164_XG_MN0 (XI1206_I164_XG_n1 I1206_P13_6 I1206_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I164_XG_MN1 (VSS I1206_G5_0 XI1206_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I172_XG_MN2 (I1206_G21_6n I1206_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I172_XG_MN0 (XI1206_I172_XG_n1 I1206_P21_14 I1206_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I172_XG_MN1 (VSS I1206_G13_6 XI1206_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I116_XG_MN2 (I1206_G20_17n I1206_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I116_XG_MN0 (XI1206_I116_XG_n1 I1206_P20_19 I1206_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I116_XG_MN1 (VSS I1206_G18_17 XI1206_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I175_XG_MN2 (I1206_G24_9n I1206_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I175_XG_MN0 (XI1206_I175_XG_n1 I1206_P24_17 I1206_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I175_XG_MN1 (VSS I1206_G16_9 XI1206_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I120_XG_MN2 (I1252_G24_21n I1252_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I120_XG_MN0 (XI1252_I120_XG_n1 I1252_P24_23 I1252_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I120_XG_MN1 (VSS I1252_G22_21 XI1252_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I179_XG_MN2 (I1252_G28_13n I1252_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I179_XG_MN0 (XI1252_I179_XG_n1 I1252_P28_21 I1252_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I179_XG_MN1 (VSS I1252_G20_13 XI1252_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I119_XG_MN2 (I1252_G23_20n I1252_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I119_XG_MN0 (XI1252_I119_XG_n1 I1252_P23_22 I1252_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I119_XG_MN1 (VSS I1252_G21_20 XI1252_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I174_XG_MN2 (I1252_G23_8n I1252_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I174_XG_MN0 (XI1252_I174_XG_n1 I1252_P23_16 I1252_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I174_XG_MN1 (VSS I1252_G15_8 XI1252_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I120_XG_MN2 (I1298_G24_21n I1298_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I120_XG_MN0 (XI1298_I120_XG_n1 I1298_P24_23 I1298_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I120_XG_MN1 (VSS I1298_G22_21 XI1298_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I181_XG_MN2 (I1298_G30_15n I1298_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I181_XG_MN0 (XI1298_I181_XG_n1 I1298_P30_23 I1298_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I181_XG_MN1 (VSS I1298_G22_15 XI1298_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I119_XG_MN2 (I1298_G23_20n I1298_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I119_XG_MN0 (XI1298_I119_XG_n1 I1298_P23_22 I1298_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I119_XG_MN1 (VSS I1298_G21_20 XI1298_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I178_XG_MN2 (I1298_G27_12n I1298_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I178_XG_MN0 (XI1298_I178_XG_n1 I1298_P27_20 I1298_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I178_XG_MN1 (VSS I1298_G19_12 XI1298_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I174_XG_MN2 (I1298_G23_8n I1298_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I174_XG_MN0 (XI1298_I174_XG_n1 I1298_P23_16 I1298_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I174_XG_MN1 (VSS I1298_G15_8 XI1298_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I119_XG_MN2 (I1344_G23_20n I1344_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I119_XG_MN0 (XI1344_I119_XG_n1 I1344_P23_22 I1344_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I119_XG_MN1 (VSS I1344_G21_20 XI1344_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I181_XG_MN2 (I1390_G30_15n I1390_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I181_XG_MN0 (XI1390_I181_XG_n1 I1390_P30_23 I1390_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I181_XG_MN1 (VSS I1390_G22_15 XI1390_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I121_XG_MN2 (I1390_G25_22n I1390_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I121_XG_MN0 (XI1390_I121_XG_n1 I1390_P25_24 I1390_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I121_XG_MN1 (VSS I1390_G23_22 XI1390_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I180_XG_MN2 (I1390_G29_14n I1390_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I180_XG_MN0 (XI1390_I180_XG_n1 I1390_P29_22 I1390_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I180_XG_MN1 (VSS I1390_G21_14 XI1390_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I120_XG_MN2 (I1436_G24_21n I1436_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I120_XG_MN0 (XI1436_I120_XG_n1 I1436_P24_23 I1436_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I120_XG_MN1 (VSS I1436_G22_21 XI1436_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I181_XG_MN2 (I1436_G30_15n I1436_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I181_XG_MN0 (XI1436_I181_XG_n1 I1436_P30_23 I1436_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I181_XG_MN1 (VSS I1436_G22_15 XI1436_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I119_XG_MN2 (I1436_G23_20n I1436_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I119_XG_MN0 (XI1436_I119_XG_n1 I1436_P23_22 I1436_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I119_XG_MN1 (VSS I1436_G21_20 XI1436_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I180_XG_MN2 (I1436_G29_14n I1436_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I180_XG_MN0 (XI1436_I180_XG_n1 I1436_P29_22 I1436_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I180_XG_MN1 (VSS I1436_G21_14 XI1436_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I174_XG_MN2 (I1436_G23_8n I1436_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I174_XG_MN0 (XI1436_I174_XG_n1 I1436_P23_16 I1436_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I174_XG_MN1 (VSS I1436_G15_8 XI1436_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I174_XG_MN2 (I1482_G23_8n I1482_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I174_XG_MN0 (XI1482_I174_XG_n1 I1482_P23_16 I1482_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I174_XG_MN1 (VSS I1482_G15_8 XI1482_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I120_XG_MN2 (I1482_G24_21n I1482_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I120_XG_MN0 (XI1482_I120_XG_n1 I1482_P24_23 I1482_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I120_XG_MN1 (VSS I1482_G22_21 XI1482_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I122_XG_MN2 (I1482_G26_23n I1482_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I122_XG_MN0 (XI1482_I122_XG_n1 I1482_P26_25 I1482_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I122_XG_MN1 (VSS I1482_G24_23 XI1482_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I127_XG_MN2 (I1528_G31_28n I1528_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I127_XG_MN0 (XI1528_I127_XG_n1 I1528_P31_30 I1528_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1528_I127_XG_MN1 (VSS I1528_G29_28 XI1528_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I117_XG_MN2 (I1206_G21_18n I1206_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I117_XG_MN0 (XI1206_I117_XG_n1 I1206_P21_20 I1206_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I117_XG_MN1 (VSS I1206_G19_18 XI1206_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I176_XG_MN2 (I1206_G25_10n I1206_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I176_XG_MN0 (XI1206_I176_XG_n1 I1206_P25_18 I1206_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I176_XG_MN1 (VSS I1206_G17_10 XI1206_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I120_XG_MN2 (I1206_G24_21n I1206_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I120_XG_MN0 (XI1206_I120_XG_n1 I1206_P24_23 I1206_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I120_XG_MN1 (VSS I1206_G22_21 XI1206_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I118_XG_MN2 (I1206_G22_19n I1206_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I118_XG_MN0 (XI1206_I118_XG_n1 I1206_P22_21 I1206_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I118_XG_MN1 (VSS I1206_G20_19 XI1206_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I165_XG_MN2 (I1206_G14_0n I1206_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I165_XG_MN0 (XI1206_I165_XG_n1 I1206_P14_7 I1206_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I165_XG_MN1 (VSS I1206_G6_0 XI1206_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I181_XG_MN2 (I1252_G30_15n I1252_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I181_XG_MN0 (XI1252_I181_XG_n1 I1252_P30_23 I1252_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I181_XG_MN1 (VSS I1252_G22_15 XI1252_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I121_XG_MN2 (I1252_G25_22n I1252_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I121_XG_MN0 (XI1252_I121_XG_n1 I1252_P25_24 I1252_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I121_XG_MN1 (VSS I1252_G23_22 XI1252_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I180_XG_MN2 (I1252_G29_14n I1252_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I180_XG_MN0 (XI1252_I180_XG_n1 I1252_P29_22 I1252_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I180_XG_MN1 (VSS I1252_G21_14 XI1252_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I122_XG_MN2 (I1298_G26_23n I1298_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I122_XG_MN0 (XI1298_I122_XG_n1 I1298_P26_25 I1298_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I122_XG_MN1 (VSS I1298_G24_23 XI1298_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I121_XG_MN2 (I1298_G25_22n I1298_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I121_XG_MN0 (XI1298_I121_XG_n1 I1298_P25_24 I1298_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I121_XG_MN1 (VSS I1298_G23_22 XI1298_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I123_XG_MN2 (I1298_G27_24n I1298_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I123_XG_MN0 (XI1298_I123_XG_n1 I1298_P27_26 I1298_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I123_XG_MN1 (VSS I1298_G25_24 XI1298_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I180_XG_MN2 (I1298_G29_14n I1298_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I180_XG_MN0 (XI1298_I180_XG_n1 I1298_P29_22 I1298_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I180_XG_MN1 (VSS I1298_G21_14 XI1298_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I122_XG_MN2 (I1344_G26_23n I1344_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I122_XG_MN0 (XI1344_I122_XG_n1 I1344_P26_25 I1344_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I122_XG_MN1 (VSS I1344_G24_23 XI1344_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I124_XG_MN2 (I1344_G28_25n I1344_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I124_XG_MN0 (XI1344_I124_XG_n1 I1344_P28_27 I1344_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I124_XG_MN1 (VSS I1344_G26_25 XI1344_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I121_XG_MN2 (I1344_G25_22n I1344_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I121_XG_MN0 (XI1344_I121_XG_n1 I1344_P25_24 I1344_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I121_XG_MN1 (VSS I1344_G23_22 XI1344_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I180_XG_MN2 (I1344_G29_14n I1344_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I180_XG_MN0 (XI1344_I180_XG_n1 I1344_P29_22 I1344_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I180_XG_MN1 (VSS I1344_G21_14 XI1344_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I122_XG_MN2 (I1390_G26_23n I1390_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I122_XG_MN0 (XI1390_I122_XG_n1 I1390_P26_25 I1390_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I122_XG_MN1 (VSS I1390_G24_23 XI1390_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I123_XG_MN2 (I1390_G27_24n I1390_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I123_XG_MN0 (XI1390_I123_XG_n1 I1390_P27_26 I1390_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I123_XG_MN1 (VSS I1390_G25_24 XI1390_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I182_XG_MN2 (I1390_G31_16n I1390_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I182_XG_MN0 (XI1390_I182_XG_n1 I1390_P31_24 I1390_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I182_XG_MN1 (VSS I1390_G23_16 XI1390_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I122_XG_MN2 (I1436_G26_23n I1436_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I122_XG_MN0 (XI1436_I122_XG_n1 I1436_P26_25 I1436_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I122_XG_MN1 (VSS I1436_G24_23 XI1436_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I121_XG_MN2 (I1436_G25_22n I1436_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I121_XG_MN0 (XI1436_I121_XG_n1 I1436_P25_24 I1436_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I121_XG_MN1 (VSS I1436_G23_22 XI1436_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I178_XG_MN2 (I1436_G27_12n I1436_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I178_XG_MN0 (XI1436_I178_XG_n1 I1436_P27_20 I1436_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I178_XG_MN1 (VSS I1436_G19_12 XI1436_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I119_XG_MN2 (I1482_G23_20n I1482_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I119_XG_MN0 (XI1482_I119_XG_n1 I1482_P23_22 I1482_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I119_XG_MN1 (VSS I1482_G21_20 XI1482_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I178_XG_MN2 (I1482_G27_12n I1482_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I178_XG_MN0 (XI1482_I178_XG_n1 I1482_P27_20 I1482_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I178_XG_MN1 (VSS I1482_G19_12 XI1482_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I180_XG_MN2 (I1482_G29_14n I1482_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I180_XG_MN0 (XI1482_I180_XG_n1 I1482_P29_22 I1482_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I180_XG_MN1 (VSS I1482_G21_14 XI1482_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I124_XG_MN2 (I1482_G28_25n I1482_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I124_XG_MN0 (XI1482_I124_XG_n1 I1482_P28_27 I1482_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I124_XG_MN1 (VSS I1482_G26_25 XI1482_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I121_XG_MN2 (I1206_G25_22n I1206_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I121_XG_MN0 (XI1206_I121_XG_n1 I1206_P25_24 I1206_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I121_XG_MN1 (VSS I1206_G23_22 XI1206_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I182_XG_MN2 (I1206_G31_16n I1206_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I182_XG_MN0 (XI1206_I182_XG_n1 I1206_P31_24 I1206_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I182_XG_MN1 (VSS I1206_G23_16 XI1206_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I119_XG_MN2 (I1206_G23_20n I1206_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I119_XG_MN0 (XI1206_I119_XG_n1 I1206_P23_22 I1206_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I119_XG_MN1 (VSS I1206_G21_20 XI1206_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I178_XG_MN2 (I1206_G27_12n I1206_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I178_XG_MN0 (XI1206_I178_XG_n1 I1206_P27_20 I1206_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I178_XG_MN1 (VSS I1206_G19_12 XI1206_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I174_XG_MN2 (I1206_G23_8n I1206_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I174_XG_MN0 (XI1206_I174_XG_n1 I1206_P23_16 I1206_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I174_XG_MN1 (VSS I1206_G15_8 XI1206_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I177_XG_MN2 (I1206_G26_11n I1206_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I177_XG_MN0 (XI1206_I177_XG_n1 I1206_P26_19 I1206_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I177_XG_MN1 (VSS I1206_G18_11 XI1206_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I173_XG_MN2 (I1206_G22_7n I1206_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I173_XG_MN0 (XI1206_I173_XG_n1 I1206_P22_15 I1206_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I173_XG_MN1 (VSS I1206_G14_7 XI1206_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I122_XG_MN2 (I1252_G26_23n I1252_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I122_XG_MN0 (XI1252_I122_XG_n1 I1252_P26_25 I1252_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I122_XG_MN1 (VSS I1252_G24_23 XI1252_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I124_XG_MN2 (I1252_G28_25n I1252_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I124_XG_MN0 (XI1252_I124_XG_n1 I1252_P28_27 I1252_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I124_XG_MN1 (VSS I1252_G26_25 XI1252_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I123_XG_MN2 (I1252_G27_24n I1252_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I123_XG_MN0 (XI1252_I123_XG_n1 I1252_P27_26 I1252_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I123_XG_MN1 (VSS I1252_G25_24 XI1252_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I182_XG_MN2 (I1252_G31_16n I1252_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I182_XG_MN0 (XI1252_I182_XG_n1 I1252_P31_24 I1252_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I182_XG_MN1 (VSS I1252_G23_16 XI1252_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I124_XG_MN2 (I1298_G28_25n I1298_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I124_XG_MN0 (XI1298_I124_XG_n1 I1298_P28_27 I1298_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I124_XG_MN1 (VSS I1298_G26_25 XI1298_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I126_XG_MN2 (I1298_G30_27n I1298_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I126_XG_MN0 (XI1298_I126_XG_n1 I1298_P30_29 I1298_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I126_XG_MN1 (VSS I1298_G28_27 XI1298_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I125_XG_MN2 (I1298_G29_26n I1298_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I125_XG_MN0 (XI1298_I125_XG_n1 I1298_P29_28 I1298_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I125_XG_MN1 (VSS I1298_G27_26 XI1298_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I126_XG_MN2 (I1344_G30_27n I1344_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I126_XG_MN0 (XI1344_I126_XG_n1 I1344_P30_29 I1344_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I126_XG_MN1 (VSS I1344_G28_27 XI1344_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I123_XG_MN2 (I1344_G27_24n I1344_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I123_XG_MN0 (XI1344_I123_XG_n1 I1344_P27_26 I1344_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I123_XG_MN1 (VSS I1344_G25_24 XI1344_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I125_XG_MN2 (I1344_G29_26n I1344_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I125_XG_MN0 (XI1344_I125_XG_n1 I1344_P29_28 I1344_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I125_XG_MN1 (VSS I1344_G27_26 XI1344_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I182_XG_MN2 (I1344_G31_16n I1344_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I182_XG_MN0 (XI1344_I182_XG_n1 I1344_P31_24 I1344_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I182_XG_MN1 (VSS I1344_G23_16 XI1344_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I124_XG_MN2 (I1390_G28_25n I1390_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I124_XG_MN0 (XI1390_I124_XG_n1 I1390_P28_27 I1390_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I124_XG_MN1 (VSS I1390_G26_25 XI1390_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I126_XG_MN2 (I1390_G30_27n I1390_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I126_XG_MN0 (XI1390_I126_XG_n1 I1390_P30_29 I1390_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I126_XG_MN1 (VSS I1390_G28_27 XI1390_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I125_XG_MN2 (I1390_G29_26n I1390_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I125_XG_MN0 (XI1390_I125_XG_n1 I1390_P29_28 I1390_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I125_XG_MN1 (VSS I1390_G27_26 XI1390_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I124_XG_MN2 (I1436_G28_25n I1436_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I124_XG_MN0 (XI1436_I124_XG_n1 I1436_P28_27 I1436_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I124_XG_MN1 (VSS I1436_G26_25 XI1436_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I123_XG_MN2 (I1436_G27_24n I1436_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I123_XG_MN0 (XI1436_I123_XG_n1 I1436_P27_26 I1436_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I123_XG_MN1 (VSS I1436_G25_24 XI1436_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I125_XG_MN2 (I1436_G29_26n I1436_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I125_XG_MN0 (XI1436_I125_XG_n1 I1436_P29_28 I1436_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I125_XG_MN1 (VSS I1436_G27_26 XI1436_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I182_XG_MN2 (I1436_G31_16n I1436_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I182_XG_MN0 (XI1436_I182_XG_n1 I1436_P31_24 I1436_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I182_XG_MN1 (VSS I1436_G23_16 XI1436_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I182_XG_MN2 (I1482_G31_16n I1482_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I182_XG_MN0 (XI1482_I182_XG_n1 I1482_P31_24 I1482_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I182_XG_MN1 (VSS I1482_G23_16 XI1482_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I121_XG_MN2 (I1482_G25_22n I1482_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I121_XG_MN0 (XI1482_I121_XG_n1 I1482_P25_24 I1482_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I121_XG_MN1 (VSS I1482_G23_22 XI1482_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I123_XG_MN2 (I1482_G27_24n I1482_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I123_XG_MN0 (XI1482_I123_XG_n1 I1482_P27_26 I1482_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I123_XG_MN1 (VSS I1482_G25_24 XI1482_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I125_XG_MN2 (I1206_G29_26n I1206_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I125_XG_MN0 (XI1206_I125_XG_n1 I1206_P29_28 I1206_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I125_XG_MN1 (VSS I1206_G27_26 XI1206_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I123_XG_MN2 (I1206_G27_24n I1206_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I123_XG_MN0 (XI1206_I123_XG_n1 I1206_P27_26 I1206_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I123_XG_MN1 (VSS I1206_G25_24 XI1206_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I180_XG_MN2 (I1206_G29_14n I1206_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I180_XG_MN0 (XI1206_I180_XG_n1 I1206_P29_22 I1206_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I180_XG_MN1 (VSS I1206_G21_14 XI1206_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I124_XG_MN2 (I1206_G28_25n I1206_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I124_XG_MN0 (XI1206_I124_XG_n1 I1206_P28_27 I1206_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I124_XG_MN1 (VSS I1206_G26_25 XI1206_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I122_XG_MN2 (I1206_G26_23n I1206_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I122_XG_MN0 (XI1206_I122_XG_n1 I1206_P26_25 I1206_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I122_XG_MN1 (VSS I1206_G24_23 XI1206_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I181_XG_MN2 (I1206_G30_15n I1206_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I181_XG_MN0 (XI1206_I181_XG_n1 I1206_P30_23 I1206_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I181_XG_MN1 (VSS I1206_G22_15 XI1206_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I179_XG_MN2 (I1206_G28_13n I1206_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I179_XG_MN0 (XI1206_I179_XG_n1 I1206_P28_21 I1206_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I179_XG_MN1 (VSS I1206_G20_13 XI1206_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I126_XG_MN2 (I1252_G30_27n I1252_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I126_XG_MN0 (XI1252_I126_XG_n1 I1252_P30_29 I1252_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I126_XG_MN1 (VSS I1252_G28_27 XI1252_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I127_XG_MN2 (I1252_G31_28n I1252_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I127_XG_MN0 (XI1252_I127_XG_n1 I1252_P31_30 I1252_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I127_XG_MN1 (VSS I1252_G29_28 XI1252_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I125_XG_MN2 (I1252_G29_26n I1252_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I125_XG_MN0 (XI1252_I125_XG_n1 I1252_P29_28 I1252_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1252_I125_XG_MN1 (VSS I1252_G27_26 XI1252_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I127_XG_MN2 (I1298_G31_28n I1298_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I127_XG_MN0 (XI1298_I127_XG_n1 I1298_P31_30 I1298_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I127_XG_MN1 (VSS I1298_G29_28 XI1298_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I182_XG_MN2 (I1298_G31_16n I1298_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I182_XG_MN0 (XI1298_I182_XG_n1 I1298_P31_24 I1298_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1298_I182_XG_MN1 (VSS I1298_G23_16 XI1298_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I127_XG_MN2 (I1344_G31_28n I1344_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I127_XG_MN0 (XI1344_I127_XG_n1 I1344_P31_30 I1344_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1344_I127_XG_MN1 (VSS I1344_G29_28 XI1344_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I127_XG_MN2 (I1390_G31_28n I1390_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I127_XG_MN0 (XI1390_I127_XG_n1 I1390_P31_30 I1390_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1390_I127_XG_MN1 (VSS I1390_G29_28 XI1390_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I126_XG_MN2 (I1436_G30_27n I1436_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I126_XG_MN0 (XI1436_I126_XG_n1 I1436_P30_29 I1436_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I126_XG_MN1 (VSS I1436_G28_27 XI1436_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I127_XG_MN2 (I1436_G31_28n I1436_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I127_XG_MN0 (XI1436_I127_XG_n1 I1436_P31_30 I1436_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1436_I127_XG_MN1 (VSS I1436_G29_28 XI1436_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I127_XG_MN2 (I1482_G31_28n I1482_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I127_XG_MN0 (XI1482_I127_XG_n1 I1482_P31_30 I1482_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I127_XG_MN1 (VSS I1482_G29_28 XI1482_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I125_XG_MN2 (I1482_G29_26n I1482_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I125_XG_MN0 (XI1482_I125_XG_n1 I1482_P29_28 I1482_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I125_XG_MN1 (VSS I1482_G27_26 XI1482_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I126_XG_MN2 (I1482_G30_27n I1482_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I126_XG_MN0 (XI1482_I126_XG_n1 I1482_P30_29 I1482_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1482_I126_XG_MN1 (VSS I1482_G28_27 XI1482_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I127_XG_MN2 (I1206_G31_28n I1206_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I127_XG_MN0 (XI1206_I127_XG_n1 I1206_P31_30 I1206_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I127_XG_MN1 (VSS I1206_G29_28 XI1206_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I126_XG_MN2 (I1206_G30_27n I1206_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I126_XG_MN0 (XI1206_I126_XG_n1 I1206_P30_29 I1206_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1206_I126_XG_MN1 (VSS I1206_G28_27 XI1206_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I96_XG_MN2 (XI654_I96_XG_n1 I654_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I96_XG_MN0 (I654_G30_29 I654_pn30 XI654_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I96_XG_MN1 (XI654_I96_XG_n1 I654_gn29 I654_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I97_XG_MN2 (XI654_I97_XG_n1 I654_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I97_XG_MN0 (I654_G31_30 I654_pn31 XI654_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I97_XG_MN1 (XI654_I97_XG_n1 I654_gn30 I654_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I95_XG_MN2 (XI654_I95_XG_n1 I654_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I95_XG_MN0 (I654_G29_28 I654_pn29 XI654_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I95_XG_MN1 (XI654_I95_XG_n1 I654_gn28 I654_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I94_XG_MN2 (XI654_I94_XG_n1 I654_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I94_XG_MN0 (I654_G28_27 I654_pn28 XI654_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I94_XG_MN1 (XI654_I94_XG_n1 I654_gn27 I654_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I97_XG_MN2 (XI608_I97_XG_n1 I608_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I97_XG_MN0 (I608_G31_30 I608_pn31 XI608_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I97_XG_MN1 (XI608_I97_XG_n1 I608_gn30 I608_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I96_XG_MN2 (XI608_I96_XG_n1 I608_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I96_XG_MN0 (I608_G30_29 I608_pn30 XI608_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I96_XG_MN1 (XI608_I96_XG_n1 I608_gn29 I608_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I95_XG_MN2 (XI608_I95_XG_n1 I608_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I95_XG_MN0 (I608_G29_28 I608_pn29 XI608_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I95_XG_MN1 (XI608_I95_XG_n1 I608_gn28 I608_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I94_XG_MN2 (XI608_I94_XG_n1 I608_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I94_XG_MN0 (I608_G28_27 I608_pn28 XI608_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I94_XG_MN1 (XI608_I94_XG_n1 I608_gn27 I608_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I97_XG_MN2 (XI562_I97_XG_n1 I562_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I97_XG_MN0 (I562_G31_30 I562_pn31 XI562_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I97_XG_MN1 (XI562_I97_XG_n1 I562_gn30 I562_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I96_XG_MN2 (XI562_I96_XG_n1 I562_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I96_XG_MN0 (I562_G30_29 I562_pn30 XI562_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I96_XG_MN1 (XI562_I96_XG_n1 I562_gn29 I562_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I95_XG_MN2 (XI562_I95_XG_n1 I562_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I95_XG_MN0 (I562_G29_28 I562_pn29 XI562_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I95_XG_MN1 (XI562_I95_XG_n1 I562_gn28 I562_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I95_XG_MN2 (XI2066_I95_XG_n1 I2066_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I95_XG_MN0 (I2066_G29_28 I2066_pn29 XI2066_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I95_XG_MN1 (XI2066_I95_XG_n1 I2066_gn28 I2066_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I96_XG_MN2 (XI2066_I96_XG_n1 I2066_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I96_XG_MN0 (I2066_G30_29 I2066_pn30 XI2066_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I96_XG_MN1 (XI2066_I96_XG_n1 I2066_gn29 I2066_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I97_XG_MN2 (XI2066_I97_XG_n1 I2066_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I97_XG_MN0 (I2066_G31_30 I2066_pn31 XI2066_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I97_XG_MN1 (XI2066_I97_XG_n1 I2066_gn30 I2066_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I96_XG_MN2 (XI1988_I96_XG_n1 I1988_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I96_XG_MN0 (I1988_G30_29 I1988_pn30 XI1988_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I96_XG_MN1 (XI1988_I96_XG_n1 I1988_gn29 I1988_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I97_XG_MN2 (XI1988_I97_XG_n1 I1988_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I97_XG_MN0 (I1988_G31_30 I1988_pn31 XI1988_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I97_XG_MN1 (XI1988_I97_XG_n1 I1988_gn30 I1988_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I95_XG_MN2 (XI1988_I95_XG_n1 I1988_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I95_XG_MN0 (I1988_G29_28 I1988_pn29 XI1988_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I95_XG_MN1 (XI1988_I95_XG_n1 I1988_gn28 I1988_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I96_XG_MN2 (XI1942_I96_XG_n1 I1942_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I96_XG_MN0 (I1942_G30_29 I1942_pn30 XI1942_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I96_XG_MN1 (XI1942_I96_XG_n1 I1942_gn29 I1942_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I97_XG_MN2 (XI1942_I97_XG_n1 I1942_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I97_XG_MN0 (I1942_G31_30 I1942_pn31 XI1942_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I97_XG_MN1 (XI1942_I97_XG_n1 I1942_gn30 I1942_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I95_XG_MN2 (XI1942_I95_XG_n1 I1942_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I95_XG_MN0 (I1942_G29_28 I1942_pn29 XI1942_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I95_XG_MN1 (XI1942_I95_XG_n1 I1942_gn28 I1942_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I94_XG_MN2 (XI1942_I94_XG_n1 I1942_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I94_XG_MN0 (I1942_G28_27 I1942_pn28 XI1942_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I94_XG_MN1 (XI1942_I94_XG_n1 I1942_gn27 I1942_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I201_XG_MN2 (XI1896_I201_XG_n1 I1896_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I201_XG_MN0 (c29_m I1896_P30_15n XI1896_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I201_XG_MN1 (XI1896_I201_XG_n1 I1896_G14_0n c29_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I155_XG_MN2 (XI1896_I155_XG_n1 I1896_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I155_XG_MN0 (I1896_G30_23 I1896_P30_27n XI1896_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I155_XG_MN1 (XI1896_I155_XG_n1 I1896_G26_23n I1896_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I93_XG_MN2 (XI1896_I93_XG_n1 I1896_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I93_XG_MN0 (I1896_G27_26 I1896_pn27 XI1896_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I93_XG_MN1 (XI1896_I93_XG_n1 I1896_gn26 I1896_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I94_XG_MN2 (XI1896_I94_XG_n1 I1896_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I94_XG_MN0 (I1896_G28_27 I1896_pn28 XI1896_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I94_XG_MN1 (XI1896_I94_XG_n1 I1896_gn27 I1896_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I96_XG_MN2 (XI700_I96_XG_n1 I700_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I96_XG_MN0 (I700_G30_29 I700_pn30 XI700_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I96_XG_MN1 (XI700_I96_XG_n1 I700_gn29 I700_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I97_XG_MN2 (XI700_I97_XG_n1 I700_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I97_XG_MN0 (I700_G31_30 I700_pn31 XI700_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I97_XG_MN1 (XI700_I97_XG_n1 I700_gn30 I700_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I202_XG_MN2 (XI654_I202_XG_n1 I654_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I202_XG_MN0 (c2_o I654_P31_16n XI654_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I202_XG_MN1 (XI654_I202_XG_n1 I654_G15_0n c2_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I152_XG_MN2 (XI654_I152_XG_n1 I654_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I152_XG_MN0 (I654_G27_20 I654_P27_24n XI654_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I152_XG_MN1 (XI654_I152_XG_n1 I654_G23_20n I654_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I156_XG_MN2 (XI654_I156_XG_n1 I654_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I156_XG_MN0 (I654_G31_24 I654_P31_28n XI654_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I156_XG_MN1 (XI654_I156_XG_n1 I654_G27_24n I654_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I93_XG_MN2 (XI654_I93_XG_n1 I654_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I93_XG_MN0 (I654_G27_26 I654_pn27 XI654_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I93_XG_MN1 (XI654_I93_XG_n1 I654_gn26 I654_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I92_XG_MN2 (XI654_I92_XG_n1 I654_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I92_XG_MN0 (I654_G26_25 I654_pn26 XI654_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I92_XG_MN1 (XI654_I92_XG_n1 I654_gn25 I654_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I202_XG_MN2 (XI608_I202_XG_n1 I608_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I202_XG_MN0 (c1_o I608_P31_16n XI608_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I202_XG_MN1 (XI608_I202_XG_n1 I608_G15_0n c1_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I198_XG_MN2 (XI608_I198_XG_n1 I608_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I198_XG_MN0 (I608_G27_0 I608_P27_12n XI608_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I198_XG_MN1 (XI608_I198_XG_n1 I608_G11_0n I608_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I156_XG_MN2 (XI608_I156_XG_n1 I608_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I156_XG_MN0 (I608_G31_24 I608_P31_28n XI608_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I156_XG_MN1 (XI608_I156_XG_n1 I608_G27_24n I608_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I93_XG_MN2 (XI608_I93_XG_n1 I608_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I93_XG_MN0 (I608_G27_26 I608_pn27 XI608_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I93_XG_MN1 (XI608_I93_XG_n1 I608_gn26 I608_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I92_XG_MN2 (XI608_I92_XG_n1 I608_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I92_XG_MN0 (I608_G26_25 I608_pn26 XI608_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I92_XG_MN1 (XI608_I92_XG_n1 I608_gn25 I608_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I91_XG_MN2 (XI608_I91_XG_n1 I608_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I91_XG_MN0 (I608_G25_24 I608_pn25 XI608_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I91_XG_MN1 (XI608_I91_XG_n1 I608_gn24 I608_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I94_XG_MN2 (XI562_I94_XG_n1 I562_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I94_XG_MN0 (I562_G28_27 I562_pn28 XI562_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I94_XG_MN1 (XI562_I94_XG_n1 I562_gn27 I562_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I93_XG_MN2 (XI562_I93_XG_n1 I562_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I93_XG_MN0 (I562_G27_26 I562_pn27 XI562_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I93_XG_MN1 (XI562_I93_XG_n1 I562_gn26 I562_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
