    I_MXI1160_I82_XG_MN2 (XI1160_I82_XG_n1 I1160_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I82_XG_MN0 (I1160_G16_15 I1160_pn16 XI1160_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I82_XG_MN1 (XI1160_I82_XG_n1 I1160_gn15 I1160_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I83_XG_MN2 (XI1160_I83_XG_n1 I1160_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I83_XG_MN0 (I1160_G17_16 I1160_pn17 XI1160_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I83_XG_MN1 (XI1160_I83_XG_n1 I1160_gn16 I1160_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I81_XG_MN2 (XI1160_I81_XG_n1 I1160_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I81_XG_MN0 (I1160_G15_14 I1160_pn15 XI1160_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I81_XG_MN1 (XI1160_I81_XG_n1 I1160_gn14 I1160_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I80_XG_MN2 (XI1160_I80_XG_n1 I1160_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I80_XG_MN0 (I1160_G14_13 I1160_pn14 XI1160_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I80_XG_MN1 (XI1160_I80_XG_n1 I1160_gn13 I1160_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I79_XG_MN2 (XI1160_I79_XG_n1 I1160_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I79_XG_MN0 (I1160_G13_12 I1160_pn13 XI1160_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I79_XG_MN1 (XI1160_I79_XG_n1 I1160_gn12 I1160_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I78_XG_MN2 (XI1160_I78_XG_n1 I1160_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I78_XG_MN0 (I1160_G12_11 I1160_pn12 XI1160_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I78_XG_MN1 (XI1160_I78_XG_n1 I1160_gn11 I1160_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I77_XG_MN2 (XI1160_I77_XG_n1 I1160_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I77_XG_MN0 (I1160_G11_10 I1160_pn11 XI1160_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I77_XG_MN1 (XI1160_I77_XG_n1 I1160_gn10 I1160_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I76_XG_MN2 (XI1160_I76_XG_n1 I1160_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I76_XG_MN0 (I1160_G10_9 I1160_pn10 XI1160_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I76_XG_MN1 (XI1160_I76_XG_n1 I1160_gn9 I1160_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I75_XG_MN2 (XI1160_I75_XG_n1 I1160_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I75_XG_MN0 (I1160_G9_8 I1160_pn9 XI1160_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I75_XG_MN1 (XI1160_I75_XG_n1 I1160_gn8 I1160_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I74_XG_MN2 (XI1160_I74_XG_n1 I1160_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I74_XG_MN0 (I1160_G8_7 I1160_pn8 XI1160_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I74_XG_MN1 (XI1160_I74_XG_n1 I1160_gn7 I1160_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I69_XG_MN2 (XI1206_I69_XG_n1 I1206_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I69_XG_MN0 (I1206_G3_2 I1206_pn3 XI1206_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I69_XG_MN1 (XI1206_I69_XG_n1 I1206_gn2 I1206_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I72_XG_MN2 (XI1252_I72_XG_n1 I1252_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I72_XG_MN0 (I1252_G6_5 I1252_pn6 XI1252_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I72_XG_MN1 (XI1252_I72_XG_n1 I1252_gn5 I1252_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I71_XG_MN2 (XI1252_I71_XG_n1 I1252_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I71_XG_MN0 (I1252_G5_4 I1252_pn5 XI1252_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I71_XG_MN1 (XI1252_I71_XG_n1 I1252_gn4 I1252_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I128_XG_MN2 (XI1252_I128_XG_n1 I1252_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I128_XG_MN0 (I1252_G4_0 I1252_P4_1n XI1252_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I128_XG_MN1 (XI1252_I128_XG_n1 I1252_G0_0n I1252_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I130_XG_MN2 (XI1252_I130_XG_n1 I1252_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I130_XG_MN0 (I1252_G5_0 I1252_P5_2n XI1252_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I130_XG_MN1 (XI1252_I130_XG_n1 I1252_G1_0n I1252_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I73_XG_MN2 (XI1298_I73_XG_n1 I1298_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I73_XG_MN0 (I1298_G7_6 I1298_pn7 XI1298_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I73_XG_MN1 (XI1298_I73_XG_n1 I1298_gn6 I1298_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I74_XG_MN2 (XI1298_I74_XG_n1 I1298_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I74_XG_MN0 (I1298_G8_7 I1298_pn8 XI1298_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I74_XG_MN1 (XI1298_I74_XG_n1 I1298_gn7 I1298_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I133_XG_MN2 (XI1298_I133_XG_n1 I1298_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I133_XG_MN0 (I1298_G8_1 I1298_P8_5n XI1298_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I133_XG_MN1 (XI1298_I133_XG_n1 I1298_G4_1n I1298_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I132_XG_MN2 (XI1298_I132_XG_n1 I1298_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I132_XG_MN0 (I1298_G7_0 I1298_P7_4n XI1298_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I132_XG_MN1 (XI1298_I132_XG_n1 I1298_G3_0n I1298_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I130_XG_MN2 (XI1298_I130_XG_n1 I1298_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I130_XG_MN0 (I1298_G5_0 I1298_P5_2n XI1298_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I130_XG_MN1 (XI1298_I130_XG_n1 I1298_G1_0n I1298_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I135_XG_MN2 (XI1344_I135_XG_n1 I1344_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I135_XG_MN0 (I1344_G10_3 I1344_P10_7n XI1344_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I135_XG_MN1 (XI1344_I135_XG_n1 I1344_G6_3n I1344_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I131_XG_MN2 (XI1344_I131_XG_n1 I1344_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I131_XG_MN0 (I1344_G6_0 I1344_P6_3n XI1344_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I131_XG_MN1 (XI1344_I131_XG_n1 I1344_G2_0n I1344_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I183_XG_MN2 (XI1344_I183_XG_n1 I1344_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I183_XG_MN0 (I1344_G16_0 I1344_P16_1n XI1344_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I183_XG_MN1 (XI1344_I183_XG_n1 I1344_G0_0n I1344_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I75_XG_MN2 (XI1344_I75_XG_n1 I1344_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I75_XG_MN0 (I1344_G9_8 I1344_pn9 XI1344_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I75_XG_MN1 (XI1344_I75_XG_n1 I1344_gn8 I1344_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I76_XG_MN2 (XI1344_I76_XG_n1 I1344_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I76_XG_MN0 (I1344_G10_9 I1344_pn10 XI1344_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I76_XG_MN1 (XI1344_I76_XG_n1 I1344_gn9 I1344_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I132_XG_MN2 (XI1344_I132_XG_n1 I1344_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I132_XG_MN0 (I1344_G7_0 I1344_P7_4n XI1344_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I132_XG_MN1 (XI1344_I132_XG_n1 I1344_G3_0n I1344_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I134_XG_MN2 (XI1344_I134_XG_n1 I1344_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I134_XG_MN0 (I1344_G9_2 I1344_P9_6n XI1344_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I134_XG_MN1 (XI1344_I134_XG_n1 I1344_G5_2n I1344_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I75_XG_MN2 (XI1390_I75_XG_n1 I1390_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I75_XG_MN0 (I1390_G9_8 I1390_pn9 XI1390_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I75_XG_MN1 (XI1390_I75_XG_n1 I1390_gn8 I1390_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I131_XG_MN2 (XI1390_I131_XG_n1 I1390_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I131_XG_MN0 (I1390_G6_0 I1390_P6_3n XI1390_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I131_XG_MN1 (XI1390_I131_XG_n1 I1390_G2_0n I1390_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I183_XG_MN2 (XI1390_I183_XG_n1 I1390_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I183_XG_MN0 (I1390_G16_0 I1390_P16_1n XI1390_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I183_XG_MN1 (XI1390_I183_XG_n1 I1390_G0_0n I1390_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I134_XG_MN2 (XI1390_I134_XG_n1 I1390_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I134_XG_MN0 (I1390_G9_2 I1390_P9_6n XI1390_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I134_XG_MN1 (XI1390_I134_XG_n1 I1390_G5_2n I1390_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I132_XG_MN2 (XI1390_I132_XG_n1 I1390_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I132_XG_MN0 (I1390_G7_0 I1390_P7_4n XI1390_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I132_XG_MN1 (XI1390_I132_XG_n1 I1390_G3_0n I1390_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I75_XG_MN2 (XI1436_I75_XG_n1 I1436_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I75_XG_MN0 (I1436_G9_8 I1436_pn9 XI1436_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I75_XG_MN1 (XI1436_I75_XG_n1 I1436_gn8 I1436_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I183_XG_MN2 (XI1436_I183_XG_n1 I1436_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I183_XG_MN0 (I1436_G16_0 I1436_P16_1n XI1436_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I183_XG_MN1 (XI1436_I183_XG_n1 I1436_G0_0n I1436_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I130_XG_MN2 (XI1436_I130_XG_n1 I1436_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I130_XG_MN0 (I1436_G5_0 I1436_P5_2n XI1436_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I130_XG_MN1 (XI1436_I130_XG_n1 I1436_G1_0n I1436_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I132_XG_MN2 (XI1436_I132_XG_n1 I1436_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I132_XG_MN0 (I1436_G7_0 I1436_P7_4n XI1436_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I132_XG_MN1 (XI1436_I132_XG_n1 I1436_G3_0n I1436_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I75_XG_MN2 (XI1482_I75_XG_n1 I1482_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I75_XG_MN0 (I1482_G9_8 I1482_pn9 XI1482_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I75_XG_MN1 (XI1482_I75_XG_n1 I1482_gn8 I1482_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I132_XG_MN2 (XI1482_I132_XG_n1 I1482_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I132_XG_MN0 (I1482_G7_0 I1482_P7_4n XI1482_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I132_XG_MN1 (XI1482_I132_XG_n1 I1482_G3_0n I1482_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I130_XG_MN2 (XI1482_I130_XG_n1 I1482_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I130_XG_MN0 (I1482_G5_0 I1482_P5_2n XI1482_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I130_XG_MN1 (XI1482_I130_XG_n1 I1482_G1_0n I1482_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I133_XG_MN2 (XI1482_I133_XG_n1 I1482_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I133_XG_MN0 (I1482_G8_1 I1482_P8_5n XI1482_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I133_XG_MN1 (XI1482_I133_XG_n1 I1482_G4_1n I1482_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I131_XG_MN2 (XI1482_I131_XG_n1 I1482_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I131_XG_MN0 (I1482_G6_0 I1482_P6_3n XI1482_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I131_XG_MN1 (XI1482_I131_XG_n1 I1482_G2_0n I1482_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I78_XG_MN2 (XI1528_I78_XG_n1 I1528_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I78_XG_MN0 (I1528_G12_11 I1528_pn12 XI1528_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I78_XG_MN1 (XI1528_I78_XG_n1 I1528_gn11 I1528_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I185_XG_MN2 (XI1528_I185_XG_n1 I1528_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I185_XG_MN0 (I1528_G18_0 I1528_P18_3n XI1528_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I185_XG_MN1 (XI1528_I185_XG_n1 I1528_G2_0n I1528_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I199_XG_MN2 (XI1528_I199_XG_n1 I1528_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I199_XG_MN0 (I1528_G28_0 I1528_P28_13n XI1528_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I199_XG_MN1 (XI1528_I199_XG_n1 I1528_G12_0n I1528_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I142_XG_MN2 (XI1528_I142_XG_n1 I1528_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I142_XG_MN0 (I1528_G17_10 I1528_P17_14n XI1528_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I142_XG_MN1 (XI1528_I142_XG_n1 I1528_G13_10n I1528_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I138_XG_MN2 (XI1528_I138_XG_n1 I1528_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I138_XG_MN0 (I1528_G13_6 I1528_P13_10n XI1528_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I138_XG_MN1 (XI1528_I138_XG_n1 I1528_G9_6n I1528_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I97_XG_MN2 (XI1160_I97_XG_n1 I1160_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I97_XG_MN0 (I1160_G31_30 I1160_pn31 XI1160_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I97_XG_MN1 (XI1160_I97_XG_n1 I1160_gn30 I1160_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I202_XG_MN2 (XI1160_I202_XG_n1 I1160_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I202_XG_MN0 (c13_o I1160_P31_16n XI1160_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I202_XG_MN1 (XI1160_I202_XG_n1 I1160_G15_0n c13_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I148_XG_MN2 (XI1160_I148_XG_n1 I1160_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I148_XG_MN0 (I1160_G23_16 I1160_P23_20n XI1160_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I148_XG_MN1 (XI1160_I148_XG_n1 I1160_G19_16n I1160_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I144_XG_MN2 (XI1160_I144_XG_n1 I1160_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I144_XG_MN0 (I1160_G19_12 I1160_P19_16n XI1160_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I144_XG_MN1 (XI1160_I144_XG_n1 I1160_G15_12n I1160_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I140_XG_MN2 (XI1160_I140_XG_n1 I1160_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I140_XG_MN0 (I1160_G15_8 I1160_P15_12n XI1160_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I140_XG_MN1 (XI1160_I140_XG_n1 I1160_G11_8n I1160_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I136_XG_MN2 (XI1160_I136_XG_n1 I1160_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I136_XG_MN0 (I1160_G11_4 I1160_P11_8n XI1160_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I136_XG_MN1 (XI1160_I136_XG_n1 I1160_G7_4n I1160_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I132_XG_MN2 (XI1160_I132_XG_n1 I1160_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I132_XG_MN0 (I1160_G7_0 I1160_P7_4n XI1160_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I132_XG_MN1 (XI1160_I132_XG_n1 I1160_G3_0n I1160_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I70_XG_MN2 (XI1206_I70_XG_n1 I1206_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I70_XG_MN0 (I1206_G4_3 I1206_pn4 XI1206_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I70_XG_MN1 (XI1206_I70_XG_n1 I1206_gn3 I1206_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I75_XG_MN2 (XI1252_I75_XG_n1 I1252_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I75_XG_MN0 (I1252_G9_8 I1252_pn9 XI1252_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I75_XG_MN1 (XI1252_I75_XG_n1 I1252_gn8 I1252_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I74_XG_MN2 (XI1252_I74_XG_n1 I1252_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I74_XG_MN0 (I1252_G8_7 I1252_pn8 XI1252_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I74_XG_MN1 (XI1252_I74_XG_n1 I1252_gn7 I1252_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I73_XG_MN2 (XI1252_I73_XG_n1 I1252_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I73_XG_MN0 (I1252_G7_6 I1252_pn7 XI1252_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I73_XG_MN1 (XI1252_I73_XG_n1 I1252_gn6 I1252_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I131_XG_MN2 (XI1252_I131_XG_n1 I1252_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I131_XG_MN0 (I1252_G6_0 I1252_P6_3n XI1252_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I131_XG_MN1 (XI1252_I131_XG_n1 I1252_G2_0n I1252_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I133_XG_MN2 (XI1252_I133_XG_n1 I1252_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I133_XG_MN0 (I1252_G8_1 I1252_P8_5n XI1252_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I133_XG_MN1 (XI1252_I133_XG_n1 I1252_G4_1n I1252_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I134_XG_MN2 (XI1252_I134_XG_n1 I1252_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I134_XG_MN0 (I1252_G9_2 I1252_P9_6n XI1252_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I134_XG_MN1 (XI1252_I134_XG_n1 I1252_G5_2n I1252_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I75_XG_MN2 (XI1298_I75_XG_n1 I1298_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I75_XG_MN0 (I1298_G9_8 I1298_pn9 XI1298_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I75_XG_MN1 (XI1298_I75_XG_n1 I1298_gn8 I1298_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I131_XG_MN2 (XI1298_I131_XG_n1 I1298_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I131_XG_MN0 (I1298_G6_0 I1298_P6_3n XI1298_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I131_XG_MN1 (XI1298_I131_XG_n1 I1298_G2_0n I1298_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I183_XG_MN2 (XI1298_I183_XG_n1 I1298_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I183_XG_MN0 (I1298_G16_0 I1298_P16_1n XI1298_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I183_XG_MN1 (XI1298_I183_XG_n1 I1298_G0_0n I1298_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I134_XG_MN2 (XI1298_I134_XG_n1 I1298_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I134_XG_MN0 (I1298_G9_2 I1298_P9_6n XI1298_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I134_XG_MN1 (XI1298_I134_XG_n1 I1298_G5_2n I1298_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I137_XG_MN2 (XI1344_I137_XG_n1 I1344_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I137_XG_MN0 (I1344_G12_5 I1344_P12_9n XI1344_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I137_XG_MN1 (XI1344_I137_XG_n1 I1344_G8_5n I1344_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I141_XG_MN2 (XI1344_I141_XG_n1 I1344_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I141_XG_MN0 (I1344_G16_9 I1344_P16_13n XI1344_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I141_XG_MN1 (XI1344_I141_XG_n1 I1344_G12_9n I1344_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I77_XG_MN2 (XI1344_I77_XG_n1 I1344_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I77_XG_MN0 (I1344_G11_10 I1344_pn11 XI1344_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I77_XG_MN1 (XI1344_I77_XG_n1 I1344_gn10 I1344_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I136_XG_MN2 (XI1344_I136_XG_n1 I1344_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I136_XG_MN0 (I1344_G11_4 I1344_P11_8n XI1344_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I136_XG_MN1 (XI1344_I136_XG_n1 I1344_G7_4n I1344_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I184_XG_MN2 (XI1344_I184_XG_n1 I1344_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I184_XG_MN0 (I1344_G17_0 I1344_P17_2n XI1344_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I184_XG_MN1 (XI1344_I184_XG_n1 I1344_G1_0n I1344_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I77_XG_MN2 (XI1390_I77_XG_n1 I1390_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I77_XG_MN0 (I1390_G11_10 I1390_pn11 XI1390_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I77_XG_MN1 (XI1390_I77_XG_n1 I1390_gn10 I1390_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I76_XG_MN2 (XI1390_I76_XG_n1 I1390_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I76_XG_MN0 (I1390_G10_9 I1390_pn10 XI1390_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I76_XG_MN1 (XI1390_I76_XG_n1 I1390_gn9 I1390_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I135_XG_MN2 (XI1390_I135_XG_n1 I1390_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I135_XG_MN0 (I1390_G10_3 I1390_P10_7n XI1390_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I135_XG_MN1 (XI1390_I135_XG_n1 I1390_G6_3n I1390_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I184_XG_MN2 (XI1390_I184_XG_n1 I1390_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I184_XG_MN0 (I1390_G17_0 I1390_P17_2n XI1390_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I184_XG_MN1 (XI1390_I184_XG_n1 I1390_G1_0n I1390_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I77_XG_MN2 (XI1436_I77_XG_n1 I1436_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I77_XG_MN0 (I1436_G11_10 I1436_pn11 XI1436_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I77_XG_MN1 (XI1436_I77_XG_n1 I1436_gn10 I1436_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I76_XG_MN2 (XI1436_I76_XG_n1 I1436_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I76_XG_MN0 (I1436_G10_9 I1436_pn10 XI1436_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I76_XG_MN1 (XI1436_I76_XG_n1 I1436_gn9 I1436_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I135_XG_MN2 (XI1436_I135_XG_n1 I1436_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I135_XG_MN0 (I1436_G10_3 I1436_P10_7n XI1436_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I135_XG_MN1 (XI1436_I135_XG_n1 I1436_G6_3n I1436_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I134_XG_MN2 (XI1436_I134_XG_n1 I1436_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I134_XG_MN0 (I1436_G9_2 I1436_P9_6n XI1436_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I134_XG_MN1 (XI1436_I134_XG_n1 I1436_G5_2n I1436_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I76_XG_MN2 (XI1482_I76_XG_n1 I1482_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I76_XG_MN0 (I1482_G10_9 I1482_pn10 XI1482_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I76_XG_MN1 (XI1482_I76_XG_n1 I1482_gn9 I1482_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I77_XG_MN2 (XI1482_I77_XG_n1 I1482_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I77_XG_MN0 (I1482_G11_10 I1482_pn11 XI1482_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I77_XG_MN1 (XI1482_I77_XG_n1 I1482_gn10 I1482_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I134_XG_MN2 (XI1482_I134_XG_n1 I1482_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I134_XG_MN0 (I1482_G9_2 I1482_P9_6n XI1482_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I134_XG_MN1 (XI1482_I134_XG_n1 I1482_G5_2n I1482_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I183_XG_MN2 (XI1482_I183_XG_n1 I1482_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I183_XG_MN0 (I1482_G16_0 I1482_P16_1n XI1482_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I183_XG_MN1 (XI1482_I183_XG_n1 I1482_G0_0n I1482_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I79_XG_MN2 (XI1528_I79_XG_n1 I1528_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I79_XG_MN0 (I1528_G13_12 I1528_pn13 XI1528_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I79_XG_MN1 (XI1528_I79_XG_n1 I1528_gn12 I1528_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I80_XG_MN2 (XI1528_I80_XG_n1 I1528_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I80_XG_MN0 (I1528_G14_13 I1528_pn14 XI1528_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I80_XG_MN1 (XI1528_I80_XG_n1 I1528_gn13 I1528_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I139_XG_MN2 (XI1528_I139_XG_n1 I1528_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I139_XG_MN0 (I1528_G14_7 I1528_P14_11n XI1528_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I139_XG_MN1 (XI1528_I139_XG_n1 I1528_G10_7n I1528_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I143_XG_MN2 (XI1528_I143_XG_n1 I1528_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I143_XG_MN0 (I1528_G18_11 I1528_P18_15n XI1528_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I143_XG_MN1 (XI1528_I143_XG_n1 I1528_G14_11n I1528_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I197_XG_MN2 (XI1528_I197_XG_n1 I1528_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I197_XG_MN0 (I1528_G26_0 I1528_P26_11n XI1528_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I197_XG_MN1 (XI1528_I197_XG_n1 I1528_G10_0n I1528_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I198_XG_MN2 (XI1528_I198_XG_n1 I1528_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I198_XG_MN0 (I1528_G27_0 I1528_P27_12n XI1528_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I198_XG_MN1 (XI1528_I198_XG_n1 I1528_G11_0n I1528_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I190_XG_MN2 (XI1528_I190_XG_n1 I1528_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I190_XG_MN0 (I1528_G21_0 I1528_P21_6n XI1528_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I190_XG_MN1 (XI1528_I190_XG_n1 I1528_G5_0n I1528_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I156_XG_MN2 (XI1160_I156_XG_n1 I1160_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I156_XG_MN0 (I1160_G31_24 I1160_P31_28n XI1160_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I156_XG_MN1 (XI1160_I156_XG_n1 I1160_G27_24n I1160_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I152_XG_MN2 (XI1160_I152_XG_n1 I1160_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I152_XG_MN0 (I1160_G27_20 I1160_P27_24n XI1160_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I152_XG_MN1 (XI1160_I152_XG_n1 I1160_G23_20n I1160_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I198_XG_MN2 (XI1160_I198_XG_n1 I1160_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I198_XG_MN0 (I1160_G27_0 I1160_P27_12n XI1160_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I198_XG_MN1 (XI1160_I198_XG_n1 I1160_G11_0n I1160_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I194_XG_MN2 (XI1160_I194_XG_n1 I1160_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I194_XG_MN0 (I1160_G23_0 I1160_P23_8n XI1160_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I194_XG_MN1 (XI1160_I194_XG_n1 I1160_G7_0n I1160_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I150_XG_MN2 (XI1160_I150_XG_n1 I1160_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I150_XG_MN0 (I1160_G25_18 I1160_P25_22n XI1160_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I150_XG_MN1 (XI1160_I150_XG_n1 I1160_G21_18n I1160_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I146_XG_MN2 (XI1160_I146_XG_n1 I1160_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I146_XG_MN0 (I1160_G21_14 I1160_P21_18n XI1160_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I146_XG_MN1 (XI1160_I146_XG_n1 I1160_G17_14n I1160_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I186_XG_MN2 (XI1160_I186_XG_n1 I1160_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I186_XG_MN0 (I1160_G19_0 I1160_P19_4n XI1160_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I186_XG_MN1 (XI1160_I186_XG_n1 I1160_G3_0n I1160_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I142_XG_MN2 (XI1160_I142_XG_n1 I1160_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I142_XG_MN0 (I1160_G17_10 I1160_P17_14n XI1160_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I142_XG_MN1 (XI1160_I142_XG_n1 I1160_G13_10n I1160_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I138_XG_MN2 (XI1160_I138_XG_n1 I1160_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I138_XG_MN0 (I1160_G13_6 I1160_P13_10n XI1160_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I138_XG_MN1 (XI1160_I138_XG_n1 I1160_G9_6n I1160_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I184_XG_MN2 (XI1160_I184_XG_n1 I1160_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I184_XG_MN0 (I1160_G17_0 I1160_P17_2n XI1160_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I184_XG_MN1 (XI1160_I184_XG_n1 I1160_G1_0n I1160_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I134_XG_MN2 (XI1160_I134_XG_n1 I1160_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I134_XG_MN0 (I1160_G9_2 I1160_P9_6n XI1160_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I134_XG_MN1 (XI1160_I134_XG_n1 I1160_G5_2n I1160_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I130_XG_MN2 (XI1160_I130_XG_n1 I1160_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I130_XG_MN0 (I1160_G5_0 I1160_P5_2n XI1160_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I130_XG_MN1 (XI1160_I130_XG_n1 I1160_G1_0n I1160_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I71_XG_MN2 (XI1206_I71_XG_n1 I1206_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I71_XG_MN0 (I1206_G5_4 I1206_pn5 XI1206_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I71_XG_MN1 (XI1206_I71_XG_n1 I1206_gn4 I1206_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I128_XG_MN2 (XI1206_I128_XG_n1 I1206_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I128_XG_MN0 (I1206_G4_0 I1206_P4_1n XI1206_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I128_XG_MN1 (XI1206_I128_XG_n1 I1206_G0_0n I1206_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I77_XG_MN2 (XI1252_I77_XG_n1 I1252_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I77_XG_MN0 (I1252_G11_10 I1252_pn11 XI1252_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I77_XG_MN1 (XI1252_I77_XG_n1 I1252_gn10 I1252_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I76_XG_MN2 (XI1252_I76_XG_n1 I1252_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I76_XG_MN0 (I1252_G10_9 I1252_pn10 XI1252_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I76_XG_MN1 (XI1252_I76_XG_n1 I1252_gn9 I1252_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I135_XG_MN2 (XI1252_I135_XG_n1 I1252_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I135_XG_MN0 (I1252_G10_3 I1252_P10_7n XI1252_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I135_XG_MN1 (XI1252_I135_XG_n1 I1252_G6_3n I1252_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I185_XG_MN2 (XI1252_I185_XG_n1 I1252_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I185_XG_MN0 (I1252_G18_0 I1252_P18_3n XI1252_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I185_XG_MN1 (XI1252_I185_XG_n1 I1252_G2_0n I1252_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I183_XG_MN2 (XI1252_I183_XG_n1 I1252_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I183_XG_MN0 (I1252_G16_0 I1252_P16_1n XI1252_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I183_XG_MN1 (XI1252_I183_XG_n1 I1252_G0_0n I1252_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I132_XG_MN2 (XI1252_I132_XG_n1 I1252_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I132_XG_MN0 (I1252_G7_0 I1252_P7_4n XI1252_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I132_XG_MN1 (XI1252_I132_XG_n1 I1252_G3_0n I1252_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I184_XG_MN2 (XI1252_I184_XG_n1 I1252_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I184_XG_MN0 (I1252_G17_0 I1252_P17_2n XI1252_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I184_XG_MN1 (XI1252_I184_XG_n1 I1252_G1_0n I1252_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I77_XG_MN2 (XI1298_I77_XG_n1 I1298_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I77_XG_MN0 (I1298_G11_10 I1298_pn11 XI1298_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I77_XG_MN1 (XI1298_I77_XG_n1 I1298_gn10 I1298_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I76_XG_MN2 (XI1298_I76_XG_n1 I1298_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I76_XG_MN0 (I1298_G10_9 I1298_pn10 XI1298_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I76_XG_MN1 (XI1298_I76_XG_n1 I1298_gn9 I1298_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I137_XG_MN2 (XI1298_I137_XG_n1 I1298_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I137_XG_MN0 (I1298_G12_5 I1298_P12_9n XI1298_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I137_XG_MN1 (XI1298_I137_XG_n1 I1298_G8_5n I1298_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I135_XG_MN2 (XI1298_I135_XG_n1 I1298_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I135_XG_MN0 (I1298_G10_3 I1298_P10_7n XI1298_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I135_XG_MN1 (XI1298_I135_XG_n1 I1298_G6_3n I1298_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I185_XG_MN2 (XI1298_I185_XG_n1 I1298_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I185_XG_MN0 (I1298_G18_0 I1298_P18_3n XI1298_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I185_XG_MN1 (XI1298_I185_XG_n1 I1298_G2_0n I1298_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I136_XG_MN2 (XI1298_I136_XG_n1 I1298_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I136_XG_MN0 (I1298_G11_4 I1298_P11_8n XI1298_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I136_XG_MN1 (XI1298_I136_XG_n1 I1298_G7_4n I1298_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I184_XG_MN2 (XI1298_I184_XG_n1 I1298_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I184_XG_MN0 (I1298_G17_0 I1298_P17_2n XI1298_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I184_XG_MN1 (XI1298_I184_XG_n1 I1298_G1_0n I1298_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I185_XG_MN2 (XI1344_I185_XG_n1 I1344_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I185_XG_MN0 (I1344_G18_0 I1344_P18_3n XI1344_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I185_XG_MN1 (XI1344_I185_XG_n1 I1344_G2_0n I1344_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I195_XG_MN2 (XI1344_I195_XG_n1 I1344_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I195_XG_MN0 (I1344_G24_0 I1344_P24_9n XI1344_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I195_XG_MN1 (XI1344_I195_XG_n1 I1344_G8_0n I1344_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I78_XG_MN2 (XI1344_I78_XG_n1 I1344_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I78_XG_MN0 (I1344_G12_11 I1344_pn12 XI1344_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I78_XG_MN1 (XI1344_I78_XG_n1 I1344_gn11 I1344_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I79_XG_MN2 (XI1344_I79_XG_n1 I1344_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I79_XG_MN0 (I1344_G13_12 I1344_pn13 XI1344_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I79_XG_MN1 (XI1344_I79_XG_n1 I1344_gn12 I1344_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I186_XG_MN2 (XI1344_I186_XG_n1 I1344_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I186_XG_MN0 (I1344_G19_0 I1344_P19_4n XI1344_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I186_XG_MN1 (XI1344_I186_XG_n1 I1344_G3_0n I1344_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I78_XG_MN2 (XI1390_I78_XG_n1 I1390_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I78_XG_MN0 (I1390_G12_11 I1390_pn12 XI1390_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I78_XG_MN1 (XI1390_I78_XG_n1 I1390_gn11 I1390_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I79_XG_MN2 (XI1390_I79_XG_n1 I1390_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I79_XG_MN0 (I1390_G13_12 I1390_pn13 XI1390_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I79_XG_MN1 (XI1390_I79_XG_n1 I1390_gn12 I1390_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I137_XG_MN2 (XI1390_I137_XG_n1 I1390_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I137_XG_MN0 (I1390_G12_5 I1390_P12_9n XI1390_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I137_XG_MN1 (XI1390_I137_XG_n1 I1390_G8_5n I1390_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I141_XG_MN2 (XI1390_I141_XG_n1 I1390_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I141_XG_MN0 (I1390_G16_9 I1390_P16_13n XI1390_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I141_XG_MN1 (XI1390_I141_XG_n1 I1390_G12_9n I1390_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I185_XG_MN2 (XI1390_I185_XG_n1 I1390_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I185_XG_MN0 (I1390_G18_0 I1390_P18_3n XI1390_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I185_XG_MN1 (XI1390_I185_XG_n1 I1390_G2_0n I1390_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I138_XG_MN2 (XI1390_I138_XG_n1 I1390_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I138_XG_MN0 (I1390_G13_6 I1390_P13_10n XI1390_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I138_XG_MN1 (XI1390_I138_XG_n1 I1390_G9_6n I1390_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I136_XG_MN2 (XI1390_I136_XG_n1 I1390_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I136_XG_MN0 (I1390_G11_4 I1390_P11_8n XI1390_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I136_XG_MN1 (XI1390_I136_XG_n1 I1390_G7_4n I1390_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I78_XG_MN2 (XI1436_I78_XG_n1 I1436_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I78_XG_MN0 (I1436_G12_11 I1436_pn12 XI1436_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I78_XG_MN1 (XI1436_I78_XG_n1 I1436_gn11 I1436_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I137_XG_MN2 (XI1436_I137_XG_n1 I1436_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I137_XG_MN0 (I1436_G12_5 I1436_P12_9n XI1436_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I137_XG_MN1 (XI1436_I137_XG_n1 I1436_G8_5n I1436_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I141_XG_MN2 (XI1436_I141_XG_n1 I1436_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I141_XG_MN0 (I1436_G16_9 I1436_P16_13n XI1436_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I141_XG_MN1 (XI1436_I141_XG_n1 I1436_G12_9n I1436_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I185_XG_MN2 (XI1436_I185_XG_n1 I1436_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I185_XG_MN0 (I1436_G18_0 I1436_P18_3n XI1436_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I185_XG_MN1 (XI1436_I185_XG_n1 I1436_G2_0n I1436_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I184_XG_MN2 (XI1436_I184_XG_n1 I1436_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I184_XG_MN0 (I1436_G17_0 I1436_P17_2n XI1436_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I184_XG_MN1 (XI1436_I184_XG_n1 I1436_G1_0n I1436_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I136_XG_MN2 (XI1436_I136_XG_n1 I1436_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I136_XG_MN0 (I1436_G11_4 I1436_P11_8n XI1436_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I136_XG_MN1 (XI1436_I136_XG_n1 I1436_G7_4n I1436_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I78_XG_MN2 (XI1482_I78_XG_n1 I1482_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I78_XG_MN0 (I1482_G12_11 I1482_pn12 XI1482_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I78_XG_MN1 (XI1482_I78_XG_n1 I1482_gn11 I1482_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I136_XG_MN2 (XI1482_I136_XG_n1 I1482_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I136_XG_MN0 (I1482_G11_4 I1482_P11_8n XI1482_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I136_XG_MN1 (XI1482_I136_XG_n1 I1482_G7_4n I1482_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I184_XG_MN2 (XI1482_I184_XG_n1 I1482_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I184_XG_MN0 (I1482_G17_0 I1482_P17_2n XI1482_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I184_XG_MN1 (XI1482_I184_XG_n1 I1482_G1_0n I1482_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I137_XG_MN2 (XI1482_I137_XG_n1 I1482_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I137_XG_MN0 (I1482_G12_5 I1482_P12_9n XI1482_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I137_XG_MN1 (XI1482_I137_XG_n1 I1482_G8_5n I1482_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I135_XG_MN2 (XI1482_I135_XG_n1 I1482_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I135_XG_MN0 (I1482_G10_3 I1482_P10_7n XI1482_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I135_XG_MN1 (XI1482_I135_XG_n1 I1482_G6_3n I1482_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I81_XG_MN2 (XI1528_I81_XG_n1 I1528_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I81_XG_MN0 (I1528_G15_14 I1528_pn15 XI1528_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I81_XG_MN1 (XI1528_I81_XG_n1 I1528_gn14 I1528_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I82_XG_MN2 (XI1528_I82_XG_n1 I1528_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I82_XG_MN0 (I1528_G16_15 I1528_pn16 XI1528_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I82_XG_MN1 (XI1528_I82_XG_n1 I1528_gn15 I1528_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I145_XG_MN2 (XI1528_I145_XG_n1 I1528_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I145_XG_MN0 (I1528_G20_13 I1528_P20_17n XI1528_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I145_XG_MN1 (XI1528_I145_XG_n1 I1528_G16_13n I1528_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I192_XG_MN2 (XI1528_I192_XG_n1 I1528_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I192_XG_MN0 (I1528_G22_0 I1528_P22_7n XI1528_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I192_XG_MN1 (XI1528_I192_XG_n1 I1528_G6_0n I1528_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I140_XG_MN2 (XI1528_I140_XG_n1 I1528_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I140_XG_MN0 (I1528_G15_8 I1528_P15_12n XI1528_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I140_XG_MN1 (XI1528_I140_XG_n1 I1528_G11_8n I1528_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I144_XG_MN2 (XI1528_I144_XG_n1 I1528_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I144_XG_MN0 (I1528_G19_12 I1528_P19_16n XI1528_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I144_XG_MN1 (XI1528_I144_XG_n1 I1528_G15_12n I1528_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I154_XG_MN2 (XI1160_I154_XG_n1 I1160_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I154_XG_MN0 (I1160_G29_22 I1160_P29_26n XI1160_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I154_XG_MN1 (XI1160_I154_XG_n1 I1160_G25_22n I1160_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I200_XG_MN2 (XI1160_I200_XG_n1 I1160_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I200_XG_MN0 (I1160_G29_0 I1160_P29_14n XI1160_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I200_XG_MN1 (XI1160_I200_XG_n1 I1160_G13_0n I1160_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I190_XG_MN2 (XI1160_I190_XG_n1 I1160_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I190_XG_MN0 (I1160_G21_0 I1160_P21_6n XI1160_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I190_XG_MN1 (XI1160_I190_XG_n1 I1160_G5_0n I1160_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I196_XG_MN2 (XI1160_I196_XG_n1 I1160_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I196_XG_MN0 (I1160_G25_0 I1160_P25_10n XI1160_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I196_XG_MN1 (XI1160_I196_XG_n1 I1160_G9_0n I1160_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I133_XG_MN2 (XI1160_I133_XG_n1 I1160_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I133_XG_MN0 (I1160_G8_1 I1160_P8_5n XI1160_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I133_XG_MN1 (XI1160_I133_XG_n1 I1160_G4_1n I1160_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I128_XG_MN2 (XI1160_I128_XG_n1 I1160_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I128_XG_MN0 (I1160_G4_0 I1160_P4_1n XI1160_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I128_XG_MN1 (XI1160_I128_XG_n1 I1160_G0_0n I1160_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I73_XG_MN2 (XI1206_I73_XG_n1 I1206_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I73_XG_MN0 (I1206_G7_6 I1206_pn7 XI1206_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I73_XG_MN1 (XI1206_I73_XG_n1 I1206_gn6 I1206_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I74_XG_MN2 (XI1206_I74_XG_n1 I1206_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I74_XG_MN0 (I1206_G8_7 I1206_pn8 XI1206_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I74_XG_MN1 (XI1206_I74_XG_n1 I1206_gn7 I1206_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I72_XG_MN2 (XI1206_I72_XG_n1 I1206_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I72_XG_MN0 (I1206_G6_5 I1206_pn6 XI1206_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I72_XG_MN1 (XI1206_I72_XG_n1 I1206_gn5 I1206_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I131_XG_MN2 (XI1206_I131_XG_n1 I1206_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I131_XG_MN0 (I1206_G6_0 I1206_P6_3n XI1206_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I131_XG_MN1 (XI1206_I131_XG_n1 I1206_G2_0n I1206_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I78_XG_MN2 (XI1252_I78_XG_n1 I1252_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I78_XG_MN0 (I1252_G12_11 I1252_pn12 XI1252_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I78_XG_MN1 (XI1252_I78_XG_n1 I1252_gn11 I1252_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I137_XG_MN2 (XI1252_I137_XG_n1 I1252_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I137_XG_MN0 (I1252_G12_5 I1252_P12_9n XI1252_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I137_XG_MN1 (XI1252_I137_XG_n1 I1252_G8_5n I1252_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I136_XG_MN2 (XI1252_I136_XG_n1 I1252_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I136_XG_MN0 (I1252_G11_4 I1252_P11_8n XI1252_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I136_XG_MN1 (XI1252_I136_XG_n1 I1252_G7_4n I1252_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I79_XG_MN2 (XI1298_I79_XG_n1 I1298_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I79_XG_MN0 (I1298_G13_12 I1298_pn13 XI1298_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I79_XG_MN1 (XI1298_I79_XG_n1 I1298_gn12 I1298_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I78_XG_MN2 (XI1298_I78_XG_n1 I1298_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I78_XG_MN0 (I1298_G12_11 I1298_pn12 XI1298_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I78_XG_MN1 (XI1298_I78_XG_n1 I1298_gn11 I1298_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I141_XG_MN2 (XI1298_I141_XG_n1 I1298_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I141_XG_MN0 (I1298_G16_9 I1298_P16_13n XI1298_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I141_XG_MN1 (XI1298_I141_XG_n1 I1298_G12_9n I1298_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I195_XG_MN2 (XI1298_I195_XG_n1 I1298_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I195_XG_MN0 (I1298_G24_0 I1298_P24_9n XI1298_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I195_XG_MN1 (XI1298_I195_XG_n1 I1298_G8_0n I1298_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I138_XG_MN2 (XI1298_I138_XG_n1 I1298_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I138_XG_MN0 (I1298_G13_6 I1298_P13_10n XI1298_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I138_XG_MN1 (XI1298_I138_XG_n1 I1298_G9_6n I1298_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I186_XG_MN2 (XI1298_I186_XG_n1 I1298_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I186_XG_MN0 (I1298_G19_0 I1298_P19_4n XI1298_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I186_XG_MN1 (XI1298_I186_XG_n1 I1298_G3_0n I1298_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I139_XG_MN2 (XI1344_I139_XG_n1 I1344_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I139_XG_MN0 (I1344_G14_7 I1344_P14_11n XI1344_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I139_XG_MN1 (XI1344_I139_XG_n1 I1344_G10_7n I1344_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I188_XG_MN2 (XI1344_I188_XG_n1 I1344_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I188_XG_MN0 (I1344_G20_0 I1344_P20_5n XI1344_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I188_XG_MN1 (XI1344_I188_XG_n1 I1344_G4_0n I1344_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I80_XG_MN2 (XI1344_I80_XG_n1 I1344_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I80_XG_MN0 (I1344_G14_13 I1344_pn14 XI1344_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I80_XG_MN1 (XI1344_I80_XG_n1 I1344_gn13 I1344_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I142_XG_MN2 (XI1344_I142_XG_n1 I1344_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I142_XG_MN0 (I1344_G17_10 I1344_P17_14n XI1344_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I142_XG_MN1 (XI1344_I142_XG_n1 I1344_G13_10n I1344_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I138_XG_MN2 (XI1344_I138_XG_n1 I1344_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I138_XG_MN0 (I1344_G13_6 I1344_P13_10n XI1344_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I138_XG_MN1 (XI1344_I138_XG_n1 I1344_G9_6n I1344_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I80_XG_MN2 (XI1390_I80_XG_n1 I1390_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I80_XG_MN0 (I1390_G14_13 I1390_pn14 XI1390_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I80_XG_MN1 (XI1390_I80_XG_n1 I1390_gn13 I1390_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I139_XG_MN2 (XI1390_I139_XG_n1 I1390_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I139_XG_MN0 (I1390_G14_7 I1390_P14_11n XI1390_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I139_XG_MN1 (XI1390_I139_XG_n1 I1390_G10_7n I1390_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I195_XG_MN2 (XI1390_I195_XG_n1 I1390_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I195_XG_MN0 (I1390_G24_0 I1390_P24_9n XI1390_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I195_XG_MN1 (XI1390_I195_XG_n1 I1390_G8_0n I1390_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I142_XG_MN2 (XI1390_I142_XG_n1 I1390_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I142_XG_MN0 (I1390_G17_10 I1390_P17_14n XI1390_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I142_XG_MN1 (XI1390_I142_XG_n1 I1390_G13_10n I1390_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I186_XG_MN2 (XI1390_I186_XG_n1 I1390_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I186_XG_MN0 (I1390_G19_0 I1390_P19_4n XI1390_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I186_XG_MN1 (XI1390_I186_XG_n1 I1390_G3_0n I1390_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I80_XG_MN2 (XI1436_I80_XG_n1 I1436_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I80_XG_MN0 (I1436_G14_13 I1436_pn14 XI1436_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I80_XG_MN1 (XI1436_I80_XG_n1 I1436_gn13 I1436_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I79_XG_MN2 (XI1436_I79_XG_n1 I1436_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I79_XG_MN0 (I1436_G13_12 I1436_pn13 XI1436_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I79_XG_MN1 (XI1436_I79_XG_n1 I1436_gn12 I1436_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I195_XG_MN2 (XI1436_I195_XG_n1 I1436_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I195_XG_MN0 (I1436_G24_0 I1436_P24_9n XI1436_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I195_XG_MN1 (XI1436_I195_XG_n1 I1436_G8_0n I1436_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I138_XG_MN2 (XI1436_I138_XG_n1 I1436_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I138_XG_MN0 (I1436_G13_6 I1436_P13_10n XI1436_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I138_XG_MN1 (XI1436_I138_XG_n1 I1436_G9_6n I1436_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I79_XG_MN2 (XI1482_I79_XG_n1 I1482_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I79_XG_MN0 (I1482_G13_12 I1482_pn13 XI1482_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I79_XG_MN1 (XI1482_I79_XG_n1 I1482_gn12 I1482_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I141_XG_MN2 (XI1482_I141_XG_n1 I1482_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I141_XG_MN0 (I1482_G16_9 I1482_P16_13n XI1482_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I141_XG_MN1 (XI1482_I141_XG_n1 I1482_G12_9n I1482_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I83_XG_MN2 (XI1528_I83_XG_n1 I1528_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I83_XG_MN0 (I1528_G17_16 I1528_pn17 XI1528_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I83_XG_MN1 (XI1528_I83_XG_n1 I1528_gn16 I1528_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I149_XG_MN2 (XI1528_I149_XG_n1 I1528_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I149_XG_MN0 (I1528_G24_17 I1528_P24_21n XI1528_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I149_XG_MN1 (XI1528_I149_XG_n1 I1528_G20_17n I1528_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I146_XG_MN2 (XI1528_I146_XG_n1 I1528_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I146_XG_MN0 (I1528_G21_14 I1528_P21_18n XI1528_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I146_XG_MN1 (XI1528_I146_XG_n1 I1528_G17_14n I1528_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I200_XG_MN2 (XI1528_I200_XG_n1 I1528_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I200_XG_MN0 (I1528_G29_0 I1528_P29_14n XI1528_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I200_XG_MN1 (XI1528_I200_XG_n1 I1528_G13_0n I1528_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I96_XG_MN2 (XI1160_I96_XG_n1 I1160_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I96_XG_MN0 (I1160_G30_29 I1160_pn30 XI1160_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I96_XG_MN1 (XI1160_I96_XG_n1 I1160_gn29 I1160_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I91_XG_MN2 (XI1160_I91_XG_n1 I1160_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I91_XG_MN0 (I1160_G25_24 I1160_pn25 XI1160_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I91_XG_MN1 (XI1160_I91_XG_n1 I1160_gn24 I1160_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I90_XG_MN2 (XI1160_I90_XG_n1 I1160_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I90_XG_MN0 (I1160_G24_23 I1160_pn24 XI1160_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I90_XG_MN1 (XI1160_I90_XG_n1 I1160_gn23 I1160_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I145_XG_MN2 (XI1160_I145_XG_n1 I1160_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I145_XG_MN0 (I1160_G20_13 I1160_P20_17n XI1160_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I145_XG_MN1 (XI1160_I145_XG_n1 I1160_G16_13n I1160_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I141_XG_MN2 (XI1160_I141_XG_n1 I1160_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I141_XG_MN0 (I1160_G16_9 I1160_P16_13n XI1160_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I141_XG_MN1 (XI1160_I141_XG_n1 I1160_G12_9n I1160_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I137_XG_MN2 (XI1160_I137_XG_n1 I1160_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I137_XG_MN0 (I1160_G12_5 I1160_P12_9n XI1160_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I137_XG_MN1 (XI1160_I137_XG_n1 I1160_G8_5n I1160_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I183_XG_MN2 (XI1160_I183_XG_n1 I1160_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I183_XG_MN0 (I1160_G16_0 I1160_P16_1n XI1160_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I183_XG_MN1 (XI1160_I183_XG_n1 I1160_G0_0n I1160_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I77_XG_MN2 (XI1206_I77_XG_n1 I1206_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I77_XG_MN0 (I1206_G11_10 I1206_pn11 XI1206_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I77_XG_MN1 (XI1206_I77_XG_n1 I1206_gn10 I1206_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I76_XG_MN2 (XI1206_I76_XG_n1 I1206_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I76_XG_MN0 (I1206_G10_9 I1206_pn10 XI1206_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I76_XG_MN1 (XI1206_I76_XG_n1 I1206_gn9 I1206_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I75_XG_MN2 (XI1206_I75_XG_n1 I1206_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I75_XG_MN0 (I1206_G9_8 I1206_pn9 XI1206_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I75_XG_MN1 (XI1206_I75_XG_n1 I1206_gn8 I1206_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I133_XG_MN2 (XI1206_I133_XG_n1 I1206_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I133_XG_MN0 (I1206_G8_1 I1206_P8_5n XI1206_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I133_XG_MN1 (XI1206_I133_XG_n1 I1206_G4_1n I1206_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I79_XG_MN2 (XI1252_I79_XG_n1 I1252_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I79_XG_MN0 (I1252_G13_12 I1252_pn13 XI1252_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I79_XG_MN1 (XI1252_I79_XG_n1 I1252_gn12 I1252_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I141_XG_MN2 (XI1252_I141_XG_n1 I1252_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I141_XG_MN0 (I1252_G16_9 I1252_P16_13n XI1252_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I141_XG_MN1 (XI1252_I141_XG_n1 I1252_G12_9n I1252_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I195_XG_MN2 (XI1252_I195_XG_n1 I1252_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I195_XG_MN0 (I1252_G24_0 I1252_P24_9n XI1252_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I195_XG_MN1 (XI1252_I195_XG_n1 I1252_G8_0n I1252_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I138_XG_MN2 (XI1252_I138_XG_n1 I1252_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I138_XG_MN0 (I1252_G13_6 I1252_P13_10n XI1252_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I138_XG_MN1 (XI1252_I138_XG_n1 I1252_G9_6n I1252_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I186_XG_MN2 (XI1252_I186_XG_n1 I1252_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I186_XG_MN0 (I1252_G19_0 I1252_P19_4n XI1252_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I186_XG_MN1 (XI1252_I186_XG_n1 I1252_G3_0n I1252_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I80_XG_MN2 (XI1298_I80_XG_n1 I1298_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I80_XG_MN0 (I1298_G14_13 I1298_pn14 XI1298_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I80_XG_MN1 (XI1298_I80_XG_n1 I1298_gn13 I1298_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I81_XG_MN2 (XI1298_I81_XG_n1 I1298_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I81_XG_MN0 (I1298_G15_14 I1298_pn15 XI1298_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I81_XG_MN1 (XI1298_I81_XG_n1 I1298_gn14 I1298_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I143_XG_MN2 (XI1298_I143_XG_n1 I1298_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I143_XG_MN0 (I1298_G18_11 I1298_P18_15n XI1298_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I143_XG_MN1 (XI1298_I143_XG_n1 I1298_G14_11n I1298_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I139_XG_MN2 (XI1298_I139_XG_n1 I1298_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I139_XG_MN0 (I1298_G14_7 I1298_P14_11n XI1298_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I139_XG_MN1 (XI1298_I139_XG_n1 I1298_G10_7n I1298_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I142_XG_MN2 (XI1298_I142_XG_n1 I1298_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I142_XG_MN0 (I1298_G17_10 I1298_P17_14n XI1298_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I142_XG_MN1 (XI1298_I142_XG_n1 I1298_G13_10n I1298_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I140_XG_MN2 (XI1298_I140_XG_n1 I1298_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I140_XG_MN0 (I1298_G15_8 I1298_P15_12n XI1298_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I140_XG_MN1 (XI1298_I140_XG_n1 I1298_G11_8n I1298_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I143_XG_MN2 (XI1344_I143_XG_n1 I1344_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I143_XG_MN0 (I1344_G18_11 I1344_P18_15n XI1344_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I143_XG_MN1 (XI1344_I143_XG_n1 I1344_G14_11n I1344_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I197_XG_MN2 (XI1344_I197_XG_n1 I1344_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I197_XG_MN0 (I1344_G26_0 I1344_P26_11n XI1344_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I197_XG_MN1 (XI1344_I197_XG_n1 I1344_G10_0n I1344_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I145_XG_MN2 (XI1344_I145_XG_n1 I1344_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I145_XG_MN0 (I1344_G20_13 I1344_P20_17n XI1344_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I145_XG_MN1 (XI1344_I145_XG_n1 I1344_G16_13n I1344_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I82_XG_MN2 (XI1344_I82_XG_n1 I1344_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I82_XG_MN0 (I1344_G16_15 I1344_pn16 XI1344_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I82_XG_MN1 (XI1344_I82_XG_n1 I1344_gn15 I1344_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I81_XG_MN2 (XI1344_I81_XG_n1 I1344_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I81_XG_MN0 (I1344_G15_14 I1344_pn15 XI1344_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I81_XG_MN1 (XI1344_I81_XG_n1 I1344_gn14 I1344_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I196_XG_MN2 (XI1344_I196_XG_n1 I1344_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I196_XG_MN0 (I1344_G25_0 I1344_P25_10n XI1344_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I196_XG_MN1 (XI1344_I196_XG_n1 I1344_G9_0n I1344_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I81_XG_MN2 (XI1390_I81_XG_n1 I1390_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I81_XG_MN0 (I1390_G15_14 I1390_pn15 XI1390_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I81_XG_MN1 (XI1390_I81_XG_n1 I1390_gn14 I1390_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I143_XG_MN2 (XI1390_I143_XG_n1 I1390_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I143_XG_MN0 (I1390_G18_11 I1390_P18_15n XI1390_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I143_XG_MN1 (XI1390_I143_XG_n1 I1390_G14_11n I1390_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I188_XG_MN2 (XI1390_I188_XG_n1 I1390_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I188_XG_MN0 (I1390_G20_0 I1390_P20_5n XI1390_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I188_XG_MN1 (XI1390_I188_XG_n1 I1390_G4_0n I1390_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I140_XG_MN2 (XI1390_I140_XG_n1 I1390_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I140_XG_MN0 (I1390_G15_8 I1390_P15_12n XI1390_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I140_XG_MN1 (XI1390_I140_XG_n1 I1390_G11_8n I1390_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I196_XG_MN2 (XI1390_I196_XG_n1 I1390_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I196_XG_MN0 (I1390_G25_0 I1390_P25_10n XI1390_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I196_XG_MN1 (XI1390_I196_XG_n1 I1390_G9_0n I1390_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I81_XG_MN2 (XI1436_I81_XG_n1 I1436_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I81_XG_MN0 (I1436_G15_14 I1436_pn15 XI1436_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I81_XG_MN1 (XI1436_I81_XG_n1 I1436_gn14 I1436_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I143_XG_MN2 (XI1436_I143_XG_n1 I1436_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I143_XG_MN0 (I1436_G18_11 I1436_P18_15n XI1436_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I143_XG_MN1 (XI1436_I143_XG_n1 I1436_G14_11n I1436_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I139_XG_MN2 (XI1436_I139_XG_n1 I1436_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I139_XG_MN0 (I1436_G14_7 I1436_P14_11n XI1436_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I139_XG_MN1 (XI1436_I139_XG_n1 I1436_G10_7n I1436_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I188_XG_MN2 (XI1436_I188_XG_n1 I1436_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I188_XG_MN0 (I1436_G20_0 I1436_P20_5n XI1436_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I188_XG_MN1 (XI1436_I188_XG_n1 I1436_G4_0n I1436_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I142_XG_MN2 (XI1436_I142_XG_n1 I1436_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I142_XG_MN0 (I1436_G17_10 I1436_P17_14n XI1436_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I142_XG_MN1 (XI1436_I142_XG_n1 I1436_G13_10n I1436_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I186_XG_MN2 (XI1436_I186_XG_n1 I1436_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I186_XG_MN0 (I1436_G19_0 I1436_P19_4n XI1436_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I186_XG_MN1 (XI1436_I186_XG_n1 I1436_G3_0n I1436_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I81_XG_MN2 (XI1482_I81_XG_n1 I1482_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I81_XG_MN0 (I1482_G15_14 I1482_pn15 XI1482_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I81_XG_MN1 (XI1482_I81_XG_n1 I1482_gn14 I1482_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I80_XG_MN2 (XI1482_I80_XG_n1 I1482_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I80_XG_MN0 (I1482_G14_13 I1482_pn14 XI1482_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I80_XG_MN1 (XI1482_I80_XG_n1 I1482_gn13 I1482_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I138_XG_MN2 (XI1482_I138_XG_n1 I1482_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I138_XG_MN0 (I1482_G13_6 I1482_P13_10n XI1482_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I138_XG_MN1 (XI1482_I138_XG_n1 I1482_G9_6n I1482_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I188_XG_MN2 (XI1482_I188_XG_n1 I1482_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I188_XG_MN0 (I1482_G20_0 I1482_P20_5n XI1482_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I188_XG_MN1 (XI1482_I188_XG_n1 I1482_G4_0n I1482_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I139_XG_MN2 (XI1482_I139_XG_n1 I1482_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I139_XG_MN0 (I1482_G14_7 I1482_P14_11n XI1482_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I139_XG_MN1 (XI1482_I139_XG_n1 I1482_G10_7n I1482_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I185_XG_MN2 (XI1482_I185_XG_n1 I1482_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I185_XG_MN0 (I1482_G18_0 I1482_P18_3n XI1482_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I185_XG_MN1 (XI1482_I185_XG_n1 I1482_G2_0n I1482_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I84_XG_MN2 (XI1528_I84_XG_n1 I1528_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I84_XG_MN0 (I1528_G18_17 I1528_pn18 XI1528_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I84_XG_MN1 (XI1528_I84_XG_n1 I1528_gn17 I1528_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I85_XG_MN2 (XI1528_I85_XG_n1 I1528_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I85_XG_MN0 (I1528_G19_18 I1528_pn19 XI1528_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I85_XG_MN1 (XI1528_I85_XG_n1 I1528_gn18 I1528_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I147_XG_MN2 (XI1528_I147_XG_n1 I1528_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I147_XG_MN0 (I1528_G22_15 I1528_P22_19n XI1528_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I147_XG_MN1 (XI1528_I147_XG_n1 I1528_G18_15n I1528_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I194_XG_MN2 (XI1528_I194_XG_n1 I1528_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I194_XG_MN0 (I1528_G23_0 I1528_P23_8n XI1528_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I194_XG_MN1 (XI1528_I194_XG_n1 I1528_G7_0n I1528_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I150_XG_MN2 (XI1528_I150_XG_n1 I1528_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I150_XG_MN0 (I1528_G25_18 I1528_P25_22n XI1528_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I150_XG_MN1 (XI1528_I150_XG_n1 I1528_G21_18n I1528_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I95_XG_MN2 (XI1160_I95_XG_n1 I1160_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I95_XG_MN0 (I1160_G29_28 I1160_pn29 XI1160_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I95_XG_MN1 (XI1160_I95_XG_n1 I1160_gn28 I1160_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I149_XG_MN2 (XI1160_I149_XG_n1 I1160_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I149_XG_MN0 (I1160_G24_17 I1160_P24_21n XI1160_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I149_XG_MN1 (XI1160_I149_XG_n1 I1160_G20_17n I1160_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I195_XG_MN2 (XI1160_I195_XG_n1 I1160_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I195_XG_MN0 (I1160_G24_0 I1160_P24_9n XI1160_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I195_XG_MN1 (XI1160_I195_XG_n1 I1160_G8_0n I1160_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I188_XG_MN2 (XI1160_I188_XG_n1 I1160_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I188_XG_MN0 (I1160_G20_0 I1160_P20_5n XI1160_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I188_XG_MN1 (XI1160_I188_XG_n1 I1160_G4_0n I1160_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I131_XG_MN2 (XI1160_I131_XG_n1 I1160_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I131_XG_MN0 (I1160_G6_0 I1160_P6_3n XI1160_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I131_XG_MN1 (XI1160_I131_XG_n1 I1160_G2_0n I1160_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I78_XG_MN2 (XI1206_I78_XG_n1 I1206_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I78_XG_MN0 (I1206_G12_11 I1206_pn12 XI1206_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I78_XG_MN1 (XI1206_I78_XG_n1 I1206_gn11 I1206_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I132_XG_MN2 (XI1206_I132_XG_n1 I1206_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I132_XG_MN0 (I1206_G7_0 I1206_P7_4n XI1206_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I132_XG_MN1 (XI1206_I132_XG_n1 I1206_G3_0n I1206_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I135_XG_MN2 (XI1206_I135_XG_n1 I1206_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I135_XG_MN0 (I1206_G10_3 I1206_P10_7n XI1206_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I135_XG_MN1 (XI1206_I135_XG_n1 I1206_G6_3n I1206_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I183_XG_MN2 (XI1206_I183_XG_n1 I1206_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I183_XG_MN0 (I1206_G16_0 I1206_P16_1n XI1206_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I183_XG_MN1 (XI1206_I183_XG_n1 I1206_G0_0n I1206_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I80_XG_MN2 (XI1252_I80_XG_n1 I1252_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I80_XG_MN0 (I1252_G14_13 I1252_pn14 XI1252_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I80_XG_MN1 (XI1252_I80_XG_n1 I1252_gn13 I1252_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I81_XG_MN2 (XI1252_I81_XG_n1 I1252_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I81_XG_MN0 (I1252_G15_14 I1252_pn15 XI1252_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I81_XG_MN1 (XI1252_I81_XG_n1 I1252_gn14 I1252_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I139_XG_MN2 (XI1252_I139_XG_n1 I1252_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I139_XG_MN0 (I1252_G14_7 I1252_P14_11n XI1252_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I139_XG_MN1 (XI1252_I139_XG_n1 I1252_G10_7n I1252_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I145_XG_MN2 (XI1252_I145_XG_n1 I1252_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I145_XG_MN0 (I1252_G20_13 I1252_P20_17n XI1252_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I145_XG_MN1 (XI1252_I145_XG_n1 I1252_G16_13n I1252_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I188_XG_MN2 (XI1252_I188_XG_n1 I1252_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I188_XG_MN0 (I1252_G20_0 I1252_P20_5n XI1252_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I188_XG_MN1 (XI1252_I188_XG_n1 I1252_G4_0n I1252_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I142_XG_MN2 (XI1252_I142_XG_n1 I1252_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I142_XG_MN0 (I1252_G17_10 I1252_P17_14n XI1252_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I142_XG_MN1 (XI1252_I142_XG_n1 I1252_G13_10n I1252_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I196_XG_MN2 (XI1252_I196_XG_n1 I1252_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I196_XG_MN0 (I1252_G25_0 I1252_P25_10n XI1252_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I196_XG_MN1 (XI1252_I196_XG_n1 I1252_G9_0n I1252_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I82_XG_MN2 (XI1298_I82_XG_n1 I1298_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I82_XG_MN0 (I1298_G16_15 I1298_pn16 XI1298_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I82_XG_MN1 (XI1298_I82_XG_n1 I1298_gn15 I1298_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I145_XG_MN2 (XI1298_I145_XG_n1 I1298_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I145_XG_MN0 (I1298_G20_13 I1298_P20_17n XI1298_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I145_XG_MN1 (XI1298_I145_XG_n1 I1298_G16_13n I1298_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I188_XG_MN2 (XI1298_I188_XG_n1 I1298_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I188_XG_MN0 (I1298_G20_0 I1298_P20_5n XI1298_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I188_XG_MN1 (XI1298_I188_XG_n1 I1298_G4_0n I1298_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I149_XG_MN2 (XI1344_I149_XG_n1 I1344_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I149_XG_MN0 (I1344_G24_17 I1344_P24_21n XI1344_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I149_XG_MN1 (XI1344_I149_XG_n1 I1344_G20_17n I1344_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I83_XG_MN2 (XI1344_I83_XG_n1 I1344_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I83_XG_MN0 (I1344_G17_16 I1344_pn17 XI1344_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I83_XG_MN1 (XI1344_I83_XG_n1 I1344_gn16 I1344_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I140_XG_MN2 (XI1344_I140_XG_n1 I1344_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I140_XG_MN0 (I1344_G15_8 I1344_P15_12n XI1344_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I140_XG_MN1 (XI1344_I140_XG_n1 I1344_G11_8n I1344_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I82_XG_MN2 (XI1390_I82_XG_n1 I1390_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I82_XG_MN0 (I1390_G16_15 I1390_pn16 XI1390_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I82_XG_MN1 (XI1390_I82_XG_n1 I1390_gn15 I1390_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I83_XG_MN2 (XI1390_I83_XG_n1 I1390_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I83_XG_MN0 (I1390_G17_16 I1390_pn17 XI1390_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I83_XG_MN1 (XI1390_I83_XG_n1 I1390_gn16 I1390_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I145_XG_MN2 (XI1390_I145_XG_n1 I1390_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I145_XG_MN0 (I1390_G20_13 I1390_P20_17n XI1390_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I145_XG_MN1 (XI1390_I145_XG_n1 I1390_G16_13n I1390_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I197_XG_MN2 (XI1390_I197_XG_n1 I1390_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I197_XG_MN0 (I1390_G26_0 I1390_P26_11n XI1390_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I197_XG_MN1 (XI1390_I197_XG_n1 I1390_G10_0n I1390_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I144_XG_MN2 (XI1390_I144_XG_n1 I1390_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I144_XG_MN0 (I1390_G19_12 I1390_P19_16n XI1390_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I144_XG_MN1 (XI1390_I144_XG_n1 I1390_G15_12n I1390_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I82_XG_MN2 (XI1436_I82_XG_n1 I1436_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I82_XG_MN0 (I1436_G16_15 I1436_pn16 XI1436_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I82_XG_MN1 (XI1436_I82_XG_n1 I1436_gn15 I1436_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I83_XG_MN2 (XI1436_I83_XG_n1 I1436_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I83_XG_MN0 (I1436_G17_16 I1436_pn17 XI1436_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I83_XG_MN1 (XI1436_I83_XG_n1 I1436_gn16 I1436_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I145_XG_MN2 (XI1436_I145_XG_n1 I1436_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I145_XG_MN0 (I1436_G20_13 I1436_P20_17n XI1436_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I145_XG_MN1 (XI1436_I145_XG_n1 I1436_G16_13n I1436_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I140_XG_MN2 (XI1436_I140_XG_n1 I1436_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I140_XG_MN0 (I1436_G15_8 I1436_P15_12n XI1436_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I140_XG_MN1 (XI1436_I140_XG_n1 I1436_G11_8n I1436_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I82_XG_MN2 (XI1482_I82_XG_n1 I1482_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I82_XG_MN0 (I1482_G16_15 I1482_pn16 XI1482_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I82_XG_MN1 (XI1482_I82_XG_n1 I1482_gn15 I1482_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I83_XG_MN2 (XI1482_I83_XG_n1 I1482_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I83_XG_MN0 (I1482_G17_16 I1482_pn17 XI1482_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I83_XG_MN1 (XI1482_I83_XG_n1 I1482_gn16 I1482_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I140_XG_MN2 (XI1482_I140_XG_n1 I1482_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I140_XG_MN0 (I1482_G15_8 I1482_P15_12n XI1482_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I140_XG_MN1 (XI1482_I140_XG_n1 I1482_G11_8n I1482_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I142_XG_MN2 (XI1482_I142_XG_n1 I1482_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I142_XG_MN0 (I1482_G17_10 I1482_P17_14n XI1482_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I142_XG_MN1 (XI1482_I142_XG_n1 I1482_G13_10n I1482_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I145_XG_MN2 (XI1482_I145_XG_n1 I1482_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I145_XG_MN0 (I1482_G20_13 I1482_P20_17n XI1482_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I145_XG_MN1 (XI1482_I145_XG_n1 I1482_G16_13n I1482_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I143_XG_MN2 (XI1482_I143_XG_n1 I1482_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I143_XG_MN0 (I1482_G18_11 I1482_P18_15n XI1482_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I143_XG_MN1 (XI1482_I143_XG_n1 I1482_G14_11n I1482_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I86_XG_MN2 (XI1528_I86_XG_n1 I1528_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I86_XG_MN0 (I1528_G20_19 I1528_pn20 XI1528_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I86_XG_MN1 (XI1528_I86_XG_n1 I1528_gn19 I1528_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I87_XG_MN2 (XI1528_I87_XG_n1 I1528_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I87_XG_MN0 (I1528_G21_20 I1528_pn21 XI1528_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I87_XG_MN1 (XI1528_I87_XG_n1 I1528_gn20 I1528_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I201_XG_MN2 (XI1528_I201_XG_n1 I1528_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I201_XG_MN0 (c21_m I1528_P30_15n XI1528_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I201_XG_MN1 (XI1528_I201_XG_n1 I1528_G14_0n c21_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I151_XG_MN2 (XI1528_I151_XG_n1 I1528_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I151_XG_MN0 (I1528_G26_19 I1528_P26_23n XI1528_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I151_XG_MN1 (XI1528_I151_XG_n1 I1528_G22_19n I1528_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I148_XG_MN2 (XI1528_I148_XG_n1 I1528_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I148_XG_MN0 (I1528_G23_16 I1528_P23_20n XI1528_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I148_XG_MN1 (XI1528_I148_XG_n1 I1528_G19_16n I1528_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I153_XG_MN2 (XI1160_I153_XG_n1 I1160_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I153_XG_MN0 (I1160_G28_21 I1160_P28_25n XI1160_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I153_XG_MN1 (XI1160_I153_XG_n1 I1160_G24_21n I1160_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I151_XG_MN2 (XI1160_I151_XG_n1 I1160_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I151_XG_MN0 (I1160_G26_19 I1160_P26_23n XI1160_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I151_XG_MN1 (XI1160_I151_XG_n1 I1160_G22_19n I1160_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I147_XG_MN2 (XI1160_I147_XG_n1 I1160_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I147_XG_MN0 (I1160_G22_15 I1160_P22_19n XI1160_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I147_XG_MN1 (XI1160_I147_XG_n1 I1160_G18_15n I1160_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I199_XG_MN2 (XI1160_I199_XG_n1 I1160_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I199_XG_MN0 (I1160_G28_0 I1160_P28_13n XI1160_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I199_XG_MN1 (XI1160_I199_XG_n1 I1160_G12_0n I1160_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I143_XG_MN2 (XI1160_I143_XG_n1 I1160_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I143_XG_MN0 (I1160_G18_11 I1160_P18_15n XI1160_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I143_XG_MN1 (XI1160_I143_XG_n1 I1160_G14_11n I1160_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I139_XG_MN2 (XI1160_I139_XG_n1 I1160_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I139_XG_MN0 (I1160_G14_7 I1160_P14_11n XI1160_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I139_XG_MN1 (XI1160_I139_XG_n1 I1160_G10_7n I1160_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I135_XG_MN2 (XI1160_I135_XG_n1 I1160_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I135_XG_MN0 (I1160_G10_3 I1160_P10_7n XI1160_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I135_XG_MN1 (XI1160_I135_XG_n1 I1160_G6_3n I1160_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I80_XG_MN2 (XI1206_I80_XG_n1 I1206_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I80_XG_MN0 (I1206_G14_13 I1206_pn14 XI1206_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I80_XG_MN1 (XI1206_I80_XG_n1 I1206_gn13 I1206_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I79_XG_MN2 (XI1206_I79_XG_n1 I1206_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I79_XG_MN0 (I1206_G13_12 I1206_pn13 XI1206_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I79_XG_MN1 (XI1206_I79_XG_n1 I1206_gn12 I1206_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I134_XG_MN2 (XI1206_I134_XG_n1 I1206_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I134_XG_MN0 (I1206_G9_2 I1206_P9_6n XI1206_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I134_XG_MN1 (XI1206_I134_XG_n1 I1206_G5_2n I1206_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I130_XG_MN2 (XI1206_I130_XG_n1 I1206_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I130_XG_MN0 (I1206_G5_0 I1206_P5_2n XI1206_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I130_XG_MN1 (XI1206_I130_XG_n1 I1206_G1_0n I1206_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I141_XG_MN2 (XI1206_I141_XG_n1 I1206_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I141_XG_MN0 (I1206_G16_9 I1206_P16_13n XI1206_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I141_XG_MN1 (XI1206_I141_XG_n1 I1206_G12_9n I1206_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I137_XG_MN2 (XI1206_I137_XG_n1 I1206_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I137_XG_MN0 (I1206_G12_5 I1206_P12_9n XI1206_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I137_XG_MN1 (XI1206_I137_XG_n1 I1206_G8_5n I1206_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I83_XG_MN2 (XI1252_I83_XG_n1 I1252_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I83_XG_MN0 (I1252_G17_16 I1252_pn17 XI1252_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I83_XG_MN1 (XI1252_I83_XG_n1 I1252_gn16 I1252_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I82_XG_MN2 (XI1252_I82_XG_n1 I1252_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I82_XG_MN0 (I1252_G16_15 I1252_pn16 XI1252_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I82_XG_MN1 (XI1252_I82_XG_n1 I1252_gn15 I1252_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I149_XG_MN2 (XI1252_I149_XG_n1 I1252_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I149_XG_MN0 (I1252_G24_17 I1252_P24_21n XI1252_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I149_XG_MN1 (XI1252_I149_XG_n1 I1252_G20_17n I1252_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I143_XG_MN2 (XI1252_I143_XG_n1 I1252_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I143_XG_MN0 (I1252_G18_11 I1252_P18_15n XI1252_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I143_XG_MN1 (XI1252_I143_XG_n1 I1252_G14_11n I1252_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I140_XG_MN2 (XI1252_I140_XG_n1 I1252_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I140_XG_MN0 (I1252_G15_8 I1252_P15_12n XI1252_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I140_XG_MN1 (XI1252_I140_XG_n1 I1252_G11_8n I1252_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I83_XG_MN2 (XI1298_I83_XG_n1 I1298_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I83_XG_MN0 (I1298_G17_16 I1298_pn17 XI1298_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I83_XG_MN1 (XI1298_I83_XG_n1 I1298_gn16 I1298_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I84_XG_MN2 (XI1298_I84_XG_n1 I1298_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I84_XG_MN0 (I1298_G18_17 I1298_pn18 XI1298_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I84_XG_MN1 (XI1298_I84_XG_n1 I1298_gn17 I1298_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I149_XG_MN2 (XI1298_I149_XG_n1 I1298_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I149_XG_MN0 (I1298_G24_17 I1298_P24_21n XI1298_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I149_XG_MN1 (XI1298_I149_XG_n1 I1298_G20_17n I1298_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I197_XG_MN2 (XI1298_I197_XG_n1 I1298_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I197_XG_MN0 (I1298_G26_0 I1298_P26_11n XI1298_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I197_XG_MN1 (XI1298_I197_XG_n1 I1298_G10_0n I1298_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I144_XG_MN2 (XI1298_I144_XG_n1 I1298_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I144_XG_MN0 (I1298_G19_12 I1298_P19_16n XI1298_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I144_XG_MN1 (XI1298_I144_XG_n1 I1298_G15_12n I1298_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I190_XG_MN2 (XI1298_I190_XG_n1 I1298_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I190_XG_MN0 (I1298_G21_0 I1298_P21_6n XI1298_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I190_XG_MN1 (XI1298_I190_XG_n1 I1298_G5_0n I1298_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I192_XG_MN2 (XI1344_I192_XG_n1 I1344_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I192_XG_MN0 (I1344_G22_0 I1344_P22_7n XI1344_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I192_XG_MN1 (XI1344_I192_XG_n1 I1344_G6_0n I1344_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I85_XG_MN2 (XI1344_I85_XG_n1 I1344_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I85_XG_MN0 (I1344_G19_18 I1344_pn19 XI1344_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I85_XG_MN1 (XI1344_I85_XG_n1 I1344_gn18 I1344_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I84_XG_MN2 (XI1344_I84_XG_n1 I1344_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I84_XG_MN0 (I1344_G18_17 I1344_pn18 XI1344_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I84_XG_MN1 (XI1344_I84_XG_n1 I1344_gn17 I1344_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I146_XG_MN2 (XI1344_I146_XG_n1 I1344_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I146_XG_MN0 (I1344_G21_14 I1344_P21_18n XI1344_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I146_XG_MN1 (XI1344_I146_XG_n1 I1344_G17_14n I1344_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I144_XG_MN2 (XI1344_I144_XG_n1 I1344_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I144_XG_MN0 (I1344_G19_12 I1344_P19_16n XI1344_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I144_XG_MN1 (XI1344_I144_XG_n1 I1344_G15_12n I1344_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I85_XG_MN2 (XI1390_I85_XG_n1 I1390_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I85_XG_MN0 (I1390_G19_18 I1390_pn19 XI1390_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I85_XG_MN1 (XI1390_I85_XG_n1 I1390_gn18 I1390_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I84_XG_MN2 (XI1390_I84_XG_n1 I1390_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I84_XG_MN0 (I1390_G18_17 I1390_pn18 XI1390_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I84_XG_MN1 (XI1390_I84_XG_n1 I1390_gn17 I1390_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I149_XG_MN2 (XI1390_I149_XG_n1 I1390_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I149_XG_MN0 (I1390_G24_17 I1390_P24_21n XI1390_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I149_XG_MN1 (XI1390_I149_XG_n1 I1390_G20_17n I1390_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I192_XG_MN2 (XI1390_I192_XG_n1 I1390_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I192_XG_MN0 (I1390_G22_0 I1390_P22_7n XI1390_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I192_XG_MN1 (XI1390_I192_XG_n1 I1390_G6_0n I1390_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I146_XG_MN2 (XI1390_I146_XG_n1 I1390_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I146_XG_MN0 (I1390_G21_14 I1390_P21_18n XI1390_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I146_XG_MN1 (XI1390_I146_XG_n1 I1390_G17_14n I1390_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I190_XG_MN2 (XI1390_I190_XG_n1 I1390_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I190_XG_MN0 (I1390_G21_0 I1390_P21_6n XI1390_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I190_XG_MN1 (XI1390_I190_XG_n1 I1390_G5_0n I1390_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I84_XG_MN2 (XI1436_I84_XG_n1 I1436_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I84_XG_MN0 (I1436_G18_17 I1436_pn18 XI1436_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I84_XG_MN1 (XI1436_I84_XG_n1 I1436_gn17 I1436_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I85_XG_MN2 (XI1436_I85_XG_n1 I1436_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I85_XG_MN0 (I1436_G19_18 I1436_pn19 XI1436_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I85_XG_MN1 (XI1436_I85_XG_n1 I1436_gn18 I1436_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I149_XG_MN2 (XI1436_I149_XG_n1 I1436_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I149_XG_MN0 (I1436_G24_17 I1436_P24_21n XI1436_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I149_XG_MN1 (XI1436_I149_XG_n1 I1436_G20_17n I1436_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I197_XG_MN2 (XI1436_I197_XG_n1 I1436_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I197_XG_MN0 (I1436_G26_0 I1436_P26_11n XI1436_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I197_XG_MN1 (XI1436_I197_XG_n1 I1436_G10_0n I1436_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I144_XG_MN2 (XI1436_I144_XG_n1 I1436_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I144_XG_MN0 (I1436_G19_12 I1436_P19_16n XI1436_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I144_XG_MN1 (XI1436_I144_XG_n1 I1436_G15_12n I1436_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I84_XG_MN2 (XI1482_I84_XG_n1 I1482_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I84_XG_MN0 (I1482_G18_17 I1482_pn18 XI1482_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I84_XG_MN1 (XI1482_I84_XG_n1 I1482_gn17 I1482_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I186_XG_MN2 (XI1482_I186_XG_n1 I1482_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I186_XG_MN0 (I1482_G19_0 I1482_P19_4n XI1482_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I186_XG_MN1 (XI1482_I186_XG_n1 I1482_G3_0n I1482_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I195_XG_MN2 (XI1482_I195_XG_n1 I1482_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I195_XG_MN0 (I1482_G24_0 I1482_P24_9n XI1482_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I195_XG_MN1 (XI1482_I195_XG_n1 I1482_G8_0n I1482_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I197_XG_MN2 (XI1482_I197_XG_n1 I1482_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I197_XG_MN0 (I1482_G26_0 I1482_P26_11n XI1482_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I197_XG_MN1 (XI1482_I197_XG_n1 I1482_G10_0n I1482_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I88_XG_MN2 (XI1528_I88_XG_n1 I1528_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I88_XG_MN0 (I1528_G22_21 I1528_pn22 XI1528_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I88_XG_MN1 (XI1528_I88_XG_n1 I1528_gn21 I1528_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I153_XG_MN2 (XI1528_I153_XG_n1 I1528_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I153_XG_MN0 (I1528_G28_21 I1528_P28_25n XI1528_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I153_XG_MN1 (XI1528_I153_XG_n1 I1528_G24_21n I1528_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I202_XG_MN2 (XI1528_I202_XG_n1 I1528_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I202_XG_MN0 (c21_o I1528_P31_16n XI1528_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I202_XG_MN1 (XI1528_I202_XG_n1 I1528_G15_0n c21_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I152_XG_MN2 (XI1528_I152_XG_n1 I1528_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I152_XG_MN0 (I1528_G27_20 I1528_P27_24n XI1528_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I152_XG_MN1 (XI1528_I152_XG_n1 I1528_G23_20n I1528_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I154_XG_MN2 (XI1528_I154_XG_n1 I1528_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I154_XG_MN0 (I1528_G29_22 I1528_P29_26n XI1528_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I154_XG_MN1 (XI1528_I154_XG_n1 I1528_G25_22n I1528_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I94_XG_MN2 (XI1160_I94_XG_n1 I1160_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I94_XG_MN0 (I1160_G28_27 I1160_pn28 XI1160_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I94_XG_MN1 (XI1160_I94_XG_n1 I1160_gn27 I1160_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I93_XG_MN2 (XI1160_I93_XG_n1 I1160_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I93_XG_MN0 (I1160_G27_26 I1160_pn27 XI1160_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I93_XG_MN1 (XI1160_I93_XG_n1 I1160_gn26 I1160_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I92_XG_MN2 (XI1160_I92_XG_n1 I1160_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I92_XG_MN0 (I1160_G26_25 I1160_pn26 XI1160_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I92_XG_MN1 (XI1160_I92_XG_n1 I1160_gn25 I1160_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I155_XG_MN2 (XI1160_I155_XG_n1 I1160_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I155_XG_MN0 (I1160_G30_23 I1160_P30_27n XI1160_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I155_XG_MN1 (XI1160_I155_XG_n1 I1160_G26_23n I1160_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I197_XG_MN2 (XI1160_I197_XG_n1 I1160_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I197_XG_MN0 (I1160_G26_0 I1160_P26_11n XI1160_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I197_XG_MN1 (XI1160_I197_XG_n1 I1160_G10_0n I1160_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I185_XG_MN2 (XI1160_I185_XG_n1 I1160_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I185_XG_MN0 (I1160_G18_0 I1160_P18_3n XI1160_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I185_XG_MN1 (XI1160_I185_XG_n1 I1160_G2_0n I1160_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I82_XG_MN2 (XI1206_I82_XG_n1 I1206_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I82_XG_MN0 (I1206_G16_15 I1206_pn16 XI1206_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I82_XG_MN1 (XI1206_I82_XG_n1 I1206_gn15 I1206_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I81_XG_MN2 (XI1206_I81_XG_n1 I1206_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I81_XG_MN0 (I1206_G15_14 I1206_pn15 XI1206_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I81_XG_MN1 (XI1206_I81_XG_n1 I1206_gn14 I1206_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I138_XG_MN2 (XI1206_I138_XG_n1 I1206_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I138_XG_MN0 (I1206_G13_6 I1206_P13_10n XI1206_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I138_XG_MN1 (XI1206_I138_XG_n1 I1206_G9_6n I1206_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I136_XG_MN2 (XI1206_I136_XG_n1 I1206_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I136_XG_MN0 (I1206_G11_4 I1206_P11_8n XI1206_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I136_XG_MN1 (XI1206_I136_XG_n1 I1206_G7_4n I1206_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I184_XG_MN2 (XI1206_I184_XG_n1 I1206_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I184_XG_MN0 (I1206_G17_0 I1206_P17_2n XI1206_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I184_XG_MN1 (XI1206_I184_XG_n1 I1206_G1_0n I1206_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I139_XG_MN2 (XI1206_I139_XG_n1 I1206_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I139_XG_MN0 (I1206_G14_7 I1206_P14_11n XI1206_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I139_XG_MN1 (XI1206_I139_XG_n1 I1206_G10_7n I1206_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I185_XG_MN2 (XI1206_I185_XG_n1 I1206_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I185_XG_MN0 (I1206_G18_0 I1206_P18_3n XI1206_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I185_XG_MN1 (XI1206_I185_XG_n1 I1206_G2_0n I1206_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I85_XG_MN2 (XI1252_I85_XG_n1 I1252_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I85_XG_MN0 (I1252_G19_18 I1252_pn19 XI1252_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I85_XG_MN1 (XI1252_I85_XG_n1 I1252_gn18 I1252_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I84_XG_MN2 (XI1252_I84_XG_n1 I1252_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I84_XG_MN0 (I1252_G18_17 I1252_pn18 XI1252_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I84_XG_MN1 (XI1252_I84_XG_n1 I1252_gn17 I1252_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I86_XG_MN2 (XI1252_I86_XG_n1 I1252_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I86_XG_MN0 (I1252_G20_19 I1252_pn20 XI1252_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I86_XG_MN1 (XI1252_I86_XG_n1 I1252_gn19 I1252_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I197_XG_MN2 (XI1252_I197_XG_n1 I1252_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I197_XG_MN0 (I1252_G26_0 I1252_P26_11n XI1252_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I197_XG_MN1 (XI1252_I197_XG_n1 I1252_G10_0n I1252_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I146_XG_MN2 (XI1252_I146_XG_n1 I1252_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I146_XG_MN0 (I1252_G21_14 I1252_P21_18n XI1252_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I146_XG_MN1 (XI1252_I146_XG_n1 I1252_G17_14n I1252_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I144_XG_MN2 (XI1252_I144_XG_n1 I1252_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I144_XG_MN0 (I1252_G19_12 I1252_P19_16n XI1252_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I144_XG_MN1 (XI1252_I144_XG_n1 I1252_G15_12n I1252_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I190_XG_MN2 (XI1252_I190_XG_n1 I1252_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I190_XG_MN0 (I1252_G21_0 I1252_P21_6n XI1252_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I190_XG_MN1 (XI1252_I190_XG_n1 I1252_G5_0n I1252_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I86_XG_MN2 (XI1298_I86_XG_n1 I1298_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I86_XG_MN0 (I1298_G20_19 I1298_pn20 XI1298_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I86_XG_MN1 (XI1298_I86_XG_n1 I1298_gn19 I1298_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I85_XG_MN2 (XI1298_I85_XG_n1 I1298_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I85_XG_MN0 (I1298_G19_18 I1298_pn19 XI1298_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I85_XG_MN1 (XI1298_I85_XG_n1 I1298_gn18 I1298_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I147_XG_MN2 (XI1298_I147_XG_n1 I1298_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I147_XG_MN0 (I1298_G22_15 I1298_P22_19n XI1298_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I147_XG_MN1 (XI1298_I147_XG_n1 I1298_G18_15n I1298_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I192_XG_MN2 (XI1298_I192_XG_n1 I1298_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I192_XG_MN0 (I1298_G22_0 I1298_P22_7n XI1298_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I192_XG_MN1 (XI1298_I192_XG_n1 I1298_G6_0n I1298_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I146_XG_MN2 (XI1298_I146_XG_n1 I1298_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I146_XG_MN0 (I1298_G21_14 I1298_P21_18n XI1298_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I146_XG_MN1 (XI1298_I146_XG_n1 I1298_G17_14n I1298_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I196_XG_MN2 (XI1298_I196_XG_n1 I1298_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I196_XG_MN0 (I1298_G25_0 I1298_P25_10n XI1298_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I196_XG_MN1 (XI1298_I196_XG_n1 I1298_G9_0n I1298_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I151_XG_MN2 (XI1344_I151_XG_n1 I1344_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I151_XG_MN0 (I1344_G26_19 I1344_P26_23n XI1344_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I151_XG_MN1 (XI1344_I151_XG_n1 I1344_G22_19n I1344_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I147_XG_MN2 (XI1344_I147_XG_n1 I1344_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I147_XG_MN0 (I1344_G22_15 I1344_P22_19n XI1344_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I147_XG_MN1 (XI1344_I147_XG_n1 I1344_G18_15n I1344_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I86_XG_MN2 (XI1344_I86_XG_n1 I1344_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I86_XG_MN0 (I1344_G20_19 I1344_pn20 XI1344_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I86_XG_MN1 (XI1344_I86_XG_n1 I1344_gn19 I1344_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I150_XG_MN2 (XI1344_I150_XG_n1 I1344_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I150_XG_MN0 (I1344_G25_18 I1344_P25_22n XI1344_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I150_XG_MN1 (XI1344_I150_XG_n1 I1344_G21_18n I1344_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I198_XG_MN2 (XI1344_I198_XG_n1 I1344_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I198_XG_MN0 (I1344_G27_0 I1344_P27_12n XI1344_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I198_XG_MN1 (XI1344_I198_XG_n1 I1344_G11_0n I1344_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I190_XG_MN2 (XI1344_I190_XG_n1 I1344_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I190_XG_MN0 (I1344_G21_0 I1344_P21_6n XI1344_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I190_XG_MN1 (XI1344_I190_XG_n1 I1344_G5_0n I1344_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I86_XG_MN2 (XI1390_I86_XG_n1 I1390_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I86_XG_MN0 (I1390_G20_19 I1390_pn20 XI1390_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I86_XG_MN1 (XI1390_I86_XG_n1 I1390_gn19 I1390_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I147_XG_MN2 (XI1390_I147_XG_n1 I1390_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I147_XG_MN0 (I1390_G22_15 I1390_P22_19n XI1390_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I147_XG_MN1 (XI1390_I147_XG_n1 I1390_G18_15n I1390_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I151_XG_MN2 (XI1390_I151_XG_n1 I1390_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I151_XG_MN0 (I1390_G26_19 I1390_P26_23n XI1390_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I151_XG_MN1 (XI1390_I151_XG_n1 I1390_G22_19n I1390_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I199_XG_MN2 (XI1390_I199_XG_n1 I1390_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I199_XG_MN0 (I1390_G28_0 I1390_P28_13n XI1390_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I199_XG_MN1 (XI1390_I199_XG_n1 I1390_G12_0n I1390_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I150_XG_MN2 (XI1390_I150_XG_n1 I1390_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I150_XG_MN0 (I1390_G25_18 I1390_P25_22n XI1390_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I150_XG_MN1 (XI1390_I150_XG_n1 I1390_G21_18n I1390_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I198_XG_MN2 (XI1390_I198_XG_n1 I1390_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I198_XG_MN0 (I1390_G27_0 I1390_P27_12n XI1390_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I198_XG_MN1 (XI1390_I198_XG_n1 I1390_G11_0n I1390_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I86_XG_MN2 (XI1436_I86_XG_n1 I1436_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I86_XG_MN0 (I1436_G20_19 I1436_pn20 XI1436_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I86_XG_MN1 (XI1436_I86_XG_n1 I1436_gn19 I1436_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I147_XG_MN2 (XI1436_I147_XG_n1 I1436_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I147_XG_MN0 (I1436_G22_15 I1436_P22_19n XI1436_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I147_XG_MN1 (XI1436_I147_XG_n1 I1436_G18_15n I1436_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I151_XG_MN2 (XI1436_I151_XG_n1 I1436_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I151_XG_MN0 (I1436_G26_19 I1436_P26_23n XI1436_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I151_XG_MN1 (XI1436_I151_XG_n1 I1436_G22_19n I1436_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I192_XG_MN2 (XI1436_I192_XG_n1 I1436_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I192_XG_MN0 (I1436_G22_0 I1436_P22_7n XI1436_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I192_XG_MN1 (XI1436_I192_XG_n1 I1436_G6_0n I1436_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I146_XG_MN2 (XI1436_I146_XG_n1 I1436_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I146_XG_MN0 (I1436_G21_14 I1436_P21_18n XI1436_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I146_XG_MN1 (XI1436_I146_XG_n1 I1436_G17_14n I1436_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I190_XG_MN2 (XI1436_I190_XG_n1 I1436_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I190_XG_MN0 (I1436_G21_0 I1436_P21_6n XI1436_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I190_XG_MN1 (XI1436_I190_XG_n1 I1436_G5_0n I1436_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I86_XG_MN2 (XI1482_I86_XG_n1 I1482_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I86_XG_MN0 (I1482_G20_19 I1482_pn20 XI1482_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I86_XG_MN1 (XI1482_I86_XG_n1 I1482_gn19 I1482_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I85_XG_MN2 (XI1482_I85_XG_n1 I1482_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I85_XG_MN0 (I1482_G19_18 I1482_pn19 XI1482_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I85_XG_MN1 (XI1482_I85_XG_n1 I1482_gn18 I1482_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I144_XG_MN2 (XI1482_I144_XG_n1 I1482_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I144_XG_MN0 (I1482_G19_12 I1482_P19_16n XI1482_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I144_XG_MN1 (XI1482_I144_XG_n1 I1482_G15_12n I1482_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I190_XG_MN2 (XI1482_I190_XG_n1 I1482_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I190_XG_MN0 (I1482_G21_0 I1482_P21_6n XI1482_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I190_XG_MN1 (XI1482_I190_XG_n1 I1482_G5_0n I1482_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I149_XG_MN2 (XI1482_I149_XG_n1 I1482_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I149_XG_MN0 (I1482_G24_17 I1482_P24_21n XI1482_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I149_XG_MN1 (XI1482_I149_XG_n1 I1482_G20_17n I1482_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I147_XG_MN2 (XI1482_I147_XG_n1 I1482_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I147_XG_MN0 (I1482_G22_15 I1482_P22_19n XI1482_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I147_XG_MN1 (XI1482_I147_XG_n1 I1482_G18_15n I1482_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I192_XG_MN2 (XI1482_I192_XG_n1 I1482_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I192_XG_MN0 (I1482_G22_0 I1482_P22_7n XI1482_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I192_XG_MN1 (XI1482_I192_XG_n1 I1482_G6_0n I1482_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I89_XG_MN2 (XI1528_I89_XG_n1 I1528_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I89_XG_MN0 (I1528_G23_22 I1528_pn23 XI1528_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I89_XG_MN1 (XI1528_I89_XG_n1 I1528_gn22 I1528_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I90_XG_MN2 (XI1528_I90_XG_n1 I1528_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I90_XG_MN0 (I1528_G24_23 I1528_pn24 XI1528_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I90_XG_MN1 (XI1528_I90_XG_n1 I1528_gn23 I1528_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I155_XG_MN2 (XI1528_I155_XG_n1 I1528_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I155_XG_MN0 (I1528_G30_23 I1528_P30_27n XI1528_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I155_XG_MN1 (XI1528_I155_XG_n1 I1528_G26_23n I1528_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I156_XG_MN2 (XI1528_I156_XG_n1 I1528_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I156_XG_MN0 (I1528_G31_24 I1528_P31_28n XI1528_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I156_XG_MN1 (XI1528_I156_XG_n1 I1528_G27_24n I1528_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I201_XG_MN2 (XI1160_I201_XG_n1 I1160_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I201_XG_MN0 (c13_m I1160_P30_15n XI1160_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I201_XG_MN1 (XI1160_I201_XG_n1 I1160_G14_0n c13_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1160_I192_XG_MN2 (XI1160_I192_XG_n1 I1160_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1160_I192_XG_MN0 (I1160_G22_0 I1160_P22_7n XI1160_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1160_I192_XG_MN1 (XI1160_I192_XG_n1 I1160_G6_0n I1160_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I84_XG_MN2 (XI1206_I84_XG_n1 I1206_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I84_XG_MN0 (I1206_G18_17 I1206_pn18 XI1206_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I84_XG_MN1 (XI1206_I84_XG_n1 I1206_gn17 I1206_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I83_XG_MN2 (XI1206_I83_XG_n1 I1206_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I83_XG_MN0 (I1206_G17_16 I1206_pn17 XI1206_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I83_XG_MN1 (XI1206_I83_XG_n1 I1206_gn16 I1206_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I140_XG_MN2 (XI1206_I140_XG_n1 I1206_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I140_XG_MN0 (I1206_G15_8 I1206_P15_12n XI1206_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I140_XG_MN1 (XI1206_I140_XG_n1 I1206_G11_8n I1206_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I142_XG_MN2 (XI1206_I142_XG_n1 I1206_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I142_XG_MN0 (I1206_G17_10 I1206_P17_14n XI1206_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I142_XG_MN1 (XI1206_I142_XG_n1 I1206_G13_10n I1206_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I186_XG_MN2 (XI1206_I186_XG_n1 I1206_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I186_XG_MN0 (I1206_G19_0 I1206_P19_4n XI1206_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I186_XG_MN1 (XI1206_I186_XG_n1 I1206_G3_0n I1206_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I143_XG_MN2 (XI1206_I143_XG_n1 I1206_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I143_XG_MN0 (I1206_G18_11 I1206_P18_15n XI1206_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I143_XG_MN1 (XI1206_I143_XG_n1 I1206_G14_11n I1206_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I188_XG_MN2 (XI1206_I188_XG_n1 I1206_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I188_XG_MN0 (I1206_G20_0 I1206_P20_5n XI1206_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I188_XG_MN1 (XI1206_I188_XG_n1 I1206_G4_0n I1206_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I87_XG_MN2 (XI1252_I87_XG_n1 I1252_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I87_XG_MN0 (I1252_G21_20 I1252_pn21 XI1252_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I87_XG_MN1 (XI1252_I87_XG_n1 I1252_gn20 I1252_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I147_XG_MN2 (XI1252_I147_XG_n1 I1252_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I147_XG_MN0 (I1252_G22_15 I1252_P22_19n XI1252_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I147_XG_MN1 (XI1252_I147_XG_n1 I1252_G18_15n I1252_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I151_XG_MN2 (XI1252_I151_XG_n1 I1252_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I151_XG_MN0 (I1252_G26_19 I1252_P26_23n XI1252_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I151_XG_MN1 (XI1252_I151_XG_n1 I1252_G22_19n I1252_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I192_XG_MN2 (XI1252_I192_XG_n1 I1252_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I192_XG_MN0 (I1252_G22_0 I1252_P22_7n XI1252_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I192_XG_MN1 (XI1252_I192_XG_n1 I1252_G6_0n I1252_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I150_XG_MN2 (XI1252_I150_XG_n1 I1252_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I150_XG_MN0 (I1252_G25_18 I1252_P25_22n XI1252_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I150_XG_MN1 (XI1252_I150_XG_n1 I1252_G21_18n I1252_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I198_XG_MN2 (XI1252_I198_XG_n1 I1252_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I198_XG_MN0 (I1252_G27_0 I1252_P27_12n XI1252_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I198_XG_MN1 (XI1252_I198_XG_n1 I1252_G11_0n I1252_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I88_XG_MN2 (XI1298_I88_XG_n1 I1298_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I88_XG_MN0 (I1298_G22_21 I1298_pn22 XI1298_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I88_XG_MN1 (XI1298_I88_XG_n1 I1298_gn21 I1298_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I87_XG_MN2 (XI1298_I87_XG_n1 I1298_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I87_XG_MN0 (I1298_G21_20 I1298_pn21 XI1298_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I87_XG_MN1 (XI1298_I87_XG_n1 I1298_gn20 I1298_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I151_XG_MN2 (XI1298_I151_XG_n1 I1298_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I151_XG_MN0 (I1298_G26_19 I1298_P26_23n XI1298_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I151_XG_MN1 (XI1298_I151_XG_n1 I1298_G22_19n I1298_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I199_XG_MN2 (XI1298_I199_XG_n1 I1298_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I199_XG_MN0 (I1298_G28_0 I1298_P28_13n XI1298_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I199_XG_MN1 (XI1298_I199_XG_n1 I1298_G12_0n I1298_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I150_XG_MN2 (XI1298_I150_XG_n1 I1298_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I150_XG_MN0 (I1298_G25_18 I1298_P25_22n XI1298_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I150_XG_MN1 (XI1298_I150_XG_n1 I1298_G21_18n I1298_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I194_XG_MN2 (XI1298_I194_XG_n1 I1298_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I194_XG_MN0 (I1298_G23_0 I1298_P23_8n XI1298_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I194_XG_MN1 (XI1298_I194_XG_n1 I1298_G7_0n I1298_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I201_XG_MN2 (XI1344_I201_XG_n1 I1344_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I201_XG_MN0 (c17_m I1344_P30_15n XI1344_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I201_XG_MN1 (XI1344_I201_XG_n1 I1344_G14_0n c17_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I199_XG_MN2 (XI1344_I199_XG_n1 I1344_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I199_XG_MN0 (I1344_G28_0 I1344_P28_13n XI1344_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I199_XG_MN1 (XI1344_I199_XG_n1 I1344_G12_0n I1344_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I87_XG_MN2 (XI1344_I87_XG_n1 I1344_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I87_XG_MN0 (I1344_G21_20 I1344_pn21 XI1344_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I87_XG_MN1 (XI1344_I87_XG_n1 I1344_gn20 I1344_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I88_XG_MN2 (XI1344_I88_XG_n1 I1344_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I88_XG_MN0 (I1344_G22_21 I1344_pn22 XI1344_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I88_XG_MN1 (XI1344_I88_XG_n1 I1344_gn21 I1344_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I148_XG_MN2 (XI1344_I148_XG_n1 I1344_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I148_XG_MN0 (I1344_G23_16 I1344_P23_20n XI1344_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I148_XG_MN1 (XI1344_I148_XG_n1 I1344_G19_16n I1344_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I194_XG_MN2 (XI1344_I194_XG_n1 I1344_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I194_XG_MN0 (I1344_G23_0 I1344_P23_8n XI1344_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I194_XG_MN1 (XI1344_I194_XG_n1 I1344_G7_0n I1344_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I88_XG_MN2 (XI1390_I88_XG_n1 I1390_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I88_XG_MN0 (I1390_G22_21 I1390_pn22 XI1390_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I88_XG_MN1 (XI1390_I88_XG_n1 I1390_gn21 I1390_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I87_XG_MN2 (XI1390_I87_XG_n1 I1390_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I87_XG_MN0 (I1390_G21_20 I1390_pn21 XI1390_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I87_XG_MN1 (XI1390_I87_XG_n1 I1390_gn20 I1390_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I153_XG_MN2 (XI1390_I153_XG_n1 I1390_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I153_XG_MN0 (I1390_G28_21 I1390_P28_25n XI1390_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I153_XG_MN1 (XI1390_I153_XG_n1 I1390_G24_21n I1390_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I201_XG_MN2 (XI1390_I201_XG_n1 I1390_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I201_XG_MN0 (c18_m I1390_P30_15n XI1390_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I201_XG_MN1 (XI1390_I201_XG_n1 I1390_G14_0n c18_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I148_XG_MN2 (XI1390_I148_XG_n1 I1390_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I148_XG_MN0 (I1390_G23_16 I1390_P23_20n XI1390_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I148_XG_MN1 (XI1390_I148_XG_n1 I1390_G19_16n I1390_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I194_XG_MN2 (XI1390_I194_XG_n1 I1390_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I194_XG_MN0 (I1390_G23_0 I1390_P23_8n XI1390_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I194_XG_MN1 (XI1390_I194_XG_n1 I1390_G7_0n I1390_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I87_XG_MN2 (XI1436_I87_XG_n1 I1436_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I87_XG_MN0 (I1436_G21_20 I1436_pn21 XI1436_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I87_XG_MN1 (XI1436_I87_XG_n1 I1436_gn20 I1436_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I199_XG_MN2 (XI1436_I199_XG_n1 I1436_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I199_XG_MN0 (I1436_G28_0 I1436_P28_13n XI1436_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I199_XG_MN1 (XI1436_I199_XG_n1 I1436_G12_0n I1436_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I150_XG_MN2 (XI1436_I150_XG_n1 I1436_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I150_XG_MN0 (I1436_G25_18 I1436_P25_22n XI1436_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I150_XG_MN1 (XI1436_I150_XG_n1 I1436_G21_18n I1436_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I196_XG_MN2 (XI1436_I196_XG_n1 I1436_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I196_XG_MN0 (I1436_G25_0 I1436_P25_10n XI1436_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I196_XG_MN1 (XI1436_I196_XG_n1 I1436_G9_0n I1436_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I87_XG_MN2 (XI1482_I87_XG_n1 I1482_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I87_XG_MN0 (I1482_G21_20 I1482_pn21 XI1482_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I87_XG_MN1 (XI1482_I87_XG_n1 I1482_gn20 I1482_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I146_XG_MN2 (XI1482_I146_XG_n1 I1482_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I146_XG_MN0 (I1482_G21_14 I1482_P21_18n XI1482_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I146_XG_MN1 (XI1482_I146_XG_n1 I1482_G17_14n I1482_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I150_XG_MN2 (XI1482_I150_XG_n1 I1482_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I150_XG_MN0 (I1482_G25_18 I1482_P25_22n XI1482_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I150_XG_MN1 (XI1482_I150_XG_n1 I1482_G21_18n I1482_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I196_XG_MN2 (XI1482_I196_XG_n1 I1482_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I196_XG_MN0 (I1482_G25_0 I1482_P25_10n XI1482_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I196_XG_MN1 (XI1482_I196_XG_n1 I1482_G9_0n I1482_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I199_XG_MN2 (XI1482_I199_XG_n1 I1482_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I199_XG_MN0 (I1482_G28_0 I1482_P28_13n XI1482_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I199_XG_MN1 (XI1482_I199_XG_n1 I1482_G12_0n I1482_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I151_XG_MN2 (XI1482_I151_XG_n1 I1482_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I151_XG_MN0 (I1482_G26_19 I1482_P26_23n XI1482_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I151_XG_MN1 (XI1482_I151_XG_n1 I1482_G22_19n I1482_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I201_XG_MN2 (XI1482_I201_XG_n1 I1482_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I201_XG_MN0 (c20_m I1482_P30_15n XI1482_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I201_XG_MN1 (XI1482_I201_XG_n1 I1482_G14_0n c20_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I91_XG_MN2 (XI1528_I91_XG_n1 I1528_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I91_XG_MN0 (I1528_G25_24 I1528_pn25 XI1528_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I91_XG_MN1 (XI1528_I91_XG_n1 I1528_gn24 I1528_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I87_XG_MN2 (XI1206_I87_XG_n1 I1206_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I87_XG_MN0 (I1206_G21_20 I1206_pn21 XI1206_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I87_XG_MN1 (XI1206_I87_XG_n1 I1206_gn20 I1206_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I86_XG_MN2 (XI1206_I86_XG_n1 I1206_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I86_XG_MN0 (I1206_G20_19 I1206_pn20 XI1206_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I86_XG_MN1 (XI1206_I86_XG_n1 I1206_gn19 I1206_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I85_XG_MN2 (XI1206_I85_XG_n1 I1206_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I85_XG_MN0 (I1206_G19_18 I1206_pn19 XI1206_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I85_XG_MN1 (XI1206_I85_XG_n1 I1206_gn18 I1206_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I144_XG_MN2 (XI1206_I144_XG_n1 I1206_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I144_XG_MN0 (I1206_G19_12 I1206_P19_16n XI1206_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I144_XG_MN1 (XI1206_I144_XG_n1 I1206_G15_12n I1206_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I190_XG_MN2 (XI1206_I190_XG_n1 I1206_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I190_XG_MN0 (I1206_G21_0 I1206_P21_6n XI1206_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I190_XG_MN1 (XI1206_I190_XG_n1 I1206_G5_0n I1206_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I149_XG_MN2 (XI1206_I149_XG_n1 I1206_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I149_XG_MN0 (I1206_G24_17 I1206_P24_21n XI1206_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I149_XG_MN1 (XI1206_I149_XG_n1 I1206_G20_17n I1206_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I145_XG_MN2 (XI1206_I145_XG_n1 I1206_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I145_XG_MN0 (I1206_G20_13 I1206_P20_17n XI1206_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I145_XG_MN1 (XI1206_I145_XG_n1 I1206_G16_13n I1206_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I195_XG_MN2 (XI1206_I195_XG_n1 I1206_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I195_XG_MN0 (I1206_G24_0 I1206_P24_9n XI1206_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I195_XG_MN1 (XI1206_I195_XG_n1 I1206_G8_0n I1206_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I88_XG_MN2 (XI1252_I88_XG_n1 I1252_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I88_XG_MN0 (I1252_G22_21 I1252_pn22 XI1252_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I88_XG_MN1 (XI1252_I88_XG_n1 I1252_gn21 I1252_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I153_XG_MN2 (XI1252_I153_XG_n1 I1252_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I153_XG_MN0 (I1252_G28_21 I1252_P28_25n XI1252_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I153_XG_MN1 (XI1252_I153_XG_n1 I1252_G24_21n I1252_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I199_XG_MN2 (XI1252_I199_XG_n1 I1252_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I199_XG_MN0 (I1252_G28_0 I1252_P28_13n XI1252_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I199_XG_MN1 (XI1252_I199_XG_n1 I1252_G12_0n I1252_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I152_XG_MN2 (XI1252_I152_XG_n1 I1252_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I152_XG_MN0 (I1252_G27_20 I1252_P27_24n XI1252_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I152_XG_MN1 (XI1252_I152_XG_n1 I1252_G23_20n I1252_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I148_XG_MN2 (XI1252_I148_XG_n1 I1252_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I148_XG_MN0 (I1252_G23_16 I1252_P23_20n XI1252_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I148_XG_MN1 (XI1252_I148_XG_n1 I1252_G19_16n I1252_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I194_XG_MN2 (XI1252_I194_XG_n1 I1252_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I194_XG_MN0 (I1252_G23_0 I1252_P23_8n XI1252_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I194_XG_MN1 (XI1252_I194_XG_n1 I1252_G7_0n I1252_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I89_XG_MN2 (XI1298_I89_XG_n1 I1298_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I89_XG_MN0 (I1298_G23_22 I1298_pn23 XI1298_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I89_XG_MN1 (XI1298_I89_XG_n1 I1298_gn22 I1298_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I153_XG_MN2 (XI1298_I153_XG_n1 I1298_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I153_XG_MN0 (I1298_G28_21 I1298_P28_25n XI1298_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I153_XG_MN1 (XI1298_I153_XG_n1 I1298_G24_21n I1298_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I201_XG_MN2 (XI1298_I201_XG_n1 I1298_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I201_XG_MN0 (c16_m I1298_P30_15n XI1298_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I201_XG_MN1 (XI1298_I201_XG_n1 I1298_G14_0n c16_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I152_XG_MN2 (XI1298_I152_XG_n1 I1298_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I152_XG_MN0 (I1298_G27_20 I1298_P27_24n XI1298_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I152_XG_MN1 (XI1298_I152_XG_n1 I1298_G23_20n I1298_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I148_XG_MN2 (XI1298_I148_XG_n1 I1298_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I148_XG_MN0 (I1298_G23_16 I1298_P23_20n XI1298_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I148_XG_MN1 (XI1298_I148_XG_n1 I1298_G19_16n I1298_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I198_XG_MN2 (XI1298_I198_XG_n1 I1298_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I198_XG_MN0 (I1298_G27_0 I1298_P27_12n XI1298_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I198_XG_MN1 (XI1298_I198_XG_n1 I1298_G11_0n I1298_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I153_XG_MN2 (XI1344_I153_XG_n1 I1344_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I153_XG_MN0 (I1344_G28_21 I1344_P28_25n XI1344_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I153_XG_MN1 (XI1344_I153_XG_n1 I1344_G24_21n I1344_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I90_XG_MN2 (XI1344_I90_XG_n1 I1344_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I90_XG_MN0 (I1344_G24_23 I1344_pn24 XI1344_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I90_XG_MN1 (XI1344_I90_XG_n1 I1344_gn23 I1344_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I89_XG_MN2 (XI1344_I89_XG_n1 I1344_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I89_XG_MN0 (I1344_G23_22 I1344_pn23 XI1344_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I89_XG_MN1 (XI1344_I89_XG_n1 I1344_gn22 I1344_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I152_XG_MN2 (XI1344_I152_XG_n1 I1344_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I152_XG_MN0 (I1344_G27_20 I1344_P27_24n XI1344_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I152_XG_MN1 (XI1344_I152_XG_n1 I1344_G23_20n I1344_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I89_XG_MN2 (XI1390_I89_XG_n1 I1390_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I89_XG_MN0 (I1390_G23_22 I1390_pn23 XI1390_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I89_XG_MN1 (XI1390_I89_XG_n1 I1390_gn22 I1390_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I90_XG_MN2 (XI1390_I90_XG_n1 I1390_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I90_XG_MN0 (I1390_G24_23 I1390_pn24 XI1390_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I90_XG_MN1 (XI1390_I90_XG_n1 I1390_gn23 I1390_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I152_XG_MN2 (XI1390_I152_XG_n1 I1390_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I152_XG_MN0 (I1390_G27_20 I1390_P27_24n XI1390_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I152_XG_MN1 (XI1390_I152_XG_n1 I1390_G23_20n I1390_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I200_XG_MN2 (XI1390_I200_XG_n1 I1390_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I200_XG_MN0 (I1390_G29_0 I1390_P29_14n XI1390_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I200_XG_MN1 (XI1390_I200_XG_n1 I1390_G13_0n I1390_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I88_XG_MN2 (XI1436_I88_XG_n1 I1436_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I88_XG_MN0 (I1436_G22_21 I1436_pn22 XI1436_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I88_XG_MN1 (XI1436_I88_XG_n1 I1436_gn21 I1436_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I89_XG_MN2 (XI1436_I89_XG_n1 I1436_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I89_XG_MN0 (I1436_G23_22 I1436_pn23 XI1436_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I89_XG_MN1 (XI1436_I89_XG_n1 I1436_gn22 I1436_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I153_XG_MN2 (XI1436_I153_XG_n1 I1436_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I153_XG_MN0 (I1436_G28_21 I1436_P28_25n XI1436_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I153_XG_MN1 (XI1436_I153_XG_n1 I1436_G24_21n I1436_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I201_XG_MN2 (XI1436_I201_XG_n1 I1436_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I201_XG_MN0 (c19_m I1436_P30_15n XI1436_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I201_XG_MN1 (XI1436_I201_XG_n1 I1436_G14_0n c19_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I148_XG_MN2 (XI1436_I148_XG_n1 I1436_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I148_XG_MN0 (I1436_G23_16 I1436_P23_20n XI1436_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I148_XG_MN1 (XI1436_I148_XG_n1 I1436_G19_16n I1436_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I200_XG_MN2 (XI1436_I200_XG_n1 I1436_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I200_XG_MN0 (I1436_G29_0 I1436_P29_14n XI1436_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I200_XG_MN1 (XI1436_I200_XG_n1 I1436_G13_0n I1436_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I194_XG_MN2 (XI1436_I194_XG_n1 I1436_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I194_XG_MN0 (I1436_G23_0 I1436_P23_8n XI1436_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I194_XG_MN1 (XI1436_I194_XG_n1 I1436_G7_0n I1436_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I88_XG_MN2 (XI1482_I88_XG_n1 I1482_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I88_XG_MN0 (I1482_G22_21 I1482_pn22 XI1482_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I88_XG_MN1 (XI1482_I88_XG_n1 I1482_gn21 I1482_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I194_XG_MN2 (XI1482_I194_XG_n1 I1482_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I194_XG_MN0 (I1482_G23_0 I1482_P23_8n XI1482_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I194_XG_MN1 (XI1482_I194_XG_n1 I1482_G7_0n I1482_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I200_XG_MN2 (XI1482_I200_XG_n1 I1482_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I200_XG_MN0 (I1482_G29_0 I1482_P29_14n XI1482_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I200_XG_MN1 (XI1482_I200_XG_n1 I1482_G13_0n I1482_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I90_XG_MN2 (XI1482_I90_XG_n1 I1482_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I90_XG_MN0 (I1482_G24_23 I1482_pn24 XI1482_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I90_XG_MN1 (XI1482_I90_XG_n1 I1482_gn23 I1482_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I153_XG_MN2 (XI1482_I153_XG_n1 I1482_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I153_XG_MN0 (I1482_G28_21 I1482_P28_25n XI1482_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I153_XG_MN1 (XI1482_I153_XG_n1 I1482_G24_21n I1482_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I155_XG_MN2 (XI1482_I155_XG_n1 I1482_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I155_XG_MN0 (I1482_G30_23 I1482_P30_27n XI1482_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I155_XG_MN1 (XI1482_I155_XG_n1 I1482_G26_23n I1482_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I92_XG_MN2 (XI1528_I92_XG_n1 I1528_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I92_XG_MN0 (I1528_G26_25 I1528_pn26 XI1528_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I92_XG_MN1 (XI1528_I92_XG_n1 I1528_gn25 I1528_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I94_XG_MN2 (XI1528_I94_XG_n1 I1528_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I94_XG_MN0 (I1528_G28_27 I1528_pn28 XI1528_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I94_XG_MN1 (XI1528_I94_XG_n1 I1528_gn27 I1528_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I93_XG_MN2 (XI1528_I93_XG_n1 I1528_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I93_XG_MN0 (I1528_G27_26 I1528_pn27 XI1528_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I93_XG_MN1 (XI1528_I93_XG_n1 I1528_gn26 I1528_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I89_XG_MN2 (XI1206_I89_XG_n1 I1206_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I89_XG_MN0 (I1206_G23_22 I1206_pn23 XI1206_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I89_XG_MN1 (XI1206_I89_XG_n1 I1206_gn22 I1206_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I88_XG_MN2 (XI1206_I88_XG_n1 I1206_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I88_XG_MN0 (I1206_G22_21 I1206_pn22 XI1206_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I88_XG_MN1 (XI1206_I88_XG_n1 I1206_gn21 I1206_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I202_XG_MN2 (XI1206_I202_XG_n1 I1206_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I202_XG_MN0 (c14_o I1206_P31_16n XI1206_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I202_XG_MN1 (XI1206_I202_XG_n1 I1206_G15_0n c14_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I146_XG_MN2 (XI1206_I146_XG_n1 I1206_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I146_XG_MN0 (I1206_G21_14 I1206_P21_18n XI1206_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I146_XG_MN1 (XI1206_I146_XG_n1 I1206_G17_14n I1206_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I196_XG_MN2 (XI1206_I196_XG_n1 I1206_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I196_XG_MN0 (I1206_G25_0 I1206_P25_10n XI1206_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I196_XG_MN1 (XI1206_I196_XG_n1 I1206_G9_0n I1206_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I192_XG_MN2 (XI1206_I192_XG_n1 I1206_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I192_XG_MN0 (I1206_G22_0 I1206_P22_7n XI1206_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I192_XG_MN1 (XI1206_I192_XG_n1 I1206_G6_0n I1206_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I89_XG_MN2 (XI1252_I89_XG_n1 I1252_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I89_XG_MN0 (I1252_G23_22 I1252_pn23 XI1252_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I89_XG_MN1 (XI1252_I89_XG_n1 I1252_gn22 I1252_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I90_XG_MN2 (XI1252_I90_XG_n1 I1252_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I90_XG_MN0 (I1252_G24_23 I1252_pn24 XI1252_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I90_XG_MN1 (XI1252_I90_XG_n1 I1252_gn23 I1252_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I201_XG_MN2 (XI1252_I201_XG_n1 I1252_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I201_XG_MN0 (c15_m I1252_P30_15n XI1252_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I201_XG_MN1 (XI1252_I201_XG_n1 I1252_G14_0n c15_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I154_XG_MN2 (XI1252_I154_XG_n1 I1252_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I154_XG_MN0 (I1252_G29_22 I1252_P29_26n XI1252_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I154_XG_MN1 (XI1252_I154_XG_n1 I1252_G25_22n I1252_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I200_XG_MN2 (XI1252_I200_XG_n1 I1252_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I200_XG_MN0 (I1252_G29_0 I1252_P29_14n XI1252_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I200_XG_MN1 (XI1252_I200_XG_n1 I1252_G13_0n I1252_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I91_XG_MN2 (XI1298_I91_XG_n1 I1298_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I91_XG_MN0 (I1298_G25_24 I1298_pn25 XI1298_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I91_XG_MN1 (XI1298_I91_XG_n1 I1298_gn24 I1298_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I90_XG_MN2 (XI1298_I90_XG_n1 I1298_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I90_XG_MN0 (I1298_G24_23 I1298_pn24 XI1298_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I90_XG_MN1 (XI1298_I90_XG_n1 I1298_gn23 I1298_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I155_XG_MN2 (XI1298_I155_XG_n1 I1298_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I155_XG_MN0 (I1298_G30_23 I1298_P30_27n XI1298_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I155_XG_MN1 (XI1298_I155_XG_n1 I1298_G26_23n I1298_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I200_XG_MN2 (XI1298_I200_XG_n1 I1298_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I200_XG_MN0 (I1298_G29_0 I1298_P29_14n XI1298_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I200_XG_MN1 (XI1298_I200_XG_n1 I1298_G13_0n I1298_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I155_XG_MN2 (XI1344_I155_XG_n1 I1344_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I155_XG_MN0 (I1344_G30_23 I1344_P30_27n XI1344_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I155_XG_MN1 (XI1344_I155_XG_n1 I1344_G26_23n I1344_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I154_XG_MN2 (XI1344_I154_XG_n1 I1344_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I154_XG_MN0 (I1344_G29_22 I1344_P29_26n XI1344_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I154_XG_MN1 (XI1344_I154_XG_n1 I1344_G25_22n I1344_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I200_XG_MN2 (XI1344_I200_XG_n1 I1344_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I200_XG_MN0 (I1344_G29_0 I1344_P29_14n XI1344_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I200_XG_MN1 (XI1344_I200_XG_n1 I1344_G13_0n I1344_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I91_XG_MN2 (XI1390_I91_XG_n1 I1390_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I91_XG_MN0 (I1390_G25_24 I1390_pn25 XI1390_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I91_XG_MN1 (XI1390_I91_XG_n1 I1390_gn24 I1390_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I155_XG_MN2 (XI1390_I155_XG_n1 I1390_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I155_XG_MN0 (I1390_G30_23 I1390_P30_27n XI1390_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I155_XG_MN1 (XI1390_I155_XG_n1 I1390_G26_23n I1390_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I154_XG_MN2 (XI1390_I154_XG_n1 I1390_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I154_XG_MN0 (I1390_G29_22 I1390_P29_26n XI1390_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I154_XG_MN1 (XI1390_I154_XG_n1 I1390_G25_22n I1390_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I202_XG_MN2 (XI1390_I202_XG_n1 I1390_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I202_XG_MN0 (c18_o I1390_P31_16n XI1390_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I202_XG_MN1 (XI1390_I202_XG_n1 I1390_G15_0n c18_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I90_XG_MN2 (XI1436_I90_XG_n1 I1436_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I90_XG_MN0 (I1436_G24_23 I1436_pn24 XI1436_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I90_XG_MN1 (XI1436_I90_XG_n1 I1436_gn23 I1436_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I91_XG_MN2 (XI1436_I91_XG_n1 I1436_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I91_XG_MN0 (I1436_G25_24 I1436_pn25 XI1436_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I91_XG_MN1 (XI1436_I91_XG_n1 I1436_gn24 I1436_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I155_XG_MN2 (XI1436_I155_XG_n1 I1436_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I155_XG_MN0 (I1436_G30_23 I1436_P30_27n XI1436_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I155_XG_MN1 (XI1436_I155_XG_n1 I1436_G26_23n I1436_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I154_XG_MN2 (XI1436_I154_XG_n1 I1436_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I154_XG_MN0 (I1436_G29_22 I1436_P29_26n XI1436_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I154_XG_MN1 (XI1436_I154_XG_n1 I1436_G25_22n I1436_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I152_XG_MN2 (XI1436_I152_XG_n1 I1436_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I152_XG_MN0 (I1436_G27_20 I1436_P27_24n XI1436_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I152_XG_MN1 (XI1436_I152_XG_n1 I1436_G23_20n I1436_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I198_XG_MN2 (XI1436_I198_XG_n1 I1436_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I198_XG_MN0 (I1436_G27_0 I1436_P27_12n XI1436_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I198_XG_MN1 (XI1436_I198_XG_n1 I1436_G11_0n I1436_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I89_XG_MN2 (XI1482_I89_XG_n1 I1482_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I89_XG_MN0 (I1482_G23_22 I1482_pn23 XI1482_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I89_XG_MN1 (XI1482_I89_XG_n1 I1482_gn22 I1482_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I148_XG_MN2 (XI1482_I148_XG_n1 I1482_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I148_XG_MN0 (I1482_G23_16 I1482_P23_20n XI1482_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I148_XG_MN1 (XI1482_I148_XG_n1 I1482_G19_16n I1482_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I198_XG_MN2 (XI1482_I198_XG_n1 I1482_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I198_XG_MN0 (I1482_G27_0 I1482_P27_12n XI1482_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I198_XG_MN1 (XI1482_I198_XG_n1 I1482_G11_0n I1482_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I91_XG_MN2 (XI1482_I91_XG_n1 I1482_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I91_XG_MN0 (I1482_G25_24 I1482_pn25 XI1482_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I91_XG_MN1 (XI1482_I91_XG_n1 I1482_gn24 I1482_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I92_XG_MN2 (XI1482_I92_XG_n1 I1482_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I92_XG_MN0 (I1482_G26_25 I1482_pn26 XI1482_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I92_XG_MN1 (XI1482_I92_XG_n1 I1482_gn25 I1482_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I96_XG_MN2 (XI1528_I96_XG_n1 I1528_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I96_XG_MN0 (I1528_G30_29 I1528_pn30 XI1528_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I96_XG_MN1 (XI1528_I96_XG_n1 I1528_gn29 I1528_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I95_XG_MN2 (XI1528_I95_XG_n1 I1528_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I95_XG_MN0 (I1528_G29_28 I1528_pn29 XI1528_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I95_XG_MN1 (XI1528_I95_XG_n1 I1528_gn28 I1528_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I90_XG_MN2 (XI1206_I90_XG_n1 I1206_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I90_XG_MN0 (I1206_G24_23 I1206_pn24 XI1206_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I90_XG_MN1 (XI1206_I90_XG_n1 I1206_gn23 I1206_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I91_XG_MN2 (XI1206_I91_XG_n1 I1206_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I91_XG_MN0 (I1206_G25_24 I1206_pn25 XI1206_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I91_XG_MN1 (XI1206_I91_XG_n1 I1206_gn24 I1206_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I152_XG_MN2 (XI1206_I152_XG_n1 I1206_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I152_XG_MN0 (I1206_G27_20 I1206_P27_24n XI1206_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I152_XG_MN1 (XI1206_I152_XG_n1 I1206_G23_20n I1206_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I148_XG_MN2 (XI1206_I148_XG_n1 I1206_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I148_XG_MN0 (I1206_G23_16 I1206_P23_20n XI1206_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I148_XG_MN1 (XI1206_I148_XG_n1 I1206_G19_16n I1206_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I150_XG_MN2 (XI1206_I150_XG_n1 I1206_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I150_XG_MN0 (I1206_G25_18 I1206_P25_22n XI1206_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I150_XG_MN1 (XI1206_I150_XG_n1 I1206_G21_18n I1206_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I194_XG_MN2 (XI1206_I194_XG_n1 I1206_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I194_XG_MN0 (I1206_G23_0 I1206_P23_8n XI1206_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I194_XG_MN1 (XI1206_I194_XG_n1 I1206_G7_0n I1206_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I151_XG_MN2 (XI1206_I151_XG_n1 I1206_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I151_XG_MN0 (I1206_G26_19 I1206_P26_23n XI1206_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I151_XG_MN1 (XI1206_I151_XG_n1 I1206_G22_19n I1206_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I147_XG_MN2 (XI1206_I147_XG_n1 I1206_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I147_XG_MN0 (I1206_G22_15 I1206_P22_19n XI1206_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I147_XG_MN1 (XI1206_I147_XG_n1 I1206_G18_15n I1206_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I197_XG_MN2 (XI1206_I197_XG_n1 I1206_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I197_XG_MN0 (I1206_G26_0 I1206_P26_11n XI1206_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I197_XG_MN1 (XI1206_I197_XG_n1 I1206_G10_0n I1206_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I92_XG_MN2 (XI1252_I92_XG_n1 I1252_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I92_XG_MN0 (I1252_G26_25 I1252_pn26 XI1252_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I92_XG_MN1 (XI1252_I92_XG_n1 I1252_gn25 I1252_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I91_XG_MN2 (XI1252_I91_XG_n1 I1252_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I91_XG_MN0 (I1252_G25_24 I1252_pn25 XI1252_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I91_XG_MN1 (XI1252_I91_XG_n1 I1252_gn24 I1252_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I155_XG_MN2 (XI1252_I155_XG_n1 I1252_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I155_XG_MN0 (I1252_G30_23 I1252_P30_27n XI1252_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I155_XG_MN1 (XI1252_I155_XG_n1 I1252_G26_23n I1252_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I156_XG_MN2 (XI1252_I156_XG_n1 I1252_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I156_XG_MN0 (I1252_G31_24 I1252_P31_28n XI1252_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I156_XG_MN1 (XI1252_I156_XG_n1 I1252_G27_24n I1252_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I202_XG_MN2 (XI1252_I202_XG_n1 I1252_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I202_XG_MN0 (c15_o I1252_P31_16n XI1252_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I202_XG_MN1 (XI1252_I202_XG_n1 I1252_G15_0n c15_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I92_XG_MN2 (XI1298_I92_XG_n1 I1298_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I92_XG_MN0 (I1298_G26_25 I1298_pn26 XI1298_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I92_XG_MN1 (XI1298_I92_XG_n1 I1298_gn25 I1298_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I93_XG_MN2 (XI1298_I93_XG_n1 I1298_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I93_XG_MN0 (I1298_G27_26 I1298_pn27 XI1298_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I93_XG_MN1 (XI1298_I93_XG_n1 I1298_gn26 I1298_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I154_XG_MN2 (XI1298_I154_XG_n1 I1298_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I154_XG_MN0 (I1298_G29_22 I1298_P29_26n XI1298_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I154_XG_MN1 (XI1298_I154_XG_n1 I1298_G25_22n I1298_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I92_XG_MN2 (XI1344_I92_XG_n1 I1344_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I92_XG_MN0 (I1344_G26_25 I1344_pn26 XI1344_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I92_XG_MN1 (XI1344_I92_XG_n1 I1344_gn25 I1344_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I93_XG_MN2 (XI1344_I93_XG_n1 I1344_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I93_XG_MN0 (I1344_G27_26 I1344_pn27 XI1344_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I93_XG_MN1 (XI1344_I93_XG_n1 I1344_gn26 I1344_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I91_XG_MN2 (XI1344_I91_XG_n1 I1344_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I91_XG_MN0 (I1344_G25_24 I1344_pn25 XI1344_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I91_XG_MN1 (XI1344_I91_XG_n1 I1344_gn24 I1344_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I156_XG_MN2 (XI1344_I156_XG_n1 I1344_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I156_XG_MN0 (I1344_G31_24 I1344_P31_28n XI1344_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I156_XG_MN1 (XI1344_I156_XG_n1 I1344_G27_24n I1344_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I202_XG_MN2 (XI1344_I202_XG_n1 I1344_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I202_XG_MN0 (c17_o I1344_P31_16n XI1344_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I202_XG_MN1 (XI1344_I202_XG_n1 I1344_G15_0n c17_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I93_XG_MN2 (XI1390_I93_XG_n1 I1390_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I93_XG_MN0 (I1390_G27_26 I1390_pn27 XI1390_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I93_XG_MN1 (XI1390_I93_XG_n1 I1390_gn26 I1390_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I92_XG_MN2 (XI1390_I92_XG_n1 I1390_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I92_XG_MN0 (I1390_G26_25 I1390_pn26 XI1390_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I92_XG_MN1 (XI1390_I92_XG_n1 I1390_gn25 I1390_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I94_XG_MN2 (XI1390_I94_XG_n1 I1390_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I94_XG_MN0 (I1390_G28_27 I1390_pn28 XI1390_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I94_XG_MN1 (XI1390_I94_XG_n1 I1390_gn27 I1390_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I156_XG_MN2 (XI1390_I156_XG_n1 I1390_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I156_XG_MN0 (I1390_G31_24 I1390_P31_28n XI1390_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I156_XG_MN1 (XI1390_I156_XG_n1 I1390_G27_24n I1390_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I93_XG_MN2 (XI1436_I93_XG_n1 I1436_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I93_XG_MN0 (I1436_G27_26 I1436_pn27 XI1436_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I93_XG_MN1 (XI1436_I93_XG_n1 I1436_gn26 I1436_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I92_XG_MN2 (XI1436_I92_XG_n1 I1436_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I92_XG_MN0 (I1436_G26_25 I1436_pn26 XI1436_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I92_XG_MN1 (XI1436_I92_XG_n1 I1436_gn25 I1436_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I202_XG_MN2 (XI1436_I202_XG_n1 I1436_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I202_XG_MN0 (c19_o I1436_P31_16n XI1436_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I202_XG_MN1 (XI1436_I202_XG_n1 I1436_G15_0n c19_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I202_XG_MN2 (XI1482_I202_XG_n1 I1482_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I202_XG_MN0 (c20_o I1482_P31_16n XI1482_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I202_XG_MN1 (XI1482_I202_XG_n1 I1482_G15_0n c20_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I152_XG_MN2 (XI1482_I152_XG_n1 I1482_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I152_XG_MN0 (I1482_G27_20 I1482_P27_24n XI1482_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I152_XG_MN1 (XI1482_I152_XG_n1 I1482_G23_20n I1482_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I154_XG_MN2 (XI1482_I154_XG_n1 I1482_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I154_XG_MN0 (I1482_G29_22 I1482_P29_26n XI1482_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I154_XG_MN1 (XI1482_I154_XG_n1 I1482_G25_22n I1482_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I93_XG_MN2 (XI1482_I93_XG_n1 I1482_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I93_XG_MN0 (I1482_G27_26 I1482_pn27 XI1482_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I93_XG_MN1 (XI1482_I93_XG_n1 I1482_gn26 I1482_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1528_I97_XG_MN2 (XI1528_I97_XG_n1 I1528_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1528_I97_XG_MN0 (I1528_G31_30 I1528_pn31 XI1528_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1528_I97_XG_MN1 (XI1528_I97_XG_n1 I1528_gn30 I1528_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I93_XG_MN2 (XI1206_I93_XG_n1 I1206_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I93_XG_MN0 (I1206_G27_26 I1206_pn27 XI1206_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I93_XG_MN1 (XI1206_I93_XG_n1 I1206_gn26 I1206_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I92_XG_MN2 (XI1206_I92_XG_n1 I1206_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I92_XG_MN0 (I1206_G26_25 I1206_pn26 XI1206_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I92_XG_MN1 (XI1206_I92_XG_n1 I1206_gn25 I1206_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I156_XG_MN2 (XI1206_I156_XG_n1 I1206_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I156_XG_MN0 (I1206_G31_24 I1206_P31_28n XI1206_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I156_XG_MN1 (XI1206_I156_XG_n1 I1206_G27_24n I1206_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I154_XG_MN2 (XI1206_I154_XG_n1 I1206_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I154_XG_MN0 (I1206_G29_22 I1206_P29_26n XI1206_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I154_XG_MN1 (XI1206_I154_XG_n1 I1206_G25_22n I1206_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I200_XG_MN2 (XI1206_I200_XG_n1 I1206_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I200_XG_MN0 (I1206_G29_0 I1206_P29_14n XI1206_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I200_XG_MN1 (XI1206_I200_XG_n1 I1206_G13_0n I1206_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I198_XG_MN2 (XI1206_I198_XG_n1 I1206_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I198_XG_MN0 (I1206_G27_0 I1206_P27_12n XI1206_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I198_XG_MN1 (XI1206_I198_XG_n1 I1206_G11_0n I1206_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I155_XG_MN2 (XI1206_I155_XG_n1 I1206_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I155_XG_MN0 (I1206_G30_23 I1206_P30_27n XI1206_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I155_XG_MN1 (XI1206_I155_XG_n1 I1206_G26_23n I1206_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I153_XG_MN2 (XI1206_I153_XG_n1 I1206_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I153_XG_MN0 (I1206_G28_21 I1206_P28_25n XI1206_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I153_XG_MN1 (XI1206_I153_XG_n1 I1206_G24_21n I1206_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I199_XG_MN2 (XI1206_I199_XG_n1 I1206_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I199_XG_MN0 (I1206_G28_0 I1206_P28_13n XI1206_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I199_XG_MN1 (XI1206_I199_XG_n1 I1206_G12_0n I1206_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I94_XG_MN2 (XI1252_I94_XG_n1 I1252_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I94_XG_MN0 (I1252_G28_27 I1252_pn28 XI1252_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I94_XG_MN1 (XI1252_I94_XG_n1 I1252_gn27 I1252_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I93_XG_MN2 (XI1252_I93_XG_n1 I1252_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I93_XG_MN0 (I1252_G27_26 I1252_pn27 XI1252_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I93_XG_MN1 (XI1252_I93_XG_n1 I1252_gn26 I1252_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I94_XG_MN2 (XI1298_I94_XG_n1 I1298_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I94_XG_MN0 (I1298_G28_27 I1298_pn28 XI1298_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I94_XG_MN1 (XI1298_I94_XG_n1 I1298_gn27 I1298_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I95_XG_MN2 (XI1298_I95_XG_n1 I1298_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I95_XG_MN0 (I1298_G29_28 I1298_pn29 XI1298_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I95_XG_MN1 (XI1298_I95_XG_n1 I1298_gn28 I1298_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I156_XG_MN2 (XI1298_I156_XG_n1 I1298_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I156_XG_MN0 (I1298_G31_24 I1298_P31_28n XI1298_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I156_XG_MN1 (XI1298_I156_XG_n1 I1298_G27_24n I1298_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I202_XG_MN2 (XI1298_I202_XG_n1 I1298_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I202_XG_MN0 (c16_o I1298_P31_16n XI1298_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I202_XG_MN1 (XI1298_I202_XG_n1 I1298_G15_0n c16_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I94_XG_MN2 (XI1344_I94_XG_n1 I1344_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I94_XG_MN0 (I1344_G28_27 I1344_pn28 XI1344_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I94_XG_MN1 (XI1344_I94_XG_n1 I1344_gn27 I1344_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I95_XG_MN2 (XI1344_I95_XG_n1 I1344_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I95_XG_MN0 (I1344_G29_28 I1344_pn29 XI1344_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I95_XG_MN1 (XI1344_I95_XG_n1 I1344_gn28 I1344_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I95_XG_MN2 (XI1390_I95_XG_n1 I1390_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I95_XG_MN0 (I1390_G29_28 I1390_pn29 XI1390_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I95_XG_MN1 (XI1390_I95_XG_n1 I1390_gn28 I1390_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I96_XG_MN2 (XI1390_I96_XG_n1 I1390_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I96_XG_MN0 (I1390_G30_29 I1390_pn30 XI1390_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I96_XG_MN1 (XI1390_I96_XG_n1 I1390_gn29 I1390_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1390_I97_XG_MN2 (XI1390_I97_XG_n1 I1390_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1390_I97_XG_MN0 (I1390_G31_30 I1390_pn31 XI1390_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1390_I97_XG_MN1 (XI1390_I97_XG_n1 I1390_gn30 I1390_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I95_XG_MN2 (XI1436_I95_XG_n1 I1436_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I95_XG_MN0 (I1436_G29_28 I1436_pn29 XI1436_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I95_XG_MN1 (XI1436_I95_XG_n1 I1436_gn28 I1436_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I94_XG_MN2 (XI1436_I94_XG_n1 I1436_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I94_XG_MN0 (I1436_G28_27 I1436_pn28 XI1436_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I94_XG_MN1 (XI1436_I94_XG_n1 I1436_gn27 I1436_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I96_XG_MN2 (XI1436_I96_XG_n1 I1436_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I96_XG_MN0 (I1436_G30_29 I1436_pn30 XI1436_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I96_XG_MN1 (XI1436_I96_XG_n1 I1436_gn29 I1436_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I97_XG_MN2 (XI1436_I97_XG_n1 I1436_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I97_XG_MN0 (I1436_G31_30 I1436_pn31 XI1436_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I97_XG_MN1 (XI1436_I97_XG_n1 I1436_gn30 I1436_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1436_I156_XG_MN2 (XI1436_I156_XG_n1 I1436_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1436_I156_XG_MN0 (I1436_G31_24 I1436_P31_28n XI1436_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1436_I156_XG_MN1 (XI1436_I156_XG_n1 I1436_G27_24n I1436_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I97_XG_MN2 (XI1482_I97_XG_n1 I1482_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I97_XG_MN0 (I1482_G31_30 I1482_pn31 XI1482_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I97_XG_MN1 (XI1482_I97_XG_n1 I1482_gn30 I1482_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I156_XG_MN2 (XI1482_I156_XG_n1 I1482_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I156_XG_MN0 (I1482_G31_24 I1482_P31_28n XI1482_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I156_XG_MN1 (XI1482_I156_XG_n1 I1482_G27_24n I1482_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I95_XG_MN2 (XI1482_I95_XG_n1 I1482_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I95_XG_MN0 (I1482_G29_28 I1482_pn29 XI1482_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I95_XG_MN1 (XI1482_I95_XG_n1 I1482_gn28 I1482_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I96_XG_MN2 (XI1482_I96_XG_n1 I1482_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I96_XG_MN0 (I1482_G30_29 I1482_pn30 XI1482_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I96_XG_MN1 (XI1482_I96_XG_n1 I1482_gn29 I1482_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1482_I94_XG_MN2 (XI1482_I94_XG_n1 I1482_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1482_I94_XG_MN0 (I1482_G28_27 I1482_pn28 XI1482_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1482_I94_XG_MN1 (XI1482_I94_XG_n1 I1482_gn27 I1482_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I97_XG_MN2 (XI1206_I97_XG_n1 I1206_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I97_XG_MN0 (I1206_G31_30 I1206_pn31 XI1206_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I97_XG_MN1 (XI1206_I97_XG_n1 I1206_gn30 I1206_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I96_XG_MN2 (XI1206_I96_XG_n1 I1206_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I96_XG_MN0 (I1206_G30_29 I1206_pn30 XI1206_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I96_XG_MN1 (XI1206_I96_XG_n1 I1206_gn29 I1206_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I95_XG_MN2 (XI1206_I95_XG_n1 I1206_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I95_XG_MN0 (I1206_G29_28 I1206_pn29 XI1206_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I95_XG_MN1 (XI1206_I95_XG_n1 I1206_gn28 I1206_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I94_XG_MN2 (XI1206_I94_XG_n1 I1206_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I94_XG_MN0 (I1206_G28_27 I1206_pn28 XI1206_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I94_XG_MN1 (XI1206_I94_XG_n1 I1206_gn27 I1206_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1206_I201_XG_MN2 (XI1206_I201_XG_n1 I1206_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1206_I201_XG_MN0 (c14_m I1206_P30_15n XI1206_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1206_I201_XG_MN1 (XI1206_I201_XG_n1 I1206_G14_0n c14_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I95_XG_MN2 (XI1252_I95_XG_n1 I1252_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I95_XG_MN0 (I1252_G29_28 I1252_pn29 XI1252_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I95_XG_MN1 (XI1252_I95_XG_n1 I1252_gn28 I1252_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I96_XG_MN2 (XI1252_I96_XG_n1 I1252_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I96_XG_MN0 (I1252_G30_29 I1252_pn30 XI1252_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I96_XG_MN1 (XI1252_I96_XG_n1 I1252_gn29 I1252_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1252_I97_XG_MN2 (XI1252_I97_XG_n1 I1252_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1252_I97_XG_MN0 (I1252_G31_30 I1252_pn31 XI1252_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1252_I97_XG_MN1 (XI1252_I97_XG_n1 I1252_gn30 I1252_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I96_XG_MN2 (XI1298_I96_XG_n1 I1298_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I96_XG_MN0 (I1298_G30_29 I1298_pn30 XI1298_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I96_XG_MN1 (XI1298_I96_XG_n1 I1298_gn29 I1298_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1298_I97_XG_MN2 (XI1298_I97_XG_n1 I1298_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1298_I97_XG_MN0 (I1298_G31_30 I1298_pn31 XI1298_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1298_I97_XG_MN1 (XI1298_I97_XG_n1 I1298_gn30 I1298_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I96_XG_MN2 (XI1344_I96_XG_n1 I1344_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I96_XG_MN0 (I1344_G30_29 I1344_pn30 XI1344_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I96_XG_MN1 (XI1344_I96_XG_n1 I1344_gn29 I1344_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1344_I97_XG_MN2 (XI1344_I97_XG_n1 I1344_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1344_I97_XG_MN0 (I1344_G31_30 I1344_pn31 XI1344_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1344_I97_XG_MN1 (XI1344_I97_XG_n1 I1344_gn30 I1344_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I30_MN1 (XI654_I30_n1 b2_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I30_MN0 (I654_gn30 p1_29 XI654_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I31_MN1 (XI654_I31_n1 b2_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I31_MN0 (I654_gn31 p1_30 XI654_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I30_MN1 (XI562_I30_n1 b0_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I30_MN0 (I562_gn30 VSS XI562_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I31_MN1 (XI2066_I31_n1 dm31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I31_MN0 (I2066_gn31 p31_31 XI2066_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2064_MN1 (XI2064_n1 p31_32_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2064_MN0 (dmn31 dd31_b3_5 XI2064_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I29_MN1 (XI1942_I29_n1 b30_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I29_MN0 (I1942_gn29 p29_28 XI1942_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I31_MN1 (XI700_I31_n1 b3_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I31_MN0 (I700_gn31 p2_30 XI700_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I127_XP_MN1 (XI654_I127_XP_n1 I654_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I127_XP_MN0 (I654_P31_28n I654_P31_30 XI654_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I28_MN1 (XI654_I28_n1 b2_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I28_MN0 (I654_gn28 p1_27 XI654_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I29_MN1 (XI654_I29_n1 b2_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I29_MN0 (I654_gn29 p1_28 XI654_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I127_XP_MN1 (XI608_I127_XP_n1 I608_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I127_XP_MN0 (I608_P31_28n I608_P31_30 XI608_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I31_MN1 (XI608_I31_n1 b1_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I31_MN0 (I608_gn31 p0_30 XI608_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I30_MN1 (XI608_I30_n1 b1_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I30_MN0 (I608_gn30 p0_29 XI608_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I28_MN1 (XI608_I28_n1 b1_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I28_MN0 (I608_gn28 p0_27 XI608_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I29_MN1 (XI608_I29_n1 b1_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I29_MN0 (I608_gn29 p0_28 XI608_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I31_MN1 (XI562_I31_n1 b0_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I31_MN0 (I562_gn31 VSS XI562_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I29_MN1 (XI562_I29_n1 b0_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I29_MN0 (I562_gn29 VSS XI562_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I28_MN1 (XI562_I28_n1 b0_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I28_MN0 (I562_gn28 VSS XI562_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I29_MN1 (XI2066_I29_n1 dm29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I29_MN0 (I2066_gn29 p31_29 XI2066_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I28_MN1 (XI2066_I28_n1 dm28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I28_MN0 (I2066_gn28 p31_28 XI2066_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I30_MN1 (XI2066_I30_n1 dm30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I30_MN0 (I2066_gn30 p31_30 XI2066_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2058_MN1 (XI2058_n1 p31_32_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2058_MN0 (dmn28 dd28_b3_5 XI2058_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2062_MN1 (XI2062_n1 p31_32_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2062_MN0 (dmn30 dd30_b3_5 XI2062_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2060_MN1 (XI2060_n1 p31_32_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2060_MN0 (dmn29 dd29_b3_5 XI2060_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I30_MN1 (XI1988_I30_n1 b31_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I30_MN0 (I1988_gn30 p30_29 XI1988_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I31_MN1 (XI1988_I31_n1 b31_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I31_MN0 (I1988_gn31 p30_30 XI1988_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I28_MN1 (XI1988_I28_n1 b31_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I28_MN0 (I1988_gn28 p30_27 XI1988_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I29_MN1 (XI1988_I29_n1 b31_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I29_MN0 (I1988_gn29 p30_28 XI1988_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I126_XP_MN1 (XI1942_I126_XP_n1 I1942_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I126_XP_MN0 (I1942_P30_27n I1942_P30_29 XI1942_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I30_MN1 (XI1942_I30_n1 b30_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I30_MN0 (I1942_gn30 p29_29 XI1942_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I127_XP_MN1 (XI1942_I127_XP_n1 I1942_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I127_XP_MN0 (I1942_P31_28n I1942_P31_30 XI1942_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I31_MN1 (XI1942_I31_n1 b30_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I31_MN0 (I1942_gn31 p29_30 XI1942_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I28_MN1 (XI1942_I28_n1 b30_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I28_MN0 (I1942_gn28 p29_27 XI1942_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I27_MN1 (XI1942_I27_n1 b30_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I27_MN0 (I1942_gn27 p29_26 XI1942_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I181_XP_MN1 (XI1896_I181_XP_n1 I1896_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I181_XP_MN0 (I1896_P30_15n I1896_P30_23 XI1896_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I126_XP_MN1 (XI1896_I126_XP_n1 I1896_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I126_XP_MN0 (I1896_P30_27n I1896_P30_29 XI1896_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I26_MN1 (XI1896_I26_n1 b29_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I26_MN0 (I1896_gn26 p28_25 XI1896_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I27_MN1 (XI1896_I27_n1 b29_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I27_MN0 (I1896_gn27 p28_26 XI1896_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I29_MN1 (XI700_I29_n1 b3_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I29_MN0 (I700_gn29 p2_28 XI700_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I30_MN1 (XI700_I30_n1 b3_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I30_MN0 (I700_gn30 p2_29 XI700_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I182_XP_MN1 (XI654_I182_XP_n1 I654_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I182_XP_MN0 (I654_P31_16n I654_P31_24 XI654_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I123_XP_MN1 (XI654_I123_XP_n1 I654_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I123_XP_MN0 (I654_P27_24n I654_P27_26 XI654_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I125_XP_MN1 (XI654_I125_XP_n1 I654_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I125_XP_MN0 (I654_P29_26n I654_P29_28 XI654_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I27_MN1 (XI654_I27_n1 b2_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I27_MN0 (I654_gn27 p1_26 XI654_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I126_XP_MN1 (XI654_I126_XP_n1 I654_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I126_XP_MN0 (I654_P30_27n I654_P30_29 XI654_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I25_MN1 (XI654_I25_n1 b2_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I25_MN0 (I654_gn25 p1_24 XI654_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I26_MN1 (XI654_I26_n1 b2_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I26_MN0 (I654_gn26 p1_25 XI654_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I182_XP_MN1 (XI608_I182_XP_n1 I608_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I182_XP_MN0 (I608_P31_16n I608_P31_24 XI608_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I125_XP_MN1 (XI608_I125_XP_n1 I608_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I125_XP_MN0 (I608_P29_26n I608_P29_28 XI608_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I123_XP_MN1 (XI608_I123_XP_n1 I608_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I123_XP_MN0 (I608_P27_24n I608_P27_26 XI608_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I126_XP_MN1 (XI608_I126_XP_n1 I608_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I126_XP_MN0 (I608_P30_27n I608_P30_29 XI608_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I25_MN1 (XI608_I25_n1 b1_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I25_MN0 (I608_gn25 p0_24 XI608_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I26_MN1 (XI608_I26_n1 b1_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I26_MN0 (I608_gn26 p0_25 XI608_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I27_MN1 (XI608_I27_n1 b1_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I27_MN0 (I608_gn27 p0_26 XI608_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I25_MN1 (XI562_I25_n1 b0_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I25_MN0 (I562_gn25 VSS XI562_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I24_MN1 (XI562_I24_n1 b0_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I24_MN0 (I562_gn24 VSS XI562_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I126_XP_MN1 (XI562_I126_XP_n1 I562_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I126_XP_MN0 (I562_P30_27n I562_P30_29 XI562_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I26_MN1 (XI562_I26_n1 b0_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I26_MN0 (I562_gn26 VSS XI562_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I27_MN1 (XI562_I27_n1 b0_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I27_MN0 (I562_gn27 VSS XI562_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I127_XP_MN1 (XI562_I127_XP_n1 I562_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I127_XP_MN0 (I562_P31_28n I562_P31_30 XI562_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I127_XP_MN1 (XI2066_I127_XP_n1 I2066_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I127_XP_MN0 (I2066_P31_28n I2066_P31_30 XI2066_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I126_XP_MN1 (XI2066_I126_XP_n1 I2066_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I126_XP_MN0 (I2066_P30_27n I2066_P30_29 XI2066_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I26_MN1 (XI2066_I26_n1 dm26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I26_MN0 (I2066_gn26 p31_26 XI2066_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I27_MN1 (XI2066_I27_n1 dm27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I27_MN0 (I2066_gn27 p31_27 XI2066_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2056_MN1 (XI2056_n1 p31_32_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2056_MN0 (dmn27 dd27_b3_5 XI2056_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I126_XP_MN1 (XI1988_I126_XP_n1 I1988_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I126_XP_MN0 (I1988_P30_27n I1988_P30_29 XI1988_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I127_XP_MN1 (XI1988_I127_XP_n1 I1988_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I127_XP_MN0 (I1988_P31_28n I1988_P31_30 XI1988_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I125_XP_MN1 (XI1988_I125_XP_n1 I1988_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I125_XP_MN0 (I1988_P29_26n I1988_P29_28 XI1988_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I27_MN1 (XI1988_I27_n1 b31_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I27_MN0 (I1988_gn27 p30_26 XI1988_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I26_MN1 (XI1988_I26_n1 b31_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I26_MN0 (I1988_gn26 p30_25 XI1988_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I181_XP_MN1 (XI1942_I181_XP_n1 I1942_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I181_XP_MN0 (I1942_P30_15n I1942_P30_23 XI1942_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I124_XP_MN1 (XI1942_I124_XP_n1 I1942_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I124_XP_MN0 (I1942_P28_25n I1942_P28_27 XI1942_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I125_XP_MN1 (XI1942_I125_XP_n1 I1942_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I125_XP_MN0 (I1942_P29_26n I1942_P29_28 XI1942_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I123_XP_MN1 (XI1942_I123_XP_n1 I1942_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I123_XP_MN0 (I1942_P27_24n I1942_P27_26 XI1942_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I25_MN1 (XI1942_I25_n1 b30_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I25_MN0 (I1942_gn25 p29_24 XI1942_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I26_MN1 (XI1942_I26_n1 b30_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I26_MN0 (I1942_gn26 p29_25 XI1942_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I177_XP_MN1 (XI1896_I177_XP_n1 I1896_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I177_XP_MN0 (I1896_P26_11n I1896_P26_19 XI1896_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I179_XP_MN1 (XI1896_I179_XP_n1 I1896_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I179_XP_MN0 (I1896_P28_13n I1896_P28_21 XI1896_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I122_XP_MN1 (XI1896_I122_XP_n1 I1896_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I122_XP_MN0 (I1896_P26_23n I1896_P26_25 XI1896_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I124_XP_MN1 (XI1896_I124_XP_n1 I1896_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I124_XP_MN0 (I1896_P28_25n I1896_P28_27 XI1896_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I25_MN1 (XI1896_I25_n1 b29_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I25_MN0 (I1896_gn25 p28_24 XI1896_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I28_MN1 (XI1896_I28_n1 b29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I28_MN0 (I1896_gn28 p28_27 XI1896_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I29_MN1 (XI1896_I29_n1 b29_29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I29_MN0 (I1896_gn29 p28_28 XI1896_I29_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I28_MN1 (XI700_I28_n1 b3_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I28_MN0 (I700_gn28 p2_27 XI700_I28_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I27_MN1 (XI700_I27_n1 b3_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I27_MN0 (I700_gn27 p2_26 XI700_I27_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I178_XP_MN1 (XI654_I178_XP_n1 I654_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I178_XP_MN0 (I654_P27_12n I654_P27_20 XI654_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I181_XP_MN1 (XI654_I181_XP_n1 I654_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I181_XP_MN0 (I654_P30_15n I654_P30_23 XI654_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I124_XP_MN1 (XI654_I124_XP_n1 I654_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I124_XP_MN0 (I654_P28_25n I654_P28_27 XI654_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I24_MN1 (XI654_I24_n1 b2_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I24_MN0 (I654_gn24 p1_23 XI654_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I178_XP_MN1 (XI608_I178_XP_n1 I608_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I178_XP_MN0 (I608_P27_12n I608_P27_20 XI608_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I122_XP_MN1 (XI608_I122_XP_n1 I608_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I122_XP_MN0 (I608_P26_23n I608_P26_25 XI608_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I124_XP_MN1 (XI608_I124_XP_n1 I608_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I124_XP_MN0 (I608_P28_25n I608_P28_27 XI608_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I23_MN1 (XI608_I23_n1 b1_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I23_MN0 (I608_gn23 p0_22 XI608_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I24_MN1 (XI608_I24_n1 b1_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I24_MN0 (I608_gn24 p0_23 XI608_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I23_MN1 (XI562_I23_n1 b0_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I23_MN0 (I562_gn23 VSS XI562_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I124_XP_MN1 (XI562_I124_XP_n1 I562_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I124_XP_MN0 (I562_P28_25n I562_P28_27 XI562_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I182_XP_MN1 (XI2066_I182_XP_n1 I2066_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I182_XP_MN0 (I2066_P31_16n I2066_P31_24 XI2066_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I125_XP_MN1 (XI2066_I125_XP_n1 I2066_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I125_XP_MN0 (I2066_P29_26n I2066_P29_28 XI2066_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I123_XP_MN1 (XI2066_I123_XP_n1 I2066_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I123_XP_MN0 (I2066_P27_24n I2066_P27_26 XI2066_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I124_XP_MN1 (XI2066_I124_XP_n1 I2066_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I124_XP_MN0 (I2066_P28_25n I2066_P28_27 XI2066_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I25_MN1 (XI2066_I25_n1 dm25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I25_MN0 (I2066_gn25 p31_25 XI2066_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2054_MN1 (XI2054_n1 p31_32_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2054_MN0 (dmn26 dd26_b3_5 XI2054_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2052_MN1 (XI2052_n1 p31_32_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2052_MN0 (dmn25 dd25_b3_5 XI2052_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I124_XP_MN1 (XI1988_I124_XP_n1 I1988_P26_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I124_XP_MN0 (I1988_P28_25n I1988_P28_27 XI1988_I124_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I123_XP_MN1 (XI1988_I123_XP_n1 I1988_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I123_XP_MN0 (I1988_P27_24n I1988_P27_26 XI1988_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I25_MN1 (XI1988_I25_n1 b31_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I25_MN0 (I1988_gn25 p30_24 XI1988_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I24_MN1 (XI1988_I24_n1 b31_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I24_MN0 (I1988_gn24 p30_23 XI1988_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I179_XP_MN1 (XI1942_I179_XP_n1 I1942_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I179_XP_MN0 (I1942_P28_13n I1942_P28_21 XI1942_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I122_XP_MN1 (XI1942_I122_XP_n1 I1942_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I122_XP_MN0 (I1942_P26_23n I1942_P26_25 XI1942_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I120_XP_MN1 (XI1942_I120_XP_n1 I1942_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I120_XP_MN0 (I1942_P24_21n I1942_P24_23 XI1942_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I180_XP_MN1 (XI1942_I180_XP_n1 I1942_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I180_XP_MN0 (I1942_P29_14n I1942_P29_22 XI1942_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I182_XP_MN1 (XI1942_I182_XP_n1 I1942_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I182_XP_MN0 (I1942_P31_16n I1942_P31_24 XI1942_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I121_XP_MN1 (XI1942_I121_XP_n1 I1942_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I121_XP_MN0 (I1942_P25_22n I1942_P25_24 XI1942_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I22_MN1 (XI1942_I22_n1 b30_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I22_MN0 (I1942_gn22 p29_21 XI1942_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I23_MN1 (XI1942_I23_n1 b30_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I23_MN0 (I1942_gn23 p29_22 XI1942_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I24_MN1 (XI1942_I24_n1 b30_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I24_MN0 (I1942_gn24 p29_23 XI1942_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I175_XP_MN1 (XI1896_I175_XP_n1 I1896_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I175_XP_MN0 (I1896_P24_9n I1896_P24_17 XI1896_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I173_XP_MN1 (XI1896_I173_XP_n1 I1896_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I173_XP_MN0 (I1896_P22_7n I1896_P22_15 XI1896_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I120_XP_MN1 (XI1896_I120_XP_n1 I1896_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I120_XP_MN0 (I1896_P24_21n I1896_P24_23 XI1896_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I24_MN1 (XI1896_I24_n1 b29_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I24_MN0 (I1896_gn24 p28_23 XI1896_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I125_XP_MN1 (XI1896_I125_XP_n1 I1896_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I125_XP_MN0 (I1896_P29_26n I1896_P29_28 XI1896_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I127_XP_MN1 (XI1896_I127_XP_n1 I1896_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I127_XP_MN0 (I1896_P31_28n I1896_P31_30 XI1896_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I26_MN1 (XI700_I26_n1 b3_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I26_MN0 (I700_gn26 p2_25 XI700_I26_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I24_MN1 (XI700_I24_n1 b3_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I24_MN0 (I700_gn24 p2_23 XI700_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I25_MN1 (XI700_I25_n1 b3_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I25_MN0 (I700_gn25 p2_24 XI700_I25_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I174_XP_MN1 (XI654_I174_XP_n1 I654_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I174_XP_MN0 (I654_P23_8n I654_P23_16 XI654_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I180_XP_MN1 (XI654_I180_XP_n1 I654_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I180_XP_MN0 (I654_P29_14n I654_P29_22 XI654_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I119_XP_MN1 (XI654_I119_XP_n1 I654_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I119_XP_MN0 (I654_P23_20n I654_P23_22 XI654_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I121_XP_MN1 (XI654_I121_XP_n1 I654_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I121_XP_MN0 (I654_P25_22n I654_P25_24 XI654_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I179_XP_MN1 (XI654_I179_XP_n1 I654_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I179_XP_MN0 (I654_P28_13n I654_P28_21 XI654_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I122_XP_MN1 (XI654_I122_XP_n1 I654_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I122_XP_MN0 (I654_P26_23n I654_P26_25 XI654_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I120_XP_MN1 (XI654_I120_XP_n1 I654_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I120_XP_MN0 (I654_P24_21n I654_P24_23 XI654_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I22_MN1 (XI654_I22_n1 b2_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I22_MN0 (I654_gn22 p1_21 XI654_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I23_MN1 (XI654_I23_n1 b2_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I23_MN0 (I654_gn23 p1_22 XI654_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I174_XP_MN1 (XI608_I174_XP_n1 I608_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I174_XP_MN0 (I608_P23_8n I608_P23_16 XI608_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I121_XP_MN1 (XI608_I121_XP_n1 I608_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I121_XP_MN0 (I608_P25_22n I608_P25_24 XI608_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I119_XP_MN1 (XI608_I119_XP_n1 I608_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I119_XP_MN0 (I608_P23_20n I608_P23_22 XI608_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I181_XP_MN1 (XI608_I181_XP_n1 I608_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I181_XP_MN0 (I608_P30_15n I608_P30_23 XI608_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I120_XP_MN1 (XI608_I120_XP_n1 I608_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I120_XP_MN0 (I608_P24_21n I608_P24_23 XI608_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I22_MN1 (XI608_I22_n1 b1_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I22_MN0 (I608_gn22 p0_21 XI608_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I22_MN1 (XI562_I22_n1 b0_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I22_MN0 (I562_gn22 VSS XI562_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I122_XP_MN1 (XI562_I122_XP_n1 I562_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I122_XP_MN0 (I562_P26_23n I562_P26_25 XI562_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I121_XP_MN1 (XI562_I121_XP_n1 I562_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I121_XP_MN0 (I562_P25_22n I562_P25_24 XI562_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I123_XP_MN1 (XI562_I123_XP_n1 I562_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I123_XP_MN0 (I562_P27_24n I562_P27_26 XI562_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I125_XP_MN1 (XI562_I125_XP_n1 I562_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I125_XP_MN0 (I562_P29_26n I562_P29_28 XI562_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I174_XP_MN1 (XI2066_I174_XP_n1 I2066_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I174_XP_MN0 (I2066_P23_8n I2066_P23_16 XI2066_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I180_XP_MN1 (XI2066_I180_XP_n1 I2066_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I180_XP_MN0 (I2066_P29_14n I2066_P29_22 XI2066_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I121_XP_MN1 (XI2066_I121_XP_n1 I2066_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I121_XP_MN0 (I2066_P25_22n I2066_P25_24 XI2066_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I181_XP_MN1 (XI2066_I181_XP_n1 I2066_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I181_XP_MN0 (I2066_P30_15n I2066_P30_23 XI2066_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I122_XP_MN1 (XI2066_I122_XP_n1 I2066_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I122_XP_MN0 (I2066_P26_23n I2066_P26_25 XI2066_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I24_MN1 (XI2066_I24_n1 dm24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I24_MN0 (I2066_gn24 p31_24 XI2066_I24_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I23_MN1 (XI2066_I23_n1 dm23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I23_MN0 (I2066_gn23 p31_23 XI2066_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2050_MN1 (XI2050_n1 p31_32_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2050_MN0 (dmn24 dd24_b3_5 XI2050_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2048_MN1 (XI2048_n1 p31_32_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2048_MN0 (dmn23 dd23_b3_5 XI2048_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I181_XP_MN1 (XI1988_I181_XP_n1 I1988_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I181_XP_MN0 (I1988_P30_15n I1988_P30_23 XI1988_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I122_XP_MN1 (XI1988_I122_XP_n1 I1988_P24_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I122_XP_MN0 (I1988_P26_23n I1988_P26_25 XI1988_I122_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I182_XP_MN1 (XI1988_I182_XP_n1 I1988_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I182_XP_MN0 (I1988_P31_16n I1988_P31_24 XI1988_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I121_XP_MN1 (XI1988_I121_XP_n1 I1988_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I121_XP_MN0 (I1988_P25_22n I1988_P25_24 XI1988_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I23_MN1 (XI1988_I23_n1 b31_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I23_MN0 (I1988_gn23 p30_22 XI1988_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I22_MN1 (XI1988_I22_n1 b31_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I22_MN0 (I1988_gn22 p30_21 XI1988_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I177_XP_MN1 (XI1942_I177_XP_n1 I1942_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I177_XP_MN0 (I1942_P26_11n I1942_P26_19 XI1942_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I178_XP_MN1 (XI1942_I178_XP_n1 I1942_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I178_XP_MN0 (I1942_P27_12n I1942_P27_20 XI1942_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I174_XP_MN1 (XI1942_I174_XP_n1 I1942_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I174_XP_MN0 (I1942_P23_8n I1942_P23_16 XI1942_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I171_XP_MN1 (XI1896_I171_XP_n1 I1896_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I171_XP_MN0 (I1896_P20_5n I1896_P20_13 XI1896_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I176_XP_MN1 (XI1896_I176_XP_n1 I1896_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I176_XP_MN0 (I1896_P25_10n I1896_P25_18 XI1896_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I118_XP_MN1 (XI1896_I118_XP_n1 I1896_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I118_XP_MN0 (I1896_P22_19n I1896_P22_21 XI1896_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I180_XP_MN1 (XI1896_I180_XP_n1 I1896_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I180_XP_MN0 (I1896_P29_14n I1896_P29_22 XI1896_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I21_MN1 (XI1896_I21_n1 b29_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I21_MN0 (I1896_gn21 p28_20 XI1896_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I121_XP_MN1 (XI1896_I121_XP_n1 I1896_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I121_XP_MN0 (I1896_P25_22n I1896_P25_24 XI1896_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I22_MN1 (XI1896_I22_n1 b29_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I22_MN0 (I1896_gn22 p28_21 XI1896_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I123_XP_MN1 (XI1896_I123_XP_n1 I1896_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I123_XP_MN0 (I1896_P27_24n I1896_P27_26 XI1896_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I23_MN1 (XI1896_I23_n1 b29_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I23_MN0 (I1896_gn23 p28_22 XI1896_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I30_MN1 (XI1896_I30_n1 b29_30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I30_MN0 (I1896_gn30 p28_29 XI1896_I30_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I31_MN1 (XI1896_I31_n1 b29_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I31_MN0 (I1896_gn31 p28_30 XI1896_I31_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I23_MN1 (XI700_I23_n1 b3_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I23_MN0 (I700_gn23 p2_22 XI700_I23_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I173_XP_MN1 (XI654_I173_XP_n1 I654_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I173_XP_MN0 (I654_P22_7n I654_P22_15 XI654_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I118_XP_MN1 (XI654_I118_XP_n1 I654_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I118_XP_MN0 (I654_P22_19n I654_P22_21 XI654_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I21_MN1 (XI654_I21_n1 b2_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I21_MN0 (I654_gn21 p1_20 XI654_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I20_MN1 (XI654_I20_n1 b2_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I20_MN0 (I654_gn20 p1_19 XI654_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I180_XP_MN1 (XI608_I180_XP_n1 I608_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I180_XP_MN0 (I608_P29_14n I608_P29_22 XI608_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I117_XP_MN1 (XI608_I117_XP_n1 I608_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I117_XP_MN0 (I608_P21_18n I608_P21_20 XI608_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I179_XP_MN1 (XI608_I179_XP_n1 I608_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I179_XP_MN0 (I608_P28_13n I608_P28_21 XI608_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I21_MN1 (XI608_I21_n1 b1_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I21_MN0 (I608_gn21 p0_20 XI608_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I21_MN1 (XI562_I21_n1 b0_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I21_MN0 (I562_gn21 VSS XI562_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I20_MN1 (XI562_I20_n1 b0_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I20_MN0 (I562_gn20 VSS XI562_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I181_XP_MN1 (XI562_I181_XP_n1 I562_P22_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I181_XP_MN0 (I562_P30_15n I562_P30_23 XI562_I181_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I119_XP_MN1 (XI562_I119_XP_n1 I562_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I119_XP_MN0 (I562_P23_20n I562_P23_22 XI562_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I180_XP_MN1 (XI562_I180_XP_n1 I562_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I180_XP_MN0 (I562_P29_14n I562_P29_22 XI562_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I182_XP_MN1 (XI562_I182_XP_n1 I562_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I182_XP_MN0 (I562_P31_16n I562_P31_24 XI562_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I178_XP_MN1 (XI2066_I178_XP_n1 I2066_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I178_XP_MN0 (I2066_P27_12n I2066_P27_20 XI2066_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I119_XP_MN1 (XI2066_I119_XP_n1 I2066_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I119_XP_MN0 (I2066_P23_20n I2066_P23_22 XI2066_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I173_XP_MN1 (XI2066_I173_XP_n1 I2066_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I173_XP_MN0 (I2066_P22_7n I2066_P22_15 XI2066_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I120_XP_MN1 (XI2066_I120_XP_n1 I2066_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I120_XP_MN0 (I2066_P24_21n I2066_P24_23 XI2066_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I22_MN1 (XI2066_I22_n1 dm22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I22_MN0 (I2066_gn22 p31_22 XI2066_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I21_MN1 (XI2066_I21_n1 dm21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I21_MN0 (I2066_gn21 p31_21 XI2066_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2044_MN1 (XI2044_n1 p31_32_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2044_MN0 (dmn21 dd21_b3_5 XI2044_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2046_MN1 (XI2046_n1 p31_32_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2046_MN0 (dmn22 dd22_b3_5 XI2046_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I179_XP_MN1 (XI1988_I179_XP_n1 I1988_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I179_XP_MN0 (I1988_P28_13n I1988_P28_21 XI1988_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I120_XP_MN1 (XI1988_I120_XP_n1 I1988_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I120_XP_MN0 (I1988_P24_21n I1988_P24_23 XI1988_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I180_XP_MN1 (XI1988_I180_XP_n1 I1988_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I180_XP_MN0 (I1988_P29_14n I1988_P29_22 XI1988_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I119_XP_MN1 (XI1988_I119_XP_n1 I1988_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I119_XP_MN0 (I1988_P23_20n I1988_P23_22 XI1988_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I21_MN1 (XI1988_I21_n1 b31_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I21_MN0 (I1988_gn21 p30_20 XI1988_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I173_XP_MN1 (XI1942_I173_XP_n1 I1942_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I173_XP_MN0 (I1942_P22_7n I1942_P22_15 XI1942_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I118_XP_MN1 (XI1942_I118_XP_n1 I1942_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I118_XP_MN0 (I1942_P22_19n I1942_P22_21 XI1942_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I176_XP_MN1 (XI1942_I176_XP_n1 I1942_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I176_XP_MN0 (I1942_P25_10n I1942_P25_18 XI1942_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I119_XP_MN1 (XI1942_I119_XP_n1 I1942_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I119_XP_MN0 (I1942_P23_20n I1942_P23_22 XI1942_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I20_MN1 (XI1942_I20_n1 b30_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I20_MN0 (I1942_gn20 p29_19 XI1942_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I21_MN1 (XI1942_I21_n1 b30_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I21_MN0 (I1942_gn21 p29_20 XI1942_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I169_XP_MN1 (XI1896_I169_XP_n1 I1896_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I169_XP_MN0 (I1896_P18_3n I1896_P18_11 XI1896_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I116_XP_MN1 (XI1896_I116_XP_n1 I1896_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I116_XP_MN0 (I1896_P20_17n I1896_P20_19 XI1896_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I172_XP_MN1 (XI1896_I172_XP_n1 I1896_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I172_XP_MN0 (I1896_P21_6n I1896_P21_14 XI1896_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I117_XP_MN1 (XI1896_I117_XP_n1 I1896_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I117_XP_MN0 (I1896_P21_18n I1896_P21_20 XI1896_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I119_XP_MN1 (XI1896_I119_XP_n1 I1896_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I119_XP_MN0 (I1896_P23_20n I1896_P23_22 XI1896_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I127_XP_MN1 (XI700_I127_XP_n1 I700_P29_28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I127_XP_MN0 (I700_P31_28n I700_P31_30 XI700_I127_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I22_MN1 (XI700_I22_n1 b3_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I22_MN0 (I700_gn22 p2_21 XI700_I22_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I21_MN1 (XI700_I21_n1 b3_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I21_MN0 (I700_gn21 p2_20 XI700_I21_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I20_MN1 (XI700_I20_n1 b3_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I20_MN0 (I700_gn20 p2_19 XI700_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I170_XP_MN1 (XI654_I170_XP_n1 I654_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I170_XP_MN0 (I654_P19_4n I654_P19_12 XI654_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I172_XP_MN1 (XI654_I172_XP_n1 I654_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I172_XP_MN0 (I654_P21_6n I654_P21_14 XI654_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I117_XP_MN1 (XI654_I117_XP_n1 I654_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I117_XP_MN0 (I654_P21_18n I654_P21_20 XI654_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I115_XP_MN1 (XI654_I115_XP_n1 I654_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I115_XP_MN0 (I654_P19_16n I654_P19_18 XI654_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I177_XP_MN1 (XI654_I177_XP_n1 I654_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I177_XP_MN0 (I654_P26_11n I654_P26_19 XI654_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I175_XP_MN1 (XI654_I175_XP_n1 I654_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I175_XP_MN0 (I654_P24_9n I654_P24_17 XI654_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I116_XP_MN1 (XI654_I116_XP_n1 I654_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I116_XP_MN0 (I654_P20_17n I654_P20_19 XI654_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I18_MN1 (XI654_I18_n1 b2_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I18_MN0 (I654_gn18 p1_17 XI654_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I19_MN1 (XI654_I19_n1 b2_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I19_MN0 (I654_gn19 p1_18 XI654_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I172_XP_MN1 (XI608_I172_XP_n1 I608_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I172_XP_MN0 (I608_P21_6n I608_P21_14 XI608_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I176_XP_MN1 (XI608_I176_XP_n1 I608_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I176_XP_MN0 (I608_P25_10n I608_P25_18 XI608_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I173_XP_MN1 (XI608_I173_XP_n1 I608_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I173_XP_MN0 (I608_P22_7n I608_P22_15 XI608_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I118_XP_MN1 (XI608_I118_XP_n1 I608_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I118_XP_MN0 (I608_P22_19n I608_P22_21 XI608_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I19_MN1 (XI608_I19_n1 b1_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I19_MN0 (I608_gn19 p0_18 XI608_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I20_MN1 (XI608_I20_n1 b1_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I20_MN0 (I608_gn20 p0_19 XI608_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I18_MN1 (XI608_I18_n1 b1_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I18_MN0 (I608_gn18 p0_17 XI608_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I19_MN1 (XI562_I19_n1 b0_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I19_MN0 (I562_gn19 VSS XI562_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I118_XP_MN1 (XI562_I118_XP_n1 I562_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I118_XP_MN0 (I562_P22_19n I562_P22_21 XI562_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I120_XP_MN1 (XI562_I120_XP_n1 I562_P22_21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I120_XP_MN0 (I562_P24_21n I562_P24_23 XI562_I120_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I173_XP_MN1 (XI562_I173_XP_n1 I562_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I173_XP_MN0 (I562_P22_7n I562_P22_15 XI562_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I172_XP_MN1 (XI562_I172_XP_n1 I562_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I172_XP_MN0 (I562_P21_6n I562_P21_14 XI562_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I117_XP_MN1 (XI562_I117_XP_n1 I562_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I117_XP_MN0 (I562_P21_18n I562_P21_20 XI562_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I178_XP_MN1 (XI562_I178_XP_n1 I562_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I178_XP_MN0 (I562_P27_12n I562_P27_20 XI562_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I174_XP_MN1 (XI562_I174_XP_n1 I562_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I174_XP_MN0 (I562_P23_8n I562_P23_16 XI562_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I172_XP_MN1 (XI2066_I172_XP_n1 I2066_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I172_XP_MN0 (I2066_P21_6n I2066_P21_14 XI2066_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I117_XP_MN1 (XI2066_I117_XP_n1 I2066_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I117_XP_MN0 (I2066_P21_18n I2066_P21_20 XI2066_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I177_XP_MN1 (XI2066_I177_XP_n1 I2066_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I177_XP_MN0 (I2066_P26_11n I2066_P26_19 XI2066_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I118_XP_MN1 (XI2066_I118_XP_n1 I2066_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I118_XP_MN0 (I2066_P22_19n I2066_P22_21 XI2066_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I19_MN1 (XI2066_I19_n1 dm19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I19_MN0 (I2066_gn19 p31_19 XI2066_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I20_MN1 (XI2066_I20_n1 dm20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I20_MN0 (I2066_gn20 p31_20 XI2066_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2042_MN1 (XI2042_n1 p31_32_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2042_MN0 (dmn20 dd20_b3_5 XI2042_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2040_MN1 (XI2040_n1 p31_32_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2040_MN0 (dmn19 dd19_b3_5 XI2040_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I177_XP_MN1 (XI1988_I177_XP_n1 I1988_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I177_XP_MN0 (I1988_P26_11n I1988_P26_19 XI1988_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I118_XP_MN1 (XI1988_I118_XP_n1 I1988_P20_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I118_XP_MN0 (I1988_P22_19n I1988_P22_21 XI1988_I118_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I174_XP_MN1 (XI1988_I174_XP_n1 I1988_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I174_XP_MN0 (I1988_P23_8n I1988_P23_16 XI1988_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I20_MN1 (XI1988_I20_n1 b31_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I20_MN0 (I1988_gn20 p30_19 XI1988_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I19_MN1 (XI1988_I19_n1 b31_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I19_MN0 (I1988_gn19 p30_18 XI1988_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I175_XP_MN1 (XI1942_I175_XP_n1 I1942_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I175_XP_MN0 (I1942_P24_9n I1942_P24_17 XI1942_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I116_XP_MN1 (XI1942_I116_XP_n1 I1942_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I116_XP_MN0 (I1942_P20_17n I1942_P20_19 XI1942_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I172_XP_MN1 (XI1942_I172_XP_n1 I1942_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I172_XP_MN0 (I1942_P21_6n I1942_P21_14 XI1942_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I115_XP_MN1 (XI1942_I115_XP_n1 I1942_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I115_XP_MN0 (I1942_P19_16n I1942_P19_18 XI1942_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I117_XP_MN1 (XI1942_I117_XP_n1 I1942_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I117_XP_MN0 (I1942_P21_18n I1942_P21_20 XI1942_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I19_MN1 (XI1942_I19_n1 b30_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I19_MN0 (I1942_gn19 p29_18 XI1942_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I110_XP_MN1 (XI1896_I110_XP_n1 I1896_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I110_XP_MN0 (I1896_P14_11n I1896_P14_13 XI1896_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I112_XP_MN1 (XI1896_I112_XP_n1 I1896_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I112_XP_MN0 (I1896_P16_13n I1896_P16_15 XI1896_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I114_XP_MN1 (XI1896_I114_XP_n1 I1896_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I114_XP_MN0 (I1896_P18_15n I1896_P18_17 XI1896_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I18_MN1 (XI1896_I18_n1 b29_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I18_MN0 (I1896_gn18 p28_17 XI1896_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I19_MN1 (XI1896_I19_n1 b29_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I19_MN0 (I1896_gn19 p28_18 XI1896_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I20_MN1 (XI1896_I20_n1 b29_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I20_MN0 (I1896_gn20 p28_19 XI1896_I20_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I178_XP_MN1 (XI1896_I178_XP_n1 I1896_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I178_XP_MN0 (I1896_P27_12n I1896_P27_20 XI1896_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I125_XP_MN1 (XI700_I125_XP_n1 I700_P27_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I125_XP_MN0 (I700_P29_26n I700_P29_28 XI700_I125_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I123_XP_MN1 (XI700_I123_XP_n1 I700_P25_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I123_XP_MN0 (I700_P27_24n I700_P27_26 XI700_I123_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I182_XP_MN1 (XI700_I182_XP_n1 I700_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I182_XP_MN0 (I700_P31_16n I700_P31_24 XI700_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I18_MN1 (XI700_I18_n1 b3_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I18_MN0 (I700_gn18 p2_17 XI700_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I19_MN1 (XI700_I19_n1 b3_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I19_MN0 (I700_gn19 p2_18 XI700_I19_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I17_MN1 (XI700_I17_n1 b3_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I17_MN0 (I700_gn17 p2_16 XI700_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I176_XP_MN1 (XI654_I176_XP_n1 I654_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I176_XP_MN0 (I654_P25_10n I654_P25_18 XI654_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I111_XP_MN1 (XI654_I111_XP_n1 I654_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I111_XP_MN0 (I654_P15_12n I654_P15_14 XI654_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I113_XP_MN1 (XI654_I113_XP_n1 I654_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I113_XP_MN0 (I654_P17_14n I654_P17_16 XI654_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I171_XP_MN1 (XI654_I171_XP_n1 I654_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I171_XP_MN0 (I654_P20_5n I654_P20_13 XI654_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I114_XP_MN1 (XI654_I114_XP_n1 I654_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I114_XP_MN0 (I654_P18_15n I654_P18_17 XI654_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I17_MN1 (XI654_I17_n1 b2_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I17_MN0 (I654_gn17 p1_16 XI654_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I16_MN1 (XI654_I16_n1 b2_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I16_MN0 (I654_gn16 p1_15 XI654_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I113_XP_MN1 (XI608_I113_XP_n1 I608_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I113_XP_MN0 (I608_P17_14n I608_P17_16 XI608_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I115_XP_MN1 (XI608_I115_XP_n1 I608_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I115_XP_MN0 (I608_P19_16n I608_P19_18 XI608_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I177_XP_MN1 (XI608_I177_XP_n1 I608_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I177_XP_MN0 (I608_P26_11n I608_P26_19 XI608_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I116_XP_MN1 (XI608_I116_XP_n1 I608_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I116_XP_MN0 (I608_P20_17n I608_P20_19 XI608_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I17_MN1 (XI608_I17_n1 b1_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I17_MN0 (I608_gn17 p0_16 XI608_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I16_MN1 (XI608_I16_n1 b1_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I16_MN0 (I608_gn16 p0_15 XI608_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I18_MN1 (XI562_I18_n1 b0_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I18_MN0 (I562_gn18 VSS XI562_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I179_XP_MN1 (XI562_I179_XP_n1 I562_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I179_XP_MN0 (I562_P28_13n I562_P28_21 XI562_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I177_XP_MN1 (XI562_I177_XP_n1 I562_P18_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I177_XP_MN0 (I562_P26_11n I562_P26_19 XI562_I177_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I176_XP_MN1 (XI562_I176_XP_n1 I562_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I176_XP_MN0 (I562_P25_10n I562_P25_18 XI562_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I115_XP_MN1 (XI562_I115_XP_n1 I562_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I115_XP_MN0 (I562_P19_16n I562_P19_18 XI562_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I170_XP_MN1 (XI2066_I170_XP_n1 I2066_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I170_XP_MN0 (I2066_P19_4n I2066_P19_12 XI2066_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I113_XP_MN1 (XI2066_I113_XP_n1 I2066_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I113_XP_MN0 (I2066_P17_14n I2066_P17_16 XI2066_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I115_XP_MN1 (XI2066_I115_XP_n1 I2066_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I115_XP_MN0 (I2066_P19_16n I2066_P19_18 XI2066_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I179_XP_MN1 (XI2066_I179_XP_n1 I2066_P20_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I179_XP_MN0 (I2066_P28_13n I2066_P28_21 XI2066_I179_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I116_XP_MN1 (XI2066_I116_XP_n1 I2066_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I116_XP_MN0 (I2066_P20_17n I2066_P20_19 XI2066_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I17_MN1 (XI2066_I17_n1 dm17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I17_MN0 (I2066_gn17 p31_17 XI2066_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I18_MN1 (XI2066_I18_n1 dm18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I18_MN0 (I2066_gn18 p31_18 XI2066_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I173_XP_MN1 (XI1988_I173_XP_n1 I1988_P14_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I173_XP_MN0 (I1988_P22_7n I1988_P22_15 XI1988_I173_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2038_MN1 (XI2038_n1 p31_32_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2038_MN0 (dmn18 dd18_b3_5 XI2038_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I116_XP_MN1 (XI1988_I116_XP_n1 I1988_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I116_XP_MN0 (I1988_P20_17n I1988_P20_19 XI1988_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I178_XP_MN1 (XI1988_I178_XP_n1 I1988_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I178_XP_MN0 (I1988_P27_12n I1988_P27_20 XI1988_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I117_XP_MN1 (XI1988_I117_XP_n1 I1988_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I117_XP_MN0 (I1988_P21_18n I1988_P21_20 XI1988_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I115_XP_MN1 (XI1988_I115_XP_n1 I1988_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I115_XP_MN0 (I1988_P19_16n I1988_P19_18 XI1988_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I18_MN1 (XI1988_I18_n1 b31_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I18_MN0 (I1988_gn18 p30_17 XI1988_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I16_MN1 (XI1988_I16_n1 b31_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I16_MN0 (I1988_gn16 p30_15 XI1988_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I17_MN1 (XI1988_I17_n1 b31_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I17_MN0 (I1988_gn17 p30_16 XI1988_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I171_XP_MN1 (XI1942_I171_XP_n1 I1942_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I171_XP_MN0 (I1942_P20_5n I1942_P20_13 XI1942_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I114_XP_MN1 (XI1942_I114_XP_n1 I1942_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I114_XP_MN0 (I1942_P18_15n I1942_P18_17 XI1942_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I113_XP_MN1 (XI1942_I113_XP_n1 I1942_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I113_XP_MN0 (I1942_P17_14n I1942_P17_16 XI1942_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I14_MN1 (XI1942_I14_n1 b30_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I14_MN0 (I1942_gn14 p29_13 XI1942_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I16_MN1 (XI1942_I16_n1 b30_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I16_MN0 (I1942_gn16 p29_15 XI1942_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I18_MN1 (XI1942_I18_n1 b30_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I18_MN0 (I1942_gn18 p29_17 XI1942_I18_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I17_MN1 (XI1942_I17_n1 b30_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I17_MN0 (I1942_gn17 p29_16 XI1942_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I15_MN1 (XI1942_I15_n1 b30_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I15_MN0 (I1942_gn15 p29_14 XI1942_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I167_XP_MN1 (XI1896_I167_XP_n1 I1896_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I167_XP_MN0 (I1896_P16_1n I1896_P16_9 XI1896_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I168_XP_MN1 (XI1896_I168_XP_n1 I1896_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I168_XP_MN0 (I1896_P17_2n I1896_P17_10 XI1896_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I106_XP_MN1 (XI1896_I106_XP_n1 I1896_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I106_XP_MN0 (I1896_P10_7n I1896_P10_9 XI1896_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I108_XP_MN1 (XI1896_I108_XP_n1 I1896_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I108_XP_MN0 (I1896_P12_9n I1896_P12_11 XI1896_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I113_XP_MN1 (XI1896_I113_XP_n1 I1896_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I113_XP_MN0 (I1896_P17_14n I1896_P17_16 XI1896_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I115_XP_MN1 (XI1896_I115_XP_n1 I1896_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I115_XP_MN0 (I1896_P19_16n I1896_P19_18 XI1896_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I182_XP_MN1 (XI1896_I182_XP_n1 I1896_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I182_XP_MN0 (I1896_P31_16n I1896_P31_24 XI1896_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I121_XP_MN1 (XI700_I121_XP_n1 I700_P23_22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I121_XP_MN0 (I700_P25_22n I700_P25_24 XI700_I121_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I119_XP_MN1 (XI700_I119_XP_n1 I700_P21_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I119_XP_MN0 (I700_P23_20n I700_P23_22 XI700_I119_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I109_XP_MN1 (XI654_I109_XP_n1 I654_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I109_XP_MN0 (I654_P13_10n I654_P13_12 XI654_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I112_XP_MN1 (XI654_I112_XP_n1 I654_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I112_XP_MN0 (I654_P16_13n I654_P16_15 XI654_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I15_MN1 (XI654_I15_n1 b2_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I15_MN0 (I654_gn15 p1_14 XI654_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I14_MN1 (XI654_I14_n1 b2_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I14_MN0 (I654_gn14 p1_13 XI654_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I170_XP_MN1 (XI608_I170_XP_n1 I608_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I170_XP_MN0 (I608_P19_4n I608_P19_12 XI608_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I111_XP_MN1 (XI608_I111_XP_n1 I608_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I111_XP_MN0 (I608_P15_12n I608_P15_14 XI608_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I171_XP_MN1 (XI608_I171_XP_n1 I608_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I171_XP_MN0 (I608_P20_5n I608_P20_13 XI608_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I114_XP_MN1 (XI608_I114_XP_n1 I608_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I114_XP_MN0 (I608_P18_15n I608_P18_17 XI608_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I112_XP_MN1 (XI608_I112_XP_n1 I608_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I112_XP_MN0 (I608_P16_13n I608_P16_15 XI608_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I15_MN1 (XI608_I15_n1 b1_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I15_MN0 (I608_gn15 p0_14 XI608_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I17_MN1 (XI562_I17_n1 b0_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I17_MN0 (I562_gn17 VSS XI562_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I116_XP_MN1 (XI562_I116_XP_n1 I562_P18_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I116_XP_MN0 (I562_P20_17n I562_P20_19 XI562_I116_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I16_MN1 (XI562_I16_n1 b0_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I16_MN0 (I562_gn16 VSS XI562_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I113_XP_MN1 (XI562_I113_XP_n1 I562_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I113_XP_MN0 (I562_P17_14n I562_P17_16 XI562_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I111_XP_MN1 (XI562_I111_XP_n1 I562_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I111_XP_MN0 (I562_P15_12n I562_P15_14 XI562_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I170_XP_MN1 (XI562_I170_XP_n1 I562_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I170_XP_MN0 (I562_P19_4n I562_P19_12 XI562_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I176_XP_MN1 (XI2066_I176_XP_n1 I2066_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I176_XP_MN0 (I2066_P25_10n I2066_P25_18 XI2066_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I111_XP_MN1 (XI2066_I111_XP_n1 I2066_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I111_XP_MN0 (I2066_P15_12n I2066_P15_14 XI2066_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I171_XP_MN1 (XI2066_I171_XP_n1 I2066_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I171_XP_MN0 (I2066_P20_5n I2066_P20_13 XI2066_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I114_XP_MN1 (XI2066_I114_XP_n1 I2066_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I114_XP_MN0 (I2066_P18_15n I2066_P18_17 XI2066_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I112_XP_MN1 (XI2066_I112_XP_n1 I2066_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I112_XP_MN0 (I2066_P16_13n I2066_P16_15 XI2066_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I15_MN1 (XI2066_I15_n1 dm15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I15_MN0 (I2066_gn15 p31_15 XI2066_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I16_MN1 (XI2066_I16_n1 dm16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I16_MN0 (I2066_gn16 p31_16 XI2066_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2034_MN1 (XI2034_n1 p31_32_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2034_MN0 (dmn16 dd16_b3_5 XI2034_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2036_MN1 (XI2036_n1 p31_32_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2036_MN0 (dmn17 dd17_b3_5 XI2036_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I114_XP_MN1 (XI1988_I114_XP_n1 I1988_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I114_XP_MN0 (I1988_P18_15n I1988_P18_17 XI1988_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I172_XP_MN1 (XI1988_I172_XP_n1 I1988_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I172_XP_MN0 (I1988_P21_6n I1988_P21_14 XI1988_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I113_XP_MN1 (XI1988_I113_XP_n1 I1988_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I113_XP_MN0 (I1988_P17_14n I1988_P17_16 XI1988_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I111_XP_MN1 (XI1988_I111_XP_n1 I1988_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I111_XP_MN0 (I1988_P15_12n I1988_P15_14 XI1988_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I15_MN1 (XI1988_I15_n1 b31_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I15_MN0 (I1988_gn15 p30_14 XI1988_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I110_XP_MN1 (XI1942_I110_XP_n1 I1942_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I110_XP_MN0 (I1942_P14_11n I1942_P14_13 XI1942_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I112_XP_MN1 (XI1942_I112_XP_n1 I1942_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I112_XP_MN0 (I1942_P16_13n I1942_P16_15 XI1942_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I170_XP_MN1 (XI1942_I170_XP_n1 I1942_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I170_XP_MN0 (I1942_P19_4n I1942_P19_12 XI1942_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I111_XP_MN1 (XI1942_I111_XP_n1 I1942_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I111_XP_MN0 (I1942_P15_12n I1942_P15_14 XI1942_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I13_MN1 (XI1942_I13_n1 b30_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I13_MN0 (I1942_gn13 p29_12 XI1942_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I109_XP_MN1 (XI1896_I109_XP_n1 I1896_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I109_XP_MN0 (I1896_P13_10n I1896_P13_12 XI1896_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I111_XP_MN1 (XI1896_I111_XP_n1 I1896_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I111_XP_MN0 (I1896_P15_12n I1896_P15_14 XI1896_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I14_MN1 (XI1896_I14_n1 b29_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I14_MN0 (I1896_gn14 p28_13 XI1896_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I17_MN1 (XI1896_I17_n1 b29_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I17_MN0 (I1896_gn17 p28_16 XI1896_I17_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I170_XP_MN1 (XI1896_I170_XP_n1 I1896_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I170_XP_MN0 (I1896_P19_4n I1896_P19_12 XI1896_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I174_XP_MN1 (XI1896_I174_XP_n1 I1896_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I174_XP_MN0 (I1896_P23_8n I1896_P23_16 XI1896_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I117_XP_MN1 (XI700_I117_XP_n1 I700_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I117_XP_MN0 (I700_P21_18n I700_P21_20 XI700_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I115_XP_MN1 (XI700_I115_XP_n1 I700_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I115_XP_MN0 (I700_P19_16n I700_P19_18 XI700_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I16_MN1 (XI700_I16_n1 b3_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I16_MN0 (I700_gn16 p2_15 XI700_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I14_MN1 (XI700_I14_n1 b3_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I14_MN0 (I700_gn14 p2_13 XI700_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I15_MN1 (XI700_I15_n1 b3_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I15_MN0 (I700_gn15 p2_14 XI700_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I168_XP_MN1 (XI654_I168_XP_n1 I654_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I168_XP_MN0 (I654_P17_2n I654_P17_10 XI654_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I107_XP_MN1 (XI654_I107_XP_n1 I654_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I107_XP_MN0 (I654_P11_8n I654_P11_10 XI654_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I169_XP_MN1 (XI654_I169_XP_n1 I654_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I169_XP_MN0 (I654_P18_3n I654_P18_11 XI654_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I110_XP_MN1 (XI654_I110_XP_n1 I654_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I110_XP_MN0 (I654_P14_11n I654_P14_13 XI654_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I13_MN1 (XI654_I13_n1 b2_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I13_MN0 (I654_gn13 p1_12 XI654_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I109_XP_MN1 (XI608_I109_XP_n1 I608_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I109_XP_MN0 (I608_P13_10n I608_P13_12 XI608_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I169_XP_MN1 (XI608_I169_XP_n1 I608_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I169_XP_MN0 (I608_P18_3n I608_P18_11 XI608_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I175_XP_MN1 (XI608_I175_XP_n1 I608_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I175_XP_MN0 (I608_P24_9n I608_P24_17 XI608_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I110_XP_MN1 (XI608_I110_XP_n1 I608_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I110_XP_MN0 (I608_P14_11n I608_P14_13 XI608_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I13_MN1 (XI608_I13_n1 b1_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I13_MN0 (I608_gn13 p0_12 XI608_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I14_MN1 (XI608_I14_n1 b1_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I14_MN0 (I608_gn14 p0_13 XI608_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I114_XP_MN1 (XI562_I114_XP_n1 I562_P16_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I114_XP_MN0 (I562_P18_15n I562_P18_17 XI562_I114_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I15_MN1 (XI562_I15_n1 b0_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I15_MN0 (I562_gn15 VSS XI562_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I14_MN1 (XI562_I14_n1 b0_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I14_MN0 (I562_gn14 VSS XI562_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I109_XP_MN1 (XI562_I109_XP_n1 I562_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I109_XP_MN0 (I562_P13_10n I562_P13_12 XI562_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I168_XP_MN1 (XI2066_I168_XP_n1 I2066_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I168_XP_MN0 (I2066_P17_2n I2066_P17_10 XI2066_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I109_XP_MN1 (XI2066_I109_XP_n1 I2066_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I109_XP_MN0 (I2066_P13_10n I2066_P13_12 XI2066_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I169_XP_MN1 (XI2066_I169_XP_n1 I2066_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I169_XP_MN0 (I2066_P18_3n I2066_P18_11 XI2066_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I110_XP_MN1 (XI2066_I110_XP_n1 I2066_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I110_XP_MN0 (I2066_P14_11n I2066_P14_13 XI2066_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I13_MN1 (XI2066_I13_n1 dm13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I13_MN0 (I2066_gn13 p31_13 XI2066_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I14_MN1 (XI2066_I14_n1 dm14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I14_MN0 (I2066_gn14 p31_14 XI2066_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2032_MN1 (XI2032_n1 p31_32_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2032_MN0 (dmn15 dd15_b3_5 XI2032_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2030_MN1 (XI2030_n1 p31_32_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2030_MN0 (dmn14 dd14_b3_5 XI2030_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I171_XP_MN1 (XI1988_I171_XP_n1 I1988_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I171_XP_MN0 (I1988_P20_5n I1988_P20_13 XI1988_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I112_XP_MN1 (XI1988_I112_XP_n1 I1988_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I112_XP_MN0 (I1988_P16_13n I1988_P16_15 XI1988_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I176_XP_MN1 (XI1988_I176_XP_n1 I1988_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I176_XP_MN0 (I1988_P25_10n I1988_P25_18 XI1988_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I14_MN1 (XI1988_I14_n1 b31_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I14_MN0 (I1988_gn14 p30_13 XI1988_I14_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I13_MN1 (XI1988_I13_n1 b31_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I13_MN0 (I1988_gn13 p30_12 XI1988_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I169_XP_MN1 (XI1942_I169_XP_n1 I1942_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I169_XP_MN0 (I1942_P18_3n I1942_P18_11 XI1942_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I108_XP_MN1 (XI1942_I108_XP_n1 I1942_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I108_XP_MN0 (I1942_P12_9n I1942_P12_11 XI1942_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I109_XP_MN1 (XI1942_I109_XP_n1 I1942_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I109_XP_MN0 (I1942_P13_10n I1942_P13_12 XI1942_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I11_MN1 (XI1942_I11_n1 b30_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I11_MN0 (I1942_gn11 p29_10 XI1942_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I12_MN1 (XI1942_I12_n1 b30_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I12_MN0 (I1942_gn12 p29_11 XI1942_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I104_XP_MN1 (XI1896_I104_XP_n1 I1896_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I104_XP_MN0 (I1896_P8_5n I1896_P8_7 XI1896_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I105_XP_MN1 (XI1896_I105_XP_n1 I1896_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I105_XP_MN0 (I1896_P9_6n I1896_P9_8 XI1896_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I107_XP_MN1 (XI1896_I107_XP_n1 I1896_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I107_XP_MN0 (I1896_P11_8n I1896_P11_10 XI1896_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I13_MN1 (XI1896_I13_n1 b29_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I13_MN0 (I1896_gn13 p28_12 XI1896_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I15_MN1 (XI1896_I15_n1 b29_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I15_MN0 (I1896_gn15 p28_14 XI1896_I15_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I16_MN1 (XI1896_I16_n1 b29_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I16_MN0 (I1896_gn16 p28_15 XI1896_I16_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I178_XP_MN1 (XI700_I178_XP_n1 I700_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I178_XP_MN0 (I700_P27_12n I700_P27_20 XI700_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I180_XP_MN1 (XI700_I180_XP_n1 I700_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I180_XP_MN0 (I700_P29_14n I700_P29_22 XI700_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I174_XP_MN1 (XI700_I174_XP_n1 I700_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I174_XP_MN0 (I700_P23_8n I700_P23_16 XI700_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I113_XP_MN1 (XI700_I113_XP_n1 I700_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I113_XP_MN0 (I700_P17_14n I700_P17_16 XI700_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I111_XP_MN1 (XI700_I111_XP_n1 I700_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I111_XP_MN0 (I700_P15_12n I700_P15_14 XI700_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I13_MN1 (XI700_I13_n1 b3_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I13_MN0 (I700_gn13 p2_12 XI700_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I12_MN1 (XI700_I12_n1 b3_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I12_MN0 (I700_gn12 p2_11 XI700_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I108_XP_MN1 (XI654_I108_XP_n1 I654_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I108_XP_MN0 (I654_P12_9n I654_P12_11 XI654_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I12_MN1 (XI654_I12_n1 b2_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I12_MN0 (I654_gn12 p1_11 XI654_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I11_MN1 (XI654_I11_n1 b2_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I11_MN0 (I654_gn11 p1_10 XI654_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I107_XP_MN1 (XI608_I107_XP_n1 I608_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I107_XP_MN0 (I608_P11_8n I608_P11_10 XI608_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I108_XP_MN1 (XI608_I108_XP_n1 I608_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I108_XP_MN0 (I608_P12_9n I608_P12_11 XI608_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I12_MN1 (XI608_I12_n1 b1_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I12_MN0 (I608_gn12 p0_11 XI608_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I171_XP_MN1 (XI562_I171_XP_n1 I562_P12_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I171_XP_MN0 (I562_P20_5n I562_P20_13 XI562_I171_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I13_MN1 (XI562_I13_n1 b0_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I13_MN0 (I562_gn13 VSS XI562_I13_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I112_XP_MN1 (XI562_I112_XP_n1 I562_P14_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I112_XP_MN0 (I562_P16_13n I562_P16_15 XI562_I112_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I110_XP_MN1 (XI562_I110_XP_n1 I562_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I110_XP_MN0 (I562_P14_11n I562_P14_13 XI562_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I168_XP_MN1 (XI562_I168_XP_n1 I562_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I168_XP_MN0 (I562_P17_2n I562_P17_10 XI562_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I12_MN1 (XI562_I12_n1 b0_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I12_MN0 (I562_gn12 VSS XI562_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I107_XP_MN1 (XI2066_I107_XP_n1 I2066_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I107_XP_MN0 (I2066_P11_8n I2066_P11_10 XI2066_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I175_XP_MN1 (XI2066_I175_XP_n1 I2066_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I175_XP_MN0 (I2066_P24_9n I2066_P24_17 XI2066_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I108_XP_MN1 (XI2066_I108_XP_n1 I2066_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I108_XP_MN0 (I2066_P12_9n I2066_P12_11 XI2066_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I12_MN1 (XI2066_I12_n1 dm12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I12_MN0 (I2066_gn12 p31_12 XI2066_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2028_MN1 (XI2028_n1 p31_32_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2028_MN0 (dmn13 dd13_b3_5 XI2028_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2026_MN1 (XI2026_n1 p31_32_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2026_MN0 (dmn12 dd12_b3_5 XI2026_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I175_XP_MN1 (XI1988_I175_XP_n1 I1988_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I175_XP_MN0 (I1988_P24_9n I1988_P24_17 XI1988_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I110_XP_MN1 (XI1988_I110_XP_n1 I1988_P12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I110_XP_MN0 (I1988_P14_11n I1988_P14_13 XI1988_I110_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I170_XP_MN1 (XI1988_I170_XP_n1 I1988_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I170_XP_MN0 (I1988_P19_4n I1988_P19_12 XI1988_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I109_XP_MN1 (XI1988_I109_XP_n1 I1988_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I109_XP_MN0 (I1988_P13_10n I1988_P13_12 XI1988_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I12_MN1 (XI1988_I12_n1 b31_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I12_MN0 (I1988_gn12 p30_11 XI1988_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I106_XP_MN1 (XI1942_I106_XP_n1 I1942_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I106_XP_MN0 (I1942_P10_7n I1942_P10_9 XI1942_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I168_XP_MN1 (XI1942_I168_XP_n1 I1942_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I168_XP_MN0 (I1942_P17_2n I1942_P17_10 XI1942_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I107_XP_MN1 (XI1942_I107_XP_n1 I1942_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I107_XP_MN0 (I1942_P11_8n I1942_P11_10 XI1942_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I10_MN1 (XI1942_I10_n1 b30_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I10_MN0 (I1942_gn10 p29_9 XI1942_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I100_XP_MN1 (XI1896_I100_XP_n1 I1896_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I100_XP_MN0 (I1896_P4_1n I1896_P4_3 XI1896_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I102_XP_MN1 (XI1896_I102_XP_n1 I1896_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I102_XP_MN0 (I1896_P6_3n I1896_P6_5 XI1896_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I103_XP_MN1 (XI1896_I103_XP_n1 I1896_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I103_XP_MN0 (I1896_P7_4n I1896_P7_6 XI1896_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I9_MN1 (XI1896_I9_n1 b29_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I9_MN0 (I1896_gn9 p28_8 XI1896_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I12_MN1 (XI1896_I12_n1 b29_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I12_MN0 (I1896_gn12 p28_11 XI1896_I12_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I170_XP_MN1 (XI1850_I170_XP_n1 I1850_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I170_XP_MN0 (I1850_P19_4n I1850_P19_12 XI1850_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I174_XP_MN1 (XI1850_I174_XP_n1 I1850_P15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I174_XP_MN0 (I1850_P23_8n I1850_P23_16 XI1850_I174_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I178_XP_MN1 (XI1850_I178_XP_n1 I1850_P19_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I178_XP_MN0 (I1850_P27_12n I1850_P27_20 XI1850_I178_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I176_XP_MN1 (XI700_I176_XP_n1 I700_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I176_XP_MN0 (I700_P25_10n I700_P25_18 XI700_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I109_XP_MN1 (XI700_I109_XP_n1 I700_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I109_XP_MN0 (I700_P13_10n I700_P13_12 XI700_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I11_MN1 (XI700_I11_n1 b3_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I11_MN0 (I700_gn11 p2_10 XI700_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I103_XP_MN1 (XI654_I103_XP_n1 I654_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I103_XP_MN0 (I654_P7_4n I654_P7_6 XI654_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I105_XP_MN1 (XI654_I105_XP_n1 I654_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I105_XP_MN0 (I654_P9_6n I654_P9_8 XI654_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I101_XP_MN1 (XI654_I101_XP_n1 I654_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I101_XP_MN0 (I654_P5_2n I654_P5_4 XI654_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I167_XP_MN1 (XI654_I167_XP_n1 I654_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I167_XP_MN0 (I654_P16_1n I654_P16_9 XI654_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I106_XP_MN1 (XI654_I106_XP_n1 I654_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I106_XP_MN0 (I654_P10_7n I654_P10_9 XI654_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I9_MN1 (XI654_I9_n1 b2_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I9_MN0 (I654_gn9 p1_8 XI654_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I10_MN1 (XI654_I10_n1 b2_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I10_MN0 (I654_gn10 p1_9 XI654_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I168_XP_MN1 (XI608_I168_XP_n1 I608_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I168_XP_MN0 (I608_P17_2n I608_P17_10 XI608_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I167_XP_MN1 (XI608_I167_XP_n1 I608_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I167_XP_MN0 (I608_P16_1n I608_P16_9 XI608_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I106_XP_MN1 (XI608_I106_XP_n1 I608_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I106_XP_MN0 (I608_P10_7n I608_P10_9 XI608_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I11_MN1 (XI608_I11_n1 b1_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I11_MN0 (I608_gn11 p0_10 XI608_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I10_MN1 (XI608_I10_n1 b1_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I10_MN0 (I608_gn10 p0_9 XI608_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I175_XP_MN1 (XI562_I175_XP_n1 I562_P16_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I175_XP_MN0 (I562_P24_9n I562_P24_17 XI562_I175_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I169_XP_MN1 (XI562_I169_XP_n1 I562_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I169_XP_MN0 (I562_P18_3n I562_P18_11 XI562_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I108_XP_MN1 (XI562_I108_XP_n1 I562_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I108_XP_MN0 (I562_P12_9n I562_P12_11 XI562_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I107_XP_MN1 (XI562_I107_XP_n1 I562_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I107_XP_MN0 (I562_P11_8n I562_P11_10 XI562_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I11_MN1 (XI562_I11_n1 b0_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I11_MN0 (I562_gn11 VSS XI562_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I103_XP_MN1 (XI2066_I103_XP_n1 I2066_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I103_XP_MN0 (I2066_P7_4n I2066_P7_6 XI2066_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I105_XP_MN1 (XI2066_I105_XP_n1 I2066_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I105_XP_MN0 (I2066_P9_6n I2066_P9_8 XI2066_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I167_XP_MN1 (XI2066_I167_XP_n1 I2066_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I167_XP_MN0 (I2066_P16_1n I2066_P16_9 XI2066_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I106_XP_MN1 (XI2066_I106_XP_n1 I2066_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I106_XP_MN0 (I2066_P10_7n I2066_P10_9 XI2066_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I11_MN1 (XI2066_I11_n1 dm11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I11_MN0 (I2066_gn11 p31_11 XI2066_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I10_MN1 (XI2066_I10_n1 dm10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I10_MN0 (I2066_gn10 p31_10 XI2066_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2022_MN1 (XI2022_n1 p31_32_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2022_MN0 (dmn10 dd10_b3_5 XI2022_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I169_XP_MN1 (XI1988_I169_XP_n1 I1988_P10_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I169_XP_MN0 (I1988_P18_3n I1988_P18_11 XI1988_I169_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I108_XP_MN1 (XI1988_I108_XP_n1 I1988_P10_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I108_XP_MN0 (I1988_P12_9n I1988_P12_11 XI1988_I108_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I168_XP_MN1 (XI1988_I168_XP_n1 I1988_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I168_XP_MN0 (I1988_P17_2n I1988_P17_10 XI1988_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I107_XP_MN1 (XI1988_I107_XP_n1 I1988_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I107_XP_MN0 (I1988_P11_8n I1988_P11_10 XI1988_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I10_MN1 (XI1988_I10_n1 b31_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I10_MN0 (I1988_gn10 p30_9 XI1988_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I11_MN1 (XI1988_I11_n1 b31_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I11_MN0 (I1988_gn11 p30_10 XI1988_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I167_XP_MN1 (XI1942_I167_XP_n1 I1942_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I167_XP_MN0 (I1942_P16_1n I1942_P16_9 XI1942_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I105_XP_MN1 (XI1942_I105_XP_n1 I1942_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I105_XP_MN0 (I1942_P9_6n I1942_P9_8 XI1942_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I103_XP_MN1 (XI1942_I103_XP_n1 I1942_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I103_XP_MN0 (I1942_P7_4n I1942_P7_6 XI1942_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I8_MN1 (XI1942_I8_n1 b30_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I8_MN0 (I1942_gn8 p29_7 XI1942_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I9_MN1 (XI1942_I9_n1 b30_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I9_MN0 (I1942_gn9 p29_8 XI1942_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I101_XP_MN1 (XI1896_I101_XP_n1 I1896_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I101_XP_MN0 (I1896_P5_2n I1896_P5_4 XI1896_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I10_MN1 (XI1896_I10_n1 b29_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I10_MN0 (I1896_gn10 p28_9 XI1896_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I11_MN1 (XI1896_I11_n1 b29_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I11_MN0 (I1896_gn11 p28_10 XI1896_I11_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I172_XP_MN1 (XI1850_I172_XP_n1 I1850_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I172_XP_MN0 (I1850_P21_6n I1850_P21_14 XI1850_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I182_XP_MN1 (XI1850_I182_XP_n1 I1850_P23_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I182_XP_MN0 (I1850_P31_16n I1850_P31_24 XI1850_I182_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I126_XP_MN1 (XI700_I126_XP_n1 I700_P28_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I126_XP_MN0 (I700_P30_27n I700_P30_29 XI700_I126_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I172_XP_MN1 (XI700_I172_XP_n1 I700_P13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I172_XP_MN0 (I700_P21_6n I700_P21_14 XI700_I172_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I10_MN1 (XI700_I10_n1 b3_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I10_MN0 (I700_gn10 p2_9 XI700_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I102_XP_MN1 (XI654_I102_XP_n1 I654_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I102_XP_MN0 (I654_P6_3n I654_P6_5 XI654_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I104_XP_MN1 (XI654_I104_XP_n1 I654_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I104_XP_MN0 (I654_P8_5n I654_P8_7 XI654_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I7_MN1 (XI654_I7_n1 b2_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I7_MN0 (I654_gn7 p1_6 XI654_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I8_MN1 (XI654_I8_n1 b2_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I8_MN0 (I654_gn8 p1_7 XI654_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I6_MN1 (XI654_I6_n1 b2_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I6_MN0 (I654_gn6 p1_5 XI654_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I103_XP_MN1 (XI608_I103_XP_n1 I608_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I103_XP_MN0 (I608_P7_4n I608_P7_6 XI608_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I105_XP_MN1 (XI608_I105_XP_n1 I608_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I105_XP_MN0 (I608_P9_6n I608_P9_8 XI608_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I104_XP_MN1 (XI608_I104_XP_n1 I608_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I104_XP_MN0 (I608_P8_5n I608_P8_7 XI608_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I7_MN1 (XI608_I7_n1 b1_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I7_MN0 (I608_gn7 p0_6 XI608_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I8_MN1 (XI608_I8_n1 b1_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I8_MN0 (I608_gn8 p0_7 XI608_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I9_MN1 (XI608_I9_n1 b1_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I9_MN0 (I608_gn9 p0_8 XI608_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I167_XP_MN1 (XI562_I167_XP_n1 I562_P8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I167_XP_MN0 (I562_P16_1n I562_P16_9 XI562_I167_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I104_XP_MN1 (XI562_I104_XP_n1 I562_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I104_XP_MN0 (I562_P8_5n I562_P8_7 XI562_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I106_XP_MN1 (XI562_I106_XP_n1 I562_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I106_XP_MN0 (I562_P10_7n I562_P10_9 XI562_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I105_XP_MN1 (XI562_I105_XP_n1 I562_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I105_XP_MN0 (I562_P9_6n I562_P9_8 XI562_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I10_MN1 (XI562_I10_n1 b0_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I10_MN0 (I562_gn10 VSS XI562_I10_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I101_XP_MN1 (XI2066_I101_XP_n1 I2066_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I101_XP_MN0 (I2066_P5_2n I2066_P5_4 XI2066_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I102_XP_MN1 (XI2066_I102_XP_n1 I2066_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I102_XP_MN0 (I2066_P6_3n I2066_P6_5 XI2066_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I104_XP_MN1 (XI2066_I104_XP_n1 I2066_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I104_XP_MN0 (I2066_P8_5n I2066_P8_7 XI2066_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I9_MN1 (XI2066_I9_n1 dm9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I9_MN0 (I2066_gn9 p31_9 XI2066_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I8_MN1 (XI2066_I8_n1 dm8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I8_MN0 (I2066_gn8 p31_8 XI2066_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2024_MN1 (XI2024_n1 p31_32_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2024_MN0 (dmn11 dd11_b3_5 XI2024_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2020_MN1 (XI2020_n1 p31_32_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2020_MN0 (dmn9 dd9_b3_5 XI2020_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I106_XP_MN1 (XI1988_I106_XP_n1 I1988_P8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I106_XP_MN0 (I1988_P10_7n I1988_P10_9 XI1988_I106_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I105_XP_MN1 (XI1988_I105_XP_n1 I1988_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I105_XP_MN0 (I1988_P9_6n I1988_P9_8 XI1988_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I9_MN1 (XI1988_I9_n1 b31_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I9_MN0 (I1988_gn9 p30_8 XI1988_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I104_XP_MN1 (XI1942_I104_XP_n1 I1942_P6_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I104_XP_MN0 (I1942_P8_5n I1942_P8_7 XI1942_I104_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I7_MN1 (XI1942_I7_n1 b30_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I7_MN0 (I1942_gn7 p29_6 XI1942_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I6_MN1 (XI1896_I6_n1 b29_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I6_MN0 (I1896_gn6 p28_5 XI1896_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I7_MN1 (XI1896_I7_n1 b29_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I7_MN0 (I1896_gn7 p28_6 XI1896_I7_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I103_XP_MN1 (XI1850_I103_XP_n1 I1850_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I103_XP_MN0 (I1850_P7_4n I1850_P7_6 XI1850_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I105_XP_MN1 (XI1850_I105_XP_n1 I1850_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I105_XP_MN0 (I1850_P9_6n I1850_P9_8 XI1850_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I107_XP_MN1 (XI1850_I107_XP_n1 I1850_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I107_XP_MN0 (I1850_P11_8n I1850_P11_10 XI1850_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I168_XP_MN1 (XI1850_I168_XP_n1 I1850_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I168_XP_MN0 (I1850_P17_2n I1850_P17_10 XI1850_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I109_XP_MN1 (XI1850_I109_XP_n1 I1850_P11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I109_XP_MN0 (I1850_P13_10n I1850_P13_12 XI1850_I109_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I111_XP_MN1 (XI1850_I111_XP_n1 I1850_P13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I111_XP_MN0 (I1850_P15_12n I1850_P15_14 XI1850_I111_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I113_XP_MN1 (XI1850_I113_XP_n1 I1850_P15_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I113_XP_MN0 (I1850_P17_14n I1850_P17_16 XI1850_I113_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I115_XP_MN1 (XI1850_I115_XP_n1 I1850_P17_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I115_XP_MN0 (I1850_P19_16n I1850_P19_18 XI1850_I115_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I117_XP_MN1 (XI1850_I117_XP_n1 I1850_P19_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I117_XP_MN0 (I1850_P21_18n I1850_P21_20 XI1850_I117_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I176_XP_MN1 (XI1850_I176_XP_n1 I1850_P17_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I176_XP_MN0 (I1850_P25_10n I1850_P25_18 XI1850_I176_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I180_XP_MN1 (XI1850_I180_XP_n1 I1850_P21_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I180_XP_MN0 (I1850_P29_14n I1850_P29_22 XI1850_I180_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I170_XP_MN1 (XI700_I170_XP_n1 I700_P11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I170_XP_MN0 (I700_P19_4n I700_P19_12 XI700_I170_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I168_XP_MN1 (XI700_I168_XP_n1 I700_P9_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I168_XP_MN0 (I700_P17_2n I700_P17_10 XI700_I168_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I107_XP_MN1 (XI700_I107_XP_n1 I700_P9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I107_XP_MN0 (I700_P11_8n I700_P11_10 XI700_I107_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I105_XP_MN1 (XI700_I105_XP_n1 I700_P7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I105_XP_MN0 (I700_P9_6n I700_P9_8 XI700_I105_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I9_MN1 (XI700_I9_n1 b3_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I9_MN0 (I700_gn9 p2_8 XI700_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I8_MN1 (XI700_I8_n1 b3_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I8_MN0 (I700_gn8 p2_7 XI700_I8_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I100_XP_MN1 (XI654_I100_XP_n1 I654_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I100_XP_MN0 (I654_P4_1n I654_P4_3 XI654_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I5_MN1 (XI654_I5_n1 b2_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I5_MN0 (I654_gn5 p1_4 XI654_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I4_MN1 (XI654_I4_n1 b2_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I4_MN0 (I654_gn4 p1_3 XI654_I4_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I101_XP_MN1 (XI608_I101_XP_n1 I608_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I101_XP_MN0 (I608_P5_2n I608_P5_4 XI608_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I100_XP_MN1 (XI608_I100_XP_n1 I608_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I100_XP_MN0 (I608_P4_1n I608_P4_3 XI608_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I102_XP_MN1 (XI608_I102_XP_n1 I608_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I102_XP_MN0 (I608_P6_3n I608_P6_5 XI608_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I5_MN1 (XI608_I5_n1 b1_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I5_MN0 (I608_gn5 p0_4 XI608_I5_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I6_MN1 (XI608_I6_n1 b1_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I6_MN0 (I608_gn6 p0_5 XI608_I6_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I100_XP_MN1 (XI562_I100_XP_n1 I562_P2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I100_XP_MN0 (I562_P4_1n I562_P4_3 XI562_I100_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I102_XP_MN1 (XI562_I102_XP_n1 I562_P4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I102_XP_MN0 (I562_P6_3n I562_P6_5 XI562_I102_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I101_XP_MN1 (XI562_I101_XP_n1 I562_P3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I101_XP_MN0 (I562_P5_2n I562_P5_4 XI562_I101_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I103_XP_MN1 (XI562_I103_XP_n1 I562_P5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I103_XP_MN0 (I562_P7_4n I562_P7_6 XI562_I103_XP_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I9_MN1 (XI562_I9_n1 b0_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I9_MN0 (I562_gn9 VSS XI562_I9_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
