    I_MXI746_I77_XG_MP2 (VDD I746_gn11 I746_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I77_XG_MP0 (XI746_I77_XG_p1 I746_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I77_XG_MP1 (I746_G11_10 I746_gn10 XI746_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I67_XG_MP2 (VDD I746_gn1 I746_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I67_XG_MP0 (XI746_I67_XG_p1 I746_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I67_XG_MP1 (I746_G1_0 I746_G0_0n XI746_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I74_XG_MP2 (VDD I792_gn8 I792_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I74_XG_MP0 (XI792_I74_XG_p1 I792_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I74_XG_MP1 (I792_G8_7 I792_gn7 XI792_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I130_XG_MP2 (VDD I792_G5_2n I792_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I130_XG_MP0 (XI792_I130_XG_p1 I792_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I130_XG_MP1 (I792_G5_0 I792_G1_0n XI792_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I133_XG_MP2 (VDD I792_G8_5n I792_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I133_XG_MP0 (XI792_I133_XG_p1 I792_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I133_XG_MP1 (I792_G8_1 I792_G4_1n XI792_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I128_XG_MP2 (VDD I792_G4_1n I792_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I128_XG_MP0 (XI792_I128_XG_p1 I792_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I128_XG_MP1 (I792_G4_0 I792_G0_0n XI792_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I73_XG_MP2 (VDD I838_gn7 I838_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I73_XG_MP0 (XI838_I73_XG_p1 I838_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I73_XG_MP1 (I838_G7_6 I838_gn6 XI838_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I72_XG_MP2 (VDD I838_gn6 I838_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I72_XG_MP0 (XI838_I72_XG_p1 I838_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I72_XG_MP1 (I838_G6_5 I838_gn5 XI838_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I130_XG_MP2 (VDD I838_G5_2n I838_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I130_XG_MP0 (XI838_I130_XG_p1 I838_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I130_XG_MP1 (I838_G5_0 I838_G1_0n XI838_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I133_XG_MP2 (VDD I838_G8_5n I838_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I133_XG_MP0 (XI838_I133_XG_p1 I838_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I133_XG_MP1 (I838_G8_1 I838_G4_1n XI838_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I128_XG_MP2 (VDD I838_G4_1n I838_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I128_XG_MP0 (XI838_I128_XG_p1 I838_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I128_XG_MP1 (I838_G4_0 I838_G0_0n XI838_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I65_XG_MP2 (VDD I884_gn0 I884_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I65_XG_MP0 (XI884_I65_XG_p1 I884_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I65_XG_MP1 (I884_G0_0 I884_cinn XI884_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I72_XG_MP2 (VDD I884_gn6 I884_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I72_XG_MP0 (XI884_I72_XG_p1 I884_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I72_XG_MP1 (I884_G6_5 I884_gn5 XI884_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I133_XG_MP2 (VDD I1712_G8_5n I1712_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I133_XG_MP0 (XI1712_I133_XG_p1 I1712_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I133_XG_MP1 (I1712_G8_1 I1712_G4_1n XI1712_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I183_XG_MP2 (VDD I1712_G16_1n I1712_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I183_XG_MP0 (XI1712_I183_XG_p1 I1712_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I183_XG_MP1 (I1712_G16_0 I1712_G0_0n XI1712_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I128_XG_MP2 (VDD I1712_G4_1n I1712_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I128_XG_MP0 (XI1712_I128_XG_p1 I1712_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I128_XG_MP1 (I1712_G4_0 I1712_G0_0n XI1712_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I70_XG_MP2 (VDD I1712_gn4 I1712_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I70_XG_MP0 (XI1712_I70_XG_p1 I1712_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I70_XG_MP1 (I1712_G4_3 I1712_gn3 XI1712_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I69_XG_MP2 (VDD I1712_gn3 I1712_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I69_XG_MP0 (XI1712_I69_XG_p1 I1712_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I69_XG_MP1 (I1712_G3_2 I1712_gn2 XI1712_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I71_XG_MP2 (VDD I1758_gn5 I1758_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I71_XG_MP0 (XI1758_I71_XG_p1 I1758_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I71_XG_MP1 (I1758_G5_4 I1758_gn4 XI1758_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I70_XG_MP2 (VDD I1758_gn4 I1758_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I70_XG_MP0 (XI1758_I70_XG_p1 I1758_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I70_XG_MP1 (I1758_G4_3 I1758_gn3 XI1758_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I128_XG_MP2 (VDD I1758_G4_1n I1758_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I128_XG_MP0 (XI1758_I128_XG_p1 I1758_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I128_XG_MP1 (I1758_G4_0 I1758_G0_0n XI1758_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I70_XG_MP2 (VDD I1804_gn4 I1804_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I70_XG_MP0 (XI1804_I70_XG_p1 I1804_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I70_XG_MP1 (I1804_G4_3 I1804_gn3 XI1804_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I71_XG_MP2 (VDD I1804_gn5 I1804_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I71_XG_MP0 (XI1804_I71_XG_p1 I1804_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I71_XG_MP1 (I1804_G5_4 I1804_gn4 XI1804_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I72_XG_MP2 (VDD I1804_gn6 I1804_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I72_XG_MP0 (XI1804_I72_XG_p1 I1804_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I72_XG_MP1 (I1804_G6_5 I1804_gn5 XI1804_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I128_XG_MP2 (VDD I1804_G4_1n I1804_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I128_XG_MP0 (XI1804_I128_XG_p1 I1804_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I128_XG_MP1 (I1804_G4_0 I1804_G0_0n XI1804_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I133_XG_MP2 (VDD I1804_G8_5n I1804_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I133_XG_MP0 (XI1804_I133_XG_p1 I1804_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I133_XG_MP1 (I1804_G8_1 I1804_G4_1n XI1804_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I131_XG_MP2 (VDD I1804_G6_3n I1804_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I131_XG_MP0 (XI1804_I131_XG_p1 I1804_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I131_XG_MP1 (I1804_G6_0 I1804_G2_0n XI1804_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I183_XG_MP2 (VDD I1804_G16_1n I1804_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I183_XG_MP0 (XI1804_I183_XG_p1 I1804_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I183_XG_MP1 (I1804_G16_0 I1804_G0_0n XI1804_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I185_XG_MP2 (VDD I1804_G18_3n I1804_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I185_XG_MP0 (XI1804_I185_XG_p1 I1804_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I185_XG_MP1 (I1804_G18_0 I1804_G2_0n XI1804_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1850_I97_XG_MP2 (VDD I1850_gn31 I1850_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1850_I97_XG_MP0 (XI1850_I97_XG_p1 I1850_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1850_I97_XG_MP1 (I1850_G31_30 I1850_gn30 XI1850_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I194_XG_MP2 (VDD I746_G23_8n I746_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I194_XG_MP0 (XI746_I194_XG_p1 I746_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I194_XG_MP1 (I746_G23_0 I746_G7_0n XI746_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I89_XG_MP2 (VDD I746_gn23 I746_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I89_XG_MP0 (XI746_I89_XG_p1 I746_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I89_XG_MP1 (I746_G23_22 I746_gn22 XI746_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I140_XG_MP2 (VDD I746_G15_12n I746_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I140_XG_MP0 (XI746_I140_XG_p1 I746_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I140_XG_MP1 (I746_G15_8 I746_G11_8n XI746_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I136_XG_MP2 (VDD I746_G11_8n I746_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I136_XG_MP0 (XI746_I136_XG_p1 I746_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I136_XG_MP1 (I746_G11_4 I746_G7_4n XI746_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I132_XG_MP2 (VDD I746_G7_4n I746_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I132_XG_MP0 (XI746_I132_XG_p1 I746_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I132_XG_MP1 (I746_G7_0 I746_G3_0n XI746_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I83_XG_MP2 (VDD I746_gn17 I746_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I83_XG_MP0 (XI746_I83_XG_p1 I746_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I83_XG_MP1 (I746_G17_16 I746_gn16 XI746_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I82_XG_MP2 (VDD I746_gn16 I746_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I82_XG_MP0 (XI746_I82_XG_p1 I746_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I82_XG_MP1 (I746_G16_15 I746_gn15 XI746_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I134_XG_MP2 (VDD I746_G9_6n I746_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I134_XG_MP0 (XI746_I134_XG_p1 I746_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I134_XG_MP1 (I746_G9_2 I746_G5_2n XI746_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I130_XG_MP2 (VDD I746_G5_2n I746_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I130_XG_MP0 (XI746_I130_XG_p1 I746_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I130_XG_MP1 (I746_G5_0 I746_G1_0n XI746_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I76_XG_MP2 (VDD I792_gn10 I792_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I76_XG_MP0 (XI792_I76_XG_p1 I792_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I76_XG_MP1 (I792_G10_9 I792_gn9 XI792_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I75_XG_MP2 (VDD I792_gn9 I792_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I75_XG_MP0 (XI792_I75_XG_p1 I792_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I75_XG_MP1 (I792_G9_8 I792_gn8 XI792_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I134_XG_MP2 (VDD I792_G9_6n I792_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I134_XG_MP0 (XI792_I134_XG_p1 I792_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I134_XG_MP1 (I792_G9_2 I792_G5_2n XI792_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I131_XG_MP2 (VDD I792_G6_3n I792_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I131_XG_MP0 (XI792_I131_XG_p1 I792_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I131_XG_MP1 (I792_G6_0 I792_G2_0n XI792_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I75_XG_MP2 (VDD I838_gn9 I838_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I75_XG_MP0 (XI838_I75_XG_p1 I838_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I75_XG_MP1 (I838_G9_8 I838_gn8 XI838_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I74_XG_MP2 (VDD I838_gn8 I838_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I74_XG_MP0 (XI838_I74_XG_p1 I838_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I74_XG_MP1 (I838_G8_7 I838_gn7 XI838_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I134_XG_MP2 (VDD I838_G9_6n I838_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I134_XG_MP0 (XI838_I134_XG_p1 I838_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I134_XG_MP1 (I838_G9_2 I838_G5_2n XI838_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I183_XG_MP2 (VDD I838_G16_1n I838_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I183_XG_MP0 (XI838_I183_XG_p1 I838_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I183_XG_MP1 (I838_G16_0 I838_G0_0n XI838_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I131_XG_MP2 (VDD I838_G6_3n I838_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I131_XG_MP0 (XI838_I131_XG_p1 I838_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I131_XG_MP1 (I838_G6_0 I838_G2_0n XI838_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I75_XG_MP2 (VDD I884_gn9 I884_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I75_XG_MP0 (XI884_I75_XG_p1 I884_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I75_XG_MP1 (I884_G9_8 I884_gn8 XI884_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I74_XG_MP2 (VDD I884_gn8 I884_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I74_XG_MP0 (XI884_I74_XG_p1 I884_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I74_XG_MP1 (I884_G8_7 I884_gn7 XI884_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I73_XG_MP2 (VDD I884_gn7 I884_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I73_XG_MP0 (XI884_I73_XG_p1 I884_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I73_XG_MP1 (I884_G7_6 I884_gn6 XI884_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I133_XG_MP2 (VDD I884_G8_5n I884_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I133_XG_MP0 (XI884_I133_XG_p1 I884_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I133_XG_MP1 (I884_G8_1 I884_G4_1n XI884_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I128_XG_MP2 (VDD I884_G4_1n I884_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I128_XG_MP0 (XI884_I128_XG_p1 I884_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I128_XG_MP1 (I884_G4_0 I884_G0_0n XI884_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I130_XG_MP2 (VDD I884_G5_2n I884_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I130_XG_MP0 (XI884_I130_XG_p1 I884_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I130_XG_MP1 (I884_G5_0 I884_G1_0n XI884_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I72_XG_MP2 (VDD I1712_gn6 I1712_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I72_XG_MP0 (XI1712_I72_XG_p1 I1712_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I72_XG_MP1 (I1712_G6_5 I1712_gn5 XI1712_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I71_XG_MP2 (VDD I1712_gn5 I1712_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I71_XG_MP0 (XI1712_I71_XG_p1 I1712_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I71_XG_MP1 (I1712_G5_4 I1712_gn4 XI1712_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I73_XG_MP2 (VDD I1758_gn7 I1758_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I73_XG_MP0 (XI1758_I73_XG_p1 I1758_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I73_XG_MP1 (I1758_G7_6 I1758_gn6 XI1758_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I72_XG_MP2 (VDD I1758_gn6 I1758_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I72_XG_MP0 (XI1758_I72_XG_p1 I1758_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I72_XG_MP1 (I1758_G6_5 I1758_gn5 XI1758_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I133_XG_MP2 (VDD I1758_G8_5n I1758_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I133_XG_MP0 (XI1758_I133_XG_p1 I1758_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I133_XG_MP1 (I1758_G8_1 I1758_G4_1n XI1758_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I183_XG_MP2 (VDD I1758_G16_1n I1758_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I183_XG_MP0 (XI1758_I183_XG_p1 I1758_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I183_XG_MP1 (I1758_G16_0 I1758_G0_0n XI1758_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I73_XG_MP2 (VDD I1804_gn7 I1804_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I73_XG_MP0 (XI1804_I73_XG_p1 I1804_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I73_XG_MP1 (I1804_G7_6 I1804_gn6 XI1804_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I74_XG_MP2 (VDD I1804_gn8 I1804_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I74_XG_MP0 (XI1804_I74_XG_p1 I1804_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I74_XG_MP1 (I1804_G8_7 I1804_gn7 XI1804_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I130_XG_MP2 (VDD I1804_G5_2n I1804_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I130_XG_MP0 (XI1804_I130_XG_p1 I1804_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I130_XG_MP1 (I1804_G5_0 I1804_G1_0n XI1804_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I135_XG_MP2 (VDD I1804_G10_7n I1804_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I135_XG_MP0 (XI1804_I135_XG_p1 I1804_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I135_XG_MP1 (I1804_G10_3 I1804_G6_3n XI1804_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I188_XG_MP2 (VDD I1804_G20_5n I1804_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I188_XG_MP0 (XI1804_I188_XG_p1 I1804_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I188_XG_MP1 (I1804_G20_0 I1804_G4_0n XI1804_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I195_XG_MP2 (VDD I1804_G24_9n I1804_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I195_XG_MP0 (XI1804_I195_XG_p1 I1804_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I195_XG_MP1 (I1804_G24_0 I1804_G8_0n XI1804_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I202_XG_MP2 (VDD I746_G31_16n c4_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I202_XG_MP0 (XI746_I202_XG_p1 I746_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I202_XG_MP1 (c4_o I746_G15_0n XI746_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I148_XG_MP2 (VDD I746_G23_20n I746_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I148_XG_MP0 (XI746_I148_XG_p1 I746_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I148_XG_MP1 (I746_G23_16 I746_G19_16n XI746_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I144_XG_MP2 (VDD I746_G19_16n I746_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I144_XG_MP0 (XI746_I144_XG_p1 I746_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I144_XG_MP1 (I746_G19_12 I746_G15_12n XI746_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I186_XG_MP2 (VDD I746_G19_4n I746_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I186_XG_MP0 (XI746_I186_XG_p1 I746_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I186_XG_MP1 (I746_G19_0 I746_G3_0n XI746_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I142_XG_MP2 (VDD I746_G17_14n I746_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I142_XG_MP0 (XI746_I142_XG_p1 I746_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I142_XG_MP1 (I746_G17_10 I746_G13_10n XI746_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I138_XG_MP2 (VDD I746_G13_10n I746_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I138_XG_MP0 (XI746_I138_XG_p1 I746_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I138_XG_MP1 (I746_G13_6 I746_G9_6n XI746_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I184_XG_MP2 (VDD I746_G17_2n I746_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I184_XG_MP0 (XI746_I184_XG_p1 I746_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I184_XG_MP1 (I746_G17_0 I746_G1_0n XI746_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I133_XG_MP2 (VDD I746_G8_5n I746_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I133_XG_MP0 (XI746_I133_XG_p1 I746_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I133_XG_MP1 (I746_G8_1 I746_G4_1n XI746_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I128_XG_MP2 (VDD I746_G4_1n I746_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I128_XG_MP0 (XI746_I128_XG_p1 I746_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I128_XG_MP1 (I746_G4_0 I746_G0_0n XI746_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I78_XG_MP2 (VDD I792_gn12 I792_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I78_XG_MP0 (XI792_I78_XG_p1 I792_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I78_XG_MP1 (I792_G12_11 I792_gn11 XI792_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I77_XG_MP2 (VDD I792_gn11 I792_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I77_XG_MP0 (XI792_I77_XG_p1 I792_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I77_XG_MP1 (I792_G11_10 I792_gn10 XI792_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I136_XG_MP2 (VDD I792_G11_8n I792_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I136_XG_MP0 (XI792_I136_XG_p1 I792_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I136_XG_MP1 (I792_G11_4 I792_G7_4n XI792_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I132_XG_MP2 (VDD I792_G7_4n I792_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I132_XG_MP0 (XI792_I132_XG_p1 I792_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I132_XG_MP1 (I792_G7_0 I792_G3_0n XI792_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I184_XG_MP2 (VDD I792_G17_2n I792_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I184_XG_MP0 (XI792_I184_XG_p1 I792_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I184_XG_MP1 (I792_G17_0 I792_G1_0n XI792_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I135_XG_MP2 (VDD I792_G10_7n I792_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I135_XG_MP0 (XI792_I135_XG_p1 I792_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I135_XG_MP1 (I792_G10_3 I792_G6_3n XI792_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I183_XG_MP2 (VDD I792_G16_1n I792_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I183_XG_MP0 (XI792_I183_XG_p1 I792_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I183_XG_MP1 (I792_G16_0 I792_G0_0n XI792_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I76_XG_MP2 (VDD I838_gn10 I838_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I76_XG_MP0 (XI838_I76_XG_p1 I838_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I76_XG_MP1 (I838_G10_9 I838_gn9 XI838_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I132_XG_MP2 (VDD I838_G7_4n I838_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I132_XG_MP0 (XI838_I132_XG_p1 I838_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I132_XG_MP1 (I838_G7_0 I838_G3_0n XI838_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I184_XG_MP2 (VDD I838_G17_2n I838_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I184_XG_MP0 (XI838_I184_XG_p1 I838_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I184_XG_MP1 (I838_G17_0 I838_G1_0n XI838_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I137_XG_MP2 (VDD I838_G12_9n I838_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I137_XG_MP0 (XI838_I137_XG_p1 I838_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I137_XG_MP1 (I838_G12_5 I838_G8_5n XI838_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I195_XG_MP2 (VDD I838_G24_9n I838_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I195_XG_MP0 (XI838_I195_XG_p1 I838_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I195_XG_MP1 (I838_G24_0 I838_G8_0n XI838_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I135_XG_MP2 (VDD I838_G10_7n I838_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I135_XG_MP0 (XI838_I135_XG_p1 I838_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I135_XG_MP1 (I838_G10_3 I838_G6_3n XI838_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I185_XG_MP2 (VDD I838_G18_3n I838_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I185_XG_MP0 (XI838_I185_XG_p1 I838_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I185_XG_MP1 (I838_G18_0 I838_G2_0n XI838_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I76_XG_MP2 (VDD I884_gn10 I884_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I76_XG_MP0 (XI884_I76_XG_p1 I884_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I76_XG_MP1 (I884_G10_9 I884_gn9 XI884_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I135_XG_MP2 (VDD I884_G10_7n I884_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I135_XG_MP0 (XI884_I135_XG_p1 I884_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I135_XG_MP1 (I884_G10_3 I884_G6_3n XI884_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I131_XG_MP2 (VDD I884_G6_3n I884_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I131_XG_MP0 (XI884_I131_XG_p1 I884_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I131_XG_MP1 (I884_G6_0 I884_G2_0n XI884_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I183_XG_MP2 (VDD I884_G16_1n I884_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I183_XG_MP0 (XI884_I183_XG_p1 I884_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I183_XG_MP1 (I884_G16_0 I884_G0_0n XI884_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I134_XG_MP2 (VDD I884_G9_6n I884_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I134_XG_MP0 (XI884_I134_XG_p1 I884_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I134_XG_MP1 (I884_G9_2 I884_G5_2n XI884_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I135_XG_MP2 (VDD I1712_G10_7n I1712_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I135_XG_MP0 (XI1712_I135_XG_p1 I1712_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I135_XG_MP1 (I1712_G10_3 I1712_G6_3n XI1712_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I131_XG_MP2 (VDD I1712_G6_3n I1712_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I131_XG_MP0 (XI1712_I131_XG_p1 I1712_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I131_XG_MP1 (I1712_G6_0 I1712_G2_0n XI1712_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I188_XG_MP2 (VDD I1712_G20_5n I1712_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I188_XG_MP0 (XI1712_I188_XG_p1 I1712_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I188_XG_MP1 (I1712_G20_0 I1712_G4_0n XI1712_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I137_XG_MP2 (VDD I1712_G12_9n I1712_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I137_XG_MP0 (XI1712_I137_XG_p1 I1712_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I137_XG_MP1 (I1712_G12_5 I1712_G8_5n XI1712_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I74_XG_MP2 (VDD I1712_gn8 I1712_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I74_XG_MP0 (XI1712_I74_XG_p1 I1712_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I74_XG_MP1 (I1712_G8_7 I1712_gn7 XI1712_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I73_XG_MP2 (VDD I1712_gn7 I1712_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I73_XG_MP0 (XI1712_I73_XG_p1 I1712_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I73_XG_MP1 (I1712_G7_6 I1712_gn6 XI1712_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I130_XG_MP2 (VDD I1712_G5_2n I1712_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I130_XG_MP0 (XI1712_I130_XG_p1 I1712_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I130_XG_MP1 (I1712_G5_0 I1712_G1_0n XI1712_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I74_XG_MP2 (VDD I1758_gn8 I1758_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I74_XG_MP0 (XI1758_I74_XG_p1 I1758_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I74_XG_MP1 (I1758_G8_7 I1758_gn7 XI1758_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I75_XG_MP2 (VDD I1758_gn9 I1758_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I75_XG_MP0 (XI1758_I75_XG_p1 I1758_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I75_XG_MP1 (I1758_G9_8 I1758_gn8 XI1758_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I135_XG_MP2 (VDD I1758_G10_7n I1758_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I135_XG_MP0 (XI1758_I135_XG_p1 I1758_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I135_XG_MP1 (I1758_G10_3 I1758_G6_3n XI1758_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I131_XG_MP2 (VDD I1758_G6_3n I1758_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I131_XG_MP0 (XI1758_I131_XG_p1 I1758_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I131_XG_MP1 (I1758_G6_0 I1758_G2_0n XI1758_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I134_XG_MP2 (VDD I1758_G9_6n I1758_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I134_XG_MP0 (XI1758_I134_XG_p1 I1758_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I134_XG_MP1 (I1758_G9_2 I1758_G5_2n XI1758_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I130_XG_MP2 (VDD I1758_G5_2n I1758_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I130_XG_MP0 (XI1758_I130_XG_p1 I1758_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I130_XG_MP1 (I1758_G5_0 I1758_G1_0n XI1758_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I75_XG_MP2 (VDD I1804_gn9 I1804_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I75_XG_MP0 (XI1804_I75_XG_p1 I1804_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I75_XG_MP1 (I1804_G9_8 I1804_gn8 XI1804_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I76_XG_MP2 (VDD I1804_gn10 I1804_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I76_XG_MP0 (XI1804_I76_XG_p1 I1804_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I76_XG_MP1 (I1804_G10_9 I1804_gn9 XI1804_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I134_XG_MP2 (VDD I1804_G9_6n I1804_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I134_XG_MP0 (XI1804_I134_XG_p1 I1804_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I134_XG_MP1 (I1804_G9_2 I1804_G5_2n XI1804_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I184_XG_MP2 (VDD I1804_G17_2n I1804_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I184_XG_MP0 (XI1804_I184_XG_p1 I1804_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I184_XG_MP1 (I1804_G17_0 I1804_G1_0n XI1804_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I137_XG_MP2 (VDD I1804_G12_9n I1804_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I137_XG_MP0 (XI1804_I137_XG_p1 I1804_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I137_XG_MP1 (I1804_G12_5 I1804_G8_5n XI1804_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I141_XG_MP2 (VDD I1804_G16_13n I1804_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I141_XG_MP0 (XI1804_I141_XG_p1 I1804_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I141_XG_MP1 (I1804_G16_9 I1804_G12_9n XI1804_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I199_XG_MP2 (VDD I1804_G28_13n I1804_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I199_XG_MP0 (XI1804_I199_XG_p1 I1804_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I199_XG_MP1 (I1804_G28_0 I1804_G12_0n XI1804_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I197_XG_MP2 (VDD I1804_G26_11n I1804_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I197_XG_MP0 (XI1804_I197_XG_p1 I1804_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I197_XG_MP1 (I1804_G26_0 I1804_G10_0n XI1804_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I152_XG_MP2 (VDD I746_G27_24n I746_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I152_XG_MP0 (XI746_I152_XG_p1 I746_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I152_XG_MP1 (I746_G27_20 I746_G23_20n XI746_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I198_XG_MP2 (VDD I746_G27_12n I746_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I198_XG_MP0 (XI746_I198_XG_p1 I746_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I198_XG_MP1 (I746_G27_0 I746_G11_0n XI746_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I150_XG_MP2 (VDD I746_G25_22n I746_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I150_XG_MP0 (XI746_I150_XG_p1 I746_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I150_XG_MP1 (I746_G25_18 I746_G21_18n XI746_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I146_XG_MP2 (VDD I746_G21_18n I746_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I146_XG_MP0 (XI746_I146_XG_p1 I746_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I146_XG_MP1 (I746_G21_14 I746_G17_14n XI746_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I190_XG_MP2 (VDD I746_G21_6n I746_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I190_XG_MP0 (XI746_I190_XG_p1 I746_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I190_XG_MP1 (I746_G21_0 I746_G5_0n XI746_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I137_XG_MP2 (VDD I746_G12_9n I746_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I137_XG_MP0 (XI746_I137_XG_p1 I746_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I137_XG_MP1 (I746_G12_5 I746_G8_5n XI746_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I131_XG_MP2 (VDD I746_G6_3n I746_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I131_XG_MP0 (XI746_I131_XG_p1 I746_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I131_XG_MP1 (I746_G6_0 I746_G2_0n XI746_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I135_XG_MP2 (VDD I746_G10_7n I746_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I135_XG_MP0 (XI746_I135_XG_p1 I746_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I135_XG_MP1 (I746_G10_3 I746_G6_3n XI746_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I183_XG_MP2 (VDD I746_G16_1n I746_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I183_XG_MP0 (XI746_I183_XG_p1 I746_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I183_XG_MP1 (I746_G16_0 I746_G0_0n XI746_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I80_XG_MP2 (VDD I792_gn14 I792_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I80_XG_MP0 (XI792_I80_XG_p1 I792_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I80_XG_MP1 (I792_G14_13 I792_gn13 XI792_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I79_XG_MP2 (VDD I792_gn13 I792_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I79_XG_MP0 (XI792_I79_XG_p1 I792_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I79_XG_MP1 (I792_G13_12 I792_gn12 XI792_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I141_XG_MP2 (VDD I792_G16_13n I792_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I141_XG_MP0 (XI792_I141_XG_p1 I792_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I141_XG_MP1 (I792_G16_9 I792_G12_9n XI792_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I137_XG_MP2 (VDD I792_G12_9n I792_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I137_XG_MP0 (XI792_I137_XG_p1 I792_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I137_XG_MP1 (I792_G12_5 I792_G8_5n XI792_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I185_XG_MP2 (VDD I792_G18_3n I792_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I185_XG_MP0 (XI792_I185_XG_p1 I792_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I185_XG_MP1 (I792_G18_0 I792_G2_0n XI792_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I79_XG_MP2 (VDD I838_gn13 I838_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I79_XG_MP0 (XI838_I79_XG_p1 I838_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I79_XG_MP1 (I838_G13_12 I838_gn12 XI838_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I77_XG_MP2 (VDD I838_gn11 I838_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I77_XG_MP0 (XI838_I77_XG_p1 I838_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I77_XG_MP1 (I838_G11_10 I838_gn10 XI838_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I78_XG_MP2 (VDD I838_gn12 I838_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I78_XG_MP0 (XI838_I78_XG_p1 I838_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I78_XG_MP1 (I838_G12_11 I838_gn11 XI838_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I138_XG_MP2 (VDD I838_G13_10n I838_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I138_XG_MP0 (XI838_I138_XG_p1 I838_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I138_XG_MP1 (I838_G13_6 I838_G9_6n XI838_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I196_XG_MP2 (VDD I838_G25_10n I838_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I196_XG_MP0 (XI838_I196_XG_p1 I838_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I196_XG_MP1 (I838_G25_0 I838_G9_0n XI838_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I141_XG_MP2 (VDD I838_G16_13n I838_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I141_XG_MP0 (XI838_I141_XG_p1 I838_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I141_XG_MP1 (I838_G16_9 I838_G12_9n XI838_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I77_XG_MP2 (VDD I884_gn11 I884_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I77_XG_MP0 (XI884_I77_XG_p1 I884_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I77_XG_MP1 (I884_G11_10 I884_gn10 XI884_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I78_XG_MP2 (VDD I884_gn12 I884_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I78_XG_MP0 (XI884_I78_XG_p1 I884_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I78_XG_MP1 (I884_G12_11 I884_gn11 XI884_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I185_XG_MP2 (VDD I884_G18_3n I884_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I185_XG_MP0 (XI884_I185_XG_p1 I884_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I185_XG_MP1 (I884_G18_0 I884_G2_0n XI884_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I137_XG_MP2 (VDD I884_G12_9n I884_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I137_XG_MP0 (XI884_I137_XG_p1 I884_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I137_XG_MP1 (I884_G12_5 I884_G8_5n XI884_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I184_XG_MP2 (VDD I884_G17_2n I884_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I184_XG_MP0 (XI884_I184_XG_p1 I884_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I184_XG_MP1 (I884_G17_0 I884_G1_0n XI884_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I185_XG_MP2 (VDD I1712_G18_3n I1712_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I185_XG_MP0 (XI1712_I185_XG_p1 I1712_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I185_XG_MP1 (I1712_G18_0 I1712_G2_0n XI1712_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I141_XG_MP2 (VDD I1712_G16_13n I1712_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I141_XG_MP0 (XI1712_I141_XG_p1 I1712_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I141_XG_MP1 (I1712_G16_9 I1712_G12_9n XI1712_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I195_XG_MP2 (VDD I1712_G24_9n I1712_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I195_XG_MP0 (XI1712_I195_XG_p1 I1712_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I195_XG_MP1 (I1712_G24_0 I1712_G8_0n XI1712_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I76_XG_MP2 (VDD I1712_gn10 I1712_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I76_XG_MP0 (XI1712_I76_XG_p1 I1712_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I76_XG_MP1 (I1712_G10_9 I1712_gn9 XI1712_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I75_XG_MP2 (VDD I1712_gn9 I1712_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I75_XG_MP0 (XI1712_I75_XG_p1 I1712_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I75_XG_MP1 (I1712_G9_8 I1712_gn8 XI1712_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I134_XG_MP2 (VDD I1712_G9_6n I1712_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I134_XG_MP0 (XI1712_I134_XG_p1 I1712_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I134_XG_MP1 (I1712_G9_2 I1712_G5_2n XI1712_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I77_XG_MP2 (VDD I1758_gn11 I1758_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I77_XG_MP0 (XI1758_I77_XG_p1 I1758_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I77_XG_MP1 (I1758_G11_10 I1758_gn10 XI1758_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I76_XG_MP2 (VDD I1758_gn10 I1758_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I76_XG_MP0 (XI1758_I76_XG_p1 I1758_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I76_XG_MP1 (I1758_G10_9 I1758_gn9 XI1758_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I141_XG_MP2 (VDD I1758_G16_13n I1758_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I141_XG_MP0 (XI1758_I141_XG_p1 I1758_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I141_XG_MP1 (I1758_G16_9 I1758_G12_9n XI1758_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I137_XG_MP2 (VDD I1758_G12_9n I1758_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I137_XG_MP0 (XI1758_I137_XG_p1 I1758_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I137_XG_MP1 (I1758_G12_5 I1758_G8_5n XI1758_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I185_XG_MP2 (VDD I1758_G18_3n I1758_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I185_XG_MP0 (XI1758_I185_XG_p1 I1758_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I185_XG_MP1 (I1758_G18_0 I1758_G2_0n XI1758_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I195_XG_MP2 (VDD I1758_G24_9n I1758_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I195_XG_MP0 (XI1758_I195_XG_p1 I1758_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I195_XG_MP1 (I1758_G24_0 I1758_G8_0n XI1758_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I184_XG_MP2 (VDD I1758_G17_2n I1758_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I184_XG_MP0 (XI1758_I184_XG_p1 I1758_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I184_XG_MP1 (I1758_G17_0 I1758_G1_0n XI1758_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I132_XG_MP2 (VDD I1758_G7_4n I1758_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I132_XG_MP0 (XI1758_I132_XG_p1 I1758_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I132_XG_MP1 (I1758_G7_0 I1758_G3_0n XI1758_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I78_XG_MP2 (VDD I1804_gn12 I1804_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I78_XG_MP0 (XI1804_I78_XG_p1 I1804_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I78_XG_MP1 (I1804_G12_11 I1804_gn11 XI1804_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I77_XG_MP2 (VDD I1804_gn11 I1804_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I77_XG_MP0 (XI1804_I77_XG_p1 I1804_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I77_XG_MP1 (I1804_G11_10 I1804_gn10 XI1804_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I132_XG_MP2 (VDD I1804_G7_4n I1804_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I132_XG_MP0 (XI1804_I132_XG_p1 I1804_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I132_XG_MP1 (I1804_G7_0 I1804_G3_0n XI1804_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I136_XG_MP2 (VDD I1804_G11_8n I1804_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I136_XG_MP0 (XI1804_I136_XG_p1 I1804_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I136_XG_MP1 (I1804_G11_4 I1804_G7_4n XI1804_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I186_XG_MP2 (VDD I1804_G19_4n I1804_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I186_XG_MP0 (XI1804_I186_XG_p1 I1804_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I186_XG_MP1 (I1804_G19_0 I1804_G3_0n XI1804_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I139_XG_MP2 (VDD I1804_G14_11n I1804_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I139_XG_MP0 (XI1804_I139_XG_p1 I1804_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I139_XG_MP1 (I1804_G14_7 I1804_G10_7n XI1804_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I143_XG_MP2 (VDD I1804_G18_15n I1804_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I143_XG_MP0 (XI1804_I143_XG_p1 I1804_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I143_XG_MP1 (I1804_G18_11 I1804_G14_11n XI1804_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I192_XG_MP2 (VDD I1804_G22_7n I1804_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I192_XG_MP0 (XI1804_I192_XG_p1 I1804_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I192_XG_MP1 (I1804_G22_0 I1804_G6_0n XI1804_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I156_XG_MP2 (VDD I746_G31_28n I746_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I156_XG_MP0 (XI746_I156_XG_p1 I746_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I156_XG_MP1 (I746_G31_24 I746_G27_24n XI746_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I154_XG_MP2 (VDD I746_G29_26n I746_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I154_XG_MP0 (XI746_I154_XG_p1 I746_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I154_XG_MP1 (I746_G29_22 I746_G25_22n XI746_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I200_XG_MP2 (VDD I746_G29_14n I746_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I200_XG_MP0 (XI746_I200_XG_p1 I746_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I200_XG_MP1 (I746_G29_0 I746_G13_0n XI746_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I196_XG_MP2 (VDD I746_G25_10n I746_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I196_XG_MP0 (XI746_I196_XG_p1 I746_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I196_XG_MP1 (I746_G25_0 I746_G9_0n XI746_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I141_XG_MP2 (VDD I746_G16_13n I746_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I141_XG_MP0 (XI746_I141_XG_p1 I746_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I141_XG_MP1 (I746_G16_9 I746_G12_9n XI746_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I82_XG_MP2 (VDD I792_gn16 I792_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I82_XG_MP0 (XI792_I82_XG_p1 I792_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I82_XG_MP1 (I792_G16_15 I792_gn15 XI792_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I83_XG_MP2 (VDD I792_gn17 I792_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I83_XG_MP0 (XI792_I83_XG_p1 I792_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I83_XG_MP1 (I792_G17_16 I792_gn16 XI792_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I81_XG_MP2 (VDD I792_gn15 I792_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I81_XG_MP0 (XI792_I81_XG_p1 I792_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I81_XG_MP1 (I792_G15_14 I792_gn14 XI792_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I138_XG_MP2 (VDD I792_G13_10n I792_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I138_XG_MP0 (XI792_I138_XG_p1 I792_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I138_XG_MP1 (I792_G13_6 I792_G9_6n XI792_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I186_XG_MP2 (VDD I792_G19_4n I792_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I186_XG_MP0 (XI792_I186_XG_p1 I792_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I186_XG_MP1 (I792_G19_0 I792_G3_0n XI792_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I139_XG_MP2 (VDD I792_G14_11n I792_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I139_XG_MP0 (XI792_I139_XG_p1 I792_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I139_XG_MP1 (I792_G14_7 I792_G10_7n XI792_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I80_XG_MP2 (VDD I838_gn14 I838_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I80_XG_MP0 (XI838_I80_XG_p1 I838_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I80_XG_MP1 (I838_G14_13 I838_gn13 XI838_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I140_XG_MP2 (VDD I838_G15_12n I838_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I140_XG_MP0 (XI838_I140_XG_p1 I838_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I140_XG_MP1 (I838_G15_8 I838_G11_8n XI838_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I136_XG_MP2 (VDD I838_G11_8n I838_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I136_XG_MP0 (XI838_I136_XG_p1 I838_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I136_XG_MP1 (I838_G11_4 I838_G7_4n XI838_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I186_XG_MP2 (VDD I838_G19_4n I838_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I186_XG_MP0 (XI838_I186_XG_p1 I838_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I186_XG_MP1 (I838_G19_0 I838_G3_0n XI838_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I142_XG_MP2 (VDD I838_G17_14n I838_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I142_XG_MP0 (XI838_I142_XG_p1 I838_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I142_XG_MP1 (I838_G17_10 I838_G13_10n XI838_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I190_XG_MP2 (VDD I838_G21_6n I838_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I190_XG_MP0 (XI838_I190_XG_p1 I838_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I190_XG_MP1 (I838_G21_0 I838_G5_0n XI838_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I188_XG_MP2 (VDD I838_G20_5n I838_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I188_XG_MP0 (XI838_I188_XG_p1 I838_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I188_XG_MP1 (I838_G20_0 I838_G4_0n XI838_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I139_XG_MP2 (VDD I838_G14_11n I838_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I139_XG_MP0 (XI838_I139_XG_p1 I838_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I139_XG_MP1 (I838_G14_7 I838_G10_7n XI838_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I197_XG_MP2 (VDD I838_G26_11n I838_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I197_XG_MP0 (XI838_I197_XG_p1 I838_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I197_XG_MP1 (I838_G26_0 I838_G10_0n XI838_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I80_XG_MP2 (VDD I884_gn14 I884_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I80_XG_MP0 (XI884_I80_XG_p1 I884_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I80_XG_MP1 (I884_G14_13 I884_gn13 XI884_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I79_XG_MP2 (VDD I884_gn13 I884_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I79_XG_MP0 (XI884_I79_XG_p1 I884_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I79_XG_MP1 (I884_G13_12 I884_gn12 XI884_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I139_XG_MP2 (VDD I884_G14_11n I884_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I139_XG_MP0 (XI884_I139_XG_p1 I884_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I139_XG_MP1 (I884_G14_7 I884_G10_7n XI884_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I141_XG_MP2 (VDD I884_G16_13n I884_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I141_XG_MP0 (XI884_I141_XG_p1 I884_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I141_XG_MP1 (I884_G16_9 I884_G12_9n XI884_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I195_XG_MP2 (VDD I884_G24_9n I884_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I195_XG_MP0 (XI884_I195_XG_p1 I884_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I195_XG_MP1 (I884_G24_0 I884_G8_0n XI884_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I142_XG_MP2 (VDD I884_G17_14n I884_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I142_XG_MP0 (XI884_I142_XG_p1 I884_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I142_XG_MP1 (I884_G17_10 I884_G13_10n XI884_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I138_XG_MP2 (VDD I884_G13_10n I884_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I138_XG_MP0 (XI884_I138_XG_p1 I884_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I138_XG_MP1 (I884_G13_6 I884_G9_6n XI884_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I196_XG_MP2 (VDD I884_G25_10n I884_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I196_XG_MP0 (XI884_I196_XG_p1 I884_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I196_XG_MP1 (I884_G25_0 I884_G9_0n XI884_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I139_XG_MP2 (VDD I1712_G14_11n I1712_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I139_XG_MP0 (XI1712_I139_XG_p1 I1712_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I139_XG_MP1 (I1712_G14_7 I1712_G10_7n XI1712_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I78_XG_MP2 (VDD I1712_gn12 I1712_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I78_XG_MP0 (XI1712_I78_XG_p1 I1712_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I78_XG_MP1 (I1712_G12_11 I1712_gn11 XI1712_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I77_XG_MP2 (VDD I1712_gn11 I1712_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I77_XG_MP0 (XI1712_I77_XG_p1 I1712_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I77_XG_MP1 (I1712_G11_10 I1712_gn10 XI1712_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I184_XG_MP2 (VDD I1712_G17_2n I1712_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I184_XG_MP0 (XI1712_I184_XG_p1 I1712_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I184_XG_MP1 (I1712_G17_0 I1712_G1_0n XI1712_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I132_XG_MP2 (VDD I1712_G7_4n I1712_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I132_XG_MP0 (XI1712_I132_XG_p1 I1712_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I132_XG_MP1 (I1712_G7_0 I1712_G3_0n XI1712_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I136_XG_MP2 (VDD I1712_G11_8n I1712_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I136_XG_MP0 (XI1712_I136_XG_p1 I1712_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I136_XG_MP1 (I1712_G11_4 I1712_G7_4n XI1712_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I79_XG_MP2 (VDD I1758_gn13 I1758_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I79_XG_MP0 (XI1758_I79_XG_p1 I1758_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I79_XG_MP1 (I1758_G13_12 I1758_gn12 XI1758_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I78_XG_MP2 (VDD I1758_gn12 I1758_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I78_XG_MP0 (XI1758_I78_XG_p1 I1758_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I78_XG_MP1 (I1758_G12_11 I1758_gn11 XI1758_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I139_XG_MP2 (VDD I1758_G14_11n I1758_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I139_XG_MP0 (XI1758_I139_XG_p1 I1758_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I139_XG_MP1 (I1758_G14_7 I1758_G10_7n XI1758_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I188_XG_MP2 (VDD I1758_G20_5n I1758_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I188_XG_MP0 (XI1758_I188_XG_p1 I1758_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I188_XG_MP1 (I1758_G20_0 I1758_G4_0n XI1758_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I138_XG_MP2 (VDD I1758_G13_10n I1758_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I138_XG_MP0 (XI1758_I138_XG_p1 I1758_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I138_XG_MP1 (I1758_G13_6 I1758_G9_6n XI1758_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I196_XG_MP2 (VDD I1758_G25_10n I1758_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I196_XG_MP0 (XI1758_I196_XG_p1 I1758_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I196_XG_MP1 (I1758_G25_0 I1758_G9_0n XI1758_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I136_XG_MP2 (VDD I1758_G11_8n I1758_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I136_XG_MP0 (XI1758_I136_XG_p1 I1758_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I136_XG_MP1 (I1758_G11_4 I1758_G7_4n XI1758_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I79_XG_MP2 (VDD I1804_gn13 I1804_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I79_XG_MP0 (XI1804_I79_XG_p1 I1804_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I79_XG_MP1 (I1804_G13_12 I1804_gn12 XI1804_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I80_XG_MP2 (VDD I1804_gn14 I1804_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I80_XG_MP0 (XI1804_I80_XG_p1 I1804_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I80_XG_MP1 (I1804_G14_13 I1804_gn13 XI1804_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I138_XG_MP2 (VDD I1804_G13_10n I1804_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I138_XG_MP0 (XI1804_I138_XG_p1 I1804_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I138_XG_MP1 (I1804_G13_6 I1804_G9_6n XI1804_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I145_XG_MP2 (VDD I1804_G20_17n I1804_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I145_XG_MP0 (XI1804_I145_XG_p1 I1804_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I145_XG_MP1 (I1804_G20_13 I1804_G16_13n XI1804_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I149_XG_MP2 (VDD I1804_G24_21n I1804_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I149_XG_MP0 (XI1804_I149_XG_p1 I1804_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I149_XG_MP1 (I1804_G24_17 I1804_G20_17n XI1804_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I201_XG_MP2 (VDD I1804_G30_15n c27_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I201_XG_MP0 (XI1804_I201_XG_p1 I1804_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I201_XG_MP1 (c27_m I1804_G14_0n XI1804_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I91_XG_MP2 (VDD I746_gn25 I746_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I91_XG_MP0 (XI746_I91_XG_p1 I746_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I91_XG_MP1 (I746_G25_24 I746_gn24 XI746_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I149_XG_MP2 (VDD I746_G24_21n I746_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I149_XG_MP0 (XI746_I149_XG_p1 I746_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I149_XG_MP1 (I746_G24_17 I746_G20_17n XI746_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I145_XG_MP2 (VDD I746_G20_17n I746_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I145_XG_MP0 (XI746_I145_XG_p1 I746_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I145_XG_MP1 (I746_G20_13 I746_G16_13n XI746_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I143_XG_MP2 (VDD I746_G18_15n I746_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I143_XG_MP0 (XI746_I143_XG_p1 I746_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I143_XG_MP1 (I746_G18_11 I746_G14_11n XI746_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I139_XG_MP2 (VDD I746_G14_11n I746_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I139_XG_MP0 (XI746_I139_XG_p1 I746_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I139_XG_MP1 (I746_G14_7 I746_G10_7n XI746_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I188_XG_MP2 (VDD I746_G20_5n I746_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I188_XG_MP0 (XI746_I188_XG_p1 I746_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I188_XG_MP1 (I746_G20_0 I746_G4_0n XI746_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I195_XG_MP2 (VDD I746_G24_9n I746_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I195_XG_MP0 (XI746_I195_XG_p1 I746_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I195_XG_MP1 (I746_G24_0 I746_G8_0n XI746_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I185_XG_MP2 (VDD I746_G18_3n I746_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I185_XG_MP0 (XI746_I185_XG_p1 I746_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I185_XG_MP1 (I746_G18_0 I746_G2_0n XI746_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I85_XG_MP2 (VDD I792_gn19 I792_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I85_XG_MP0 (XI792_I85_XG_p1 I792_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I85_XG_MP1 (I792_G19_18 I792_gn18 XI792_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I84_XG_MP2 (VDD I792_gn18 I792_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I84_XG_MP0 (XI792_I84_XG_p1 I792_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I84_XG_MP1 (I792_G18_17 I792_gn17 XI792_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I144_XG_MP2 (VDD I792_G19_16n I792_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I144_XG_MP0 (XI792_I144_XG_p1 I792_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I144_XG_MP1 (I792_G19_12 I792_G15_12n XI792_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I140_XG_MP2 (VDD I792_G15_12n I792_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I140_XG_MP0 (XI792_I140_XG_p1 I792_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I140_XG_MP1 (I792_G15_8 I792_G11_8n XI792_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I142_XG_MP2 (VDD I792_G17_14n I792_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I142_XG_MP0 (XI792_I142_XG_p1 I792_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I142_XG_MP1 (I792_G17_10 I792_G13_10n XI792_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I145_XG_MP2 (VDD I792_G20_17n I792_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I145_XG_MP0 (XI792_I145_XG_p1 I792_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I145_XG_MP1 (I792_G20_13 I792_G16_13n XI792_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I143_XG_MP2 (VDD I792_G18_15n I792_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I143_XG_MP0 (XI792_I143_XG_p1 I792_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I143_XG_MP1 (I792_G18_11 I792_G14_11n XI792_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I188_XG_MP2 (VDD I792_G20_5n I792_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I188_XG_MP0 (XI792_I188_XG_p1 I792_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I188_XG_MP1 (I792_G20_0 I792_G4_0n XI792_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I195_XG_MP2 (VDD I792_G24_9n I792_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I195_XG_MP0 (XI792_I195_XG_p1 I792_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I195_XG_MP1 (I792_G24_0 I792_G8_0n XI792_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I81_XG_MP2 (VDD I838_gn15 I838_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I81_XG_MP0 (XI838_I81_XG_p1 I838_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I81_XG_MP1 (I838_G15_14 I838_gn14 XI838_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I144_XG_MP2 (VDD I838_G19_16n I838_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I144_XG_MP0 (XI838_I144_XG_p1 I838_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I144_XG_MP1 (I838_G19_12 I838_G15_12n XI838_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I150_XG_MP2 (VDD I838_G25_22n I838_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I150_XG_MP0 (XI838_I150_XG_p1 I838_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I150_XG_MP1 (I838_G25_18 I838_G21_18n XI838_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I146_XG_MP2 (VDD I838_G21_18n I838_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I146_XG_MP0 (XI838_I146_XG_p1 I838_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I146_XG_MP1 (I838_G21_14 I838_G17_14n XI838_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I200_XG_MP2 (VDD I838_G29_14n I838_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I200_XG_MP0 (XI838_I200_XG_p1 I838_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I200_XG_MP1 (I838_G29_0 I838_G13_0n XI838_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I145_XG_MP2 (VDD I838_G20_17n I838_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I145_XG_MP0 (XI838_I145_XG_p1 I838_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I145_XG_MP1 (I838_G20_13 I838_G16_13n XI838_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I149_XG_MP2 (VDD I838_G24_21n I838_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I149_XG_MP0 (XI838_I149_XG_p1 I838_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I149_XG_MP1 (I838_G24_17 I838_G20_17n XI838_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI838_I143_XG_MP2 (VDD I838_G18_15n I838_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI838_I143_XG_MP0 (XI838_I143_XG_p1 I838_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI838_I143_XG_MP1 (I838_G18_11 I838_G14_11n XI838_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I82_XG_MP2 (VDD I884_gn16 I884_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I82_XG_MP0 (XI884_I82_XG_p1 I884_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I82_XG_MP1 (I884_G16_15 I884_gn15 XI884_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I81_XG_MP2 (VDD I884_gn15 I884_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I81_XG_MP0 (XI884_I81_XG_p1 I884_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I81_XG_MP1 (I884_G15_14 I884_gn14 XI884_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I143_XG_MP2 (VDD I884_G18_15n I884_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I143_XG_MP0 (XI884_I143_XG_p1 I884_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I143_XG_MP1 (I884_G18_11 I884_G14_11n XI884_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I197_XG_MP2 (VDD I884_G26_11n I884_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I197_XG_MP0 (XI884_I197_XG_p1 I884_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I197_XG_MP1 (I884_G26_0 I884_G10_0n XI884_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I188_XG_MP2 (VDD I884_G20_5n I884_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I188_XG_MP0 (XI884_I188_XG_p1 I884_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I188_XG_MP1 (I884_G20_0 I884_G4_0n XI884_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I190_XG_MP2 (VDD I884_G21_6n I884_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I190_XG_MP0 (XI884_I190_XG_p1 I884_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I190_XG_MP1 (I884_G21_0 I884_G5_0n XI884_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I136_XG_MP2 (VDD I884_G11_8n I884_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I136_XG_MP0 (XI884_I136_XG_p1 I884_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I136_XG_MP1 (I884_G11_4 I884_G7_4n XI884_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI884_I132_XG_MP2 (VDD I884_G7_4n I884_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI884_I132_XG_MP0 (XI884_I132_XG_p1 I884_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI884_I132_XG_MP1 (I884_G7_0 I884_G3_0n XI884_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I192_XG_MP2 (VDD I1712_G22_7n I1712_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I192_XG_MP0 (XI1712_I192_XG_p1 I1712_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I192_XG_MP1 (I1712_G22_0 I1712_G6_0n XI1712_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I143_XG_MP2 (VDD I1712_G18_15n I1712_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I143_XG_MP0 (XI1712_I143_XG_p1 I1712_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I143_XG_MP1 (I1712_G18_11 I1712_G14_11n XI1712_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I145_XG_MP2 (VDD I1712_G20_17n I1712_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I145_XG_MP0 (XI1712_I145_XG_p1 I1712_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I145_XG_MP1 (I1712_G20_13 I1712_G16_13n XI1712_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I199_XG_MP2 (VDD I1712_G28_13n I1712_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I199_XG_MP0 (XI1712_I199_XG_p1 I1712_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I199_XG_MP1 (I1712_G28_0 I1712_G12_0n XI1712_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I80_XG_MP2 (VDD I1712_gn14 I1712_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I80_XG_MP0 (XI1712_I80_XG_p1 I1712_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I80_XG_MP1 (I1712_G14_13 I1712_gn13 XI1712_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I79_XG_MP2 (VDD I1712_gn13 I1712_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I79_XG_MP0 (XI1712_I79_XG_p1 I1712_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I79_XG_MP1 (I1712_G13_12 I1712_gn12 XI1712_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I142_XG_MP2 (VDD I1712_G17_14n I1712_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I142_XG_MP0 (XI1712_I142_XG_p1 I1712_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I142_XG_MP1 (I1712_G17_10 I1712_G13_10n XI1712_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I138_XG_MP2 (VDD I1712_G13_10n I1712_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I138_XG_MP0 (XI1712_I138_XG_p1 I1712_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I138_XG_MP1 (I1712_G13_6 I1712_G9_6n XI1712_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I196_XG_MP2 (VDD I1712_G25_10n I1712_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I196_XG_MP0 (XI1712_I196_XG_p1 I1712_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I196_XG_MP1 (I1712_G25_0 I1712_G9_0n XI1712_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1712_I186_XG_MP2 (VDD I1712_G19_4n I1712_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1712_I186_XG_MP0 (XI1712_I186_XG_p1 I1712_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1712_I186_XG_MP1 (I1712_G19_0 I1712_G3_0n XI1712_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I80_XG_MP2 (VDD I1758_gn14 I1758_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I80_XG_MP0 (XI1758_I80_XG_p1 I1758_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I80_XG_MP1 (I1758_G14_13 I1758_gn13 XI1758_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I81_XG_MP2 (VDD I1758_gn15 I1758_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I81_XG_MP0 (XI1758_I81_XG_p1 I1758_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I81_XG_MP1 (I1758_G15_14 I1758_gn14 XI1758_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I145_XG_MP2 (VDD I1758_G20_17n I1758_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I145_XG_MP0 (XI1758_I145_XG_p1 I1758_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I145_XG_MP1 (I1758_G20_13 I1758_G16_13n XI1758_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I143_XG_MP2 (VDD I1758_G18_15n I1758_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I143_XG_MP0 (XI1758_I143_XG_p1 I1758_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I143_XG_MP1 (I1758_G18_11 I1758_G14_11n XI1758_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I197_XG_MP2 (VDD I1758_G26_11n I1758_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I197_XG_MP0 (XI1758_I197_XG_p1 I1758_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I197_XG_MP1 (I1758_G26_0 I1758_G10_0n XI1758_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I142_XG_MP2 (VDD I1758_G17_14n I1758_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I142_XG_MP0 (XI1758_I142_XG_p1 I1758_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I142_XG_MP1 (I1758_G17_10 I1758_G13_10n XI1758_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1758_I186_XG_MP2 (VDD I1758_G19_4n I1758_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1758_I186_XG_MP0 (XI1758_I186_XG_p1 I1758_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1758_I186_XG_MP1 (I1758_G19_0 I1758_G3_0n XI1758_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I81_XG_MP2 (VDD I1804_gn15 I1804_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I81_XG_MP0 (XI1804_I81_XG_p1 I1804_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I81_XG_MP1 (I1804_G15_14 I1804_gn14 XI1804_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I82_XG_MP2 (VDD I1804_gn16 I1804_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I82_XG_MP0 (XI1804_I82_XG_p1 I1804_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I82_XG_MP1 (I1804_G16_15 I1804_gn15 XI1804_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I142_XG_MP2 (VDD I1804_G17_14n I1804_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I142_XG_MP0 (XI1804_I142_XG_p1 I1804_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I142_XG_MP1 (I1804_G17_10 I1804_G13_10n XI1804_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I196_XG_MP2 (VDD I1804_G25_10n I1804_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I196_XG_MP0 (XI1804_I196_XG_p1 I1804_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I196_XG_MP1 (I1804_G25_0 I1804_G9_0n XI1804_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I190_XG_MP2 (VDD I1804_G21_6n I1804_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I190_XG_MP0 (XI1804_I190_XG_p1 I1804_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I190_XG_MP1 (I1804_G21_0 I1804_G5_0n XI1804_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI1804_I147_XG_MP2 (VDD I1804_G22_19n I1804_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI1804_I147_XG_MP0 (XI1804_I147_XG_p1 I1804_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI1804_I147_XG_MP1 (I1804_G22_15 I1804_G18_15n XI1804_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I90_XG_MP2 (VDD I746_gn24 I746_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I90_XG_MP0 (XI746_I90_XG_p1 I746_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I90_XG_MP1 (I746_G24_23 I746_gn23 XI746_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I92_XG_MP2 (VDD I746_gn26 I746_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I92_XG_MP0 (XI746_I92_XG_p1 I746_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I92_XG_MP1 (I746_G26_25 I746_gn25 XI746_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I153_XG_MP2 (VDD I746_G28_25n I746_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I153_XG_MP0 (XI746_I153_XG_p1 I746_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I153_XG_MP1 (I746_G28_21 I746_G24_21n XI746_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I147_XG_MP2 (VDD I746_G22_19n I746_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I147_XG_MP0 (XI746_I147_XG_p1 I746_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I147_XG_MP1 (I746_G22_15 I746_G18_15n XI746_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I199_XG_MP2 (VDD I746_G28_13n I746_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I199_XG_MP0 (XI746_I199_XG_p1 I746_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I199_XG_MP1 (I746_G28_0 I746_G12_0n XI746_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI746_I192_XG_MP2 (VDD I746_G22_7n I746_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI746_I192_XG_MP0 (XI746_I192_XG_p1 I746_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI746_I192_XG_MP1 (I746_G22_0 I746_G6_0n XI746_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I87_XG_MP2 (VDD I792_gn21 I792_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I87_XG_MP0 (XI792_I87_XG_p1 I792_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I87_XG_MP1 (I792_G21_20 I792_gn20 XI792_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I86_XG_MP2 (VDD I792_gn20 I792_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I86_XG_MP0 (XI792_I86_XG_p1 I792_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I86_XG_MP1 (I792_G20_19 I792_gn19 XI792_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I146_XG_MP2 (VDD I792_G21_18n I792_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I146_XG_MP0 (XI792_I146_XG_p1 I792_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I146_XG_MP1 (I792_G21_14 I792_G17_14n XI792_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I190_XG_MP2 (VDD I792_G21_6n I792_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09359p as=0.08159p pd=0.92u ps=1.16u
    I_MXI792_I190_XG_MP0 (XI792_I190_XG_p1 I792_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10559p as=0.09359p pd=0.92u ps=0.92u
    I_MXI792_I190_XG_MP1 (I792_G21_0 I792_G5_0n XI792_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16319p as=0.10559p pd=1.64u ps=0.92u
    I_MXI792_I196_XG_MP2 (VDD I792_G25_10n I792_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I196_XG_MP0 (XI792_I196_XG_p1 I792_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I196_XG_MP1 (I792_G25_0 I792_G9_0n XI792_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I149_XG_MP2 (VDD I792_G24_21n I792_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I149_XG_MP0 (XI792_I149_XG_p1 I792_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I149_XG_MP1 (I792_G24_17 I792_G20_17n XI792_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I199_XG_MP2 (VDD I792_G28_13n I792_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I199_XG_MP0 (XI792_I199_XG_p1 I792_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I199_XG_MP1 (I792_G28_0 I792_G12_0n XI792_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I82_XG_MP2 (VDD I838_gn16 I838_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I82_XG_MP0 (XI838_I82_XG_p1 I838_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I82_XG_MP1 (I838_G16_15 I838_gn15 XI838_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I83_XG_MP2 (VDD I838_gn17 I838_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I83_XG_MP0 (XI838_I83_XG_p1 I838_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I83_XG_MP1 (I838_G17_16 I838_gn16 XI838_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I198_XG_MP2 (VDD I838_G27_12n I838_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I198_XG_MP0 (XI838_I198_XG_p1 I838_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I198_XG_MP1 (I838_G27_0 I838_G11_0n XI838_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I84_XG_MP2 (VDD I838_gn18 I838_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I84_XG_MP0 (XI838_I84_XG_p1 I838_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I84_XG_MP1 (I838_G18_17 I838_gn17 XI838_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I199_XG_MP2 (VDD I838_G28_13n I838_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I199_XG_MP0 (XI838_I199_XG_p1 I838_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I199_XG_MP1 (I838_G28_0 I838_G12_0n XI838_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I83_XG_MP2 (VDD I884_gn17 I884_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I83_XG_MP0 (XI884_I83_XG_p1 I884_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I83_XG_MP1 (I884_G17_16 I884_gn16 XI884_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I192_XG_MP2 (VDD I884_G22_7n I884_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I192_XG_MP0 (XI884_I192_XG_p1 I884_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I192_XG_MP1 (I884_G22_0 I884_G6_0n XI884_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I145_XG_MP2 (VDD I884_G20_17n I884_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I145_XG_MP0 (XI884_I145_XG_p1 I884_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I145_XG_MP1 (I884_G20_13 I884_G16_13n XI884_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I149_XG_MP2 (VDD I884_G24_21n I884_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I149_XG_MP0 (XI884_I149_XG_p1 I884_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I149_XG_MP1 (I884_G24_17 I884_G20_17n XI884_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I146_XG_MP2 (VDD I884_G21_18n I884_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I146_XG_MP0 (XI884_I146_XG_p1 I884_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I146_XG_MP1 (I884_G21_14 I884_G17_14n XI884_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I140_XG_MP2 (VDD I884_G15_12n I884_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I140_XG_MP0 (XI884_I140_XG_p1 I884_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I140_XG_MP1 (I884_G15_8 I884_G11_8n XI884_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I197_XG_MP2 (VDD I1712_G26_11n I1712_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I197_XG_MP0 (XI1712_I197_XG_p1 I1712_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I197_XG_MP1 (I1712_G26_0 I1712_G10_0n XI1712_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I149_XG_MP2 (VDD I1712_G24_21n I1712_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I149_XG_MP0 (XI1712_I149_XG_p1 I1712_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I149_XG_MP1 (I1712_G24_17 I1712_G20_17n XI1712_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I81_XG_MP2 (VDD I1712_gn15 I1712_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I81_XG_MP0 (XI1712_I81_XG_p1 I1712_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I81_XG_MP1 (I1712_G15_14 I1712_gn14 XI1712_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I140_XG_MP2 (VDD I1712_G15_12n I1712_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I140_XG_MP0 (XI1712_I140_XG_p1 I1712_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I140_XG_MP1 (I1712_G15_8 I1712_G11_8n XI1712_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I82_XG_MP2 (VDD I1758_gn16 I1758_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I82_XG_MP0 (XI1758_I82_XG_p1 I1758_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I82_XG_MP1 (I1758_G16_15 I1758_gn15 XI1758_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I83_XG_MP2 (VDD I1758_gn17 I1758_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I83_XG_MP0 (XI1758_I83_XG_p1 I1758_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I83_XG_MP1 (I1758_G17_16 I1758_gn16 XI1758_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I149_XG_MP2 (VDD I1758_G24_21n I1758_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I149_XG_MP0 (XI1758_I149_XG_p1 I1758_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I149_XG_MP1 (I1758_G24_17 I1758_G20_17n XI1758_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I199_XG_MP2 (VDD I1758_G28_13n I1758_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I199_XG_MP0 (XI1758_I199_XG_p1 I1758_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I199_XG_MP1 (I1758_G28_0 I1758_G12_0n XI1758_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I146_XG_MP2 (VDD I1758_G21_18n I1758_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I146_XG_MP0 (XI1758_I146_XG_p1 I1758_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I146_XG_MP1 (I1758_G21_14 I1758_G17_14n XI1758_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I190_XG_MP2 (VDD I1758_G21_6n I1758_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I190_XG_MP0 (XI1758_I190_XG_p1 I1758_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I190_XG_MP1 (I1758_G21_0 I1758_G5_0n XI1758_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I140_XG_MP2 (VDD I1758_G15_12n I1758_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I140_XG_MP0 (XI1758_I140_XG_p1 I1758_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I140_XG_MP1 (I1758_G15_8 I1758_G11_8n XI1758_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I144_XG_MP2 (VDD I1758_G19_16n I1758_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I144_XG_MP0 (XI1758_I144_XG_p1 I1758_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I144_XG_MP1 (I1758_G19_12 I1758_G15_12n XI1758_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I83_XG_MP2 (VDD I1804_gn17 I1804_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I83_XG_MP0 (XI1804_I83_XG_p1 I1804_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I83_XG_MP1 (I1804_G17_16 I1804_gn16 XI1804_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I84_XG_MP2 (VDD I1804_gn18 I1804_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I84_XG_MP0 (XI1804_I84_XG_p1 I1804_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I84_XG_MP1 (I1804_G18_17 I1804_gn17 XI1804_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I140_XG_MP2 (VDD I1804_G15_12n I1804_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I140_XG_MP0 (XI1804_I140_XG_p1 I1804_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I140_XG_MP1 (I1804_G15_8 I1804_G11_8n XI1804_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I144_XG_MP2 (VDD I1804_G19_16n I1804_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I144_XG_MP0 (XI1804_I144_XG_p1 I1804_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I144_XG_MP1 (I1804_G19_12 I1804_G15_12n XI1804_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I198_XG_MP2 (VDD I1804_G27_12n I1804_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I198_XG_MP0 (XI1804_I198_XG_p1 I1804_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I198_XG_MP1 (I1804_G27_0 I1804_G11_0n XI1804_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I146_XG_MP2 (VDD I1804_G21_18n I1804_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I146_XG_MP0 (XI1804_I146_XG_p1 I1804_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I146_XG_MP1 (I1804_G21_14 I1804_G17_14n XI1804_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I200_XG_MP2 (VDD I1804_G29_14n I1804_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I200_XG_MP0 (XI1804_I200_XG_p1 I1804_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I200_XG_MP1 (I1804_G29_0 I1804_G13_0n XI1804_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I153_XG_MP2 (VDD I1804_G28_25n I1804_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I153_XG_MP0 (XI1804_I153_XG_p1 I1804_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I153_XG_MP1 (I1804_G28_21 I1804_G24_21n XI1804_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I151_XG_MP2 (VDD I1804_G26_23n I1804_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I151_XG_MP0 (XI1804_I151_XG_p1 I1804_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I151_XG_MP1 (I1804_G26_19 I1804_G22_19n XI1804_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI746_I97_XG_MP2 (VDD I746_gn31 I746_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI746_I97_XG_MP0 (XI746_I97_XG_p1 I746_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI746_I97_XG_MP1 (I746_G31_30 I746_gn30 XI746_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI746_I93_XG_MP2 (VDD I746_gn27 I746_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI746_I93_XG_MP0 (XI746_I93_XG_p1 I746_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI746_I93_XG_MP1 (I746_G27_26 I746_gn26 XI746_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI746_I151_XG_MP2 (VDD I746_G26_23n I746_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI746_I151_XG_MP0 (XI746_I151_XG_p1 I746_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI746_I151_XG_MP1 (I746_G26_19 I746_G22_19n XI746_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI746_I197_XG_MP2 (VDD I746_G26_11n I746_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI746_I197_XG_MP0 (XI746_I197_XG_p1 I746_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI746_I197_XG_MP1 (I746_G26_0 I746_G10_0n XI746_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I90_XG_MP2 (VDD I792_gn24 I792_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I90_XG_MP0 (XI792_I90_XG_p1 I792_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I90_XG_MP1 (I792_G24_23 I792_gn23 XI792_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I89_XG_MP2 (VDD I792_gn23 I792_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I89_XG_MP0 (XI792_I89_XG_p1 I792_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I89_XG_MP1 (I792_G23_22 I792_gn22 XI792_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I88_XG_MP2 (VDD I792_gn22 I792_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I88_XG_MP0 (XI792_I88_XG_p1 I792_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I88_XG_MP1 (I792_G22_21 I792_gn21 XI792_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I154_XG_MP2 (VDD I792_G29_26n I792_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I154_XG_MP0 (XI792_I154_XG_p1 I792_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I154_XG_MP1 (I792_G29_22 I792_G25_22n XI792_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I150_XG_MP2 (VDD I792_G25_22n I792_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I150_XG_MP0 (XI792_I150_XG_p1 I792_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I150_XG_MP1 (I792_G25_18 I792_G21_18n XI792_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I200_XG_MP2 (VDD I792_G29_14n I792_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I200_XG_MP0 (XI792_I200_XG_p1 I792_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I200_XG_MP1 (I792_G29_0 I792_G13_0n XI792_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I153_XG_MP2 (VDD I792_G28_25n I792_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I153_XG_MP0 (XI792_I153_XG_p1 I792_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I153_XG_MP1 (I792_G28_21 I792_G24_21n XI792_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I147_XG_MP2 (VDD I792_G22_19n I792_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I147_XG_MP0 (XI792_I147_XG_p1 I792_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I147_XG_MP1 (I792_G22_15 I792_G18_15n XI792_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I192_XG_MP2 (VDD I792_G22_7n I792_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I192_XG_MP0 (XI792_I192_XG_p1 I792_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I192_XG_MP1 (I792_G22_0 I792_G6_0n XI792_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I202_XG_MP2 (VDD I838_G31_16n c6_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I202_XG_MP0 (XI838_I202_XG_p1 I838_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I202_XG_MP1 (c6_o I838_G15_0n XI838_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I194_XG_MP2 (VDD I838_G23_8n I838_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I194_XG_MP0 (XI838_I194_XG_p1 I838_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I194_XG_MP1 (I838_G23_0 I838_G7_0n XI838_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I154_XG_MP2 (VDD I838_G29_26n I838_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I154_XG_MP0 (XI838_I154_XG_p1 I838_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I154_XG_MP1 (I838_G29_22 I838_G25_22n XI838_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I85_XG_MP2 (VDD I838_gn19 I838_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I85_XG_MP0 (XI838_I85_XG_p1 I838_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I85_XG_MP1 (I838_G19_18 I838_gn18 XI838_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I86_XG_MP2 (VDD I838_gn20 I838_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I86_XG_MP0 (XI838_I86_XG_p1 I838_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I86_XG_MP1 (I838_G20_19 I838_gn19 XI838_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I147_XG_MP2 (VDD I838_G22_19n I838_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I147_XG_MP0 (XI838_I147_XG_p1 I838_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I147_XG_MP1 (I838_G22_15 I838_G18_15n XI838_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I151_XG_MP2 (VDD I838_G26_23n I838_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I151_XG_MP0 (XI838_I151_XG_p1 I838_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I151_XG_MP1 (I838_G26_19 I838_G22_19n XI838_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I192_XG_MP2 (VDD I838_G22_7n I838_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I192_XG_MP0 (XI838_I192_XG_p1 I838_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I192_XG_MP1 (I838_G22_0 I838_G6_0n XI838_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I85_XG_MP2 (VDD I884_gn19 I884_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I85_XG_MP0 (XI884_I85_XG_p1 I884_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I85_XG_MP1 (I884_G19_18 I884_gn18 XI884_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I84_XG_MP2 (VDD I884_gn18 I884_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I84_XG_MP0 (XI884_I84_XG_p1 I884_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I84_XG_MP1 (I884_G18_17 I884_gn17 XI884_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I147_XG_MP2 (VDD I884_G22_19n I884_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I147_XG_MP0 (XI884_I147_XG_p1 I884_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I147_XG_MP1 (I884_G22_15 I884_G18_15n XI884_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I151_XG_MP2 (VDD I884_G26_23n I884_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I151_XG_MP0 (XI884_I151_XG_p1 I884_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I151_XG_MP1 (I884_G26_19 I884_G22_19n XI884_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I199_XG_MP2 (VDD I884_G28_13n I884_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I199_XG_MP0 (XI884_I199_XG_p1 I884_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I199_XG_MP1 (I884_G28_0 I884_G12_0n XI884_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I150_XG_MP2 (VDD I884_G25_22n I884_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I150_XG_MP0 (XI884_I150_XG_p1 I884_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I150_XG_MP1 (I884_G25_18 I884_G21_18n XI884_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I144_XG_MP2 (VDD I884_G19_16n I884_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I144_XG_MP0 (XI884_I144_XG_p1 I884_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I144_XG_MP1 (I884_G19_12 I884_G15_12n XI884_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I186_XG_MP2 (VDD I884_G19_4n I884_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I186_XG_MP0 (XI884_I186_XG_p1 I884_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I186_XG_MP1 (I884_G19_0 I884_G3_0n XI884_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I147_XG_MP2 (VDD I1712_G22_19n I1712_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I147_XG_MP0 (XI1712_I147_XG_p1 I1712_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I147_XG_MP1 (I1712_G22_15 I1712_G18_15n XI1712_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I153_XG_MP2 (VDD I1712_G28_25n I1712_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I153_XG_MP0 (XI1712_I153_XG_p1 I1712_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I153_XG_MP1 (I1712_G28_21 I1712_G24_21n XI1712_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I82_XG_MP2 (VDD I1712_gn16 I1712_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I82_XG_MP0 (XI1712_I82_XG_p1 I1712_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I82_XG_MP1 (I1712_G16_15 I1712_gn15 XI1712_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I83_XG_MP2 (VDD I1712_gn17 I1712_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I83_XG_MP0 (XI1712_I83_XG_p1 I1712_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I83_XG_MP1 (I1712_G17_16 I1712_gn16 XI1712_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I146_XG_MP2 (VDD I1712_G21_18n I1712_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I146_XG_MP0 (XI1712_I146_XG_p1 I1712_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I146_XG_MP1 (I1712_G21_14 I1712_G17_14n XI1712_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I190_XG_MP2 (VDD I1712_G21_6n I1712_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I190_XG_MP0 (XI1712_I190_XG_p1 I1712_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I190_XG_MP1 (I1712_G21_0 I1712_G5_0n XI1712_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I144_XG_MP2 (VDD I1712_G19_16n I1712_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I144_XG_MP0 (XI1712_I144_XG_p1 I1712_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I144_XG_MP1 (I1712_G19_12 I1712_G15_12n XI1712_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I198_XG_MP2 (VDD I1712_G27_12n I1712_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I198_XG_MP0 (XI1712_I198_XG_p1 I1712_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I198_XG_MP1 (I1712_G27_0 I1712_G11_0n XI1712_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I85_XG_MP2 (VDD I1758_gn19 I1758_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I85_XG_MP0 (XI1758_I85_XG_p1 I1758_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I85_XG_MP1 (I1758_G19_18 I1758_gn18 XI1758_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I84_XG_MP2 (VDD I1758_gn18 I1758_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I84_XG_MP0 (XI1758_I84_XG_p1 I1758_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I84_XG_MP1 (I1758_G18_17 I1758_gn17 XI1758_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I147_XG_MP2 (VDD I1758_G22_19n I1758_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I147_XG_MP0 (XI1758_I147_XG_p1 I1758_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I147_XG_MP1 (I1758_G22_15 I1758_G18_15n XI1758_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I192_XG_MP2 (VDD I1758_G22_7n I1758_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I192_XG_MP0 (XI1758_I192_XG_p1 I1758_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I192_XG_MP1 (I1758_G22_0 I1758_G6_0n XI1758_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I150_XG_MP2 (VDD I1758_G25_22n I1758_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I150_XG_MP0 (XI1758_I150_XG_p1 I1758_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I150_XG_MP1 (I1758_G25_18 I1758_G21_18n XI1758_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I198_XG_MP2 (VDD I1758_G27_12n I1758_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I198_XG_MP0 (XI1758_I198_XG_p1 I1758_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I198_XG_MP1 (I1758_G27_0 I1758_G11_0n XI1758_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I85_XG_MP2 (VDD I1804_gn19 I1804_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I85_XG_MP0 (XI1804_I85_XG_p1 I1804_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I85_XG_MP1 (I1804_G19_18 I1804_gn18 XI1804_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I86_XG_MP2 (VDD I1804_gn20 I1804_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I86_XG_MP0 (XI1804_I86_XG_p1 I1804_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I86_XG_MP1 (I1804_G20_19 I1804_gn19 XI1804_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I194_XG_MP2 (VDD I1804_G23_8n I1804_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I194_XG_MP0 (XI1804_I194_XG_p1 I1804_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I194_XG_MP1 (I1804_G23_0 I1804_G7_0n XI1804_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I150_XG_MP2 (VDD I1804_G25_22n I1804_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I150_XG_MP0 (XI1804_I150_XG_p1 I1804_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I150_XG_MP1 (I1804_G25_18 I1804_G21_18n XI1804_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I155_XG_MP2 (VDD I1804_G30_27n I1804_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I155_XG_MP0 (XI1804_I155_XG_p1 I1804_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I155_XG_MP1 (I1804_G30_23 I1804_G26_23n XI1804_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI746_I96_XG_MP2 (VDD I746_gn30 I746_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI746_I96_XG_MP0 (XI746_I96_XG_p1 I746_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI746_I96_XG_MP1 (I746_G30_29 I746_gn29 XI746_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI746_I95_XG_MP2 (VDD I746_gn29 I746_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI746_I95_XG_MP0 (XI746_I95_XG_p1 I746_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI746_I95_XG_MP1 (I746_G29_28 I746_gn28 XI746_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI746_I94_XG_MP2 (VDD I746_gn28 I746_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI746_I94_XG_MP0 (XI746_I94_XG_p1 I746_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI746_I94_XG_MP1 (I746_G28_27 I746_gn27 XI746_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI746_I155_XG_MP2 (VDD I746_G30_27n I746_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI746_I155_XG_MP0 (XI746_I155_XG_p1 I746_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI746_I155_XG_MP1 (I746_G30_23 I746_G26_23n XI746_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI746_I201_XG_MP2 (VDD I746_G30_15n c4_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI746_I201_XG_MP0 (XI746_I201_XG_p1 I746_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI746_I201_XG_MP1 (c4_m I746_G14_0n XI746_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I92_XG_MP2 (VDD I792_gn26 I792_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I92_XG_MP0 (XI792_I92_XG_p1 I792_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I92_XG_MP1 (I792_G26_25 I792_gn25 XI792_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I91_XG_MP2 (VDD I792_gn25 I792_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I91_XG_MP0 (XI792_I91_XG_p1 I792_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I91_XG_MP1 (I792_G25_24 I792_gn24 XI792_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I93_XG_MP2 (VDD I792_gn27 I792_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I93_XG_MP0 (XI792_I93_XG_p1 I792_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I93_XG_MP1 (I792_G27_26 I792_gn26 XI792_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I152_XG_MP2 (VDD I792_G27_24n I792_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I152_XG_MP0 (XI792_I152_XG_p1 I792_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I152_XG_MP1 (I792_G27_20 I792_G23_20n XI792_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I148_XG_MP2 (VDD I792_G23_20n I792_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I148_XG_MP0 (XI792_I148_XG_p1 I792_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I148_XG_MP1 (I792_G23_16 I792_G19_16n XI792_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I198_XG_MP2 (VDD I792_G27_12n I792_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I198_XG_MP0 (XI792_I198_XG_p1 I792_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I198_XG_MP1 (I792_G27_0 I792_G11_0n XI792_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I151_XG_MP2 (VDD I792_G26_23n I792_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I151_XG_MP0 (XI792_I151_XG_p1 I792_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I151_XG_MP1 (I792_G26_19 I792_G22_19n XI792_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I197_XG_MP2 (VDD I792_G26_11n I792_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I197_XG_MP0 (XI792_I197_XG_p1 I792_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I197_XG_MP1 (I792_G26_0 I792_G10_0n XI792_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I156_XG_MP2 (VDD I838_G31_28n I838_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I156_XG_MP0 (XI838_I156_XG_p1 I838_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I156_XG_MP1 (I838_G31_24 I838_G27_24n XI838_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I152_XG_MP2 (VDD I838_G27_24n I838_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I152_XG_MP0 (XI838_I152_XG_p1 I838_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I152_XG_MP1 (I838_G27_20 I838_G23_20n XI838_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I148_XG_MP2 (VDD I838_G23_20n I838_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I148_XG_MP0 (XI838_I148_XG_p1 I838_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I148_XG_MP1 (I838_G23_16 I838_G19_16n XI838_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I87_XG_MP2 (VDD I838_gn21 I838_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I87_XG_MP0 (XI838_I87_XG_p1 I838_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I87_XG_MP1 (I838_G21_20 I838_gn20 XI838_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I153_XG_MP2 (VDD I838_G28_25n I838_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I153_XG_MP0 (XI838_I153_XG_p1 I838_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I153_XG_MP1 (I838_G28_21 I838_G24_21n XI838_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I201_XG_MP2 (VDD I838_G30_15n c6_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I201_XG_MP0 (XI838_I201_XG_p1 I838_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I201_XG_MP1 (c6_m I838_G14_0n XI838_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I87_XG_MP2 (VDD I884_gn21 I884_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I87_XG_MP0 (XI884_I87_XG_p1 I884_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I87_XG_MP1 (I884_G21_20 I884_gn20 XI884_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I86_XG_MP2 (VDD I884_gn20 I884_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I86_XG_MP0 (XI884_I86_XG_p1 I884_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I86_XG_MP1 (I884_G20_19 I884_gn19 XI884_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I88_XG_MP2 (VDD I884_gn22 I884_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I88_XG_MP0 (XI884_I88_XG_p1 I884_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I88_XG_MP1 (I884_G22_21 I884_gn21 XI884_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I201_XG_MP2 (VDD I884_G30_15n c7_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I201_XG_MP0 (XI884_I201_XG_p1 I884_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I201_XG_MP1 (c7_m I884_G14_0n XI884_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I153_XG_MP2 (VDD I884_G28_25n I884_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I153_XG_MP0 (XI884_I153_XG_p1 I884_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I153_XG_MP1 (I884_G28_21 I884_G24_21n XI884_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I200_XG_MP2 (VDD I884_G29_14n I884_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I200_XG_MP0 (XI884_I200_XG_p1 I884_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I200_XG_MP1 (I884_G29_0 I884_G13_0n XI884_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I198_XG_MP2 (VDD I884_G27_12n I884_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I198_XG_MP0 (XI884_I198_XG_p1 I884_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I198_XG_MP1 (I884_G27_0 I884_G11_0n XI884_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I151_XG_MP2 (VDD I1712_G26_23n I1712_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I151_XG_MP0 (XI1712_I151_XG_p1 I1712_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I151_XG_MP1 (I1712_G26_19 I1712_G22_19n XI1712_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I201_XG_MP2 (VDD I1712_G30_15n c25_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I201_XG_MP0 (XI1712_I201_XG_p1 I1712_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I201_XG_MP1 (c25_m I1712_G14_0n XI1712_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I84_XG_MP2 (VDD I1712_gn18 I1712_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I84_XG_MP0 (XI1712_I84_XG_p1 I1712_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I84_XG_MP1 (I1712_G18_17 I1712_gn17 XI1712_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I85_XG_MP2 (VDD I1712_gn19 I1712_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I85_XG_MP0 (XI1712_I85_XG_p1 I1712_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I85_XG_MP1 (I1712_G19_18 I1712_gn18 XI1712_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I200_XG_MP2 (VDD I1712_G29_14n I1712_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I200_XG_MP0 (XI1712_I200_XG_p1 I1712_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I200_XG_MP1 (I1712_G29_0 I1712_G13_0n XI1712_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I86_XG_MP2 (VDD I1758_gn20 I1758_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I86_XG_MP0 (XI1758_I86_XG_p1 I1758_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I86_XG_MP1 (I1758_G20_19 I1758_gn19 XI1758_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I87_XG_MP2 (VDD I1758_gn21 I1758_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I87_XG_MP0 (XI1758_I87_XG_p1 I1758_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I87_XG_MP1 (I1758_G21_20 I1758_gn20 XI1758_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I151_XG_MP2 (VDD I1758_G26_23n I1758_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I151_XG_MP0 (XI1758_I151_XG_p1 I1758_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I151_XG_MP1 (I1758_G26_19 I1758_G22_19n XI1758_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I153_XG_MP2 (VDD I1758_G28_25n I1758_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I153_XG_MP0 (XI1758_I153_XG_p1 I1758_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I153_XG_MP1 (I1758_G28_21 I1758_G24_21n XI1758_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I201_XG_MP2 (VDD I1758_G30_15n c26_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I201_XG_MP0 (XI1758_I201_XG_p1 I1758_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I201_XG_MP1 (c26_m I1758_G14_0n XI1758_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I200_XG_MP2 (VDD I1758_G29_14n I1758_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I200_XG_MP0 (XI1758_I200_XG_p1 I1758_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I200_XG_MP1 (I1758_G29_0 I1758_G13_0n XI1758_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I148_XG_MP2 (VDD I1758_G23_20n I1758_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I148_XG_MP0 (XI1758_I148_XG_p1 I1758_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I148_XG_MP1 (I1758_G23_16 I1758_G19_16n XI1758_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I152_XG_MP2 (VDD I1758_G27_24n I1758_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I152_XG_MP0 (XI1758_I152_XG_p1 I1758_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I152_XG_MP1 (I1758_G27_20 I1758_G23_20n XI1758_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I194_XG_MP2 (VDD I1758_G23_8n I1758_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I194_XG_MP0 (XI1758_I194_XG_p1 I1758_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I194_XG_MP1 (I1758_G23_0 I1758_G7_0n XI1758_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I87_XG_MP2 (VDD I1804_gn21 I1804_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I87_XG_MP0 (XI1804_I87_XG_p1 I1804_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I87_XG_MP1 (I1804_G21_20 I1804_gn20 XI1804_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I148_XG_MP2 (VDD I1804_G23_20n I1804_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I148_XG_MP0 (XI1804_I148_XG_p1 I1804_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I148_XG_MP1 (I1804_G23_16 I1804_G19_16n XI1804_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I88_XG_MP2 (VDD I1804_gn22 I1804_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I88_XG_MP0 (XI1804_I88_XG_p1 I1804_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I88_XG_MP1 (I1804_G22_21 I1804_gn21 XI1804_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I152_XG_MP2 (VDD I1804_G27_24n I1804_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I152_XG_MP0 (XI1804_I152_XG_p1 I1804_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I152_XG_MP1 (I1804_G27_20 I1804_G23_20n XI1804_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I154_XG_MP2 (VDD I1804_G29_26n I1804_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I154_XG_MP0 (XI1804_I154_XG_p1 I1804_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I154_XG_MP1 (I1804_G29_22 I1804_G25_22n XI1804_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I92_XG_MP2 (VDD I1804_gn26 I1804_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I92_XG_MP0 (XI1804_I92_XG_p1 I1804_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I92_XG_MP1 (I1804_G26_25 I1804_gn25 XI1804_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I94_XG_MP2 (VDD I792_gn28 I792_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I94_XG_MP0 (XI792_I94_XG_p1 I792_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I94_XG_MP1 (I792_G28_27 I792_gn27 XI792_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I156_XG_MP2 (VDD I792_G31_28n I792_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I156_XG_MP0 (XI792_I156_XG_p1 I792_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I156_XG_MP1 (I792_G31_24 I792_G27_24n XI792_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I202_XG_MP2 (VDD I792_G31_16n c5_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I202_XG_MP0 (XI792_I202_XG_p1 I792_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I202_XG_MP1 (c5_o I792_G15_0n XI792_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I194_XG_MP2 (VDD I792_G23_8n I792_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I194_XG_MP0 (XI792_I194_XG_p1 I792_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I194_XG_MP1 (I792_G23_0 I792_G7_0n XI792_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I155_XG_MP2 (VDD I792_G30_27n I792_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I155_XG_MP0 (XI792_I155_XG_p1 I792_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I155_XG_MP1 (I792_G30_23 I792_G26_23n XI792_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I201_XG_MP2 (VDD I792_G30_15n c5_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I201_XG_MP0 (XI792_I201_XG_p1 I792_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I201_XG_MP1 (c5_m I792_G14_0n XI792_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I97_XG_MP2 (VDD I838_gn31 I838_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I97_XG_MP0 (XI838_I97_XG_p1 I838_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I97_XG_MP1 (I838_G31_30 I838_gn30 XI838_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I89_XG_MP2 (VDD I838_gn23 I838_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I89_XG_MP0 (XI838_I89_XG_p1 I838_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I89_XG_MP1 (I838_G23_22 I838_gn22 XI838_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I90_XG_MP2 (VDD I838_gn24 I838_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I90_XG_MP0 (XI838_I90_XG_p1 I838_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I90_XG_MP1 (I838_G24_23 I838_gn23 XI838_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I88_XG_MP2 (VDD I838_gn22 I838_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I88_XG_MP0 (XI838_I88_XG_p1 I838_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I88_XG_MP1 (I838_G22_21 I838_gn21 XI838_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I155_XG_MP2 (VDD I838_G30_27n I838_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I155_XG_MP0 (XI838_I155_XG_p1 I838_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I155_XG_MP1 (I838_G30_23 I838_G26_23n XI838_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I90_XG_MP2 (VDD I884_gn24 I884_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I90_XG_MP0 (XI884_I90_XG_p1 I884_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I90_XG_MP1 (I884_G24_23 I884_gn23 XI884_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I89_XG_MP2 (VDD I884_gn23 I884_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I89_XG_MP0 (XI884_I89_XG_p1 I884_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I89_XG_MP1 (I884_G23_22 I884_gn22 XI884_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I155_XG_MP2 (VDD I884_G30_27n I884_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I155_XG_MP0 (XI884_I155_XG_p1 I884_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I155_XG_MP1 (I884_G30_23 I884_G26_23n XI884_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I154_XG_MP2 (VDD I884_G29_26n I884_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I154_XG_MP0 (XI884_I154_XG_p1 I884_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I154_XG_MP1 (I884_G29_22 I884_G25_22n XI884_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I152_XG_MP2 (VDD I884_G27_24n I884_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I152_XG_MP0 (XI884_I152_XG_p1 I884_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I152_XG_MP1 (I884_G27_20 I884_G23_20n XI884_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I148_XG_MP2 (VDD I884_G23_20n I884_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I148_XG_MP0 (XI884_I148_XG_p1 I884_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I148_XG_MP1 (I884_G23_16 I884_G19_16n XI884_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I155_XG_MP2 (VDD I1712_G30_27n I1712_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I155_XG_MP0 (XI1712_I155_XG_p1 I1712_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I155_XG_MP1 (I1712_G30_23 I1712_G26_23n XI1712_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I86_XG_MP2 (VDD I1712_gn20 I1712_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I86_XG_MP0 (XI1712_I86_XG_p1 I1712_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I86_XG_MP1 (I1712_G20_19 I1712_gn19 XI1712_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I87_XG_MP2 (VDD I1712_gn21 I1712_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I87_XG_MP0 (XI1712_I87_XG_p1 I1712_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I87_XG_MP1 (I1712_G21_20 I1712_gn20 XI1712_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I154_XG_MP2 (VDD I1712_G29_26n I1712_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I154_XG_MP0 (XI1712_I154_XG_p1 I1712_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I154_XG_MP1 (I1712_G29_22 I1712_G25_22n XI1712_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I150_XG_MP2 (VDD I1712_G25_22n I1712_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I150_XG_MP0 (XI1712_I150_XG_p1 I1712_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I150_XG_MP1 (I1712_G25_18 I1712_G21_18n XI1712_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I152_XG_MP2 (VDD I1712_G27_24n I1712_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I152_XG_MP0 (XI1712_I152_XG_p1 I1712_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I152_XG_MP1 (I1712_G27_20 I1712_G23_20n XI1712_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I148_XG_MP2 (VDD I1712_G23_20n I1712_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I148_XG_MP0 (XI1712_I148_XG_p1 I1712_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I148_XG_MP1 (I1712_G23_16 I1712_G19_16n XI1712_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I202_XG_MP2 (VDD I1712_G31_16n c25_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I202_XG_MP0 (XI1712_I202_XG_p1 I1712_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I202_XG_MP1 (c25_o I1712_G15_0n XI1712_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I194_XG_MP2 (VDD I1712_G23_8n I1712_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I194_XG_MP0 (XI1712_I194_XG_p1 I1712_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I194_XG_MP1 (I1712_G23_0 I1712_G7_0n XI1712_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I88_XG_MP2 (VDD I1758_gn22 I1758_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I88_XG_MP0 (XI1758_I88_XG_p1 I1758_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I88_XG_MP1 (I1758_G22_21 I1758_gn21 XI1758_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I89_XG_MP2 (VDD I1758_gn23 I1758_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I89_XG_MP0 (XI1758_I89_XG_p1 I1758_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I89_XG_MP1 (I1758_G23_22 I1758_gn22 XI1758_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I90_XG_MP2 (VDD I1758_gn24 I1758_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I90_XG_MP0 (XI1758_I90_XG_p1 I1758_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I90_XG_MP1 (I1758_G24_23 I1758_gn23 XI1758_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I155_XG_MP2 (VDD I1758_G30_27n I1758_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I155_XG_MP0 (XI1758_I155_XG_p1 I1758_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I155_XG_MP1 (I1758_G30_23 I1758_G26_23n XI1758_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I154_XG_MP2 (VDD I1758_G29_26n I1758_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I154_XG_MP0 (XI1758_I154_XG_p1 I1758_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I154_XG_MP1 (I1758_G29_22 I1758_G25_22n XI1758_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I156_XG_MP2 (VDD I1758_G31_28n I1758_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I156_XG_MP0 (XI1758_I156_XG_p1 I1758_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I156_XG_MP1 (I1758_G31_24 I1758_G27_24n XI1758_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I202_XG_MP2 (VDD I1758_G31_16n c26_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I202_XG_MP0 (XI1758_I202_XG_p1 I1758_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I202_XG_MP1 (c26_o I1758_G15_0n XI1758_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I202_XG_MP2 (VDD I1804_G31_16n c27_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I202_XG_MP0 (XI1804_I202_XG_p1 I1804_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I202_XG_MP1 (c27_o I1804_G15_0n XI1804_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I89_XG_MP2 (VDD I1804_gn23 I1804_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I89_XG_MP0 (XI1804_I89_XG_p1 I1804_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I89_XG_MP1 (I1804_G23_22 I1804_gn22 XI1804_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I156_XG_MP2 (VDD I1804_G31_28n I1804_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I156_XG_MP0 (XI1804_I156_XG_p1 I1804_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I156_XG_MP1 (I1804_G31_24 I1804_G27_24n XI1804_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I90_XG_MP2 (VDD I1804_gn24 I1804_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I90_XG_MP0 (XI1804_I90_XG_p1 I1804_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I90_XG_MP1 (I1804_G24_23 I1804_gn23 XI1804_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I91_XG_MP2 (VDD I1804_gn25 I1804_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I91_XG_MP0 (XI1804_I91_XG_p1 I1804_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I91_XG_MP1 (I1804_G25_24 I1804_gn24 XI1804_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I93_XG_MP2 (VDD I1804_gn27 I1804_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I93_XG_MP0 (XI1804_I93_XG_p1 I1804_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I93_XG_MP1 (I1804_G27_26 I1804_gn26 XI1804_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I97_XG_MP2 (VDD I792_gn31 I792_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I97_XG_MP0 (XI792_I97_XG_p1 I792_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I97_XG_MP1 (I792_G31_30 I792_gn30 XI792_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I96_XG_MP2 (VDD I792_gn30 I792_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I96_XG_MP0 (XI792_I96_XG_p1 I792_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I96_XG_MP1 (I792_G30_29 I792_gn29 XI792_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI792_I95_XG_MP2 (VDD I792_gn29 I792_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI792_I95_XG_MP0 (XI792_I95_XG_p1 I792_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI792_I95_XG_MP1 (I792_G29_28 I792_gn28 XI792_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I96_XG_MP2 (VDD I838_gn30 I838_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I96_XG_MP0 (XI838_I96_XG_p1 I838_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I96_XG_MP1 (I838_G30_29 I838_gn29 XI838_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I95_XG_MP2 (VDD I838_gn29 I838_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I95_XG_MP0 (XI838_I95_XG_p1 I838_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I95_XG_MP1 (I838_G29_28 I838_gn28 XI838_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I93_XG_MP2 (VDD I838_gn27 I838_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I93_XG_MP0 (XI838_I93_XG_p1 I838_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I93_XG_MP1 (I838_G27_26 I838_gn26 XI838_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I94_XG_MP2 (VDD I838_gn28 I838_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I94_XG_MP0 (XI838_I94_XG_p1 I838_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I94_XG_MP1 (I838_G28_27 I838_gn27 XI838_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I91_XG_MP2 (VDD I838_gn25 I838_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I91_XG_MP0 (XI838_I91_XG_p1 I838_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I91_XG_MP1 (I838_G25_24 I838_gn24 XI838_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI838_I92_XG_MP2 (VDD I838_gn26 I838_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI838_I92_XG_MP0 (XI838_I92_XG_p1 I838_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI838_I92_XG_MP1 (I838_G26_25 I838_gn25 XI838_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I91_XG_MP2 (VDD I884_gn25 I884_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I91_XG_MP0 (XI884_I91_XG_p1 I884_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I91_XG_MP1 (I884_G25_24 I884_gn24 XI884_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I92_XG_MP2 (VDD I884_gn26 I884_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I92_XG_MP0 (XI884_I92_XG_p1 I884_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I92_XG_MP1 (I884_G26_25 I884_gn25 XI884_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I156_XG_MP2 (VDD I884_G31_28n I884_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I156_XG_MP0 (XI884_I156_XG_p1 I884_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I156_XG_MP1 (I884_G31_24 I884_G27_24n XI884_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I202_XG_MP2 (VDD I884_G31_16n c7_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I202_XG_MP0 (XI884_I202_XG_p1 I884_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I202_XG_MP1 (c7_o I884_G15_0n XI884_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I90_XG_MP2 (VDD I1712_gn24 I1712_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I90_XG_MP0 (XI1712_I90_XG_p1 I1712_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I90_XG_MP1 (I1712_G24_23 I1712_gn23 XI1712_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I88_XG_MP2 (VDD I1712_gn22 I1712_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I88_XG_MP0 (XI1712_I88_XG_p1 I1712_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I88_XG_MP1 (I1712_G22_21 I1712_gn21 XI1712_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I89_XG_MP2 (VDD I1712_gn23 I1712_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I89_XG_MP0 (XI1712_I89_XG_p1 I1712_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I89_XG_MP1 (I1712_G23_22 I1712_gn22 XI1712_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I156_XG_MP2 (VDD I1712_G31_28n I1712_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I156_XG_MP0 (XI1712_I156_XG_p1 I1712_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I156_XG_MP1 (I1712_G31_24 I1712_G27_24n XI1712_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I91_XG_MP2 (VDD I1758_gn25 I1758_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I91_XG_MP0 (XI1758_I91_XG_p1 I1758_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I91_XG_MP1 (I1758_G25_24 I1758_gn24 XI1758_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I92_XG_MP2 (VDD I1758_gn26 I1758_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I92_XG_MP0 (XI1758_I92_XG_p1 I1758_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I92_XG_MP1 (I1758_G26_25 I1758_gn25 XI1758_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I93_XG_MP2 (VDD I1758_gn27 I1758_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I93_XG_MP0 (XI1758_I93_XG_p1 I1758_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I93_XG_MP1 (I1758_G27_26 I1758_gn26 XI1758_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I94_XG_MP2 (VDD I1758_gn28 I1758_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I94_XG_MP0 (XI1758_I94_XG_p1 I1758_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I94_XG_MP1 (I1758_G28_27 I1758_gn27 XI1758_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I97_XG_MP2 (VDD I1804_gn31 I1804_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I97_XG_MP0 (XI1804_I97_XG_p1 I1804_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I97_XG_MP1 (I1804_G31_30 I1804_gn30 XI1804_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I95_XG_MP2 (VDD I1804_gn29 I1804_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I95_XG_MP0 (XI1804_I95_XG_p1 I1804_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I95_XG_MP1 (I1804_G29_28 I1804_gn28 XI1804_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I96_XG_MP2 (VDD I1804_gn30 I1804_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I96_XG_MP0 (XI1804_I96_XG_p1 I1804_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I96_XG_MP1 (I1804_G30_29 I1804_gn29 XI1804_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1804_I94_XG_MP2 (VDD I1804_gn28 I1804_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1804_I94_XG_MP0 (XI1804_I94_XG_p1 I1804_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1804_I94_XG_MP1 (I1804_G28_27 I1804_gn27 XI1804_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I200_XG_MP2 (VDD I1068_G29_14n I1068_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I200_XG_MP0 (XI1068_I200_XG_p1 I1068_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I200_XG_MP1 (I1068_G29_0 I1068_G13_0n XI1068_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I196_XG_MP2 (VDD I1068_G25_10n I1068_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I196_XG_MP0 (XI1068_I196_XG_p1 I1068_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I196_XG_MP1 (I1068_G25_0 I1068_G9_0n XI1068_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I190_XG_MP2 (VDD I1068_G21_6n I1068_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I190_XG_MP0 (XI1068_I190_XG_p1 I1068_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I190_XG_MP1 (I1068_G21_0 I1068_G5_0n XI1068_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I142_XG_MP2 (VDD I1068_G17_14n I1068_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I142_XG_MP0 (XI1068_I142_XG_p1 I1068_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I142_XG_MP1 (I1068_G17_10 I1068_G13_10n XI1068_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I184_XG_MP2 (VDD I1068_G17_2n I1068_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I184_XG_MP0 (XI1068_I184_XG_p1 I1068_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I184_XG_MP1 (I1068_G17_0 I1068_G1_0n XI1068_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I138_XG_MP2 (VDD I1068_G13_10n I1068_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I138_XG_MP0 (XI1068_I138_XG_p1 I1068_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I138_XG_MP1 (I1068_G13_6 I1068_G9_6n XI1068_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I134_XG_MP2 (VDD I1068_G9_6n I1068_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I134_XG_MP0 (XI1068_I134_XG_p1 I1068_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I134_XG_MP1 (I1068_G9_2 I1068_G5_2n XI1068_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I130_XG_MP2 (VDD I1068_G5_2n I1068_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I130_XG_MP0 (XI1068_I130_XG_p1 I1068_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I130_XG_MP1 (I1068_G5_0 I1068_G1_0n XI1068_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I71_XG_MP2 (VDD I1068_gn5 I1068_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I71_XG_MP0 (XI1068_I71_XG_p1 I1068_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I71_XG_MP1 (I1068_G5_4 I1068_gn4 XI1068_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I70_XG_MP2 (VDD I1068_gn4 I1068_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I70_XG_MP0 (XI1068_I70_XG_p1 I1068_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I70_XG_MP1 (I1068_G4_3 I1068_gn3 XI1068_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I97_XG_MP2 (VDD I884_gn31 I884_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I97_XG_MP0 (XI884_I97_XG_p1 I884_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I97_XG_MP1 (I884_G31_30 I884_gn30 XI884_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I96_XG_MP2 (VDD I884_gn30 I884_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I96_XG_MP0 (XI884_I96_XG_p1 I884_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I96_XG_MP1 (I884_G30_29 I884_gn29 XI884_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I94_XG_MP2 (VDD I884_gn28 I884_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I94_XG_MP0 (XI884_I94_XG_p1 I884_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I94_XG_MP1 (I884_G28_27 I884_gn27 XI884_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I93_XG_MP2 (VDD I884_gn27 I884_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I93_XG_MP0 (XI884_I93_XG_p1 I884_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I93_XG_MP1 (I884_G27_26 I884_gn26 XI884_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I194_XG_MP2 (VDD I884_G23_8n I884_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I194_XG_MP0 (XI884_I194_XG_p1 I884_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I194_XG_MP1 (I884_G23_0 I884_G7_0n XI884_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I92_XG_MP2 (VDD I1712_gn26 I1712_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I92_XG_MP0 (XI1712_I92_XG_p1 I1712_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I92_XG_MP1 (I1712_G26_25 I1712_gn25 XI1712_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I91_XG_MP2 (VDD I1712_gn25 I1712_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I91_XG_MP0 (XI1712_I91_XG_p1 I1712_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I91_XG_MP1 (I1712_G25_24 I1712_gn24 XI1712_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I93_XG_MP2 (VDD I1712_gn27 I1712_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I93_XG_MP0 (XI1712_I93_XG_p1 I1712_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I93_XG_MP1 (I1712_G27_26 I1712_gn26 XI1712_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I95_XG_MP2 (VDD I1712_gn29 I1712_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I95_XG_MP0 (XI1712_I95_XG_p1 I1712_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I95_XG_MP1 (I1712_G29_28 I1712_gn28 XI1712_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I96_XG_MP2 (VDD I1712_gn30 I1712_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I96_XG_MP0 (XI1712_I96_XG_p1 I1712_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I96_XG_MP1 (I1712_G30_29 I1712_gn29 XI1712_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I97_XG_MP2 (VDD I1712_gn31 I1712_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I97_XG_MP0 (XI1712_I97_XG_p1 I1712_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I97_XG_MP1 (I1712_G31_30 I1712_gn30 XI1712_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I95_XG_MP2 (VDD I1758_gn29 I1758_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I95_XG_MP0 (XI1758_I95_XG_p1 I1758_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I95_XG_MP1 (I1758_G29_28 I1758_gn28 XI1758_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I96_XG_MP2 (VDD I1758_gn30 I1758_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I96_XG_MP0 (XI1758_I96_XG_p1 I1758_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I96_XG_MP1 (I1758_G30_29 I1758_gn29 XI1758_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1758_I97_XG_MP2 (VDD I1758_gn31 I1758_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1758_I97_XG_MP0 (XI1758_I97_XG_p1 I1758_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1758_I97_XG_MP1 (I1758_G31_30 I1758_gn30 XI1758_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I154_XG_MP2 (VDD I1068_G29_26n I1068_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I154_XG_MP0 (XI1068_I154_XG_p1 I1068_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I154_XG_MP1 (I1068_G29_22 I1068_G25_22n XI1068_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I150_XG_MP2 (VDD I1068_G25_22n I1068_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I150_XG_MP0 (XI1068_I150_XG_p1 I1068_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I150_XG_MP1 (I1068_G25_18 I1068_G21_18n XI1068_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I198_XG_MP2 (VDD I1068_G27_12n I1068_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I198_XG_MP0 (XI1068_I198_XG_p1 I1068_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I198_XG_MP1 (I1068_G27_0 I1068_G11_0n XI1068_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I146_XG_MP2 (VDD I1068_G21_18n I1068_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I146_XG_MP0 (XI1068_I146_XG_p1 I1068_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I146_XG_MP1 (I1068_G21_14 I1068_G17_14n XI1068_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I194_XG_MP2 (VDD I1068_G23_8n I1068_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I194_XG_MP0 (XI1068_I194_XG_p1 I1068_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I194_XG_MP1 (I1068_G23_0 I1068_G7_0n XI1068_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I186_XG_MP2 (VDD I1068_G19_4n I1068_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I186_XG_MP0 (XI1068_I186_XG_p1 I1068_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I186_XG_MP1 (I1068_G19_0 I1068_G3_0n XI1068_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I136_XG_MP2 (VDD I1068_G11_8n I1068_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I136_XG_MP0 (XI1068_I136_XG_p1 I1068_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I136_XG_MP1 (I1068_G11_4 I1068_G7_4n XI1068_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I132_XG_MP2 (VDD I1068_G7_4n I1068_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I132_XG_MP0 (XI1068_I132_XG_p1 I1068_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I132_XG_MP1 (I1068_G7_0 I1068_G3_0n XI1068_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I73_XG_MP2 (VDD I1068_gn7 I1068_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I73_XG_MP0 (XI1068_I73_XG_p1 I1068_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I73_XG_MP1 (I1068_G7_6 I1068_gn6 XI1068_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I72_XG_MP2 (VDD I1068_gn6 I1068_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I72_XG_MP0 (XI1068_I72_XG_p1 I1068_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I72_XG_MP1 (I1068_G6_5 I1068_gn5 XI1068_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I69_XG_MP2 (VDD I1068_gn3 I1068_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I69_XG_MP0 (XI1068_I69_XG_p1 I1068_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I69_XG_MP1 (I1068_G3_2 I1068_gn2 XI1068_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I65_XG_MP2 (VDD I976_gn0 I976_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I65_XG_MP0 (XI976_I65_XG_p1 I976_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I65_XG_MP1 (I976_G0_0 I976_cinn XI976_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI884_I95_XG_MP2 (VDD I884_gn29 I884_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI884_I95_XG_MP0 (XI884_I95_XG_p1 I884_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI884_I95_XG_MP1 (I884_G29_28 I884_gn28 XI884_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1712_I94_XG_MP2 (VDD I1712_gn28 I1712_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1712_I94_XG_MP0 (XI1712_I94_XG_p1 I1712_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1712_I94_XG_MP1 (I1712_G28_27 I1712_gn27 XI1712_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I65_XG_MP2 (VDD I1666_gn0 I1666_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I65_XG_MP0 (XI1666_I65_XG_p1 I1666_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I65_XG_MP1 (I1666_G0_0 I1666_cinn XI1666_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I68_XG_MP2 (VDD I1574_gn2 I1574_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I68_XG_MP0 (XI1574_I68_XG_p1 I1574_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I68_XG_MP1 (I1574_G2_1 I1574_gn1 XI1574_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I156_XG_MP2 (VDD I1068_G31_28n I1068_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I156_XG_MP0 (XI1068_I156_XG_p1 I1068_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I156_XG_MP1 (I1068_G31_24 I1068_G27_24n XI1068_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I152_XG_MP2 (VDD I1068_G27_24n I1068_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I152_XG_MP0 (XI1068_I152_XG_p1 I1068_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I152_XG_MP1 (I1068_G27_20 I1068_G23_20n XI1068_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I148_XG_MP2 (VDD I1068_G23_20n I1068_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I148_XG_MP0 (XI1068_I148_XG_p1 I1068_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I148_XG_MP1 (I1068_G23_16 I1068_G19_16n XI1068_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I144_XG_MP2 (VDD I1068_G19_16n I1068_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I144_XG_MP0 (XI1068_I144_XG_p1 I1068_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I144_XG_MP1 (I1068_G19_12 I1068_G15_12n XI1068_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I140_XG_MP2 (VDD I1068_G15_12n I1068_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I140_XG_MP0 (XI1068_I140_XG_p1 I1068_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I140_XG_MP1 (I1068_G15_8 I1068_G11_8n XI1068_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I74_XG_MP2 (VDD I1068_gn8 I1068_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I74_XG_MP0 (XI1068_I74_XG_p1 I1068_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I74_XG_MP1 (I1068_G8_7 I1068_gn7 XI1068_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I75_XG_MP2 (VDD I1068_gn9 I1068_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I75_XG_MP0 (XI1068_I75_XG_p1 I1068_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I75_XG_MP1 (I1068_G9_8 I1068_gn8 XI1068_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I68_XG_MP2 (VDD I1068_gn2 I1068_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I68_XG_MP0 (XI1068_I68_XG_p1 I1068_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I68_XG_MP1 (I1068_G2_1 I1068_gn1 XI1068_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I65_XG_MP2 (VDD I1022_gn0 I1022_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I65_XG_MP0 (XI1022_I65_XG_p1 I1022_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I65_XG_MP1 (I1022_G0_0 I1022_cinn XI1022_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I67_XG_MP2 (VDD I1022_gn1 I1022_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I67_XG_MP0 (XI1022_I67_XG_p1 I1022_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I67_XG_MP1 (I1022_G1_0 I1022_G0_0n XI1022_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I68_XG_MP2 (VDD I1022_gn2 I1022_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I68_XG_MP0 (XI1022_I68_XG_p1 I1022_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I68_XG_MP1 (I1022_G2_1 I1022_gn1 XI1022_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I65_XG_MP2 (VDD I930_gn0 I930_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I65_XG_MP0 (XI930_I65_XG_p1 I930_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I65_XG_MP1 (I930_G0_0 I930_cinn XI930_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I70_XG_MP2 (VDD I930_gn4 I930_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I70_XG_MP0 (XI930_I70_XG_p1 I930_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I70_XG_MP1 (I930_G4_3 I930_gn3 XI930_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I71_XG_MP2 (VDD I930_gn5 I930_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I71_XG_MP0 (XI930_I71_XG_p1 I930_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I71_XG_MP1 (I930_G5_4 I930_gn4 XI930_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I67_XG_MP2 (VDD I1666_gn1 I1666_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I67_XG_MP0 (XI1666_I67_XG_p1 I1666_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I67_XG_MP1 (I1666_G1_0 I1666_G0_0n XI1666_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I68_XG_MP2 (VDD I1666_gn2 I1666_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I68_XG_MP0 (XI1666_I68_XG_p1 I1666_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I68_XG_MP1 (I1666_G2_1 I1666_gn1 XI1666_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I69_XG_MP2 (VDD I1666_gn3 I1666_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I69_XG_MP0 (XI1666_I69_XG_p1 I1666_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I69_XG_MP1 (I1666_G3_2 I1666_gn2 XI1666_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I65_XG_MP2 (VDD I1620_gn0 I1620_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I65_XG_MP0 (XI1620_I65_XG_p1 I1620_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I65_XG_MP1 (I1620_G0_0 I1620_cinn XI1620_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I65_XG_MP2 (VDD I1574_gn0 I1574_G0_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I65_XG_MP0 (XI1574_I65_XG_p1 I1574_pn0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I65_XG_MP1 (I1574_G0_0 I1574_cinn XI1574_I65_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I69_XG_MP2 (VDD I1574_gn3 I1574_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I69_XG_MP0 (XI1574_I69_XG_p1 I1574_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I69_XG_MP1 (I1574_G3_2 I1574_gn2 XI1574_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I67_XG_MP2 (VDD I1574_gn1 I1574_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I67_XG_MP0 (XI1574_I67_XG_p1 I1574_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I67_XG_MP1 (I1574_G1_0 I1574_G0_0n XI1574_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I70_XG_MP2 (VDD I1574_gn4 I1574_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I70_XG_MP0 (XI1574_I70_XG_p1 I1574_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I70_XG_MP1 (I1574_G4_3 I1574_gn3 XI1574_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I128_XG_MP2 (VDD I1574_G4_1n I1574_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I128_XG_MP0 (XI1574_I128_XG_p1 I1574_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I128_XG_MP1 (I1574_G4_0 I1574_G0_0n XI1574_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I93_XG_MP2 (VDD I1068_gn27 I1068_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I93_XG_MP0 (XI1068_I93_XG_p1 I1068_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I93_XG_MP1 (I1068_G27_26 I1068_gn26 XI1068_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I197_XG_MP2 (VDD I1068_G26_11n I1068_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I197_XG_MP0 (XI1068_I197_XG_p1 I1068_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I197_XG_MP1 (I1068_G26_0 I1068_G10_0n XI1068_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I202_XG_MP2 (VDD I1068_G31_16n c11_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I202_XG_MP0 (XI1068_I202_XG_p1 I1068_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I202_XG_MP1 (c11_o I1068_G15_0n XI1068_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I185_XG_MP2 (VDD I1068_G18_3n I1068_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I185_XG_MP0 (XI1068_I185_XG_p1 I1068_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I185_XG_MP1 (I1068_G18_0 I1068_G2_0n XI1068_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I135_XG_MP2 (VDD I1068_G10_7n I1068_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I135_XG_MP0 (XI1068_I135_XG_p1 I1068_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I135_XG_MP1 (I1068_G10_3 I1068_G6_3n XI1068_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I131_XG_MP2 (VDD I1068_G6_3n I1068_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I131_XG_MP0 (XI1068_I131_XG_p1 I1068_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I131_XG_MP1 (I1068_G6_0 I1068_G2_0n XI1068_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I67_XG_MP2 (VDD I1068_gn1 I1068_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I67_XG_MP0 (XI1068_I67_XG_p1 I1068_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I67_XG_MP1 (I1068_G1_0 I1068_G0_0n XI1068_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I69_XG_MP2 (VDD I1022_gn3 I1022_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I69_XG_MP0 (XI1022_I69_XG_p1 I1022_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I69_XG_MP1 (I1022_G3_2 I1022_gn2 XI1022_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I70_XG_MP2 (VDD I1022_gn4 I1022_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I70_XG_MP0 (XI1022_I70_XG_p1 I1022_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I70_XG_MP1 (I1022_G4_3 I1022_gn3 XI1022_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I67_XG_MP2 (VDD I976_gn1 I976_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I67_XG_MP0 (XI976_I67_XG_p1 I976_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I67_XG_MP1 (I976_G1_0 I976_G0_0n XI976_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I68_XG_MP2 (VDD I976_gn2 I976_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I68_XG_MP0 (XI976_I68_XG_p1 I976_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I68_XG_MP1 (I976_G2_1 I976_gn1 XI976_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I69_XG_MP2 (VDD I976_gn3 I976_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I69_XG_MP0 (XI976_I69_XG_p1 I976_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I69_XG_MP1 (I976_G3_2 I976_gn2 XI976_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I70_XG_MP2 (VDD I976_gn4 I976_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I70_XG_MP0 (XI976_I70_XG_p1 I976_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I70_XG_MP1 (I976_G4_3 I976_gn3 XI976_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I67_XG_MP2 (VDD I930_gn1 I930_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I67_XG_MP0 (XI930_I67_XG_p1 I930_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I67_XG_MP1 (I930_G1_0 I930_G0_0n XI930_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I68_XG_MP2 (VDD I930_gn2 I930_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I68_XG_MP0 (XI930_I68_XG_p1 I930_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I68_XG_MP1 (I930_G2_1 I930_gn1 XI930_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I69_XG_MP2 (VDD I930_gn3 I930_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I69_XG_MP0 (XI930_I69_XG_p1 I930_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I69_XG_MP1 (I930_G3_2 I930_gn2 XI930_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I72_XG_MP2 (VDD I930_gn6 I930_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I72_XG_MP0 (XI930_I72_XG_p1 I930_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I72_XG_MP1 (I930_G6_5 I930_gn5 XI930_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I74_XG_MP2 (VDD I930_gn8 I930_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I74_XG_MP0 (XI930_I74_XG_p1 I930_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I74_XG_MP1 (I930_G8_7 I930_gn7 XI930_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I73_XG_MP2 (VDD I930_gn7 I930_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I73_XG_MP0 (XI930_I73_XG_p1 I930_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I73_XG_MP1 (I930_G7_6 I930_gn6 XI930_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I183_XG_MP2 (VDD I1666_G16_1n I1666_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I183_XG_MP0 (XI1666_I183_XG_p1 I1666_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I183_XG_MP1 (I1666_G16_0 I1666_G0_0n XI1666_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I128_XG_MP2 (VDD I1666_G4_1n I1666_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I128_XG_MP0 (XI1666_I128_XG_p1 I1666_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I128_XG_MP1 (I1666_G4_0 I1666_G0_0n XI1666_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I70_XG_MP2 (VDD I1666_gn4 I1666_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I70_XG_MP0 (XI1666_I70_XG_p1 I1666_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I70_XG_MP1 (I1666_G4_3 I1666_gn3 XI1666_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I71_XG_MP2 (VDD I1666_gn5 I1666_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I71_XG_MP0 (XI1666_I71_XG_p1 I1666_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I71_XG_MP1 (I1666_G5_4 I1666_gn4 XI1666_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I67_XG_MP2 (VDD I1620_gn1 I1620_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I67_XG_MP0 (XI1620_I67_XG_p1 I1620_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I67_XG_MP1 (I1620_G1_0 I1620_G0_0n XI1620_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I68_XG_MP2 (VDD I1620_gn2 I1620_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I68_XG_MP0 (XI1620_I68_XG_p1 I1620_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I68_XG_MP1 (I1620_G2_1 I1620_gn1 XI1620_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I69_XG_MP2 (VDD I1620_gn3 I1620_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I69_XG_MP0 (XI1620_I69_XG_p1 I1620_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I69_XG_MP1 (I1620_G3_2 I1620_gn2 XI1620_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I70_XG_MP2 (VDD I1620_gn4 I1620_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I70_XG_MP0 (XI1620_I70_XG_p1 I1620_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I70_XG_MP1 (I1620_G4_3 I1620_gn3 XI1620_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I71_XG_MP2 (VDD I1620_gn5 I1620_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I71_XG_MP0 (XI1620_I71_XG_p1 I1620_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I71_XG_MP1 (I1620_G5_4 I1620_gn4 XI1620_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I71_XG_MP2 (VDD I1574_gn5 I1574_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I71_XG_MP0 (XI1574_I71_XG_p1 I1574_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I71_XG_MP1 (I1574_G5_4 I1574_gn4 XI1574_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I72_XG_MP2 (VDD I1574_gn6 I1574_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I72_XG_MP0 (XI1574_I72_XG_p1 I1574_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I72_XG_MP1 (I1574_G6_5 I1574_gn5 XI1574_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I133_XG_MP2 (VDD I1574_G8_5n I1574_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I133_XG_MP0 (XI1574_I133_XG_p1 I1574_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I133_XG_MP1 (I1574_G8_1 I1574_G4_1n XI1574_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I183_XG_MP2 (VDD I1574_G16_1n I1574_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I183_XG_MP0 (XI1574_I183_XG_p1 I1574_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I183_XG_MP1 (I1574_G16_0 I1574_G0_0n XI1574_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I94_XG_MP2 (VDD I1068_gn28 I1068_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I94_XG_MP0 (XI1068_I94_XG_p1 I1068_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I94_XG_MP1 (I1068_G28_27 I1068_gn27 XI1068_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I92_XG_MP2 (VDD I1068_gn26 I1068_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I92_XG_MP0 (XI1068_I92_XG_p1 I1068_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I92_XG_MP1 (I1068_G26_25 I1068_gn25 XI1068_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I155_XG_MP2 (VDD I1068_G30_27n I1068_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I155_XG_MP0 (XI1068_I155_XG_p1 I1068_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I155_XG_MP1 (I1068_G30_23 I1068_G26_23n XI1068_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I201_XG_MP2 (VDD I1068_G30_15n c11_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I201_XG_MP0 (XI1068_I201_XG_p1 I1068_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I201_XG_MP1 (c11_m I1068_G14_0n XI1068_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I151_XG_MP2 (VDD I1068_G26_23n I1068_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I151_XG_MP0 (XI1068_I151_XG_p1 I1068_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I151_XG_MP1 (I1068_G26_19 I1068_G22_19n XI1068_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I147_XG_MP2 (VDD I1068_G22_19n I1068_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I147_XG_MP0 (XI1068_I147_XG_p1 I1068_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I147_XG_MP1 (I1068_G22_15 I1068_G18_15n XI1068_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I192_XG_MP2 (VDD I1068_G22_7n I1068_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I192_XG_MP0 (XI1068_I192_XG_p1 I1068_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I192_XG_MP1 (I1068_G22_0 I1068_G6_0n XI1068_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I143_XG_MP2 (VDD I1068_G18_15n I1068_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I143_XG_MP0 (XI1068_I143_XG_p1 I1068_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I143_XG_MP1 (I1068_G18_11 I1068_G14_11n XI1068_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I139_XG_MP2 (VDD I1068_G14_11n I1068_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I139_XG_MP0 (XI1068_I139_XG_p1 I1068_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I139_XG_MP1 (I1068_G14_7 I1068_G10_7n XI1068_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I137_XG_MP2 (VDD I1068_G12_9n I1068_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I137_XG_MP0 (XI1068_I137_XG_p1 I1068_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I137_XG_MP1 (I1068_G12_5 I1068_G8_5n XI1068_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I133_XG_MP2 (VDD I1068_G8_5n I1068_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I133_XG_MP0 (XI1068_I133_XG_p1 I1068_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I133_XG_MP1 (I1068_G8_1 I1068_G4_1n XI1068_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I76_XG_MP2 (VDD I1068_gn10 I1068_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I76_XG_MP0 (XI1068_I76_XG_p1 I1068_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I76_XG_MP1 (I1068_G10_9 I1068_gn9 XI1068_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I128_XG_MP2 (VDD I1068_G4_1n I1068_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I128_XG_MP0 (XI1068_I128_XG_p1 I1068_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I128_XG_MP1 (I1068_G4_0 I1068_G0_0n XI1068_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I130_XG_MP2 (VDD I1022_G5_2n I1022_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I130_XG_MP0 (XI1022_I130_XG_p1 I1022_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I130_XG_MP1 (I1022_G5_0 I1022_G1_0n XI1022_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I128_XG_MP2 (VDD I1022_G4_1n I1022_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I128_XG_MP0 (XI1022_I128_XG_p1 I1022_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I128_XG_MP1 (I1022_G4_0 I1022_G0_0n XI1022_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I131_XG_MP2 (VDD I1022_G6_3n I1022_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I131_XG_MP0 (XI1022_I131_XG_p1 I1022_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I131_XG_MP1 (I1022_G6_0 I1022_G2_0n XI1022_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I72_XG_MP2 (VDD I1022_gn6 I1022_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I72_XG_MP0 (XI1022_I72_XG_p1 I1022_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I72_XG_MP1 (I1022_G6_5 I1022_gn5 XI1022_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I71_XG_MP2 (VDD I1022_gn5 I1022_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I71_XG_MP0 (XI1022_I71_XG_p1 I1022_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I71_XG_MP1 (I1022_G5_4 I1022_gn4 XI1022_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I71_XG_MP2 (VDD I976_gn5 I976_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I71_XG_MP0 (XI976_I71_XG_p1 I976_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I71_XG_MP1 (I976_G5_4 I976_gn4 XI976_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I72_XG_MP2 (VDD I976_gn6 I976_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I72_XG_MP0 (XI976_I72_XG_p1 I976_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I72_XG_MP1 (I976_G6_5 I976_gn5 XI976_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I128_XG_MP2 (VDD I930_G4_1n I930_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I128_XG_MP0 (XI930_I128_XG_p1 I930_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I128_XG_MP1 (I930_G4_0 I930_G0_0n XI930_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I133_XG_MP2 (VDD I930_G8_5n I930_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I133_XG_MP0 (XI930_I133_XG_p1 I930_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I133_XG_MP1 (I930_G8_1 I930_G4_1n XI930_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I75_XG_MP2 (VDD I930_gn9 I930_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I75_XG_MP0 (XI930_I75_XG_p1 I930_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I75_XG_MP1 (I930_G9_8 I930_gn8 XI930_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I195_XG_MP2 (VDD I1666_G24_9n I1666_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I195_XG_MP0 (XI1666_I195_XG_p1 I1666_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I195_XG_MP1 (I1666_G24_0 I1666_G8_0n XI1666_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I133_XG_MP2 (VDD I1666_G8_5n I1666_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I133_XG_MP0 (XI1666_I133_XG_p1 I1666_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I133_XG_MP1 (I1666_G8_1 I1666_G4_1n XI1666_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I185_XG_MP2 (VDD I1666_G18_3n I1666_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I185_XG_MP0 (XI1666_I185_XG_p1 I1666_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I185_XG_MP1 (I1666_G18_0 I1666_G2_0n XI1666_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I131_XG_MP2 (VDD I1666_G6_3n I1666_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I131_XG_MP0 (XI1666_I131_XG_p1 I1666_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I131_XG_MP1 (I1666_G6_0 I1666_G2_0n XI1666_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I130_XG_MP2 (VDD I1666_G5_2n I1666_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I130_XG_MP0 (XI1666_I130_XG_p1 I1666_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I130_XG_MP1 (I1666_G5_0 I1666_G1_0n XI1666_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I72_XG_MP2 (VDD I1666_gn6 I1666_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I72_XG_MP0 (XI1666_I72_XG_p1 I1666_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I72_XG_MP1 (I1666_G6_5 I1666_gn5 XI1666_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I73_XG_MP2 (VDD I1666_gn7 I1666_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I73_XG_MP0 (XI1666_I73_XG_p1 I1666_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I73_XG_MP1 (I1666_G7_6 I1666_gn6 XI1666_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I128_XG_MP2 (VDD I1620_G4_1n I1620_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I128_XG_MP0 (XI1620_I128_XG_p1 I1620_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I128_XG_MP1 (I1620_G4_0 I1620_G0_0n XI1620_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I131_XG_MP2 (VDD I1620_G6_3n I1620_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I131_XG_MP0 (XI1620_I131_XG_p1 I1620_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I131_XG_MP1 (I1620_G6_0 I1620_G2_0n XI1620_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I72_XG_MP2 (VDD I1620_gn6 I1620_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I72_XG_MP0 (XI1620_I72_XG_p1 I1620_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I72_XG_MP1 (I1620_G6_5 I1620_gn5 XI1620_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I73_XG_MP2 (VDD I1620_gn7 I1620_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I73_XG_MP0 (XI1620_I73_XG_p1 I1620_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I73_XG_MP1 (I1620_G7_6 I1620_gn6 XI1620_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I74_XG_MP2 (VDD I1574_gn8 I1574_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I74_XG_MP0 (XI1574_I74_XG_p1 I1574_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I74_XG_MP1 (I1574_G8_7 I1574_gn7 XI1574_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I73_XG_MP2 (VDD I1574_gn7 I1574_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I73_XG_MP0 (XI1574_I73_XG_p1 I1574_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I73_XG_MP1 (I1574_G7_6 I1574_gn6 XI1574_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I131_XG_MP2 (VDD I1574_G6_3n I1574_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I131_XG_MP0 (XI1574_I131_XG_p1 I1574_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I131_XG_MP1 (I1574_G6_0 I1574_G2_0n XI1574_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I137_XG_MP2 (VDD I1574_G12_9n I1574_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I137_XG_MP0 (XI1574_I137_XG_p1 I1574_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I137_XG_MP1 (I1574_G12_5 I1574_G8_5n XI1574_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I188_XG_MP2 (VDD I1574_G20_5n I1574_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I188_XG_MP0 (XI1574_I188_XG_p1 I1574_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I188_XG_MP1 (I1574_G20_0 I1574_G4_0n XI1574_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I95_XG_MP2 (VDD I1068_gn29 I1068_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I95_XG_MP0 (XI1068_I95_XG_p1 I1068_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I95_XG_MP1 (I1068_G29_28 I1068_gn28 XI1068_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I91_XG_MP2 (VDD I1068_gn25 I1068_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I91_XG_MP0 (XI1068_I91_XG_p1 I1068_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I91_XG_MP1 (I1068_G25_24 I1068_gn24 XI1068_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I153_XG_MP2 (VDD I1068_G28_25n I1068_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I153_XG_MP0 (XI1068_I153_XG_p1 I1068_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I153_XG_MP1 (I1068_G28_21 I1068_G24_21n XI1068_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I199_XG_MP2 (VDD I1068_G28_13n I1068_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I199_XG_MP0 (XI1068_I199_XG_p1 I1068_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I199_XG_MP1 (I1068_G28_0 I1068_G12_0n XI1068_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I149_XG_MP2 (VDD I1068_G24_21n I1068_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I149_XG_MP0 (XI1068_I149_XG_p1 I1068_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I149_XG_MP1 (I1068_G24_17 I1068_G20_17n XI1068_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I188_XG_MP2 (VDD I1068_G20_5n I1068_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I188_XG_MP0 (XI1068_I188_XG_p1 I1068_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I188_XG_MP1 (I1068_G20_0 I1068_G4_0n XI1068_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I145_XG_MP2 (VDD I1068_G20_17n I1068_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I145_XG_MP0 (XI1068_I145_XG_p1 I1068_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I145_XG_MP1 (I1068_G20_13 I1068_G16_13n XI1068_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I141_XG_MP2 (VDD I1068_G16_13n I1068_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I141_XG_MP0 (XI1068_I141_XG_p1 I1068_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I141_XG_MP1 (I1068_G16_9 I1068_G12_9n XI1068_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I183_XG_MP2 (VDD I1068_G16_1n I1068_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I183_XG_MP0 (XI1068_I183_XG_p1 I1068_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I183_XG_MP1 (I1068_G16_0 I1068_G0_0n XI1068_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I77_XG_MP2 (VDD I1068_gn11 I1068_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I77_XG_MP0 (XI1068_I77_XG_p1 I1068_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I77_XG_MP1 (I1068_G11_10 I1068_gn10 XI1068_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I134_XG_MP2 (VDD I1022_G9_6n I1022_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I134_XG_MP0 (XI1022_I134_XG_p1 I1022_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I134_XG_MP1 (I1022_G9_2 I1022_G5_2n XI1022_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I183_XG_MP2 (VDD I1022_G16_1n I1022_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I183_XG_MP0 (XI1022_I183_XG_p1 I1022_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I183_XG_MP1 (I1022_G16_0 I1022_G0_0n XI1022_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I133_XG_MP2 (VDD I1022_G8_5n I1022_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I133_XG_MP0 (XI1022_I133_XG_p1 I1022_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I133_XG_MP1 (I1022_G8_1 I1022_G4_1n XI1022_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I73_XG_MP2 (VDD I1022_gn7 I1022_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I73_XG_MP0 (XI1022_I73_XG_p1 I1022_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I73_XG_MP1 (I1022_G7_6 I1022_gn6 XI1022_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I74_XG_MP2 (VDD I1022_gn8 I1022_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I74_XG_MP0 (XI1022_I74_XG_p1 I1022_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I74_XG_MP1 (I1022_G8_7 I1022_gn7 XI1022_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I75_XG_MP2 (VDD I1022_gn9 I1022_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I75_XG_MP0 (XI1022_I75_XG_p1 I1022_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I75_XG_MP1 (I1022_G9_8 I1022_gn8 XI1022_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I128_XG_MP2 (VDD I976_G4_1n I976_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I128_XG_MP0 (XI976_I128_XG_p1 I976_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I128_XG_MP1 (I976_G4_0 I976_G0_0n XI976_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I74_XG_MP2 (VDD I976_gn8 I976_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I74_XG_MP0 (XI976_I74_XG_p1 I976_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I74_XG_MP1 (I976_G8_7 I976_gn7 XI976_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I73_XG_MP2 (VDD I976_gn7 I976_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I73_XG_MP0 (XI976_I73_XG_p1 I976_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I73_XG_MP1 (I976_G7_6 I976_gn6 XI976_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I183_XG_MP2 (VDD I930_G16_1n I930_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I183_XG_MP0 (XI930_I183_XG_p1 I930_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I183_XG_MP1 (I930_G16_0 I930_G0_0n XI930_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I131_XG_MP2 (VDD I930_G6_3n I930_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I131_XG_MP0 (XI930_I131_XG_p1 I930_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I131_XG_MP1 (I930_G6_0 I930_G2_0n XI930_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I76_XG_MP2 (VDD I930_gn10 I930_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I76_XG_MP0 (XI930_I76_XG_p1 I930_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I76_XG_MP1 (I930_G10_9 I930_gn9 XI930_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I77_XG_MP2 (VDD I930_gn11 I930_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I77_XG_MP0 (XI930_I77_XG_p1 I930_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I77_XG_MP1 (I930_G11_10 I930_gn10 XI930_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I134_XG_MP2 (VDD I930_G9_6n I930_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I134_XG_MP0 (XI930_I134_XG_p1 I930_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I134_XG_MP1 (I930_G9_2 I930_G5_2n XI930_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I130_XG_MP2 (VDD I930_G5_2n I930_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I130_XG_MP0 (XI930_I130_XG_p1 I930_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I130_XG_MP1 (I930_G5_0 I930_G1_0n XI930_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I137_XG_MP2 (VDD I1666_G12_9n I1666_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I137_XG_MP0 (XI1666_I137_XG_p1 I1666_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I137_XG_MP1 (I1666_G12_5 I1666_G8_5n XI1666_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I135_XG_MP2 (VDD I1666_G10_7n I1666_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I135_XG_MP0 (XI1666_I135_XG_p1 I1666_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I135_XG_MP1 (I1666_G10_3 I1666_G6_3n XI1666_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I134_XG_MP2 (VDD I1666_G9_6n I1666_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I134_XG_MP0 (XI1666_I134_XG_p1 I1666_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I134_XG_MP1 (I1666_G9_2 I1666_G5_2n XI1666_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I132_XG_MP2 (VDD I1666_G7_4n I1666_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I132_XG_MP0 (XI1666_I132_XG_p1 I1666_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I132_XG_MP1 (I1666_G7_0 I1666_G3_0n XI1666_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I75_XG_MP2 (VDD I1666_gn9 I1666_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I75_XG_MP0 (XI1666_I75_XG_p1 I1666_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I75_XG_MP1 (I1666_G9_8 I1666_gn8 XI1666_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I76_XG_MP2 (VDD I1666_gn10 I1666_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I76_XG_MP0 (XI1666_I76_XG_p1 I1666_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I76_XG_MP1 (I1666_G10_9 I1666_gn9 XI1666_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I74_XG_MP2 (VDD I1666_gn8 I1666_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I74_XG_MP0 (XI1666_I74_XG_p1 I1666_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I74_XG_MP1 (I1666_G8_7 I1666_gn7 XI1666_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I130_XG_MP2 (VDD I1620_G5_2n I1620_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I130_XG_MP0 (XI1620_I130_XG_p1 I1620_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I130_XG_MP1 (I1620_G5_0 I1620_G1_0n XI1620_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I133_XG_MP2 (VDD I1620_G8_5n I1620_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I133_XG_MP0 (XI1620_I133_XG_p1 I1620_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I133_XG_MP1 (I1620_G8_1 I1620_G4_1n XI1620_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I135_XG_MP2 (VDD I1620_G10_7n I1620_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I135_XG_MP0 (XI1620_I135_XG_p1 I1620_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I135_XG_MP1 (I1620_G10_3 I1620_G6_3n XI1620_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I74_XG_MP2 (VDD I1620_gn8 I1620_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I74_XG_MP0 (XI1620_I74_XG_p1 I1620_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I74_XG_MP1 (I1620_G8_7 I1620_gn7 XI1620_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I75_XG_MP2 (VDD I1620_gn9 I1620_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I75_XG_MP0 (XI1620_I75_XG_p1 I1620_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I75_XG_MP1 (I1620_G9_8 I1620_gn8 XI1620_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I132_XG_MP2 (VDD I1574_G7_4n I1574_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I132_XG_MP0 (XI1574_I132_XG_p1 I1574_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I132_XG_MP1 (I1574_G7_0 I1574_G3_0n XI1574_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I130_XG_MP2 (VDD I1574_G5_2n I1574_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I130_XG_MP0 (XI1574_I130_XG_p1 I1574_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I130_XG_MP1 (I1574_G5_0 I1574_G1_0n XI1574_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I134_XG_MP2 (VDD I1574_G9_6n I1574_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I134_XG_MP0 (XI1574_I134_XG_p1 I1574_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I134_XG_MP1 (I1574_G9_2 I1574_G5_2n XI1574_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I75_XG_MP2 (VDD I1574_gn9 I1574_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I75_XG_MP0 (XI1574_I75_XG_p1 I1574_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I75_XG_MP1 (I1574_G9_8 I1574_gn8 XI1574_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I76_XG_MP2 (VDD I1574_gn10 I1574_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I76_XG_MP0 (XI1574_I76_XG_p1 I1574_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I76_XG_MP1 (I1574_G10_9 I1574_gn9 XI1574_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I135_XG_MP2 (VDD I1574_G10_7n I1574_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I135_XG_MP0 (XI1574_I135_XG_p1 I1574_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I135_XG_MP1 (I1574_G10_3 I1574_G6_3n XI1574_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I141_XG_MP2 (VDD I1574_G16_13n I1574_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I141_XG_MP0 (XI1574_I141_XG_p1 I1574_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I141_XG_MP1 (I1574_G16_9 I1574_G12_9n XI1574_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I96_XG_MP2 (VDD I1068_gn30 I1068_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I96_XG_MP0 (XI1068_I96_XG_p1 I1068_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I96_XG_MP1 (I1068_G30_29 I1068_gn29 XI1068_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I90_XG_MP2 (VDD I1068_gn24 I1068_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I90_XG_MP0 (XI1068_I90_XG_p1 I1068_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I90_XG_MP1 (I1068_G24_23 I1068_gn23 XI1068_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I89_XG_MP2 (VDD I1068_gn23 I1068_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I89_XG_MP0 (XI1068_I89_XG_p1 I1068_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I89_XG_MP1 (I1068_G23_22 I1068_gn22 XI1068_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I88_XG_MP2 (VDD I1068_gn22 I1068_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I88_XG_MP0 (XI1068_I88_XG_p1 I1068_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I88_XG_MP1 (I1068_G22_21 I1068_gn21 XI1068_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I87_XG_MP2 (VDD I1068_gn21 I1068_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I87_XG_MP0 (XI1068_I87_XG_p1 I1068_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I87_XG_MP1 (I1068_G21_20 I1068_gn20 XI1068_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I86_XG_MP2 (VDD I1068_gn20 I1068_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I86_XG_MP0 (XI1068_I86_XG_p1 I1068_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I86_XG_MP1 (I1068_G20_19 I1068_gn19 XI1068_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I85_XG_MP2 (VDD I1068_gn19 I1068_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I85_XG_MP0 (XI1068_I85_XG_p1 I1068_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I85_XG_MP1 (I1068_G19_18 I1068_gn18 XI1068_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I195_XG_MP2 (VDD I1068_G24_9n I1068_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I195_XG_MP0 (XI1068_I195_XG_p1 I1068_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I195_XG_MP1 (I1068_G24_0 I1068_G8_0n XI1068_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I79_XG_MP2 (VDD I1068_gn13 I1068_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I79_XG_MP0 (XI1068_I79_XG_p1 I1068_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I79_XG_MP1 (I1068_G13_12 I1068_gn12 XI1068_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I78_XG_MP2 (VDD I1068_gn12 I1068_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I78_XG_MP0 (XI1068_I78_XG_p1 I1068_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I78_XG_MP1 (I1068_G12_11 I1068_gn11 XI1068_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I184_XG_MP2 (VDD I1022_G17_2n I1022_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I184_XG_MP0 (XI1022_I184_XG_p1 I1022_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I184_XG_MP1 (I1022_G17_0 I1022_G1_0n XI1022_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I132_XG_MP2 (VDD I1022_G7_4n I1022_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I132_XG_MP0 (XI1022_I132_XG_p1 I1022_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I132_XG_MP1 (I1022_G7_0 I1022_G3_0n XI1022_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I136_XG_MP2 (VDD I1022_G11_8n I1022_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I136_XG_MP0 (XI1022_I136_XG_p1 I1022_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I136_XG_MP1 (I1022_G11_4 I1022_G7_4n XI1022_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I195_XG_MP2 (VDD I1022_G24_9n I1022_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I195_XG_MP0 (XI1022_I195_XG_p1 I1022_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I195_XG_MP1 (I1022_G24_0 I1022_G8_0n XI1022_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I135_XG_MP2 (VDD I1022_G10_7n I1022_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I135_XG_MP0 (XI1022_I135_XG_p1 I1022_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I135_XG_MP1 (I1022_G10_3 I1022_G6_3n XI1022_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I76_XG_MP2 (VDD I1022_gn10 I1022_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I76_XG_MP0 (XI1022_I76_XG_p1 I1022_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I76_XG_MP1 (I1022_G10_9 I1022_gn9 XI1022_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I77_XG_MP2 (VDD I1022_gn11 I1022_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I77_XG_MP0 (XI1022_I77_XG_p1 I1022_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I77_XG_MP1 (I1022_G11_10 I1022_gn10 XI1022_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I133_XG_MP2 (VDD I976_G8_5n I976_G8_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I133_XG_MP0 (XI976_I133_XG_p1 I976_P8_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I133_XG_MP1 (I976_G8_1 I976_G4_1n XI976_I133_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I131_XG_MP2 (VDD I976_G6_3n I976_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I131_XG_MP0 (XI976_I131_XG_p1 I976_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I131_XG_MP1 (I976_G6_0 I976_G2_0n XI976_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I130_XG_MP2 (VDD I976_G5_2n I976_G5_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I130_XG_MP0 (XI976_I130_XG_p1 I976_P5_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I130_XG_MP1 (I976_G5_0 I976_G1_0n XI976_I130_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I132_XG_MP2 (VDD I976_G7_4n I976_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I132_XG_MP0 (XI976_I132_XG_p1 I976_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I132_XG_MP1 (I976_G7_0 I976_G3_0n XI976_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I75_XG_MP2 (VDD I976_gn9 I976_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I75_XG_MP0 (XI976_I75_XG_p1 I976_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I75_XG_MP1 (I976_G9_8 I976_gn8 XI976_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I76_XG_MP2 (VDD I976_gn10 I976_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I76_XG_MP0 (XI976_I76_XG_p1 I976_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I76_XG_MP1 (I976_G10_9 I976_gn9 XI976_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I195_XG_MP2 (VDD I930_G24_9n I930_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I195_XG_MP0 (XI930_I195_XG_p1 I930_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I195_XG_MP1 (I930_G24_0 I930_G8_0n XI930_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I141_XG_MP2 (VDD I930_G16_13n I930_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I141_XG_MP0 (XI930_I141_XG_p1 I930_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I141_XG_MP1 (I930_G16_9 I930_G12_9n XI930_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I137_XG_MP2 (VDD I930_G12_9n I930_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I137_XG_MP0 (XI930_I137_XG_p1 I930_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I137_XG_MP1 (I930_G12_5 I930_G8_5n XI930_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I135_XG_MP2 (VDD I930_G10_7n I930_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I135_XG_MP0 (XI930_I135_XG_p1 I930_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I135_XG_MP1 (I930_G10_3 I930_G6_3n XI930_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I78_XG_MP2 (VDD I930_gn12 I930_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I78_XG_MP0 (XI930_I78_XG_p1 I930_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I78_XG_MP1 (I930_G12_11 I930_gn11 XI930_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I132_XG_MP2 (VDD I930_G7_4n I930_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I132_XG_MP0 (XI930_I132_XG_p1 I930_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I132_XG_MP1 (I930_G7_0 I930_G3_0n XI930_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I184_XG_MP2 (VDD I930_G17_2n I930_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I184_XG_MP0 (XI930_I184_XG_p1 I930_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I184_XG_MP1 (I930_G17_0 I930_G1_0n XI930_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I188_XG_MP2 (VDD I1666_G20_5n I1666_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I188_XG_MP0 (XI1666_I188_XG_p1 I1666_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I188_XG_MP1 (I1666_G20_0 I1666_G4_0n XI1666_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I141_XG_MP2 (VDD I1666_G16_13n I1666_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I141_XG_MP0 (XI1666_I141_XG_p1 I1666_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I141_XG_MP1 (I1666_G16_9 I1666_G12_9n XI1666_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I184_XG_MP2 (VDD I1666_G17_2n I1666_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I184_XG_MP0 (XI1666_I184_XG_p1 I1666_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I184_XG_MP1 (I1666_G17_0 I1666_G1_0n XI1666_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I136_XG_MP2 (VDD I1666_G11_8n I1666_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I136_XG_MP0 (XI1666_I136_XG_p1 I1666_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I136_XG_MP1 (I1666_G11_4 I1666_G7_4n XI1666_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I77_XG_MP2 (VDD I1666_gn11 I1666_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I77_XG_MP0 (XI1666_I77_XG_p1 I1666_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I77_XG_MP1 (I1666_G11_10 I1666_gn10 XI1666_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I78_XG_MP2 (VDD I1666_gn12 I1666_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I78_XG_MP0 (XI1666_I78_XG_p1 I1666_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I78_XG_MP1 (I1666_G12_11 I1666_gn11 XI1666_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I132_XG_MP2 (VDD I1620_G7_4n I1620_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I132_XG_MP0 (XI1620_I132_XG_p1 I1620_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I132_XG_MP1 (I1620_G7_0 I1620_G3_0n XI1620_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I134_XG_MP2 (VDD I1620_G9_6n I1620_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I134_XG_MP0 (XI1620_I134_XG_p1 I1620_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I134_XG_MP1 (I1620_G9_2 I1620_G5_2n XI1620_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I183_XG_MP2 (VDD I1620_G16_1n I1620_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I183_XG_MP0 (XI1620_I183_XG_p1 I1620_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I183_XG_MP1 (I1620_G16_0 I1620_G0_0n XI1620_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I76_XG_MP2 (VDD I1620_gn10 I1620_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I76_XG_MP0 (XI1620_I76_XG_p1 I1620_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I76_XG_MP1 (I1620_G10_9 I1620_gn9 XI1620_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I77_XG_MP2 (VDD I1620_gn11 I1620_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I77_XG_MP0 (XI1620_I77_XG_p1 I1620_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I77_XG_MP1 (I1620_G11_10 I1620_gn10 XI1620_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I136_XG_MP2 (VDD I1574_G11_8n I1574_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I136_XG_MP0 (XI1574_I136_XG_p1 I1574_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I136_XG_MP1 (I1574_G11_4 I1574_G7_4n XI1574_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I184_XG_MP2 (VDD I1574_G17_2n I1574_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I184_XG_MP0 (XI1574_I184_XG_p1 I1574_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I184_XG_MP1 (I1574_G17_0 I1574_G1_0n XI1574_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I77_XG_MP2 (VDD I1574_gn11 I1574_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I77_XG_MP0 (XI1574_I77_XG_p1 I1574_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I77_XG_MP1 (I1574_G11_10 I1574_gn10 XI1574_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I78_XG_MP2 (VDD I1574_gn12 I1574_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I78_XG_MP0 (XI1574_I78_XG_p1 I1574_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I78_XG_MP1 (I1574_G12_11 I1574_gn11 XI1574_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I185_XG_MP2 (VDD I1574_G18_3n I1574_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I185_XG_MP0 (XI1574_I185_XG_p1 I1574_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I185_XG_MP1 (I1574_G18_0 I1574_G2_0n XI1574_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I195_XG_MP2 (VDD I1574_G24_9n I1574_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I195_XG_MP0 (XI1574_I195_XG_p1 I1574_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I195_XG_MP1 (I1574_G24_0 I1574_G8_0n XI1574_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I84_XG_MP2 (VDD I1068_gn18 I1068_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I84_XG_MP0 (XI1068_I84_XG_p1 I1068_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I84_XG_MP1 (I1068_G18_17 I1068_gn17 XI1068_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I83_XG_MP2 (VDD I1068_gn17 I1068_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I83_XG_MP0 (XI1068_I83_XG_p1 I1068_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I83_XG_MP1 (I1068_G17_16 I1068_gn16 XI1068_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I81_XG_MP2 (VDD I1068_gn15 I1068_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I81_XG_MP0 (XI1068_I81_XG_p1 I1068_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I81_XG_MP1 (I1068_G15_14 I1068_gn14 XI1068_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I80_XG_MP2 (VDD I1068_gn14 I1068_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I80_XG_MP0 (XI1068_I80_XG_p1 I1068_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I80_XG_MP1 (I1068_G14_13 I1068_gn13 XI1068_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I196_XG_MP2 (VDD I1022_G25_10n I1022_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I196_XG_MP0 (XI1022_I196_XG_p1 I1022_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I196_XG_MP1 (I1022_G25_0 I1022_G9_0n XI1022_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I138_XG_MP2 (VDD I1022_G13_10n I1022_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I138_XG_MP0 (XI1022_I138_XG_p1 I1022_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I138_XG_MP1 (I1022_G13_6 I1022_G9_6n XI1022_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I185_XG_MP2 (VDD I1022_G18_3n I1022_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I185_XG_MP0 (XI1022_I185_XG_p1 I1022_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I185_XG_MP1 (I1022_G18_0 I1022_G2_0n XI1022_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I141_XG_MP2 (VDD I1022_G16_13n I1022_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I141_XG_MP0 (XI1022_I141_XG_p1 I1022_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I141_XG_MP1 (I1022_G16_9 I1022_G12_9n XI1022_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I137_XG_MP2 (VDD I1022_G12_9n I1022_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I137_XG_MP0 (XI1022_I137_XG_p1 I1022_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I137_XG_MP1 (I1022_G12_5 I1022_G8_5n XI1022_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I79_XG_MP2 (VDD I1022_gn13 I1022_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I79_XG_MP0 (XI1022_I79_XG_p1 I1022_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I79_XG_MP1 (I1022_G13_12 I1022_gn12 XI1022_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I78_XG_MP2 (VDD I1022_gn12 I1022_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I78_XG_MP0 (XI1022_I78_XG_p1 I1022_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I78_XG_MP1 (I1022_G12_11 I1022_gn11 XI1022_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I183_XG_MP2 (VDD I976_G16_1n I976_G16_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I183_XG_MP0 (XI976_I183_XG_p1 I976_P16_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I183_XG_MP1 (I976_G16_0 I976_G0_0n XI976_I183_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I134_XG_MP2 (VDD I976_G9_6n I976_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I134_XG_MP0 (XI976_I134_XG_p1 I976_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I134_XG_MP1 (I976_G9_2 I976_G5_2n XI976_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I77_XG_MP2 (VDD I976_gn11 I976_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I77_XG_MP0 (XI976_I77_XG_p1 I976_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I77_XG_MP1 (I976_G11_10 I976_gn10 XI976_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I188_XG_MP2 (VDD I930_G20_5n I930_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I188_XG_MP0 (XI930_I188_XG_p1 I930_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I188_XG_MP1 (I930_G20_0 I930_G4_0n XI930_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I79_XG_MP2 (VDD I930_gn13 I930_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I79_XG_MP0 (XI930_I79_XG_p1 I930_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I79_XG_MP1 (I930_G13_12 I930_gn12 XI930_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I136_XG_MP2 (VDD I930_G11_8n I930_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I136_XG_MP0 (XI930_I136_XG_p1 I930_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I136_XG_MP1 (I930_G11_4 I930_G7_4n XI930_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I138_XG_MP2 (VDD I930_G13_10n I930_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I138_XG_MP0 (XI930_I138_XG_p1 I930_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I138_XG_MP1 (I930_G13_6 I930_G9_6n XI930_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I197_XG_MP2 (VDD I1666_G26_11n I1666_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I197_XG_MP0 (XI1666_I197_XG_p1 I1666_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I197_XG_MP1 (I1666_G26_0 I1666_G10_0n XI1666_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I139_XG_MP2 (VDD I1666_G14_11n I1666_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I139_XG_MP0 (XI1666_I139_XG_p1 I1666_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I139_XG_MP1 (I1666_G14_7 I1666_G10_7n XI1666_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I196_XG_MP2 (VDD I1666_G25_10n I1666_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I196_XG_MP0 (XI1666_I196_XG_p1 I1666_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I196_XG_MP1 (I1666_G25_0 I1666_G9_0n XI1666_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I186_XG_MP2 (VDD I1666_G19_4n I1666_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I186_XG_MP0 (XI1666_I186_XG_p1 I1666_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I186_XG_MP1 (I1666_G19_0 I1666_G3_0n XI1666_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I138_XG_MP2 (VDD I1666_G13_10n I1666_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I138_XG_MP0 (XI1666_I138_XG_p1 I1666_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I138_XG_MP1 (I1666_G13_6 I1666_G9_6n XI1666_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I79_XG_MP2 (VDD I1666_gn13 I1666_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I79_XG_MP0 (XI1666_I79_XG_p1 I1666_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I79_XG_MP1 (I1666_G13_12 I1666_gn12 XI1666_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I136_XG_MP2 (VDD I1620_G11_8n I1620_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I136_XG_MP0 (XI1620_I136_XG_p1 I1620_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I136_XG_MP1 (I1620_G11_4 I1620_G7_4n XI1620_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I184_XG_MP2 (VDD I1620_G17_2n I1620_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I184_XG_MP0 (XI1620_I184_XG_p1 I1620_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I184_XG_MP1 (I1620_G17_0 I1620_G1_0n XI1620_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I185_XG_MP2 (VDD I1620_G18_3n I1620_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I185_XG_MP0 (XI1620_I185_XG_p1 I1620_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I185_XG_MP1 (I1620_G18_0 I1620_G2_0n XI1620_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I195_XG_MP2 (VDD I1620_G24_9n I1620_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I195_XG_MP0 (XI1620_I195_XG_p1 I1620_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I195_XG_MP1 (I1620_G24_0 I1620_G8_0n XI1620_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I137_XG_MP2 (VDD I1620_G12_9n I1620_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I137_XG_MP0 (XI1620_I137_XG_p1 I1620_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I137_XG_MP1 (I1620_G12_5 I1620_G8_5n XI1620_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I141_XG_MP2 (VDD I1620_G16_13n I1620_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I141_XG_MP0 (XI1620_I141_XG_p1 I1620_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I141_XG_MP1 (I1620_G16_9 I1620_G12_9n XI1620_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I78_XG_MP2 (VDD I1620_gn12 I1620_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I78_XG_MP0 (XI1620_I78_XG_p1 I1620_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I78_XG_MP1 (I1620_G12_11 I1620_gn11 XI1620_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I79_XG_MP2 (VDD I1620_gn13 I1620_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I79_XG_MP0 (XI1620_I79_XG_p1 I1620_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I79_XG_MP1 (I1620_G13_12 I1620_gn12 XI1620_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I186_XG_MP2 (VDD I1574_G19_4n I1574_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I186_XG_MP0 (XI1574_I186_XG_p1 I1574_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I186_XG_MP1 (I1574_G19_0 I1574_G3_0n XI1574_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I138_XG_MP2 (VDD I1574_G13_10n I1574_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I138_XG_MP0 (XI1574_I138_XG_p1 I1574_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I138_XG_MP1 (I1574_G13_6 I1574_G9_6n XI1574_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I79_XG_MP2 (VDD I1574_gn13 I1574_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I79_XG_MP0 (XI1574_I79_XG_p1 I1574_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I79_XG_MP1 (I1574_G13_12 I1574_gn12 XI1574_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I80_XG_MP2 (VDD I1574_gn14 I1574_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I80_XG_MP0 (XI1574_I80_XG_p1 I1574_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I80_XG_MP1 (I1574_G14_13 I1574_gn13 XI1574_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I139_XG_MP2 (VDD I1574_G14_11n I1574_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I139_XG_MP0 (XI1574_I139_XG_p1 I1574_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I139_XG_MP1 (I1574_G14_7 I1574_G10_7n XI1574_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I143_XG_MP2 (VDD I1574_G18_15n I1574_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I143_XG_MP0 (XI1574_I143_XG_p1 I1574_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I143_XG_MP1 (I1574_G18_11 I1574_G14_11n XI1574_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I197_XG_MP2 (VDD I1574_G26_11n I1574_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I197_XG_MP0 (XI1574_I197_XG_p1 I1574_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I197_XG_MP1 (I1574_G26_0 I1574_G10_0n XI1574_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I97_XG_MP2 (VDD I1068_gn31 I1068_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I97_XG_MP0 (XI1068_I97_XG_p1 I1068_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I97_XG_MP1 (I1068_G31_30 I1068_gn30 XI1068_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1068_I82_XG_MP2 (VDD I1068_gn16 I1068_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1068_I82_XG_MP0 (XI1068_I82_XG_p1 I1068_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1068_I82_XG_MP1 (I1068_G16_15 I1068_gn15 XI1068_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I142_XG_MP2 (VDD I1022_G17_14n I1022_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I142_XG_MP0 (XI1022_I142_XG_p1 I1022_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I142_XG_MP1 (I1022_G17_10 I1022_G13_10n XI1022_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I186_XG_MP2 (VDD I1022_G19_4n I1022_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I186_XG_MP0 (XI1022_I186_XG_p1 I1022_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I186_XG_MP1 (I1022_G19_0 I1022_G3_0n XI1022_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I188_XG_MP2 (VDD I1022_G20_5n I1022_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I188_XG_MP0 (XI1022_I188_XG_p1 I1022_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I188_XG_MP1 (I1022_G20_0 I1022_G4_0n XI1022_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I139_XG_MP2 (VDD I1022_G14_11n I1022_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I139_XG_MP0 (XI1022_I139_XG_p1 I1022_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I139_XG_MP1 (I1022_G14_7 I1022_G10_7n XI1022_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I80_XG_MP2 (VDD I1022_gn14 I1022_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I80_XG_MP0 (XI1022_I80_XG_p1 I1022_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I80_XG_MP1 (I1022_G14_13 I1022_gn13 XI1022_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I137_XG_MP2 (VDD I976_G12_9n I976_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I137_XG_MP0 (XI976_I137_XG_p1 I976_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I137_XG_MP1 (I976_G12_5 I976_G8_5n XI976_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I135_XG_MP2 (VDD I976_G10_7n I976_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I135_XG_MP0 (XI976_I135_XG_p1 I976_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I135_XG_MP1 (I976_G10_3 I976_G6_3n XI976_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I184_XG_MP2 (VDD I976_G17_2n I976_G17_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I184_XG_MP0 (XI976_I184_XG_p1 I976_P17_2n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I184_XG_MP1 (I976_G17_0 I976_G1_0n XI976_I184_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I136_XG_MP2 (VDD I976_G11_8n I976_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I136_XG_MP0 (XI976_I136_XG_p1 I976_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I136_XG_MP1 (I976_G11_4 I976_G7_4n XI976_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I78_XG_MP2 (VDD I976_gn12 I976_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I78_XG_MP0 (XI976_I78_XG_p1 I976_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I78_XG_MP1 (I976_G12_11 I976_gn11 XI976_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I79_XG_MP2 (VDD I976_gn13 I976_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I79_XG_MP0 (XI976_I79_XG_p1 I976_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I79_XG_MP1 (I976_G13_12 I976_gn12 XI976_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I82_XG_MP2 (VDD I930_gn16 I930_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I82_XG_MP0 (XI930_I82_XG_p1 I930_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I82_XG_MP1 (I930_G16_15 I930_gn15 XI930_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I145_XG_MP2 (VDD I930_G20_17n I930_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I145_XG_MP0 (XI930_I145_XG_p1 I930_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I145_XG_MP1 (I930_G20_13 I930_G16_13n XI930_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I139_XG_MP2 (VDD I930_G14_11n I930_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I139_XG_MP0 (XI930_I139_XG_p1 I930_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I139_XG_MP1 (I930_G14_7 I930_G10_7n XI930_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I81_XG_MP2 (VDD I930_gn15 I930_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I81_XG_MP0 (XI930_I81_XG_p1 I930_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I81_XG_MP1 (I930_G15_14 I930_gn14 XI930_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I80_XG_MP2 (VDD I930_gn14 I930_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I80_XG_MP0 (XI930_I80_XG_p1 I930_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I80_XG_MP1 (I930_G14_13 I930_gn13 XI930_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I186_XG_MP2 (VDD I930_G19_4n I930_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I186_XG_MP0 (XI930_I186_XG_p1 I930_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I186_XG_MP1 (I930_G19_0 I930_G3_0n XI930_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I142_XG_MP2 (VDD I930_G17_14n I930_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I142_XG_MP0 (XI930_I142_XG_p1 I930_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I142_XG_MP1 (I930_G17_10 I930_G13_10n XI930_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I199_XG_MP2 (VDD I1666_G28_13n I1666_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I199_XG_MP0 (XI1666_I199_XG_p1 I1666_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I199_XG_MP1 (I1666_G28_0 I1666_G12_0n XI1666_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I145_XG_MP2 (VDD I1666_G20_17n I1666_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I145_XG_MP0 (XI1666_I145_XG_p1 I1666_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I145_XG_MP1 (I1666_G20_13 I1666_G16_13n XI1666_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I143_XG_MP2 (VDD I1666_G18_15n I1666_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I143_XG_MP0 (XI1666_I143_XG_p1 I1666_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I143_XG_MP1 (I1666_G18_11 I1666_G14_11n XI1666_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I142_XG_MP2 (VDD I1666_G17_14n I1666_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I142_XG_MP0 (XI1666_I142_XG_p1 I1666_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I142_XG_MP1 (I1666_G17_10 I1666_G13_10n XI1666_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I82_XG_MP2 (VDD I1666_gn16 I1666_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I82_XG_MP0 (XI1666_I82_XG_p1 I1666_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I82_XG_MP1 (I1666_G16_15 I1666_gn15 XI1666_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I80_XG_MP2 (VDD I1666_gn14 I1666_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I80_XG_MP0 (XI1666_I80_XG_p1 I1666_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I80_XG_MP1 (I1666_G14_13 I1666_gn13 XI1666_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I81_XG_MP2 (VDD I1666_gn15 I1666_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I81_XG_MP0 (XI1666_I81_XG_p1 I1666_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I81_XG_MP1 (I1666_G15_14 I1666_gn14 XI1666_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I140_XG_MP2 (VDD I1620_G15_12n I1620_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I140_XG_MP0 (XI1620_I140_XG_p1 I1620_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I140_XG_MP1 (I1620_G15_8 I1620_G11_8n XI1620_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I138_XG_MP2 (VDD I1620_G13_10n I1620_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I138_XG_MP0 (XI1620_I138_XG_p1 I1620_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I138_XG_MP1 (I1620_G13_6 I1620_G9_6n XI1620_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I139_XG_MP2 (VDD I1620_G14_11n I1620_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I139_XG_MP0 (XI1620_I139_XG_p1 I1620_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I139_XG_MP1 (I1620_G14_7 I1620_G10_7n XI1620_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I143_XG_MP2 (VDD I1620_G18_15n I1620_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I143_XG_MP0 (XI1620_I143_XG_p1 I1620_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I143_XG_MP1 (I1620_G18_11 I1620_G14_11n XI1620_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I80_XG_MP2 (VDD I1620_gn14 I1620_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I80_XG_MP0 (XI1620_I80_XG_p1 I1620_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I80_XG_MP1 (I1620_G14_13 I1620_gn13 XI1620_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I81_XG_MP2 (VDD I1620_gn15 I1620_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I81_XG_MP0 (XI1620_I81_XG_p1 I1620_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I81_XG_MP1 (I1620_G15_14 I1620_gn14 XI1620_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I196_XG_MP2 (VDD I1574_G25_10n I1574_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I196_XG_MP0 (XI1574_I196_XG_p1 I1574_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I196_XG_MP1 (I1574_G25_0 I1574_G9_0n XI1574_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I142_XG_MP2 (VDD I1574_G17_14n I1574_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I142_XG_MP0 (XI1574_I142_XG_p1 I1574_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I142_XG_MP1 (I1574_G17_10 I1574_G13_10n XI1574_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I81_XG_MP2 (VDD I1574_gn15 I1574_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I81_XG_MP0 (XI1574_I81_XG_p1 I1574_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I81_XG_MP1 (I1574_G15_14 I1574_gn14 XI1574_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I145_XG_MP2 (VDD I1574_G20_17n I1574_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I145_XG_MP0 (XI1574_I145_XG_p1 I1574_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I145_XG_MP1 (I1574_G20_13 I1574_G16_13n XI1574_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I190_XG_MP2 (VDD I1022_G21_6n I1022_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I190_XG_MP0 (XI1022_I190_XG_p1 I1022_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I190_XG_MP1 (I1022_G21_0 I1022_G5_0n XI1022_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I140_XG_MP2 (VDD I1022_G15_12n I1022_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I140_XG_MP0 (XI1022_I140_XG_p1 I1022_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I140_XG_MP1 (I1022_G15_8 I1022_G11_8n XI1022_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I197_XG_MP2 (VDD I1022_G26_11n I1022_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I197_XG_MP0 (XI1022_I197_XG_p1 I1022_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I197_XG_MP1 (I1022_G26_0 I1022_G10_0n XI1022_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I143_XG_MP2 (VDD I1022_G18_15n I1022_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I143_XG_MP0 (XI1022_I143_XG_p1 I1022_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I143_XG_MP1 (I1022_G18_11 I1022_G14_11n XI1022_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I145_XG_MP2 (VDD I1022_G20_17n I1022_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I145_XG_MP0 (XI1022_I145_XG_p1 I1022_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I145_XG_MP1 (I1022_G20_13 I1022_G16_13n XI1022_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I81_XG_MP2 (VDD I1022_gn15 I1022_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I81_XG_MP0 (XI1022_I81_XG_p1 I1022_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I81_XG_MP1 (I1022_G15_14 I1022_gn14 XI1022_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I82_XG_MP2 (VDD I1022_gn16 I1022_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I82_XG_MP0 (XI1022_I82_XG_p1 I1022_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I82_XG_MP1 (I1022_G16_15 I1022_gn15 XI1022_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I138_XG_MP2 (VDD I976_G13_10n I976_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I138_XG_MP0 (XI976_I138_XG_p1 I976_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I138_XG_MP1 (I976_G13_6 I976_G9_6n XI976_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I140_XG_MP2 (VDD I976_G15_12n I976_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I140_XG_MP0 (XI976_I140_XG_p1 I976_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I140_XG_MP1 (I976_G15_8 I976_G11_8n XI976_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I81_XG_MP2 (VDD I976_gn15 I976_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I81_XG_MP0 (XI976_I81_XG_p1 I976_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I81_XG_MP1 (I976_G15_14 I976_gn14 XI976_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I80_XG_MP2 (VDD I976_gn14 I976_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I80_XG_MP0 (XI976_I80_XG_p1 I976_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I80_XG_MP1 (I976_G14_13 I976_gn13 XI976_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I83_XG_MP2 (VDD I930_gn17 I930_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I83_XG_MP0 (XI930_I83_XG_p1 I930_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I83_XG_MP1 (I930_G17_16 I930_gn16 XI930_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I84_XG_MP2 (VDD I930_gn18 I930_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I84_XG_MP0 (XI930_I84_XG_p1 I930_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I84_XG_MP1 (I930_G18_17 I930_gn17 XI930_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I149_XG_MP2 (VDD I930_G24_21n I930_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I149_XG_MP0 (XI930_I149_XG_p1 I930_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I149_XG_MP1 (I930_G24_17 I930_G20_17n XI930_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I143_XG_MP2 (VDD I930_G18_15n I930_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I143_XG_MP0 (XI930_I143_XG_p1 I930_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I143_XG_MP1 (I930_G18_11 I930_G14_11n XI930_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I185_XG_MP2 (VDD I930_G18_3n I930_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I185_XG_MP0 (XI930_I185_XG_p1 I930_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I185_XG_MP1 (I930_G18_0 I930_G2_0n XI930_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I144_XG_MP2 (VDD I930_G19_16n I930_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I144_XG_MP0 (XI930_I144_XG_p1 I930_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I144_XG_MP1 (I930_G19_12 I930_G15_12n XI930_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I140_XG_MP2 (VDD I930_G15_12n I930_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I140_XG_MP0 (XI930_I140_XG_p1 I930_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I140_XG_MP1 (I930_G15_8 I930_G11_8n XI930_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I196_XG_MP2 (VDD I930_G25_10n I930_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I196_XG_MP0 (XI930_I196_XG_p1 I930_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I196_XG_MP1 (I930_G25_0 I930_G9_0n XI930_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I149_XG_MP2 (VDD I1666_G24_21n I1666_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I149_XG_MP0 (XI1666_I149_XG_p1 I1666_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I149_XG_MP1 (I1666_G24_17 I1666_G20_17n XI1666_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I192_XG_MP2 (VDD I1666_G22_7n I1666_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I192_XG_MP0 (XI1666_I192_XG_p1 I1666_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I192_XG_MP1 (I1666_G22_0 I1666_G6_0n XI1666_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I190_XG_MP2 (VDD I1666_G21_6n I1666_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I190_XG_MP0 (XI1666_I190_XG_p1 I1666_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I190_XG_MP1 (I1666_G21_0 I1666_G5_0n XI1666_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I146_XG_MP2 (VDD I1666_G21_18n I1666_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I146_XG_MP0 (XI1666_I146_XG_p1 I1666_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I146_XG_MP1 (I1666_G21_14 I1666_G17_14n XI1666_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I144_XG_MP2 (VDD I1666_G19_16n I1666_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I144_XG_MP0 (XI1666_I144_XG_p1 I1666_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I144_XG_MP1 (I1666_G19_12 I1666_G15_12n XI1666_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I140_XG_MP2 (VDD I1666_G15_12n I1666_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I140_XG_MP0 (XI1666_I140_XG_p1 I1666_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I140_XG_MP1 (I1666_G15_8 I1666_G11_8n XI1666_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I84_XG_MP2 (VDD I1666_gn18 I1666_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I84_XG_MP0 (XI1666_I84_XG_p1 I1666_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I84_XG_MP1 (I1666_G18_17 I1666_gn17 XI1666_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I83_XG_MP2 (VDD I1666_gn17 I1666_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I83_XG_MP0 (XI1666_I83_XG_p1 I1666_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I83_XG_MP1 (I1666_G17_16 I1666_gn16 XI1666_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I186_XG_MP2 (VDD I1620_G19_4n I1620_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I186_XG_MP0 (XI1620_I186_XG_p1 I1620_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I186_XG_MP1 (I1620_G19_0 I1620_G3_0n XI1620_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I142_XG_MP2 (VDD I1620_G17_14n I1620_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I142_XG_MP0 (XI1620_I142_XG_p1 I1620_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I142_XG_MP1 (I1620_G17_10 I1620_G13_10n XI1620_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I188_XG_MP2 (VDD I1620_G20_5n I1620_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I188_XG_MP0 (XI1620_I188_XG_p1 I1620_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I188_XG_MP1 (I1620_G20_0 I1620_G4_0n XI1620_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I145_XG_MP2 (VDD I1620_G20_17n I1620_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I145_XG_MP0 (XI1620_I145_XG_p1 I1620_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I145_XG_MP1 (I1620_G20_13 I1620_G16_13n XI1620_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I82_XG_MP2 (VDD I1620_gn16 I1620_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I82_XG_MP0 (XI1620_I82_XG_p1 I1620_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I82_XG_MP1 (I1620_G16_15 I1620_gn15 XI1620_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I83_XG_MP2 (VDD I1620_gn17 I1620_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I83_XG_MP0 (XI1620_I83_XG_p1 I1620_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I83_XG_MP1 (I1620_G17_16 I1620_gn16 XI1620_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I190_XG_MP2 (VDD I1574_G21_6n I1574_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I190_XG_MP0 (XI1574_I190_XG_p1 I1574_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I190_XG_MP1 (I1574_G21_0 I1574_G5_0n XI1574_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I140_XG_MP2 (VDD I1574_G15_12n I1574_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I140_XG_MP0 (XI1574_I140_XG_p1 I1574_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I140_XG_MP1 (I1574_G15_8 I1574_G11_8n XI1574_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I146_XG_MP2 (VDD I1574_G21_18n I1574_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I146_XG_MP0 (XI1574_I146_XG_p1 I1574_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I146_XG_MP1 (I1574_G21_14 I1574_G17_14n XI1574_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I82_XG_MP2 (VDD I1574_gn16 I1574_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I82_XG_MP0 (XI1574_I82_XG_p1 I1574_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I82_XG_MP1 (I1574_G16_15 I1574_gn15 XI1574_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I83_XG_MP2 (VDD I1574_gn17 I1574_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I83_XG_MP0 (XI1574_I83_XG_p1 I1574_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I83_XG_MP1 (I1574_G17_16 I1574_gn16 XI1574_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I192_XG_MP2 (VDD I1574_G22_7n I1574_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I192_XG_MP0 (XI1574_I192_XG_p1 I1574_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I192_XG_MP1 (I1574_G22_0 I1574_G6_0n XI1574_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I199_XG_MP2 (VDD I1574_G28_13n I1574_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I199_XG_MP0 (XI1574_I199_XG_p1 I1574_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I199_XG_MP1 (I1574_G28_0 I1574_G12_0n XI1574_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I149_XG_MP2 (VDD I1574_G24_21n I1574_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I149_XG_MP0 (XI1574_I149_XG_p1 I1574_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I149_XG_MP1 (I1574_G24_17 I1574_G20_17n XI1574_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I200_XG_MP2 (VDD I1022_G29_14n I1022_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I200_XG_MP0 (XI1022_I200_XG_p1 I1022_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I200_XG_MP1 (I1022_G29_0 I1022_G13_0n XI1022_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I146_XG_MP2 (VDD I1022_G21_18n I1022_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I146_XG_MP0 (XI1022_I146_XG_p1 I1022_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I146_XG_MP1 (I1022_G21_14 I1022_G17_14n XI1022_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I198_XG_MP2 (VDD I1022_G27_12n I1022_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I198_XG_MP0 (XI1022_I198_XG_p1 I1022_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I198_XG_MP1 (I1022_G27_0 I1022_G11_0n XI1022_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I144_XG_MP2 (VDD I1022_G19_16n I1022_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I144_XG_MP0 (XI1022_I144_XG_p1 I1022_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I144_XG_MP1 (I1022_G19_12 I1022_G15_12n XI1022_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I149_XG_MP2 (VDD I1022_G24_21n I1022_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I149_XG_MP0 (XI1022_I149_XG_p1 I1022_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I149_XG_MP1 (I1022_G24_17 I1022_G20_17n XI1022_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I84_XG_MP2 (VDD I1022_gn18 I1022_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I84_XG_MP0 (XI1022_I84_XG_p1 I1022_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I84_XG_MP1 (I1022_G18_17 I1022_gn17 XI1022_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I85_XG_MP2 (VDD I1022_gn19 I1022_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I85_XG_MP0 (XI1022_I85_XG_p1 I1022_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I85_XG_MP1 (I1022_G19_18 I1022_gn18 XI1022_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I83_XG_MP2 (VDD I1022_gn17 I1022_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I83_XG_MP0 (XI1022_I83_XG_p1 I1022_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I83_XG_MP1 (I1022_G17_16 I1022_gn16 XI1022_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I185_XG_MP2 (VDD I976_G18_3n I976_G18_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I185_XG_MP0 (XI976_I185_XG_p1 I976_P18_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I185_XG_MP1 (I976_G18_0 I976_G2_0n XI976_I185_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I141_XG_MP2 (VDD I976_G16_13n I976_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I141_XG_MP0 (XI976_I141_XG_p1 I976_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I141_XG_MP1 (I976_G16_9 I976_G12_9n XI976_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I139_XG_MP2 (VDD I976_G14_11n I976_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I139_XG_MP0 (XI976_I139_XG_p1 I976_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I139_XG_MP1 (I976_G14_7 I976_G10_7n XI976_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I142_XG_MP2 (VDD I976_G17_14n I976_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I142_XG_MP0 (XI976_I142_XG_p1 I976_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I142_XG_MP1 (I976_G17_10 I976_G13_10n XI976_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I82_XG_MP2 (VDD I976_gn16 I976_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I82_XG_MP0 (XI976_I82_XG_p1 I976_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I82_XG_MP1 (I976_G16_15 I976_gn15 XI976_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I83_XG_MP2 (VDD I976_gn17 I976_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I83_XG_MP0 (XI976_I83_XG_p1 I976_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I83_XG_MP1 (I976_G17_16 I976_gn16 XI976_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I85_XG_MP2 (VDD I930_gn19 I930_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I85_XG_MP0 (XI930_I85_XG_p1 I930_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I85_XG_MP1 (I930_G19_18 I930_gn18 XI930_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I192_XG_MP2 (VDD I930_G22_7n I930_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I192_XG_MP0 (XI930_I192_XG_p1 I930_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I192_XG_MP1 (I930_G22_0 I930_G6_0n XI930_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I197_XG_MP2 (VDD I930_G26_11n I930_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I197_XG_MP0 (XI930_I197_XG_p1 I930_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I197_XG_MP1 (I930_G26_0 I930_G10_0n XI930_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I194_XG_MP2 (VDD I930_G23_8n I930_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I194_XG_MP0 (XI930_I194_XG_p1 I930_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I194_XG_MP1 (I930_G23_0 I930_G7_0n XI930_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I202_XG_MP2 (VDD I930_G31_16n c8_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I202_XG_MP0 (XI930_I202_XG_p1 I930_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I202_XG_MP1 (c8_o I930_G15_0n XI930_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I146_XG_MP2 (VDD I930_G21_18n I930_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I146_XG_MP0 (XI930_I146_XG_p1 I930_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I146_XG_MP1 (I930_G21_14 I930_G17_14n XI930_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I190_XG_MP2 (VDD I930_G21_6n I930_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I190_XG_MP0 (XI930_I190_XG_p1 I930_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I190_XG_MP1 (I930_G21_0 I930_G5_0n XI930_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I153_XG_MP2 (VDD I1666_G28_25n I1666_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I153_XG_MP0 (XI1666_I153_XG_p1 I1666_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I153_XG_MP1 (I1666_G28_21 I1666_G24_21n XI1666_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I151_XG_MP2 (VDD I1666_G26_23n I1666_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I151_XG_MP0 (XI1666_I151_XG_p1 I1666_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I151_XG_MP1 (I1666_G26_19 I1666_G22_19n XI1666_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I147_XG_MP2 (VDD I1666_G22_19n I1666_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I147_XG_MP0 (XI1666_I147_XG_p1 I1666_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I147_XG_MP1 (I1666_G22_15 I1666_G18_15n XI1666_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I200_XG_MP2 (VDD I1666_G29_14n I1666_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I200_XG_MP0 (XI1666_I200_XG_p1 I1666_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I200_XG_MP1 (I1666_G29_0 I1666_G13_0n XI1666_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I150_XG_MP2 (VDD I1666_G25_22n I1666_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I150_XG_MP0 (XI1666_I150_XG_p1 I1666_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I150_XG_MP1 (I1666_G25_18 I1666_G21_18n XI1666_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I87_XG_MP2 (VDD I1666_gn21 I1666_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I87_XG_MP0 (XI1666_I87_XG_p1 I1666_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I87_XG_MP1 (I1666_G21_20 I1666_gn20 XI1666_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I85_XG_MP2 (VDD I1666_gn19 I1666_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I85_XG_MP0 (XI1666_I85_XG_p1 I1666_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I85_XG_MP1 (I1666_G19_18 I1666_gn18 XI1666_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I86_XG_MP2 (VDD I1666_gn20 I1666_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I86_XG_MP0 (XI1666_I86_XG_p1 I1666_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I86_XG_MP1 (I1666_G20_19 I1666_gn19 XI1666_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I144_XG_MP2 (VDD I1620_G19_16n I1620_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I144_XG_MP0 (XI1620_I144_XG_p1 I1620_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I144_XG_MP1 (I1620_G19_12 I1620_G15_12n XI1620_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I190_XG_MP2 (VDD I1620_G21_6n I1620_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I190_XG_MP0 (XI1620_I190_XG_p1 I1620_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I190_XG_MP1 (I1620_G21_0 I1620_G5_0n XI1620_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I146_XG_MP2 (VDD I1620_G21_18n I1620_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I146_XG_MP0 (XI1620_I146_XG_p1 I1620_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I146_XG_MP1 (I1620_G21_14 I1620_G17_14n XI1620_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I197_XG_MP2 (VDD I1620_G26_11n I1620_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I197_XG_MP0 (XI1620_I197_XG_p1 I1620_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I197_XG_MP1 (I1620_G26_0 I1620_G10_0n XI1620_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I149_XG_MP2 (VDD I1620_G24_21n I1620_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I149_XG_MP0 (XI1620_I149_XG_p1 I1620_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I149_XG_MP1 (I1620_G24_17 I1620_G20_17n XI1620_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I84_XG_MP2 (VDD I1620_gn18 I1620_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I84_XG_MP0 (XI1620_I84_XG_p1 I1620_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I84_XG_MP1 (I1620_G18_17 I1620_gn17 XI1620_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I85_XG_MP2 (VDD I1620_gn19 I1620_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I85_XG_MP0 (XI1620_I85_XG_p1 I1620_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I85_XG_MP1 (I1620_G19_18 I1620_gn18 XI1620_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I144_XG_MP2 (VDD I1574_G19_16n I1574_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I144_XG_MP0 (XI1574_I144_XG_p1 I1574_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I144_XG_MP1 (I1574_G19_12 I1574_G15_12n XI1574_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I150_XG_MP2 (VDD I1574_G25_22n I1574_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I150_XG_MP0 (XI1574_I150_XG_p1 I1574_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I150_XG_MP1 (I1574_G25_18 I1574_G21_18n XI1574_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I85_XG_MP2 (VDD I1574_gn19 I1574_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I85_XG_MP0 (XI1574_I85_XG_p1 I1574_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I85_XG_MP1 (I1574_G19_18 I1574_gn18 XI1574_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I84_XG_MP2 (VDD I1574_gn18 I1574_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I84_XG_MP0 (XI1574_I84_XG_p1 I1574_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I84_XG_MP1 (I1574_G18_17 I1574_gn17 XI1574_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I147_XG_MP2 (VDD I1574_G22_19n I1574_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I147_XG_MP0 (XI1574_I147_XG_p1 I1574_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I147_XG_MP1 (I1574_G22_15 I1574_G18_15n XI1574_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1114_I81_XG_MP2 (VDD I1114_gn15 I1114_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1114_I81_XG_MP0 (XI1114_I81_XG_p1 I1114_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1114_I81_XG_MP1 (I1114_G15_14 I1114_gn14 XI1114_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1114_I80_XG_MP2 (VDD I1114_gn14 I1114_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1114_I80_XG_MP0 (XI1114_I80_XG_p1 I1114_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1114_I80_XG_MP1 (I1114_G14_13 I1114_gn13 XI1114_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I150_XG_MP2 (VDD I1022_G25_22n I1022_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I150_XG_MP0 (XI1022_I150_XG_p1 I1022_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I150_XG_MP1 (I1022_G25_18 I1022_G21_18n XI1022_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I192_XG_MP2 (VDD I1022_G22_7n I1022_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I192_XG_MP0 (XI1022_I192_XG_p1 I1022_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I192_XG_MP1 (I1022_G22_0 I1022_G6_0n XI1022_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I151_XG_MP2 (VDD I1022_G26_23n I1022_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I151_XG_MP0 (XI1022_I151_XG_p1 I1022_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I151_XG_MP1 (I1022_G26_19 I1022_G22_19n XI1022_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I147_XG_MP2 (VDD I1022_G22_19n I1022_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I147_XG_MP0 (XI1022_I147_XG_p1 I1022_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I147_XG_MP1 (I1022_G22_15 I1022_G18_15n XI1022_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I87_XG_MP2 (VDD I1022_gn21 I1022_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I87_XG_MP0 (XI1022_I87_XG_p1 I1022_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I87_XG_MP1 (I1022_G21_20 I1022_gn20 XI1022_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I86_XG_MP2 (VDD I1022_gn20 I1022_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I86_XG_MP0 (XI1022_I86_XG_p1 I1022_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I86_XG_MP1 (I1022_G20_19 I1022_gn19 XI1022_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I188_XG_MP2 (VDD I976_G20_5n I976_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I188_XG_MP0 (XI976_I188_XG_p1 I976_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I188_XG_MP1 (I976_G20_0 I976_G4_0n XI976_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I143_XG_MP2 (VDD I976_G18_15n I976_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I143_XG_MP0 (XI976_I143_XG_p1 I976_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I143_XG_MP1 (I976_G18_11 I976_G14_11n XI976_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I186_XG_MP2 (VDD I976_G19_4n I976_G19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I186_XG_MP0 (XI976_I186_XG_p1 I976_P19_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I186_XG_MP1 (I976_G19_0 I976_G3_0n XI976_I186_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I196_XG_MP2 (VDD I976_G25_10n I976_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I196_XG_MP0 (XI976_I196_XG_p1 I976_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I196_XG_MP1 (I976_G25_0 I976_G9_0n XI976_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I144_XG_MP2 (VDD I976_G19_16n I976_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I144_XG_MP0 (XI976_I144_XG_p1 I976_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I144_XG_MP1 (I976_G19_12 I976_G15_12n XI976_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I84_XG_MP2 (VDD I976_gn18 I976_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I84_XG_MP0 (XI976_I84_XG_p1 I976_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I84_XG_MP1 (I976_G18_17 I976_gn17 XI976_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I85_XG_MP2 (VDD I976_gn19 I976_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I85_XG_MP0 (XI976_I85_XG_p1 I976_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I85_XG_MP1 (I976_G19_18 I976_gn18 XI976_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I86_XG_MP2 (VDD I930_gn20 I930_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I86_XG_MP0 (XI930_I86_XG_p1 I930_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I86_XG_MP1 (I930_G20_19 I930_gn19 XI930_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I147_XG_MP2 (VDD I930_G22_19n I930_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I147_XG_MP0 (XI930_I147_XG_p1 I930_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I147_XG_MP1 (I930_G22_15 I930_G18_15n XI930_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I151_XG_MP2 (VDD I930_G26_23n I930_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I151_XG_MP0 (XI930_I151_XG_p1 I930_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I151_XG_MP1 (I930_G26_19 I930_G22_19n XI930_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I87_XG_MP2 (VDD I930_gn21 I930_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I87_XG_MP0 (XI930_I87_XG_p1 I930_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I87_XG_MP1 (I930_G21_20 I930_gn20 XI930_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I148_XG_MP2 (VDD I930_G23_20n I930_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I148_XG_MP0 (XI930_I148_XG_p1 I930_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I148_XG_MP1 (I930_G23_16 I930_G19_16n XI930_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I198_XG_MP2 (VDD I930_G27_12n I930_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I198_XG_MP0 (XI930_I198_XG_p1 I930_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I198_XG_MP1 (I930_G27_0 I930_G11_0n XI930_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I150_XG_MP2 (VDD I930_G25_22n I930_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I150_XG_MP0 (XI930_I150_XG_p1 I930_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I150_XG_MP1 (I930_G25_18 I930_G21_18n XI930_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I201_XG_MP2 (VDD I1666_G30_15n c24_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I201_XG_MP0 (XI1666_I201_XG_p1 I1666_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I201_XG_MP1 (c24_m I1666_G14_0n XI1666_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I198_XG_MP2 (VDD I1666_G27_12n I1666_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I198_XG_MP0 (XI1666_I198_XG_p1 I1666_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I198_XG_MP1 (I1666_G27_0 I1666_G11_0n XI1666_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I194_XG_MP2 (VDD I1666_G23_8n I1666_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I194_XG_MP0 (XI1666_I194_XG_p1 I1666_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I194_XG_MP1 (I1666_G23_0 I1666_G7_0n XI1666_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I88_XG_MP2 (VDD I1666_gn22 I1666_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I88_XG_MP0 (XI1666_I88_XG_p1 I1666_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I88_XG_MP1 (I1666_G22_21 I1666_gn21 XI1666_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I196_XG_MP2 (VDD I1620_G25_10n I1620_G25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I196_XG_MP0 (XI1620_I196_XG_p1 I1620_P25_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I196_XG_MP1 (I1620_G25_0 I1620_G9_0n XI1620_I196_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I150_XG_MP2 (VDD I1620_G25_22n I1620_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I150_XG_MP0 (XI1620_I150_XG_p1 I1620_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I150_XG_MP1 (I1620_G25_18 I1620_G21_18n XI1620_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I192_XG_MP2 (VDD I1620_G22_7n I1620_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I192_XG_MP0 (XI1620_I192_XG_p1 I1620_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I192_XG_MP1 (I1620_G22_0 I1620_G6_0n XI1620_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I151_XG_MP2 (VDD I1620_G26_23n I1620_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I151_XG_MP0 (XI1620_I151_XG_p1 I1620_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I151_XG_MP1 (I1620_G26_19 I1620_G22_19n XI1620_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I147_XG_MP2 (VDD I1620_G22_19n I1620_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I147_XG_MP0 (XI1620_I147_XG_p1 I1620_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I147_XG_MP1 (I1620_G22_15 I1620_G18_15n XI1620_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I87_XG_MP2 (VDD I1620_gn21 I1620_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I87_XG_MP0 (XI1620_I87_XG_p1 I1620_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I87_XG_MP1 (I1620_G21_20 I1620_gn20 XI1620_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I86_XG_MP2 (VDD I1620_gn20 I1620_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I86_XG_MP0 (XI1620_I86_XG_p1 I1620_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I86_XG_MP1 (I1620_G20_19 I1620_gn19 XI1620_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I194_XG_MP2 (VDD I1574_G23_8n I1574_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I194_XG_MP0 (XI1574_I194_XG_p1 I1574_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I194_XG_MP1 (I1574_G23_0 I1574_G7_0n XI1574_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I200_XG_MP2 (VDD I1574_G29_14n I1574_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I200_XG_MP0 (XI1574_I200_XG_p1 I1574_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I200_XG_MP1 (I1574_G29_0 I1574_G13_0n XI1574_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I86_XG_MP2 (VDD I1574_gn20 I1574_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I86_XG_MP0 (XI1574_I86_XG_p1 I1574_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I86_XG_MP1 (I1574_G20_19 I1574_gn19 XI1574_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I87_XG_MP2 (VDD I1574_gn21 I1574_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I87_XG_MP0 (XI1574_I87_XG_p1 I1574_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I87_XG_MP1 (I1574_G21_20 I1574_gn20 XI1574_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I201_XG_MP2 (VDD I1574_G30_15n c22_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I201_XG_MP0 (XI1574_I201_XG_p1 I1574_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I201_XG_MP1 (c22_m I1574_G14_0n XI1574_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I153_XG_MP2 (VDD I1574_G28_25n I1574_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I153_XG_MP0 (XI1574_I153_XG_p1 I1574_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I153_XG_MP1 (I1574_G28_21 I1574_G24_21n XI1574_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I151_XG_MP2 (VDD I1574_G26_23n I1574_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I151_XG_MP0 (XI1574_I151_XG_p1 I1574_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I151_XG_MP1 (I1574_G26_19 I1574_G22_19n XI1574_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1114_I95_XG_MP2 (VDD I1114_gn29 I1114_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1114_I95_XG_MP0 (XI1114_I95_XG_p1 I1114_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1114_I95_XG_MP1 (I1114_G29_28 I1114_gn28 XI1114_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1114_I93_XG_MP2 (VDD I1114_gn27 I1114_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1114_I93_XG_MP0 (XI1114_I93_XG_p1 I1114_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1114_I93_XG_MP1 (I1114_G27_26 I1114_gn26 XI1114_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1114_I94_XG_MP2 (VDD I1114_gn28 I1114_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1114_I94_XG_MP0 (XI1114_I94_XG_p1 I1114_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1114_I94_XG_MP1 (I1114_G28_27 I1114_gn27 XI1114_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1114_I92_XG_MP2 (VDD I1114_gn26 I1114_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1114_I92_XG_MP0 (XI1114_I92_XG_p1 I1114_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1114_I92_XG_MP1 (I1114_G26_25 I1114_gn25 XI1114_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1114_I91_XG_MP2 (VDD I1114_gn25 I1114_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1114_I91_XG_MP0 (XI1114_I91_XG_p1 I1114_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1114_I91_XG_MP1 (I1114_G25_24 I1114_gn24 XI1114_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1114_I90_XG_MP2 (VDD I1114_gn24 I1114_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1114_I90_XG_MP0 (XI1114_I90_XG_p1 I1114_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1114_I90_XG_MP1 (I1114_G24_23 I1114_gn23 XI1114_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1114_I89_XG_MP2 (VDD I1114_gn23 I1114_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1114_I89_XG_MP0 (XI1114_I89_XG_p1 I1114_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1114_I89_XG_MP1 (I1114_G23_22 I1114_gn22 XI1114_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1114_I88_XG_MP2 (VDD I1114_gn22 I1114_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1114_I88_XG_MP0 (XI1114_I88_XG_p1 I1114_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1114_I88_XG_MP1 (I1114_G22_21 I1114_gn21 XI1114_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1114_I87_XG_MP2 (VDD I1114_gn21 I1114_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1114_I87_XG_MP0 (XI1114_I87_XG_p1 I1114_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1114_I87_XG_MP1 (I1114_G21_20 I1114_gn20 XI1114_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1114_I86_XG_MP2 (VDD I1114_gn20 I1114_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1114_I86_XG_MP0 (XI1114_I86_XG_p1 I1114_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1114_I86_XG_MP1 (I1114_G20_19 I1114_gn19 XI1114_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1114_I85_XG_MP2 (VDD I1114_gn19 I1114_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1114_I85_XG_MP0 (XI1114_I85_XG_p1 I1114_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1114_I85_XG_MP1 (I1114_G19_18 I1114_gn18 XI1114_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1114_I84_XG_MP2 (VDD I1114_gn18 I1114_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1114_I84_XG_MP0 (XI1114_I84_XG_p1 I1114_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1114_I84_XG_MP1 (I1114_G18_17 I1114_gn17 XI1114_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1114_I83_XG_MP2 (VDD I1114_gn17 I1114_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1114_I83_XG_MP0 (XI1114_I83_XG_p1 I1114_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1114_I83_XG_MP1 (I1114_G17_16 I1114_gn16 XI1114_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1114_I82_XG_MP2 (VDD I1114_gn16 I1114_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1114_I82_XG_MP0 (XI1114_I82_XG_p1 I1114_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1114_I82_XG_MP1 (I1114_G16_15 I1114_gn15 XI1114_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1114_I79_XG_MP2 (VDD I1114_gn13 I1114_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1114_I79_XG_MP0 (XI1114_I79_XG_p1 I1114_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1114_I79_XG_MP1 (I1114_G13_12 I1114_gn12 XI1114_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1114_I78_XG_MP2 (VDD I1114_gn12 I1114_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1114_I78_XG_MP0 (XI1114_I78_XG_p1 I1114_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1114_I78_XG_MP1 (I1114_G12_11 I1114_gn11 XI1114_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1114_I77_XG_MP2 (VDD I1114_gn11 I1114_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1114_I77_XG_MP0 (XI1114_I77_XG_p1 I1114_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1114_I77_XG_MP1 (I1114_G11_10 I1114_gn10 XI1114_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I154_XG_MP2 (VDD I1022_G29_26n I1022_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I154_XG_MP0 (XI1022_I154_XG_p1 I1022_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I154_XG_MP1 (I1022_G29_22 I1022_G25_22n XI1022_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I194_XG_MP2 (VDD I1022_G23_8n I1022_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I194_XG_MP0 (XI1022_I194_XG_p1 I1022_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I194_XG_MP1 (I1022_G23_0 I1022_G7_0n XI1022_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I148_XG_MP2 (VDD I1022_G23_20n I1022_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I148_XG_MP0 (XI1022_I148_XG_p1 I1022_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I148_XG_MP1 (I1022_G23_16 I1022_G19_16n XI1022_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I152_XG_MP2 (VDD I1022_G27_24n I1022_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I152_XG_MP0 (XI1022_I152_XG_p1 I1022_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I152_XG_MP1 (I1022_G27_20 I1022_G23_20n XI1022_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I199_XG_MP2 (VDD I1022_G28_13n I1022_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I199_XG_MP0 (XI1022_I199_XG_p1 I1022_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I199_XG_MP1 (I1022_G28_0 I1022_G12_0n XI1022_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I153_XG_MP2 (VDD I1022_G28_25n I1022_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I153_XG_MP0 (XI1022_I153_XG_p1 I1022_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I153_XG_MP1 (I1022_G28_21 I1022_G24_21n XI1022_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I88_XG_MP2 (VDD I1022_gn22 I1022_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I88_XG_MP0 (XI1022_I88_XG_p1 I1022_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I88_XG_MP1 (I1022_G22_21 I1022_gn21 XI1022_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1022_I89_XG_MP2 (VDD I1022_gn23 I1022_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1022_I89_XG_MP0 (XI1022_I89_XG_p1 I1022_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1022_I89_XG_MP1 (I1022_G23_22 I1022_gn22 XI1022_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I195_XG_MP2 (VDD I976_G24_9n I976_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I195_XG_MP0 (XI976_I195_XG_p1 I976_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I195_XG_MP1 (I976_G24_0 I976_G8_0n XI976_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I145_XG_MP2 (VDD I976_G20_17n I976_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I145_XG_MP0 (XI976_I145_XG_p1 I976_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I145_XG_MP1 (I976_G20_13 I976_G16_13n XI976_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I149_XG_MP2 (VDD I976_G24_21n I976_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I149_XG_MP0 (XI976_I149_XG_p1 I976_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I149_XG_MP1 (I976_G24_17 I976_G20_17n XI976_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I190_XG_MP2 (VDD I976_G21_6n I976_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I190_XG_MP0 (XI976_I190_XG_p1 I976_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I190_XG_MP1 (I976_G21_0 I976_G5_0n XI976_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I150_XG_MP2 (VDD I976_G25_22n I976_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I150_XG_MP0 (XI976_I150_XG_p1 I976_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I150_XG_MP1 (I976_G25_18 I976_G21_18n XI976_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I146_XG_MP2 (VDD I976_G21_18n I976_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I146_XG_MP0 (XI976_I146_XG_p1 I976_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I146_XG_MP1 (I976_G21_14 I976_G17_14n XI976_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I87_XG_MP2 (VDD I976_gn21 I976_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I87_XG_MP0 (XI976_I87_XG_p1 I976_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I87_XG_MP1 (I976_G21_20 I976_gn20 XI976_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI976_I86_XG_MP2 (VDD I976_gn20 I976_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI976_I86_XG_MP0 (XI976_I86_XG_p1 I976_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI976_I86_XG_MP1 (I976_G20_19 I976_gn19 XI976_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I199_XG_MP2 (VDD I930_G28_13n I930_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I199_XG_MP0 (XI930_I199_XG_p1 I930_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I199_XG_MP1 (I930_G28_0 I930_G12_0n XI930_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I88_XG_MP2 (VDD I930_gn22 I930_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I88_XG_MP0 (XI930_I88_XG_p1 I930_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I88_XG_MP1 (I930_G22_21 I930_gn21 XI930_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I152_XG_MP2 (VDD I930_G27_24n I930_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I152_XG_MP0 (XI930_I152_XG_p1 I930_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I152_XG_MP1 (I930_G27_20 I930_G23_20n XI930_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI930_I200_XG_MP2 (VDD I930_G29_14n I930_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI930_I200_XG_MP0 (XI930_I200_XG_p1 I930_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI930_I200_XG_MP1 (I930_G29_0 I930_G13_0n XI930_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I90_XG_MP2 (VDD I1666_gn24 I1666_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I90_XG_MP0 (XI1666_I90_XG_p1 I1666_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I90_XG_MP1 (I1666_G24_23 I1666_gn23 XI1666_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I91_XG_MP2 (VDD I1666_gn25 I1666_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I91_XG_MP0 (XI1666_I91_XG_p1 I1666_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I91_XG_MP1 (I1666_G25_24 I1666_gn24 XI1666_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I155_XG_MP2 (VDD I1666_G30_27n I1666_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I155_XG_MP0 (XI1666_I155_XG_p1 I1666_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I155_XG_MP1 (I1666_G30_23 I1666_G26_23n XI1666_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I154_XG_MP2 (VDD I1666_G29_26n I1666_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I154_XG_MP0 (XI1666_I154_XG_p1 I1666_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I154_XG_MP1 (I1666_G29_22 I1666_G25_22n XI1666_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I152_XG_MP2 (VDD I1666_G27_24n I1666_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I152_XG_MP0 (XI1666_I152_XG_p1 I1666_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I152_XG_MP1 (I1666_G27_20 I1666_G23_20n XI1666_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I148_XG_MP2 (VDD I1666_G23_20n I1666_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I148_XG_MP0 (XI1666_I148_XG_p1 I1666_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I148_XG_MP1 (I1666_G23_16 I1666_G19_16n XI1666_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1666_I89_XG_MP2 (VDD I1666_gn23 I1666_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1666_I89_XG_MP0 (XI1666_I89_XG_p1 I1666_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1666_I89_XG_MP1 (I1666_G23_22 I1666_gn22 XI1666_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I194_XG_MP2 (VDD I1620_G23_8n I1620_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I194_XG_MP0 (XI1620_I194_XG_p1 I1620_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I194_XG_MP1 (I1620_G23_0 I1620_G7_0n XI1620_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I148_XG_MP2 (VDD I1620_G23_20n I1620_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I148_XG_MP0 (XI1620_I148_XG_p1 I1620_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I148_XG_MP1 (I1620_G23_16 I1620_G19_16n XI1620_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I200_XG_MP2 (VDD I1620_G29_14n I1620_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I200_XG_MP0 (XI1620_I200_XG_p1 I1620_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I200_XG_MP1 (I1620_G29_0 I1620_G13_0n XI1620_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I199_XG_MP2 (VDD I1620_G28_13n I1620_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I199_XG_MP0 (XI1620_I199_XG_p1 I1620_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I199_XG_MP1 (I1620_G28_0 I1620_G12_0n XI1620_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I153_XG_MP2 (VDD I1620_G28_25n I1620_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I153_XG_MP0 (XI1620_I153_XG_p1 I1620_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I153_XG_MP1 (I1620_G28_21 I1620_G24_21n XI1620_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I88_XG_MP2 (VDD I1620_gn22 I1620_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I88_XG_MP0 (XI1620_I88_XG_p1 I1620_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I88_XG_MP1 (I1620_G22_21 I1620_gn21 XI1620_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I89_XG_MP2 (VDD I1620_gn23 I1620_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I89_XG_MP0 (XI1620_I89_XG_p1 I1620_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I89_XG_MP1 (I1620_G23_22 I1620_gn22 XI1620_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1620_I90_XG_MP2 (VDD I1620_gn24 I1620_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1620_I90_XG_MP0 (XI1620_I90_XG_p1 I1620_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1620_I90_XG_MP1 (I1620_G24_23 I1620_gn23 XI1620_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I198_XG_MP2 (VDD I1574_G27_12n I1574_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I198_XG_MP0 (XI1574_I198_XG_p1 I1574_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I198_XG_MP1 (I1574_G27_0 I1574_G11_0n XI1574_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I152_XG_MP2 (VDD I1574_G27_24n I1574_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I152_XG_MP0 (XI1574_I152_XG_p1 I1574_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I152_XG_MP1 (I1574_G27_20 I1574_G23_20n XI1574_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I148_XG_MP2 (VDD I1574_G23_20n I1574_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08158p pd=0.92u ps=1.16u
    I_MXI1574_I148_XG_MP0 (XI1574_I148_XG_p1 I1574_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10558p as=0.09358p pd=0.92u ps=0.92u
    I_MXI1574_I148_XG_MP1 (I1574_G23_16 I1574_G19_16n XI1574_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16318p as=0.10558p pd=1.64u ps=0.92u
    I_MXI1574_I88_XG_MP2 (VDD I1574_gn22 I1574_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09358p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1574_I88_XG_MP0 (XI1574_I88_XG_p1 I1574_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1574_I88_XG_MP1 (I1574_G22_21 I1574_gn21 XI1574_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1574_I89_XG_MP2 (VDD I1574_gn23 I1574_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1574_I89_XG_MP0 (XI1574_I89_XG_p1 I1574_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1574_I89_XG_MP1 (I1574_G23_22 I1574_gn22 XI1574_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1574_I155_XG_MP2 (VDD I1574_G30_27n I1574_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1574_I155_XG_MP0 (XI1574_I155_XG_p1 I1574_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1574_I155_XG_MP1 (I1574_G30_23 I1574_G26_23n XI1574_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I96_XG_MP2 (VDD I1114_gn30 I1114_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I96_XG_MP0 (XI1114_I96_XG_p1 I1114_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I96_XG_MP1 (I1114_G30_29 I1114_gn29 XI1114_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I155_XG_MP2 (VDD I1114_G30_27n I1114_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I155_XG_MP0 (XI1114_I155_XG_p1 I1114_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I155_XG_MP1 (I1114_G30_23 I1114_G26_23n XI1114_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I153_XG_MP2 (VDD I1114_G28_25n I1114_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I153_XG_MP0 (XI1114_I153_XG_p1 I1114_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I153_XG_MP1 (I1114_G28_21 I1114_G24_21n XI1114_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I151_XG_MP2 (VDD I1114_G26_23n I1114_G26_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I151_XG_MP0 (XI1114_I151_XG_p1 I1114_P26_23n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I151_XG_MP1 (I1114_G26_19 I1114_G22_19n XI1114_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I149_XG_MP2 (VDD I1114_G24_21n I1114_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I149_XG_MP0 (XI1114_I149_XG_p1 I1114_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I149_XG_MP1 (I1114_G24_17 I1114_G20_17n XI1114_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I145_XG_MP2 (VDD I1114_G20_17n I1114_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I145_XG_MP0 (XI1114_I145_XG_p1 I1114_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I145_XG_MP1 (I1114_G20_13 I1114_G16_13n XI1114_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I143_XG_MP2 (VDD I1114_G18_15n I1114_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I143_XG_MP0 (XI1114_I143_XG_p1 I1114_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I143_XG_MP1 (I1114_G18_11 I1114_G14_11n XI1114_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I141_XG_MP2 (VDD I1114_G16_13n I1114_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I141_XG_MP0 (XI1114_I141_XG_p1 I1114_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I141_XG_MP1 (I1114_G16_9 I1114_G12_9n XI1114_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I76_XG_MP2 (VDD I1114_gn10 I1114_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I76_XG_MP0 (XI1114_I76_XG_p1 I1114_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I76_XG_MP1 (I1114_G10_9 I1114_gn9 XI1114_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I75_XG_MP2 (VDD I1114_gn9 I1114_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I75_XG_MP0 (XI1114_I75_XG_p1 I1114_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I75_XG_MP1 (I1114_G9_8 I1114_gn8 XI1114_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I74_XG_MP2 (VDD I1114_gn8 I1114_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I74_XG_MP0 (XI1114_I74_XG_p1 I1114_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I74_XG_MP1 (I1114_G8_7 I1114_gn7 XI1114_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1114_I73_XG_MP2 (VDD I1114_gn7 I1114_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1114_I73_XG_MP0 (XI1114_I73_XG_p1 I1114_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1114_I73_XG_MP1 (I1114_G7_6 I1114_gn6 XI1114_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1022_I202_XG_MP2 (VDD I1022_G31_16n c10_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1022_I202_XG_MP0 (XI1022_I202_XG_p1 I1022_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1022_I202_XG_MP1 (c10_o I1022_G15_0n XI1022_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1022_I201_XG_MP2 (VDD I1022_G30_15n c10_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1022_I201_XG_MP0 (XI1022_I201_XG_p1 I1022_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1022_I201_XG_MP1 (c10_m I1022_G14_0n XI1022_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1022_I155_XG_MP2 (VDD I1022_G30_27n I1022_G30_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1022_I155_XG_MP0 (XI1022_I155_XG_p1 I1022_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1022_I155_XG_MP1 (I1022_G30_23 I1022_G26_23n XI1022_I155_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1022_I90_XG_MP2 (VDD I1022_gn24 I1022_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1022_I90_XG_MP0 (XI1022_I90_XG_p1 I1022_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1022_I90_XG_MP1 (I1022_G24_23 I1022_gn23 XI1022_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI1022_I91_XG_MP2 (VDD I1022_gn25 I1022_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI1022_I91_XG_MP0 (XI1022_I91_XG_p1 I1022_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI1022_I91_XG_MP1 (I1022_G25_24 I1022_gn24 XI1022_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I192_XG_MP2 (VDD I976_G22_7n I976_G22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I192_XG_MP0 (XI976_I192_XG_p1 I976_P22_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I192_XG_MP1 (I976_G22_0 I976_G6_0n XI976_I192_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I147_XG_MP2 (VDD I976_G22_19n I976_G22_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I147_XG_MP0 (XI976_I147_XG_p1 I976_P22_19n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I147_XG_MP1 (I976_G22_15 I976_G18_15n XI976_I147_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I194_XG_MP2 (VDD I976_G23_8n I976_G23_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I194_XG_MP0 (XI976_I194_XG_p1 I976_P23_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I194_XG_MP1 (I976_G23_0 I976_G7_0n XI976_I194_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI976_I88_XG_MP2 (VDD I976_gn22 I976_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI976_I88_XG_MP0 (XI976_I88_XG_p1 I976_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI976_I88_XG_MP1 (I976_G22_21 I976_gn21 XI976_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI930_I153_XG_MP2 (VDD I930_G28_25n I930_G28_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI930_I153_XG_MP0 (XI930_I153_XG_p1 I930_P28_25n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI930_I153_XG_MP1 (I930_G28_21 I930_G24_21n XI930_I153_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI930_I89_XG_MP2 (VDD I930_gn23 I930_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI930_I89_XG_MP0 (XI930_I89_XG_p1 I930_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
    I_MXI930_I89_XG_MP1 (I930_G23_22 I930_gn22 XI930_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16317p as=0.10557p pd=1.64u ps=0.92u
    I_MXI930_I90_XG_MP2 (VDD I930_gn24 I930_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.09357p as=0.08157p pd=0.92u ps=1.16u
    I_MXI930_I90_XG_MP0 (XI930_I90_XG_p1 I930_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10557p as=0.09357p pd=0.92u ps=0.92u
