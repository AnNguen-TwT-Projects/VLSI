    I_MXI1747_MP0 (VDD dd21_b3_4 XI1747_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1744_MP1 (VDD qu6_b3_3 XI1744_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1744_MP5 (b26_18 XI1744_Bn XI1744_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1744_MP4 (XI1744_p1 XI1744_An b26_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1744_MP2 (VDD dd18_b3_4 XI1744_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1744_MP3 (XI1744_p1 qu6_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1744_MP0 (VDD dd18_b3_4 XI1744_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1760_MP1 (VDD c26_o XI1760_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1760_MP5 (p26_32 XI1760_Bn XI1760_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1760_MP4 (XI1760_p1 XI1760_An p26_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1760_MP2 (VDD h26 XI1760_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1760_MP3 (XI1760_p1 c26_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1760_MP0 (VDD h26 XI1760_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1759_MP1 (VDD qu6_b3_5 XI1759_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1759_MP5 (h26 XI1759_Bn XI1759_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1759_MP4 (XI1759_p1 XI1759_An h26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1759_MP2 (VDD p25_31 XI1759_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1759_MP3 (XI1759_p1 qu6_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1759_MP0 (VDD p25_31 XI1759_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1793_MP1 (VDD qu5_b3_3 XI1793_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1793_MP5 (b27_21 XI1793_Bn XI1793_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1793_MP4 (XI1793_p1 XI1793_An b27_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1793_MP2 (VDD dd21_b3_4 XI1793_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1793_MP3 (XI1793_p1 qu5_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1793_MP0 (VDD dd21_b3_4 XI1793_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1790_MP1 (VDD qu5_b3_3 XI1790_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1790_MP5 (b27_18 XI1790_Bn XI1790_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1790_MP4 (XI1790_p1 XI1790_An b27_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1790_MP2 (VDD dd18_b3_4 XI1790_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1790_MP3 (XI1790_p1 qu5_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1790_MP0 (VDD dd18_b3_4 XI1790_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1794_MP1 (VDD qu5_b3_3 XI1794_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1794_MP5 (b27_22 XI1794_Bn XI1794_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1794_MP4 (XI1794_p1 XI1794_An b27_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1794_MP2 (VDD dd22_b3_4 XI1794_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1794_MP3 (XI1794_p1 qu5_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1794_MP0 (VDD dd22_b3_4 XI1794_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1041_MP1 (VDD qu21_b3_0 XI1041_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1041_MP5 (b11_5 XI1041_Bn XI1041_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1041_MP4 (XI1041_p1 XI1041_An b11_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1041_MP2 (VDD dd5_b3_2 XI1041_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1041_MP3 (XI1041_p1 qu21_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1041_MP0 (VDD dd5_b3_2 XI1041_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1040_MP1 (VDD qu21_b3_0 XI1040_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1040_MP5 (b11_4 XI1040_Bn XI1040_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1040_MP4 (XI1040_p1 XI1040_An b11_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1040_MP2 (VDD dd4_b3_2 XI1040_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1040_MP3 (XI1040_p1 qu21_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1040_MP0 (VDD dd4_b3_2 XI1040_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI837_MP1 (VDD qu26_b3_5 XI837_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI837_MP5 (b6_31 XI837_Bn XI837_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI837_MP4 (XI837_p1 XI837_An b6_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI837_MP2 (VDD dd31_b3_1 XI837_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI837_MP3 (XI837_p1 qu26_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI837_MP0 (VDD dd31_b3_1 XI837_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI836_MP1 (VDD qu26_b3_5 XI836_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI836_MP5 (b6_30 XI836_Bn XI836_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI836_MP4 (XI836_p1 XI836_An b6_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI836_MP2 (VDD dd30_b3_1 XI836_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI836_MP3 (XI836_p1 qu26_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI836_MP0 (VDD dd30_b3_1 XI836_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI835_MP1 (VDD qu26_b3_4 XI835_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI835_MP5 (b6_29 XI835_Bn XI835_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI835_MP4 (XI835_p1 XI835_An b6_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI835_MP2 (VDD dd29_b3_1 XI835_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI835_MP3 (XI835_p1 qu26_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI835_MP0 (VDD dd29_b3_1 XI835_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI832_MP1 (VDD qu26_b3_4 XI832_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI832_MP5 (b6_26 XI832_Bn XI832_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI832_MP4 (XI832_p1 XI832_An b6_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI832_MP2 (VDD dd26_b3_1 XI832_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI832_MP3 (XI832_p1 qu26_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI832_MP0 (VDD dd26_b3_1 XI832_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI830_MP1 (VDD qu26_b3_4 XI830_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI830_MP5 (b6_24 XI830_Bn XI830_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI830_MP4 (XI830_p1 XI830_An b6_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI830_MP2 (VDD dd24_b3_1 XI830_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI830_MP3 (XI830_p1 qu26_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI830_MP0 (VDD dd24_b3_1 XI830_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI829_MP1 (VDD qu26_b3_3 XI829_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI829_MP5 (b6_23 XI829_Bn XI829_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI829_MP4 (XI829_p1 XI829_An b6_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI829_MP2 (VDD dd23_b3_1 XI829_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI829_MP3 (XI829_p1 qu26_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI829_MP0 (VDD dd23_b3_1 XI829_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI828_MP1 (VDD qu26_b3_3 XI828_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI828_MP5 (b6_22 XI828_Bn XI828_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI828_MP4 (XI828_p1 XI828_An b6_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI828_MP2 (VDD dd22_b3_1 XI828_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI828_MP3 (XI828_p1 qu26_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI828_MP0 (VDD dd22_b3_1 XI828_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI827_MP1 (VDD qu26_b3_3 XI827_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI827_MP5 (b6_21 XI827_Bn XI827_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI827_MP4 (XI827_p1 XI827_An b6_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI827_MP2 (VDD dd21_b3_1 XI827_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI827_MP3 (XI827_p1 qu26_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI827_MP0 (VDD dd21_b3_1 XI827_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI882_MP1 (VDD qu25_b3_5 XI882_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI882_MP5 (b7_30 XI882_Bn XI882_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI882_MP4 (XI882_p1 XI882_An b7_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI882_MP2 (VDD dd30_b3_1 XI882_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI882_MP3 (XI882_p1 qu25_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI882_MP0 (VDD dd30_b3_1 XI882_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI874_MP1 (VDD qu25_b3_3 XI874_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI874_MP5 (b7_22 XI874_Bn XI874_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI874_MP4 (XI874_p1 XI874_An b7_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI874_MP2 (VDD dd22_b3_1 XI874_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI874_MP3 (XI874_p1 qu25_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI874_MP0 (VDD dd22_b3_1 XI874_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI886_MP1 (VDD c7_o XI886_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI886_MP5 (p7_32 XI886_Bn XI886_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI886_MP4 (XI886_p1 XI886_An p7_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI886_MP2 (VDD h7 XI886_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI886_MP3 (XI886_p1 c7_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI886_MP0 (VDD h7 XI886_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI876_MP1 (VDD qu25_b3_4 XI876_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI876_MP5 (b7_24 XI876_Bn XI876_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI876_MP4 (XI876_p1 XI876_An b7_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI876_MP2 (VDD dd24_b3_1 XI876_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI876_MP3 (XI876_p1 qu25_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI876_MP0 (VDD dd24_b3_1 XI876_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI878_MP1 (VDD qu25_b3_4 XI878_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI878_MP5 (b7_26 XI878_Bn XI878_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI878_MP4 (XI878_p1 XI878_An b7_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI878_MP2 (VDD dd26_b3_1 XI878_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI878_MP3 (XI878_p1 qu25_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI878_MP0 (VDD dd26_b3_1 XI878_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1700_MP1 (VDD qu7_b3_3 XI1700_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1700_MP5 (b25_20 XI1700_Bn XI1700_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1700_MP4 (XI1700_p1 XI1700_An b25_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1700_MP2 (VDD dd20_b3_4 XI1700_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1700_MP3 (XI1700_p1 qu7_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1700_MP0 (VDD dd20_b3_4 XI1700_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1702_MP1 (VDD qu7_b3_3 XI1702_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1702_MP5 (b25_22 XI1702_Bn XI1702_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1702_MP4 (XI1702_p1 XI1702_An b25_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1702_MP2 (VDD dd22_b3_4 XI1702_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1702_MP3 (XI1702_p1 qu7_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1702_MP0 (VDD dd22_b3_4 XI1702_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1701_MP1 (VDD qu7_b3_3 XI1701_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1701_MP5 (b25_21 XI1701_Bn XI1701_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1701_MP4 (XI1701_p1 XI1701_An b25_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1701_MP2 (VDD dd21_b3_4 XI1701_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1701_MP3 (XI1701_p1 qu7_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1701_MP0 (VDD dd21_b3_4 XI1701_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1713_MP1 (VDD qu7_b3_5 XI1713_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1713_MP5 (h25 XI1713_Bn XI1713_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1713_MP4 (XI1713_p1 XI1713_An h25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1713_MP2 (VDD p24_31 XI1713_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1713_MP3 (XI1713_p1 qu7_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1713_MP0 (VDD p24_31 XI1713_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1749_MP1 (VDD qu6_b3_3 XI1749_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1749_MP5 (b26_23 XI1749_Bn XI1749_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1749_MP4 (XI1749_p1 XI1749_An b26_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1749_MP2 (VDD dd23_b3_4 XI1749_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1749_MP3 (XI1749_p1 qu6_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1749_MP0 (VDD dd23_b3_4 XI1749_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1750_MP1 (VDD qu6_b3_4 XI1750_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1750_MP5 (b26_24 XI1750_Bn XI1750_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1750_MP4 (XI1750_p1 XI1750_An b26_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1750_MP2 (VDD dd24_b3_4 XI1750_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1750_MP3 (XI1750_p1 qu6_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1750_MP0 (VDD dd24_b3_4 XI1750_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1756_MP1 (VDD qu6_b3_5 XI1756_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1756_MP5 (b26_30 XI1756_Bn XI1756_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1756_MP4 (XI1756_p1 XI1756_An b26_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1756_MP2 (VDD dd30_b3_4 XI1756_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1756_MP3 (XI1756_p1 qu6_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1756_MP0 (VDD dd30_b3_4 XI1756_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1757_MP1 (VDD qu6_b3_5 XI1757_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1757_MP5 (b26_31 XI1757_Bn XI1757_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1757_MP4 (XI1757_p1 XI1757_An b26_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1757_MP2 (VDD dd31_b3_4 XI1757_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1757_MP3 (XI1757_p1 qu6_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1757_MP0 (VDD dd31_b3_4 XI1757_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1803_MP1 (VDD qu5_b3_5 XI1803_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1803_MP5 (b27_31 XI1803_Bn XI1803_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1803_MP4 (XI1803_p1 XI1803_An b27_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1803_MP2 (VDD dd31_b3_4 XI1803_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1803_MP3 (XI1803_p1 qu5_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1803_MP0 (VDD dd31_b3_4 XI1803_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1795_MP1 (VDD qu5_b3_3 XI1795_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1795_MP5 (b27_23 XI1795_Bn XI1795_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1795_MP4 (XI1795_p1 XI1795_An b27_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1795_MP2 (VDD dd23_b3_4 XI1795_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1795_MP3 (XI1795_p1 qu5_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1795_MP0 (VDD dd23_b3_4 XI1795_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1802_MP1 (VDD qu5_b3_5 XI1802_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1802_MP5 (b27_30 XI1802_Bn XI1802_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1802_MP4 (XI1802_p1 XI1802_An b27_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1802_MP2 (VDD dd30_b3_4 XI1802_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1802_MP3 (XI1802_p1 qu5_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1802_MP0 (VDD dd30_b3_4 XI1802_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1796_MP1 (VDD qu5_b3_4 XI1796_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1796_MP5 (b27_24 XI1796_Bn XI1796_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1796_MP4 (XI1796_p1 XI1796_An b27_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1796_MP2 (VDD dd24_b3_4 XI1796_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1796_MP3 (XI1796_p1 qu5_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1796_MP0 (VDD dd24_b3_4 XI1796_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1800_MP1 (VDD qu5_b3_4 XI1800_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1800_MP5 (b27_28 XI1800_Bn XI1800_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1800_MP4 (XI1800_p1 XI1800_An b27_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1800_MP2 (VDD dd28_b3_4 XI1800_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1800_MP3 (XI1800_p1 qu5_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1800_MP0 (VDD dd28_b3_4 XI1800_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1799_MP1 (VDD qu5_b3_4 XI1799_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1799_MP5 (b27_27 XI1799_Bn XI1799_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1799_MP4 (XI1799_p1 XI1799_An b27_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1799_MP2 (VDD dd27_b3_4 XI1799_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1799_MP3 (XI1799_p1 qu5_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1799_MP0 (VDD dd27_b3_4 XI1799_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I207_MP1 (VDD I1068_G3_0n XI1068_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I207_MP5 (p11_4 XI1068_I207_Bn XI1068_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I207_MP4 (XI1068_I207_p1 XI1068_I207_An p11_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I207_MP2 (VDD I1068_pn4 XI1068_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I207_MP3 (XI1068_I207_p1 I1068_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I207_MP0 (VDD I1068_pn4 XI1068_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1042_MP1 (VDD qu21_b3_1 XI1042_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1042_MP5 (b11_6 XI1042_Bn XI1042_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1042_MP4 (XI1042_p1 XI1042_An b11_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1042_MP2 (VDD dd6_b3_2 XI1042_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1042_MP3 (XI1042_p1 qu21_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1042_MP0 (VDD dd6_b3_2 XI1042_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1039_MP1 (VDD qu21_b3_0 XI1039_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1039_MP5 (b11_3 XI1039_Bn XI1039_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1039_MP4 (XI1039_p1 XI1039_An b11_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1039_MP2 (VDD dd3_b3_2 XI1039_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1039_MP3 (XI1039_p1 qu21_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1039_MP0 (VDD dd3_b3_2 XI1039_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI834_MP1 (VDD qu26_b3_4 XI834_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI834_MP5 (b6_28 XI834_Bn XI834_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI834_MP4 (XI834_p1 XI834_An b6_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI834_MP2 (VDD dd28_b3_1 XI834_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI834_MP3 (XI834_p1 qu26_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI834_MP0 (VDD dd28_b3_1 XI834_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI990_MP1 (VDD qu22_b3_0 XI990_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI990_MP5 (b10_0 XI990_Bn XI990_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI990_MP4 (XI990_p1 XI990_An b10_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI990_MP2 (VDD B_0_b3_1 XI990_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI990_MP3 (XI990_p1 qu22_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI990_MP0 (VDD B_0_b3_1 XI990_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI833_MP1 (VDD qu26_b3_4 XI833_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI833_MP5 (b6_27 XI833_Bn XI833_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI833_MP4 (XI833_p1 XI833_An b6_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI833_MP2 (VDD dd27_b3_1 XI833_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI833_MP3 (XI833_p1 qu26_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI833_MP0 (VDD dd27_b3_1 XI833_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI991_MP1 (VDD qu22_b3_0 XI991_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI991_MP5 (b10_1 XI991_Bn XI991_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI991_MP4 (XI991_p1 XI991_An b10_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI991_MP2 (VDD dd1_b3_1 XI991_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI991_MP3 (XI991_p1 qu22_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI991_MP0 (VDD dd1_b3_1 XI991_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI831_MP1 (VDD qu26_b3_4 XI831_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI831_MP5 (b6_25 XI831_Bn XI831_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI831_MP4 (XI831_p1 XI831_An b6_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI831_MP2 (VDD dd25_b3_1 XI831_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI831_MP3 (XI831_p1 qu26_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI831_MP0 (VDD dd25_b3_1 XI831_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI883_MP1 (VDD qu25_b3_5 XI883_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI883_MP5 (b7_31 XI883_Bn XI883_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI883_MP4 (XI883_p1 XI883_An b7_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI883_MP2 (VDD dd31_b3_1 XI883_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI883_MP3 (XI883_p1 qu25_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI883_MP0 (VDD dd31_b3_1 XI883_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI898_MP1 (VDD qu24_b3_0 XI898_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI898_MP5 (b8_0 XI898_Bn XI898_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI898_MP4 (XI898_p1 XI898_An b8_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI898_MP2 (VDD B_0_b3_1 XI898_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI898_MP3 (XI898_p1 qu24_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI898_MP0 (VDD B_0_b3_1 XI898_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI881_MP1 (VDD qu25_b3_4 XI881_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI881_MP5 (b7_29 XI881_Bn XI881_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI881_MP4 (XI881_p1 XI881_An b7_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI881_MP2 (VDD dd29_b3_1 XI881_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI881_MP3 (XI881_p1 qu25_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI881_MP0 (VDD dd29_b3_1 XI881_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI877_MP1 (VDD qu25_b3_4 XI877_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI877_MP5 (b7_25 XI877_Bn XI877_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI877_MP4 (XI877_p1 XI877_An b7_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI877_MP2 (VDD dd25_b3_1 XI877_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI877_MP3 (XI877_p1 qu25_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI877_MP0 (VDD dd25_b3_1 XI877_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI880_MP1 (VDD qu25_b3_4 XI880_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI880_MP5 (b7_28 XI880_Bn XI880_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI880_MP4 (XI880_p1 XI880_An b7_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI880_MP2 (VDD dd28_b3_1 XI880_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI880_MP3 (XI880_p1 qu25_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI880_MP0 (VDD dd28_b3_1 XI880_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI879_MP1 (VDD qu25_b3_4 XI879_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI879_MP5 (b7_27 XI879_Bn XI879_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI879_MP4 (XI879_p1 XI879_An b7_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI879_MP2 (VDD dd27_b3_1 XI879_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI879_MP3 (XI879_p1 qu25_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI879_MP0 (VDD dd27_b3_1 XI879_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1706_MP1 (VDD qu7_b3_4 XI1706_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1706_MP5 (b25_26 XI1706_Bn XI1706_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1706_MP4 (XI1706_p1 XI1706_An b25_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1706_MP2 (VDD dd26_b3_4 XI1706_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1706_MP3 (XI1706_p1 qu7_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1706_MP0 (VDD dd26_b3_4 XI1706_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1708_MP1 (VDD qu7_b3_4 XI1708_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1708_MP5 (b25_28 XI1708_Bn XI1708_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1708_MP4 (XI1708_p1 XI1708_An b25_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1708_MP2 (VDD dd28_b3_4 XI1708_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1708_MP3 (XI1708_p1 qu7_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1708_MP0 (VDD dd28_b3_4 XI1708_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1703_MP1 (VDD qu7_b3_3 XI1703_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1703_MP5 (b25_23 XI1703_Bn XI1703_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1703_MP4 (XI1703_p1 XI1703_An b25_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1703_MP2 (VDD dd23_b3_4 XI1703_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1703_MP3 (XI1703_p1 qu7_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1703_MP0 (VDD dd23_b3_4 XI1703_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1709_MP1 (VDD qu7_b3_4 XI1709_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1709_MP5 (b25_29 XI1709_Bn XI1709_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1709_MP4 (XI1709_p1 XI1709_An b25_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1709_MP2 (VDD dd29_b3_4 XI1709_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1709_MP3 (XI1709_p1 qu7_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1709_MP0 (VDD dd29_b3_4 XI1709_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1710_MP1 (VDD qu7_b3_5 XI1710_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1710_MP5 (b25_30 XI1710_Bn XI1710_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1710_MP4 (XI1710_p1 XI1710_An b25_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1710_MP2 (VDD dd30_b3_4 XI1710_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1710_MP3 (XI1710_p1 qu7_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1710_MP0 (VDD dd30_b3_4 XI1710_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1711_MP1 (VDD qu7_b3_5 XI1711_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1711_MP5 (b25_31 XI1711_Bn XI1711_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1711_MP4 (XI1711_p1 XI1711_An b25_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1711_MP2 (VDD dd31_b3_4 XI1711_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1711_MP3 (XI1711_p1 qu7_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1711_MP0 (VDD dd31_b3_4 XI1711_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1635_MP1 (VDD qu8_b3_0 XI1635_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1635_MP5 (b24_1 XI1635_Bn XI1635_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1635_MP4 (XI1635_p1 XI1635_An b24_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1635_MP2 (VDD dd1_b3_4 XI1635_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1635_MP3 (XI1635_p1 qu8_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1635_MP0 (VDD dd1_b3_4 XI1635_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1636_MP1 (VDD qu8_b3_0 XI1636_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1636_MP5 (b24_2 XI1636_Bn XI1636_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1636_MP4 (XI1636_p1 XI1636_An b24_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1636_MP2 (VDD dd2_b3_4 XI1636_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1636_MP3 (XI1636_p1 qu8_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1636_MP0 (VDD dd2_b3_4 XI1636_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1634_MP1 (VDD qu8_b3_0 XI1634_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1634_MP5 (b24_0 XI1634_Bn XI1634_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1634_MP4 (XI1634_p1 XI1634_An b24_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1634_MP2 (VDD B_0_b3_4 XI1634_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1634_MP3 (XI1634_p1 qu8_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1634_MP0 (VDD B_0_b3_4 XI1634_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1751_MP1 (VDD qu6_b3_4 XI1751_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1751_MP5 (b26_25 XI1751_Bn XI1751_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1751_MP4 (XI1751_p1 XI1751_An b26_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1751_MP2 (VDD dd25_b3_4 XI1751_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1751_MP3 (XI1751_p1 qu6_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1751_MP0 (VDD dd25_b3_4 XI1751_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1752_MP1 (VDD qu6_b3_4 XI1752_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1752_MP5 (b26_26 XI1752_Bn XI1752_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1752_MP4 (XI1752_p1 XI1752_An b26_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1752_MP2 (VDD dd26_b3_4 XI1752_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1752_MP3 (XI1752_p1 qu6_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1752_MP0 (VDD dd26_b3_4 XI1752_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1753_MP1 (VDD qu6_b3_4 XI1753_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1753_MP5 (b26_27 XI1753_Bn XI1753_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1753_MP4 (XI1753_p1 XI1753_An b26_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1753_MP2 (VDD dd27_b3_4 XI1753_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1753_MP3 (XI1753_p1 qu6_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1753_MP0 (VDD dd27_b3_4 XI1753_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1754_MP1 (VDD qu6_b3_4 XI1754_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1754_MP5 (b26_28 XI1754_Bn XI1754_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1754_MP4 (XI1754_p1 XI1754_An b26_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1754_MP2 (VDD dd28_b3_4 XI1754_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1754_MP3 (XI1754_p1 qu6_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1754_MP0 (VDD dd28_b3_4 XI1754_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1588_MP1 (VDD qu9_b3_0 XI1588_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1588_MP5 (b23_0 XI1588_Bn XI1588_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1588_MP4 (XI1588_p1 XI1588_An b23_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1588_MP2 (VDD B_0_b3_4 XI1588_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1588_MP3 (XI1588_p1 qu9_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1588_MP0 (VDD B_0_b3_4 XI1588_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1755_MP1 (VDD qu6_b3_4 XI1755_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1755_MP5 (b26_29 XI1755_Bn XI1755_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1755_MP4 (XI1755_p1 XI1755_An b26_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1755_MP2 (VDD dd29_b3_4 XI1755_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1755_MP3 (XI1755_p1 qu6_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1755_MP0 (VDD dd29_b3_4 XI1755_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1590_MP1 (VDD qu9_b3_0 XI1590_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1590_MP5 (b23_2 XI1590_Bn XI1590_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1590_MP4 (XI1590_p1 XI1590_An b23_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1590_MP2 (VDD dd2_b3_4 XI1590_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1590_MP3 (XI1590_p1 qu9_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1590_MP0 (VDD dd2_b3_4 XI1590_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1591_MP1 (VDD qu9_b3_0 XI1591_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1591_MP5 (b23_3 XI1591_Bn XI1591_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1591_MP4 (XI1591_p1 XI1591_An b23_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1591_MP2 (VDD dd3_b3_4 XI1591_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1591_MP3 (XI1591_p1 qu9_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1591_MP0 (VDD dd3_b3_4 XI1591_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1545_MP1 (VDD qu10_b3_0 XI1545_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1545_MP5 (b22_3 XI1545_Bn XI1545_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1545_MP4 (XI1545_p1 XI1545_An b22_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1545_MP2 (VDD dd3_b3_4 XI1545_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1545_MP3 (XI1545_p1 qu10_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1545_MP0 (VDD dd3_b3_4 XI1545_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1543_MP1 (VDD qu10_b3_0 XI1543_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1543_MP5 (b22_1 XI1543_Bn XI1543_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1543_MP4 (XI1543_p1 XI1543_An b22_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1543_MP2 (VDD dd1_b3_4 XI1543_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1543_MP3 (XI1543_p1 qu10_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1543_MP0 (VDD dd1_b3_4 XI1543_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1544_MP1 (VDD qu10_b3_0 XI1544_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1544_MP5 (b22_2 XI1544_Bn XI1544_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1544_MP4 (XI1544_p1 XI1544_An b22_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1544_MP2 (VDD dd2_b3_4 XI1544_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1544_MP3 (XI1544_p1 qu10_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1544_MP0 (VDD dd2_b3_4 XI1544_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1801_MP1 (VDD qu5_b3_4 XI1801_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1801_MP5 (b27_29 XI1801_Bn XI1801_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1801_MP4 (XI1801_p1 XI1801_An b27_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1801_MP2 (VDD dd29_b3_4 XI1801_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1801_MP3 (XI1801_p1 qu5_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1801_MP0 (VDD dd29_b3_4 XI1801_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I206_MP1 (VDD I1574_G2_0n XI1574_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I206_MP5 (p22_3 XI1574_I206_Bn XI1574_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I206_MP4 (XI1574_I206_p1 XI1574_I206_An p22_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I206_MP2 (VDD I1574_pn3 XI1574_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I206_MP3 (XI1574_I206_p1 I1574_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I206_MP0 (VDD I1574_pn3 XI1574_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1797_MP1 (VDD qu5_b3_4 XI1797_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1797_MP5 (b27_25 XI1797_Bn XI1797_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1797_MP4 (XI1797_p1 XI1797_An b27_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1797_MP2 (VDD dd25_b3_4 XI1797_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1797_MP3 (XI1797_p1 qu5_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1797_MP0 (VDD dd25_b3_4 XI1797_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1798_MP1 (VDD qu5_b3_4 XI1798_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1798_MP5 (b27_26 XI1798_Bn XI1798_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1798_MP4 (XI1798_p1 XI1798_An b27_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1798_MP2 (VDD dd26_b3_4 XI1798_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1798_MP3 (XI1798_p1 qu5_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1798_MP0 (VDD dd26_b3_4 XI1798_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I213_MP1 (VDD I1068_G9_0n XI1068_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I213_MP5 (p11_10 XI1068_I213_Bn XI1068_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I213_MP4 (XI1068_I213_p1 XI1068_I213_An p11_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I213_MP2 (VDD I1068_pn10 XI1068_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I213_MP3 (XI1068_I213_p1 I1068_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I213_MP0 (VDD I1068_pn10 XI1068_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1044_MP1 (VDD qu21_b3_1 XI1044_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1044_MP5 (b11_8 XI1044_Bn XI1044_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1044_MP4 (XI1044_p1 XI1044_An b11_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1044_MP2 (VDD dd8_b3_2 XI1044_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1044_MP3 (XI1044_p1 qu21_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1044_MP0 (VDD dd8_b3_2 XI1044_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I206_MP1 (VDD I1068_G2_0n XI1068_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I206_MP5 (p11_3 XI1068_I206_Bn XI1068_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I206_MP4 (XI1068_I206_p1 XI1068_I206_An p11_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I206_MP2 (VDD I1068_pn3 XI1068_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I206_MP3 (XI1068_I206_p1 I1068_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I206_MP0 (VDD I1068_pn3 XI1068_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1038_MP1 (VDD qu21_b3_0 XI1038_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1038_MP5 (b11_2 XI1038_Bn XI1038_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1038_MP4 (XI1038_p1 XI1038_An b11_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1038_MP2 (VDD dd2_b3_2 XI1038_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1038_MP3 (XI1038_p1 qu21_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1038_MP0 (VDD dd2_b3_2 XI1038_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI995_MP1 (VDD qu22_b3_0 XI995_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI995_MP5 (b10_5 XI995_Bn XI995_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI995_MP4 (XI995_p1 XI995_An b10_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI995_MP2 (VDD dd5_b3_1 XI995_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI995_MP3 (XI995_p1 qu22_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI995_MP0 (VDD dd5_b3_1 XI995_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI992_MP1 (VDD qu22_b3_0 XI992_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI992_MP5 (b10_2 XI992_Bn XI992_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI992_MP4 (XI992_p1 XI992_An b10_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI992_MP2 (VDD dd2_b3_1 XI992_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI992_MP3 (XI992_p1 qu22_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI992_MP0 (VDD dd2_b3_1 XI992_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI944_MP1 (VDD qu23_b3_0 XI944_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI944_MP5 (b9_0 XI944_Bn XI944_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI944_MP4 (XI944_p1 XI944_An b9_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI944_MP2 (VDD B_0_b3_1 XI944_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI944_MP3 (XI944_p1 qu23_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI944_MP0 (VDD B_0_b3_1 XI944_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI945_MP1 (VDD qu23_b3_0 XI945_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI945_MP5 (b9_1 XI945_Bn XI945_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI945_MP4 (XI945_p1 XI945_An b9_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI945_MP2 (VDD dd1_b3_1 XI945_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI945_MP3 (XI945_p1 qu23_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI945_MP0 (VDD dd1_b3_1 XI945_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI946_MP1 (VDD qu23_b3_0 XI946_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI946_MP5 (b9_2 XI946_Bn XI946_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI946_MP4 (XI946_p1 XI946_An b9_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI946_MP2 (VDD dd2_b3_1 XI946_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI946_MP3 (XI946_p1 qu23_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI946_MP0 (VDD dd2_b3_1 XI946_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI947_MP1 (VDD qu23_b3_0 XI947_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI947_MP5 (b9_3 XI947_Bn XI947_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI947_MP4 (XI947_p1 XI947_An b9_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI947_MP2 (VDD dd3_b3_1 XI947_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI947_MP3 (XI947_p1 qu23_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI947_MP0 (VDD dd3_b3_1 XI947_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI948_MP1 (VDD qu23_b3_0 XI948_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI948_MP5 (b9_4 XI948_Bn XI948_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI948_MP4 (XI948_p1 XI948_An b9_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI948_MP2 (VDD dd4_b3_1 XI948_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI948_MP3 (XI948_p1 qu23_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI948_MP0 (VDD dd4_b3_1 XI948_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI949_MP1 (VDD qu23_b3_0 XI949_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI949_MP5 (b9_5 XI949_Bn XI949_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI949_MP4 (XI949_p1 XI949_An b9_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI949_MP2 (VDD dd5_b3_1 XI949_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI949_MP3 (XI949_p1 qu23_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI949_MP0 (VDD dd5_b3_1 XI949_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI899_MP1 (VDD qu24_b3_0 XI899_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI899_MP5 (b8_1 XI899_Bn XI899_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI899_MP4 (XI899_p1 XI899_An b8_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI899_MP2 (VDD dd1_b3_1 XI899_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI899_MP3 (XI899_p1 qu24_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI899_MP0 (VDD dd1_b3_1 XI899_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI902_MP1 (VDD qu24_b3_0 XI902_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI902_MP5 (b8_4 XI902_Bn XI902_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI902_MP4 (XI902_p1 XI902_An b8_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI902_MP2 (VDD dd4_b3_1 XI902_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI902_MP3 (XI902_p1 qu24_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI902_MP0 (VDD dd4_b3_1 XI902_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI903_MP1 (VDD qu24_b3_0 XI903_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI903_MP5 (b8_5 XI903_Bn XI903_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI903_MP4 (XI903_p1 XI903_An b8_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI903_MP2 (VDD dd5_b3_1 XI903_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI903_MP3 (XI903_p1 qu24_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI903_MP0 (VDD dd5_b3_1 XI903_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI900_MP1 (VDD qu24_b3_0 XI900_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI900_MP5 (b8_2 XI900_Bn XI900_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI900_MP4 (XI900_p1 XI900_An b8_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI900_MP2 (VDD dd2_b3_1 XI900_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI900_MP3 (XI900_p1 qu24_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI900_MP0 (VDD dd2_b3_1 XI900_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI901_MP1 (VDD qu24_b3_0 XI901_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI901_MP5 (b8_3 XI901_Bn XI901_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI901_MP4 (XI901_p1 XI901_An b8_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI901_MP2 (VDD dd3_b3_1 XI901_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI901_MP3 (XI901_p1 qu24_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI901_MP0 (VDD dd3_b3_1 XI901_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1704_MP1 (VDD qu7_b3_4 XI1704_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1704_MP5 (b25_24 XI1704_Bn XI1704_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1704_MP4 (XI1704_p1 XI1704_An b25_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1704_MP2 (VDD dd24_b3_4 XI1704_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1704_MP3 (XI1704_p1 qu7_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1704_MP0 (VDD dd24_b3_4 XI1704_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1705_MP1 (VDD qu7_b3_4 XI1705_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1705_MP5 (b25_25 XI1705_Bn XI1705_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1705_MP4 (XI1705_p1 XI1705_An b25_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1705_MP2 (VDD dd25_b3_4 XI1705_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1705_MP3 (XI1705_p1 qu7_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1705_MP0 (VDD dd25_b3_4 XI1705_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1707_MP1 (VDD qu7_b3_4 XI1707_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1707_MP5 (b25_27 XI1707_Bn XI1707_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1707_MP4 (XI1707_p1 XI1707_An b25_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1707_MP2 (VDD dd27_b3_4 XI1707_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1707_MP3 (XI1707_p1 qu7_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1707_MP0 (VDD dd27_b3_4 XI1707_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I206_MP1 (VDD I1666_G2_0n XI1666_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I206_MP5 (p24_3 XI1666_I206_Bn XI1666_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I206_MP4 (XI1666_I206_p1 XI1666_I206_An p24_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I206_MP2 (VDD I1666_pn3 XI1666_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I206_MP3 (XI1666_I206_p1 I1666_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I206_MP0 (VDD I1666_pn3 XI1666_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1639_MP1 (VDD qu8_b3_0 XI1639_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1639_MP5 (b24_5 XI1639_Bn XI1639_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1639_MP4 (XI1639_p1 XI1639_An b24_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1639_MP2 (VDD dd5_b3_4 XI1639_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1639_MP3 (XI1639_p1 qu8_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1639_MP0 (VDD dd5_b3_4 XI1639_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1638_MP1 (VDD qu8_b3_0 XI1638_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1638_MP5 (b24_4 XI1638_Bn XI1638_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1638_MP4 (XI1638_p1 XI1638_An b24_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1638_MP2 (VDD dd4_b3_4 XI1638_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1638_MP3 (XI1638_p1 qu8_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1638_MP0 (VDD dd4_b3_4 XI1638_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1637_MP1 (VDD qu8_b3_0 XI1637_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1637_MP5 (b24_3 XI1637_Bn XI1637_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1637_MP4 (XI1637_p1 XI1637_An b24_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1637_MP2 (VDD dd3_b3_4 XI1637_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1637_MP3 (XI1637_p1 qu8_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1637_MP0 (VDD dd3_b3_4 XI1637_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1589_MP1 (VDD qu9_b3_0 XI1589_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1589_MP5 (b23_1 XI1589_Bn XI1589_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1589_MP4 (XI1589_p1 XI1589_An b23_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1589_MP2 (VDD dd1_b3_4 XI1589_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1589_MP3 (XI1589_p1 qu9_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1589_MP0 (VDD dd1_b3_4 XI1589_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1593_MP1 (VDD qu9_b3_0 XI1593_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1593_MP5 (b23_5 XI1593_Bn XI1593_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1593_MP4 (XI1593_p1 XI1593_An b23_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1593_MP2 (VDD dd5_b3_4 XI1593_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1593_MP3 (XI1593_p1 qu9_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1593_MP0 (VDD dd5_b3_4 XI1593_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1592_MP1 (VDD qu9_b3_0 XI1592_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1592_MP5 (b23_4 XI1592_Bn XI1592_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1592_MP4 (XI1592_p1 XI1592_An b23_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1592_MP2 (VDD dd4_b3_4 XI1592_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1592_MP3 (XI1592_p1 qu9_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1592_MP0 (VDD dd4_b3_4 XI1592_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1542_MP1 (VDD qu10_b3_0 XI1542_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1542_MP5 (b22_0 XI1542_Bn XI1542_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1542_MP4 (XI1542_p1 XI1542_An b22_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1542_MP2 (VDD B_0_b3_3 XI1542_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1542_MP3 (XI1542_p1 qu10_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1542_MP0 (VDD B_0_b3_3 XI1542_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1547_MP1 (VDD qu10_b3_0 XI1547_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1547_MP5 (b22_5 XI1547_Bn XI1547_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1547_MP4 (XI1547_p1 XI1547_An b22_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1547_MP2 (VDD dd5_b3_4 XI1547_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1547_MP3 (XI1547_p1 qu10_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1547_MP0 (VDD dd5_b3_4 XI1547_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1546_MP1 (VDD qu10_b3_0 XI1546_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1546_MP5 (b22_4 XI1546_Bn XI1546_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1546_MP4 (XI1546_p1 XI1546_An b22_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1546_MP2 (VDD dd4_b3_4 XI1546_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1546_MP3 (XI1546_p1 qu10_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1546_MP0 (VDD dd4_b3_4 XI1546_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1063_MP1 (VDD qu21_b3_4 XI1063_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1063_MP5 (b11_27 XI1063_Bn XI1063_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1063_MP4 (XI1063_p1 XI1063_An b11_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1063_MP2 (VDD dd27_b3_2 XI1063_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1063_MP3 (XI1063_p1 qu21_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1063_MP0 (VDD dd27_b3_2 XI1063_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1062_MP1 (VDD qu21_b3_4 XI1062_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1062_MP5 (b11_26 XI1062_Bn XI1062_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1062_MP4 (XI1062_p1 XI1062_An b11_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1062_MP2 (VDD dd26_b3_2 XI1062_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1062_MP3 (XI1062_p1 qu21_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1062_MP0 (VDD dd26_b3_2 XI1062_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1043_MP1 (VDD qu21_b3_1 XI1043_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1043_MP5 (b11_7 XI1043_Bn XI1043_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1043_MP4 (XI1043_p1 XI1043_An b11_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1043_MP2 (VDD dd7_b3_2 XI1043_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1043_MP3 (XI1043_p1 qu21_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1043_MP0 (VDD dd7_b3_2 XI1043_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I207_MP1 (VDD I1022_G3_0n XI1022_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I207_MP5 (p10_4 XI1022_I207_Bn XI1022_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I207_MP4 (XI1022_I207_p1 XI1022_I207_An p10_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I207_MP2 (VDD I1022_pn4 XI1022_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I207_MP3 (XI1022_I207_p1 I1022_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I207_MP0 (VDD I1022_pn4 XI1022_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1037_MP1 (VDD qu21_b3_0 XI1037_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1037_MP5 (b11_1 XI1037_Bn XI1037_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1037_MP4 (XI1037_p1 XI1037_An b11_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1037_MP2 (VDD dd1_b3_2 XI1037_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1037_MP3 (XI1037_p1 qu21_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1037_MP0 (VDD dd1_b3_2 XI1037_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I206_MP1 (VDD I1022_G2_0n XI1022_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I206_MP5 (p10_3 XI1022_I206_Bn XI1022_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I206_MP4 (XI1022_I206_p1 XI1022_I206_An p10_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I206_MP2 (VDD I1022_pn3 XI1022_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I206_MP3 (XI1022_I206_p1 I1022_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I206_MP0 (VDD I1022_pn3 XI1022_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI996_MP1 (VDD qu22_b3_1 XI996_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI996_MP5 (b10_6 XI996_Bn XI996_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI996_MP4 (XI996_p1 XI996_An b10_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI996_MP2 (VDD dd6_b3_1 XI996_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI996_MP3 (XI996_p1 qu22_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI996_MP0 (VDD dd6_b3_1 XI996_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI994_MP1 (VDD qu22_b3_0 XI994_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI994_MP5 (b10_4 XI994_Bn XI994_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI994_MP4 (XI994_p1 XI994_An b10_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI994_MP2 (VDD dd4_b3_1 XI994_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI994_MP3 (XI994_p1 qu22_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI994_MP0 (VDD dd4_b3_1 XI994_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI993_MP1 (VDD qu22_b3_0 XI993_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI993_MP5 (b10_3 XI993_Bn XI993_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI993_MP4 (XI993_p1 XI993_An b10_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI993_MP2 (VDD dd3_b3_1 XI993_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI993_MP3 (XI993_p1 qu22_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI993_MP0 (VDD dd3_b3_1 XI993_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I206_MP1 (VDD I976_G2_0n XI976_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I206_MP5 (p9_3 XI976_I206_Bn XI976_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I206_MP4 (XI976_I206_p1 XI976_I206_An p9_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I206_MP2 (VDD I976_pn3 XI976_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I206_MP3 (XI976_I206_p1 I976_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I206_MP0 (VDD I976_pn3 XI976_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI950_MP1 (VDD qu23_b3_1 XI950_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI950_MP5 (b9_6 XI950_Bn XI950_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI950_MP4 (XI950_p1 XI950_An b9_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI950_MP2 (VDD dd6_b3_1 XI950_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI950_MP3 (XI950_p1 qu23_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI950_MP0 (VDD dd6_b3_1 XI950_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI905_MP1 (VDD qu24_b3_1 XI905_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI905_MP5 (b8_7 XI905_Bn XI905_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI905_MP4 (XI905_p1 XI905_An b8_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI905_MP2 (VDD dd7_b3_1 XI905_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI905_MP3 (XI905_p1 qu24_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI905_MP0 (VDD dd7_b3_1 XI905_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI904_MP1 (VDD qu24_b3_1 XI904_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI904_MP5 (b8_6 XI904_Bn XI904_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI904_MP4 (XI904_p1 XI904_An b8_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI904_MP2 (VDD dd6_b3_1 XI904_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI904_MP3 (XI904_p1 qu24_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI904_MP0 (VDD dd6_b3_1 XI904_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI906_MP1 (VDD qu24_b3_1 XI906_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI906_MP5 (b8_8 XI906_Bn XI906_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI906_MP4 (XI906_p1 XI906_An b8_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI906_MP2 (VDD dd8_b3_1 XI906_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI906_MP3 (XI906_p1 qu24_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI906_MP0 (VDD dd8_b3_1 XI906_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I206_MP1 (VDD I930_G2_0n XI930_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I206_MP5 (p8_3 XI930_I206_Bn XI930_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I206_MP4 (XI930_I206_p1 XI930_I206_An p8_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I206_MP2 (VDD I930_pn3 XI930_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I206_MP3 (XI930_I206_p1 I930_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I206_MP0 (VDD I930_pn3 XI930_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I207_MP1 (VDD I930_G3_0n XI930_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I207_MP5 (p8_4 XI930_I207_Bn XI930_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I207_MP4 (XI930_I207_p1 XI930_I207_An p8_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I207_MP2 (VDD I930_pn4 XI930_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I207_MP3 (XI930_I207_p1 I930_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I207_MP0 (VDD I930_pn4 XI930_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I212_MP1 (VDD I1666_G8_0n XI1666_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I212_MP5 (p24_9 XI1666_I212_Bn XI1666_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I212_MP4 (XI1666_I212_p1 XI1666_I212_An p24_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I212_MP2 (VDD I1666_pn9 XI1666_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I212_MP3 (XI1666_I212_p1 I1666_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I212_MP0 (VDD I1666_pn9 XI1666_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I207_MP1 (VDD I1666_G3_0n XI1666_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I207_MP5 (p24_4 XI1666_I207_Bn XI1666_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I207_MP4 (XI1666_I207_p1 XI1666_I207_An p24_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I207_MP2 (VDD I1666_pn4 XI1666_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I207_MP3 (XI1666_I207_p1 I1666_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I207_MP0 (VDD I1666_pn4 XI1666_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1640_MP1 (VDD qu8_b3_1 XI1640_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1640_MP5 (b24_6 XI1640_Bn XI1640_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1640_MP4 (XI1640_p1 XI1640_An b24_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1640_MP2 (VDD dd6_b3_4 XI1640_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1640_MP3 (XI1640_p1 qu8_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1640_MP0 (VDD dd6_b3_4 XI1640_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I207_MP1 (VDD I1620_G3_0n XI1620_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I207_MP5 (p23_4 XI1620_I207_Bn XI1620_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I207_MP4 (XI1620_I207_p1 XI1620_I207_An p23_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I207_MP2 (VDD I1620_pn4 XI1620_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I207_MP3 (XI1620_I207_p1 I1620_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I207_MP0 (VDD I1620_pn4 XI1620_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I206_MP1 (VDD I1620_G2_0n XI1620_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I206_MP5 (p23_3 XI1620_I206_Bn XI1620_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I206_MP4 (XI1620_I206_p1 XI1620_I206_An p23_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I206_MP2 (VDD I1620_pn3 XI1620_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I206_MP3 (XI1620_I206_p1 I1620_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I206_MP0 (VDD I1620_pn3 XI1620_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1594_MP1 (VDD qu9_b3_1 XI1594_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1594_MP5 (b23_6 XI1594_Bn XI1594_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1594_MP4 (XI1594_p1 XI1594_An b23_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1594_MP2 (VDD dd6_b3_4 XI1594_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1594_MP3 (XI1594_p1 qu9_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1594_MP0 (VDD dd6_b3_4 XI1594_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1548_MP1 (VDD qu10_b3_1 XI1548_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1548_MP5 (b22_6 XI1548_Bn XI1548_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1548_MP4 (XI1548_p1 XI1548_An b22_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1548_MP2 (VDD dd6_b3_4 XI1548_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1548_MP3 (XI1548_p1 qu10_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1548_MP0 (VDD dd6_b3_4 XI1548_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I207_MP1 (VDD I1574_G3_0n XI1574_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I207_MP5 (p22_4 XI1574_I207_Bn XI1574_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I207_MP4 (XI1574_I207_p1 XI1574_I207_An p22_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I207_MP2 (VDD I1574_pn4 XI1574_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I207_MP3 (XI1574_I207_p1 I1574_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I207_MP0 (VDD I1574_pn4 XI1574_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1064_MP1 (VDD qu21_b3_4 XI1064_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1064_MP5 (b11_28 XI1064_Bn XI1064_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1064_MP4 (XI1064_p1 XI1064_An b11_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1064_MP2 (VDD dd28_b3_2 XI1064_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1064_MP3 (XI1064_p1 qu21_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1064_MP0 (VDD dd28_b3_2 XI1064_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I214_MP1 (VDD I1068_G10_0n XI1068_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I214_MP5 (p11_11 XI1068_I214_Bn XI1068_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I214_MP4 (XI1068_I214_p1 XI1068_I214_An p11_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I214_MP2 (VDD I1068_pn11 XI1068_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I214_MP3 (XI1068_I214_p1 I1068_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I214_MP0 (VDD I1068_pn11 XI1068_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI999_MP1 (VDD qu22_b3_1 XI999_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI999_MP5 (b10_9 XI999_Bn XI999_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI999_MP4 (XI999_p1 XI999_An b10_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI999_MP2 (VDD dd9_b3_1 XI999_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI999_MP3 (XI999_p1 qu22_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI999_MP0 (VDD dd9_b3_1 XI999_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI997_MP1 (VDD qu22_b3_1 XI997_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI997_MP5 (b10_7 XI997_Bn XI997_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI997_MP4 (XI997_p1 XI997_An b10_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI997_MP2 (VDD dd7_b3_1 XI997_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI997_MP3 (XI997_p1 qu22_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI997_MP0 (VDD dd7_b3_1 XI997_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1000_MP1 (VDD qu22_b3_1 XI1000_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1000_MP5 (b10_10 XI1000_Bn XI1000_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1000_MP4 (XI1000_p1 XI1000_An b10_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1000_MP2 (VDD dd10_b3_1 XI1000_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1000_MP3 (XI1000_p1 qu22_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1000_MP0 (VDD dd10_b3_1 XI1000_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI998_MP1 (VDD qu22_b3_1 XI998_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI998_MP5 (b10_8 XI998_Bn XI998_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI998_MP4 (XI998_p1 XI998_An b10_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI998_MP2 (VDD dd8_b3_1 XI998_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI998_MP3 (XI998_p1 qu22_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI998_MP0 (VDD dd8_b3_1 XI998_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I207_MP1 (VDD I976_G3_0n XI976_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I207_MP5 (p9_4 XI976_I207_Bn XI976_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I207_MP4 (XI976_I207_p1 XI976_I207_An p9_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I207_MP2 (VDD I976_pn4 XI976_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I207_MP3 (XI976_I207_p1 I976_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I207_MP0 (VDD I976_pn4 XI976_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI951_MP1 (VDD qu23_b3_1 XI951_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI951_MP5 (b9_7 XI951_Bn XI951_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI951_MP4 (XI951_p1 XI951_An b9_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI951_MP2 (VDD dd7_b3_1 XI951_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI951_MP3 (XI951_p1 qu23_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI951_MP0 (VDD dd7_b3_1 XI951_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI952_MP1 (VDD qu23_b3_1 XI952_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI952_MP5 (b9_8 XI952_Bn XI952_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI952_MP4 (XI952_p1 XI952_An b9_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI952_MP2 (VDD dd8_b3_1 XI952_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI952_MP3 (XI952_p1 qu23_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI952_MP0 (VDD dd8_b3_1 XI952_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI954_MP1 (VDD qu23_b3_1 XI954_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI954_MP5 (b9_10 XI954_Bn XI954_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI954_MP4 (XI954_p1 XI954_An b9_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI954_MP2 (VDD dd10_b3_1 XI954_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI954_MP3 (XI954_p1 qu23_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI954_MP0 (VDD dd10_b3_1 XI954_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI907_MP1 (VDD qu24_b3_1 XI907_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI907_MP5 (b8_9 XI907_Bn XI907_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI907_MP4 (XI907_p1 XI907_An b8_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI907_MP2 (VDD dd9_b3_1 XI907_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI907_MP3 (XI907_p1 qu24_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI907_MP0 (VDD dd9_b3_1 XI907_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI909_MP1 (VDD qu24_b3_1 XI909_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI909_MP5 (b8_11 XI909_Bn XI909_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI909_MP4 (XI909_p1 XI909_An b8_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI909_MP2 (VDD dd11_b3_1 XI909_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI909_MP3 (XI909_p1 qu24_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI909_MP0 (VDD dd11_b3_1 XI909_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI931_MP1 (VDD qu24_b3_5 XI931_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI931_MP5 (h8 XI931_Bn XI931_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI931_MP4 (XI931_p1 XI931_An h8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI931_MP2 (VDD p7_31 XI931_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI931_MP3 (XI931_p1 qu24_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI931_MP0 (VDD p7_31 XI931_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI908_MP1 (VDD qu24_b3_1 XI908_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI908_MP5 (b8_10 XI908_Bn XI908_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI908_MP4 (XI908_p1 XI908_An b8_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI908_MP2 (VDD dd10_b3_1 XI908_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI908_MP3 (XI908_p1 qu24_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI908_MP0 (VDD dd10_b3_1 XI908_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1641_MP1 (VDD qu8_b3_1 XI1641_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1641_MP5 (b24_7 XI1641_Bn XI1641_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1641_MP4 (XI1641_p1 XI1641_An b24_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1641_MP2 (VDD dd7_b3_4 XI1641_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1641_MP3 (XI1641_p1 qu8_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1641_MP0 (VDD dd7_b3_4 XI1641_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1642_MP1 (VDD qu8_b3_1 XI1642_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1642_MP5 (b24_8 XI1642_Bn XI1642_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1642_MP4 (XI1642_p1 XI1642_An b24_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1642_MP2 (VDD dd8_b3_4 XI1642_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1642_MP3 (XI1642_p1 qu8_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1642_MP0 (VDD dd8_b3_4 XI1642_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1596_MP1 (VDD qu9_b3_1 XI1596_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1596_MP5 (b23_8 XI1596_Bn XI1596_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1596_MP4 (XI1596_p1 XI1596_An b23_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1596_MP2 (VDD dd8_b3_4 XI1596_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1596_MP3 (XI1596_p1 qu9_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1596_MP0 (VDD dd8_b3_4 XI1596_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1595_MP1 (VDD qu9_b3_1 XI1595_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1595_MP5 (b23_7 XI1595_Bn XI1595_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1595_MP4 (XI1595_p1 XI1595_An b23_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1595_MP2 (VDD dd7_b3_4 XI1595_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1595_MP3 (XI1595_p1 qu9_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1595_MP0 (VDD dd7_b3_4 XI1595_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1550_MP1 (VDD qu10_b3_1 XI1550_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1550_MP5 (b22_8 XI1550_Bn XI1550_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1550_MP4 (XI1550_p1 XI1550_An b22_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1550_MP2 (VDD dd8_b3_4 XI1550_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1550_MP3 (XI1550_p1 qu10_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1550_MP0 (VDD dd8_b3_4 XI1550_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1549_MP1 (VDD qu10_b3_1 XI1549_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1549_MP5 (b22_7 XI1549_Bn XI1549_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1549_MP4 (XI1549_p1 XI1549_An b22_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1549_MP2 (VDD dd7_b3_4 XI1549_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1549_MP3 (XI1549_p1 qu10_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1549_MP0 (VDD dd7_b3_4 XI1549_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1046_MP1 (VDD qu21_b3_1 XI1046_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1046_MP5 (b11_10 XI1046_Bn XI1046_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1046_MP4 (XI1046_p1 XI1046_An b11_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1046_MP2 (VDD dd10_b3_2 XI1046_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1046_MP3 (XI1046_p1 qu21_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1046_MP0 (VDD dd10_b3_2 XI1046_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I212_MP1 (VDD I1022_G8_0n XI1022_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I212_MP5 (p10_9 XI1022_I212_Bn XI1022_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I212_MP4 (XI1022_I212_p1 XI1022_I212_An p10_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I212_MP2 (VDD I1022_pn9 XI1022_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I212_MP3 (XI1022_I212_p1 I1022_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I212_MP0 (VDD I1022_pn9 XI1022_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1001_MP1 (VDD qu22_b3_1 XI1001_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1001_MP5 (b10_11 XI1001_Bn XI1001_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1001_MP4 (XI1001_p1 XI1001_An b10_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1001_MP2 (VDD dd11_b3_1 XI1001_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1001_MP3 (XI1001_p1 qu22_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1001_MP0 (VDD dd11_b3_1 XI1001_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI953_MP1 (VDD qu23_b3_1 XI953_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI953_MP5 (b9_9 XI953_Bn XI953_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI953_MP4 (XI953_p1 XI953_An b9_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI953_MP2 (VDD dd9_b3_1 XI953_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI953_MP3 (XI953_p1 qu23_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI953_MP0 (VDD dd9_b3_1 XI953_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI955_MP1 (VDD qu23_b3_1 XI955_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI955_MP5 (b9_11 XI955_Bn XI955_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI955_MP4 (XI955_p1 XI955_An b9_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI955_MP2 (VDD dd11_b3_1 XI955_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI955_MP3 (XI955_p1 qu23_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI955_MP0 (VDD dd11_b3_1 XI955_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI910_MP1 (VDD qu24_b3_2 XI910_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI910_MP5 (b8_12 XI910_Bn XI910_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI910_MP4 (XI910_p1 XI910_An b8_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI910_MP2 (VDD dd12_b3_1 XI910_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI910_MP3 (XI910_p1 qu24_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI910_MP0 (VDD dd12_b3_1 XI910_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I212_MP1 (VDD I930_G8_0n XI930_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I212_MP5 (p8_9 XI930_I212_Bn XI930_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I212_MP4 (XI930_I212_p1 XI930_I212_An p8_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I212_MP2 (VDD I930_pn9 XI930_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I212_MP3 (XI930_I212_p1 I930_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I212_MP0 (VDD I930_pn9 XI930_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I213_MP1 (VDD I1666_G9_0n XI1666_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I213_MP5 (p24_10 XI1666_I213_Bn XI1666_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I213_MP4 (XI1666_I213_p1 XI1666_I213_An p24_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I213_MP2 (VDD I1666_pn10 XI1666_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I213_MP3 (XI1666_I213_p1 I1666_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I213_MP0 (VDD I1666_pn10 XI1666_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1643_MP1 (VDD qu8_b3_1 XI1643_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1643_MP5 (b24_9 XI1643_Bn XI1643_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1643_MP4 (XI1643_p1 XI1643_An b24_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1643_MP2 (VDD dd9_b3_4 XI1643_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1643_MP3 (XI1643_p1 qu8_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1643_MP0 (VDD dd9_b3_4 XI1643_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1644_MP1 (VDD qu8_b3_1 XI1644_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1644_MP5 (b24_10 XI1644_Bn XI1644_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1644_MP4 (XI1644_p1 XI1644_An b24_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1644_MP2 (VDD dd10_b3_4 XI1644_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1644_MP3 (XI1644_p1 qu8_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1644_MP0 (VDD dd10_b3_4 XI1644_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1645_MP1 (VDD qu8_b3_1 XI1645_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1645_MP5 (b24_11 XI1645_Bn XI1645_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1645_MP4 (XI1645_p1 XI1645_An b24_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1645_MP2 (VDD dd11_b3_4 XI1645_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1645_MP3 (XI1645_p1 qu8_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1645_MP0 (VDD dd11_b3_4 XI1645_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I212_MP1 (VDD I1620_G8_0n XI1620_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I212_MP5 (p23_9 XI1620_I212_Bn XI1620_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I212_MP4 (XI1620_I212_p1 XI1620_I212_An p23_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I212_MP2 (VDD I1620_pn9 XI1620_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I212_MP3 (XI1620_I212_p1 I1620_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I212_MP0 (VDD I1620_pn9 XI1620_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1597_MP1 (VDD qu9_b3_1 XI1597_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1597_MP5 (b23_9 XI1597_Bn XI1597_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1597_MP4 (XI1597_p1 XI1597_An b23_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1597_MP2 (VDD dd9_b3_4 XI1597_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1597_MP3 (XI1597_p1 qu9_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1597_MP0 (VDD dd9_b3_4 XI1597_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1599_MP1 (VDD qu9_b3_1 XI1599_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1599_MP5 (b23_11 XI1599_Bn XI1599_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1599_MP4 (XI1599_p1 XI1599_An b23_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1599_MP2 (VDD dd11_b3_4 XI1599_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1599_MP3 (XI1599_p1 qu9_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1599_MP0 (VDD dd11_b3_4 XI1599_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1598_MP1 (VDD qu9_b3_1 XI1598_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1598_MP5 (b23_10 XI1598_Bn XI1598_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1598_MP4 (XI1598_p1 XI1598_An b23_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1598_MP2 (VDD dd10_b3_4 XI1598_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1598_MP3 (XI1598_p1 qu9_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1598_MP0 (VDD dd10_b3_4 XI1598_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1552_MP1 (VDD qu10_b3_1 XI1552_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1552_MP5 (b22_10 XI1552_Bn XI1552_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1552_MP4 (XI1552_p1 XI1552_An b22_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1552_MP2 (VDD dd10_b3_4 XI1552_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1552_MP3 (XI1552_p1 qu10_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1552_MP0 (VDD dd10_b3_4 XI1552_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1551_MP1 (VDD qu10_b3_1 XI1551_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1551_MP5 (b22_9 XI1551_Bn XI1551_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1551_MP4 (XI1551_p1 XI1551_An b22_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1551_MP2 (VDD dd9_b3_4 XI1551_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1551_MP3 (XI1551_p1 qu10_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1551_MP0 (VDD dd9_b3_4 XI1551_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I212_MP1 (VDD I1574_G8_0n XI1574_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I212_MP5 (p22_9 XI1574_I212_Bn XI1574_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I212_MP4 (XI1574_I212_p1 XI1574_I212_An p22_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I212_MP2 (VDD I1574_pn9 XI1574_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I212_MP3 (XI1574_I212_p1 I1574_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I212_MP0 (VDD I1574_pn9 XI1574_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I215_MP1 (VDD I1068_G11_0n XI1068_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I215_MP5 (p11_12 XI1068_I215_Bn XI1068_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I215_MP4 (XI1068_I215_p1 XI1068_I215_An p11_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I215_MP2 (VDD I1068_pn12 XI1068_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I215_MP3 (XI1068_I215_p1 I1068_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I215_MP0 (VDD I1068_pn12 XI1068_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I212_MP1 (VDD I1068_G8_0n XI1068_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I212_MP5 (p11_9 XI1068_I212_Bn XI1068_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I212_MP4 (XI1068_I212_p1 XI1068_I212_An p11_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I212_MP2 (VDD I1068_pn9 XI1068_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I212_MP3 (XI1068_I212_p1 I1068_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I212_MP0 (VDD I1068_pn9 XI1068_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1045_MP1 (VDD qu21_b3_1 XI1045_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1045_MP5 (b11_9 XI1045_Bn XI1045_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1045_MP4 (XI1045_p1 XI1045_An b11_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1045_MP2 (VDD dd9_b3_2 XI1045_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1045_MP3 (XI1045_p1 qu21_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1045_MP0 (VDD dd9_b3_2 XI1045_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1047_MP1 (VDD qu21_b3_1 XI1047_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1047_MP5 (b11_11 XI1047_Bn XI1047_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1047_MP4 (XI1047_p1 XI1047_An b11_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1047_MP2 (VDD dd11_b3_2 XI1047_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1047_MP3 (XI1047_p1 qu21_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1047_MP0 (VDD dd11_b3_2 XI1047_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I213_MP1 (VDD I1022_G9_0n XI1022_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I213_MP5 (p10_10 XI1022_I213_Bn XI1022_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I213_MP4 (XI1022_I213_p1 XI1022_I213_An p10_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I213_MP2 (VDD I1022_pn10 XI1022_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I213_MP3 (XI1022_I213_p1 I1022_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I213_MP0 (VDD I1022_pn10 XI1022_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1002_MP1 (VDD qu22_b3_2 XI1002_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1002_MP5 (b10_12 XI1002_Bn XI1002_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1002_MP4 (XI1002_p1 XI1002_An b10_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1002_MP2 (VDD dd12_b3_1 XI1002_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1002_MP3 (XI1002_p1 qu22_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1002_MP0 (VDD dd12_b3_1 XI1002_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I212_MP1 (VDD I976_G8_0n XI976_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I212_MP5 (p9_9 XI976_I212_Bn XI976_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I212_MP4 (XI976_I212_p1 XI976_I212_An p9_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I212_MP2 (VDD I976_pn9 XI976_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I212_MP3 (XI976_I212_p1 I976_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I212_MP0 (VDD I976_pn9 XI976_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I213_MP1 (VDD I976_G9_0n XI976_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I213_MP5 (p9_10 XI976_I213_Bn XI976_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I213_MP4 (XI976_I213_p1 XI976_I213_An p9_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I213_MP2 (VDD I976_pn10 XI976_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I213_MP3 (XI976_I213_p1 I976_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I213_MP0 (VDD I976_pn10 XI976_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI956_MP1 (VDD qu23_b3_2 XI956_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI956_MP5 (b9_12 XI956_Bn XI956_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI956_MP4 (XI956_p1 XI956_An b9_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI956_MP2 (VDD dd12_b3_1 XI956_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI956_MP3 (XI956_p1 qu23_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI956_MP0 (VDD dd12_b3_1 XI956_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI911_MP1 (VDD qu24_b3_2 XI911_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI911_MP5 (b8_13 XI911_Bn XI911_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI911_MP4 (XI911_p1 XI911_An b8_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI911_MP2 (VDD dd13_b3_1 XI911_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI911_MP3 (XI911_p1 qu24_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI911_MP0 (VDD dd13_b3_1 XI911_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI932_MP1 (VDD c8_o XI932_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI932_MP5 (p8_32 XI932_Bn XI932_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI932_MP4 (XI932_p1 XI932_An p8_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI932_MP2 (VDD h8 XI932_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI932_MP3 (XI932_p1 c8_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI932_MP0 (VDD h8 XI932_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I213_MP1 (VDD I930_G9_0n XI930_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I213_MP5 (p8_10 XI930_I213_Bn XI930_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I213_MP4 (XI930_I213_p1 XI930_I213_An p8_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I213_MP2 (VDD I930_pn10 XI930_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I213_MP3 (XI930_I213_p1 I930_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I213_MP0 (VDD I930_pn10 XI930_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I216_MP1 (VDD I1666_G12_0n XI1666_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I216_MP5 (p24_13 XI1666_I216_Bn XI1666_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I216_MP4 (XI1666_I216_p1 XI1666_I216_An p24_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I216_MP2 (VDD I1666_pn13 XI1666_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I216_MP3 (XI1666_I216_p1 I1666_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I216_MP0 (VDD I1666_pn13 XI1666_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I214_MP1 (VDD I1666_G10_0n XI1666_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I214_MP5 (p24_11 XI1666_I214_Bn XI1666_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I214_MP4 (XI1666_I214_p1 XI1666_I214_An p24_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I214_MP2 (VDD I1666_pn11 XI1666_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I214_MP3 (XI1666_I214_p1 I1666_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I214_MP0 (VDD I1666_pn11 XI1666_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I215_MP1 (VDD I1666_G11_0n XI1666_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I215_MP5 (p24_12 XI1666_I215_Bn XI1666_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I215_MP4 (XI1666_I215_p1 XI1666_I215_An p24_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I215_MP2 (VDD I1666_pn12 XI1666_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I215_MP3 (XI1666_I215_p1 I1666_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I215_MP0 (VDD I1666_pn12 XI1666_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1646_MP1 (VDD qu8_b3_2 XI1646_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1646_MP5 (b24_12 XI1646_Bn XI1646_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1646_MP4 (XI1646_p1 XI1646_An b24_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1646_MP2 (VDD dd12_b3_4 XI1646_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1646_MP3 (XI1646_p1 qu8_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1646_MP0 (VDD dd12_b3_4 XI1646_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I213_MP1 (VDD I1620_G9_0n XI1620_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I213_MP5 (p23_10 XI1620_I213_Bn XI1620_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I213_MP4 (XI1620_I213_p1 XI1620_I213_An p23_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I213_MP2 (VDD I1620_pn10 XI1620_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I213_MP3 (XI1620_I213_p1 I1620_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I213_MP0 (VDD I1620_pn10 XI1620_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I214_MP1 (VDD I1620_G10_0n XI1620_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I214_MP5 (p23_11 XI1620_I214_Bn XI1620_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I214_MP4 (XI1620_I214_p1 XI1620_I214_An p23_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I214_MP2 (VDD I1620_pn11 XI1620_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I214_MP3 (XI1620_I214_p1 I1620_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I214_MP0 (VDD I1620_pn11 XI1620_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1601_MP1 (VDD qu9_b3_2 XI1601_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1601_MP5 (b23_13 XI1601_Bn XI1601_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1601_MP4 (XI1601_p1 XI1601_An b23_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1601_MP2 (VDD dd13_b3_4 XI1601_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1601_MP3 (XI1601_p1 qu9_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1601_MP0 (VDD dd13_b3_4 XI1601_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1600_MP1 (VDD qu9_b3_2 XI1600_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1600_MP5 (b23_12 XI1600_Bn XI1600_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1600_MP4 (XI1600_p1 XI1600_An b23_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1600_MP2 (VDD dd12_b3_4 XI1600_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1600_MP3 (XI1600_p1 qu9_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1600_MP0 (VDD dd12_b3_4 XI1600_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1553_MP1 (VDD qu10_b3_1 XI1553_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1553_MP5 (b22_11 XI1553_Bn XI1553_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1553_MP4 (XI1553_p1 XI1553_An b22_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1553_MP2 (VDD dd11_b3_4 XI1553_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1553_MP3 (XI1553_p1 qu10_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1553_MP0 (VDD dd11_b3_4 XI1553_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1554_MP1 (VDD qu10_b3_2 XI1554_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1554_MP5 (b22_12 XI1554_Bn XI1554_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1554_MP4 (XI1554_p1 XI1554_An b22_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1554_MP2 (VDD dd12_b3_4 XI1554_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1554_MP3 (XI1554_p1 qu10_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1554_MP0 (VDD dd12_b3_4 XI1554_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I213_MP1 (VDD I1574_G9_0n XI1574_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I213_MP5 (p22_10 XI1574_I213_Bn XI1574_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I213_MP4 (XI1574_I213_p1 XI1574_I213_An p22_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I213_MP2 (VDD I1574_pn10 XI1574_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I213_MP3 (XI1574_I213_p1 I1574_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I213_MP0 (VDD I1574_pn10 XI1574_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I214_MP1 (VDD I1574_G10_0n XI1574_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I214_MP5 (p22_11 XI1574_I214_Bn XI1574_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I214_MP4 (XI1574_I214_p1 XI1574_I214_An p22_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I214_MP2 (VDD I1574_pn11 XI1574_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I214_MP3 (XI1574_I214_p1 I1574_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I214_MP0 (VDD I1574_pn11 XI1574_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1065_MP1 (VDD qu21_b3_4 XI1065_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1065_MP5 (b11_29 XI1065_Bn XI1065_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1065_MP4 (XI1065_p1 XI1065_An b11_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1065_MP2 (VDD dd29_b3_2 XI1065_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1065_MP3 (XI1065_p1 qu21_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1065_MP0 (VDD dd29_b3_2 XI1065_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1061_MP1 (VDD qu21_b3_4 XI1061_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1061_MP5 (b11_25 XI1061_Bn XI1061_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1061_MP4 (XI1061_p1 XI1061_An b11_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1061_MP2 (VDD dd25_b3_2 XI1061_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1061_MP3 (XI1061_p1 qu21_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1061_MP0 (VDD dd25_b3_2 XI1061_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I217_MP1 (VDD I1068_G13_0n XI1068_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I217_MP5 (p11_14 XI1068_I217_Bn XI1068_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I217_MP4 (XI1068_I217_p1 XI1068_I217_An p11_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I217_MP2 (VDD I1068_pn14 XI1068_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I217_MP3 (XI1068_I217_p1 I1068_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I217_MP0 (VDD I1068_pn14 XI1068_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I216_MP1 (VDD I1068_G12_0n XI1068_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I216_MP5 (p11_13 XI1068_I216_Bn XI1068_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I216_MP4 (XI1068_I216_p1 XI1068_I216_An p11_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I216_MP2 (VDD I1068_pn13 XI1068_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I216_MP3 (XI1068_I216_p1 I1068_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I216_MP0 (VDD I1068_pn13 XI1068_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1048_MP1 (VDD qu21_b3_2 XI1048_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1048_MP5 (b11_12 XI1048_Bn XI1048_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1048_MP4 (XI1048_p1 XI1048_An b11_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1048_MP2 (VDD dd12_b3_2 XI1048_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1048_MP3 (XI1048_p1 qu21_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1048_MP0 (VDD dd12_b3_2 XI1048_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I215_MP1 (VDD I1022_G11_0n XI1022_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I215_MP5 (p10_12 XI1022_I215_Bn XI1022_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I215_MP4 (XI1022_I215_p1 XI1022_I215_An p10_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I215_MP2 (VDD I1022_pn12 XI1022_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I215_MP3 (XI1022_I215_p1 I1022_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I215_MP0 (VDD I1022_pn12 XI1022_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I214_MP1 (VDD I1022_G10_0n XI1022_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I214_MP5 (p10_11 XI1022_I214_Bn XI1022_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I214_MP4 (XI1022_I214_p1 XI1022_I214_An p10_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I214_MP2 (VDD I1022_pn11 XI1022_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I214_MP3 (XI1022_I214_p1 I1022_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I214_MP0 (VDD I1022_pn11 XI1022_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1004_MP1 (VDD qu22_b3_2 XI1004_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1004_MP5 (b10_14 XI1004_Bn XI1004_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1004_MP4 (XI1004_p1 XI1004_An b10_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1004_MP2 (VDD dd14_b3_1 XI1004_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1004_MP3 (XI1004_p1 qu22_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1004_MP0 (VDD dd14_b3_1 XI1004_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1003_MP1 (VDD qu22_b3_2 XI1003_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1003_MP5 (b10_13 XI1003_Bn XI1003_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1003_MP4 (XI1003_p1 XI1003_An b10_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1003_MP2 (VDD dd13_b3_1 XI1003_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1003_MP3 (XI1003_p1 qu22_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1003_MP0 (VDD dd13_b3_1 XI1003_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I214_MP1 (VDD I976_G10_0n XI976_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I214_MP5 (p9_11 XI976_I214_Bn XI976_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I214_MP4 (XI976_I214_p1 XI976_I214_An p9_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I214_MP2 (VDD I976_pn11 XI976_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I214_MP3 (XI976_I214_p1 I976_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I214_MP0 (VDD I976_pn11 XI976_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI957_MP1 (VDD qu23_b3_2 XI957_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI957_MP5 (b9_13 XI957_Bn XI957_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI957_MP4 (XI957_p1 XI957_An b9_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI957_MP2 (VDD dd13_b3_1 XI957_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI957_MP3 (XI957_p1 qu23_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI957_MP0 (VDD dd13_b3_1 XI957_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI958_MP1 (VDD qu23_b3_2 XI958_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI958_MP5 (b9_14 XI958_Bn XI958_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI958_MP4 (XI958_p1 XI958_An b9_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI958_MP2 (VDD dd14_b3_1 XI958_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI958_MP3 (XI958_p1 qu23_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI958_MP0 (VDD dd14_b3_1 XI958_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI961_MP1 (VDD qu23_b3_2 XI961_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI961_MP5 (b9_17 XI961_Bn XI961_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI961_MP4 (XI961_p1 XI961_An b9_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI961_MP2 (VDD dd17_b3_1 XI961_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI961_MP3 (XI961_p1 qu23_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI961_MP0 (VDD dd17_b3_1 XI961_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI959_MP1 (VDD qu23_b3_2 XI959_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI959_MP5 (b9_15 XI959_Bn XI959_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI959_MP4 (XI959_p1 XI959_An b9_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI959_MP2 (VDD dd15_b3_1 XI959_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI959_MP3 (XI959_p1 qu23_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI959_MP0 (VDD dd15_b3_1 XI959_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI913_MP1 (VDD qu24_b3_2 XI913_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI913_MP5 (b8_15 XI913_Bn XI913_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI913_MP4 (XI913_p1 XI913_An b8_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI913_MP2 (VDD dd15_b3_1 XI913_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI913_MP3 (XI913_p1 qu24_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI913_MP0 (VDD dd15_b3_1 XI913_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI912_MP1 (VDD qu24_b3_2 XI912_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI912_MP5 (b8_14 XI912_Bn XI912_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI912_MP4 (XI912_p1 XI912_An b8_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI912_MP2 (VDD dd14_b3_1 XI912_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI912_MP3 (XI912_p1 qu24_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI912_MP0 (VDD dd14_b3_1 XI912_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI914_MP1 (VDD qu24_b3_2 XI914_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI914_MP5 (b8_16 XI914_Bn XI914_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI914_MP4 (XI914_p1 XI914_An b8_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI914_MP2 (VDD dd16_b3_1 XI914_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI914_MP3 (XI914_p1 qu24_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI914_MP0 (VDD dd16_b3_1 XI914_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I214_MP1 (VDD I930_G10_0n XI930_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I214_MP5 (p8_11 XI930_I214_Bn XI930_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I214_MP4 (XI930_I214_p1 XI930_I214_An p8_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I214_MP2 (VDD I930_pn11 XI930_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I214_MP3 (XI930_I214_p1 I930_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I214_MP0 (VDD I930_pn11 XI930_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1647_MP1 (VDD qu8_b3_2 XI1647_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1647_MP5 (b24_13 XI1647_Bn XI1647_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1647_MP4 (XI1647_p1 XI1647_An b24_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1647_MP2 (VDD dd13_b3_4 XI1647_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1647_MP3 (XI1647_p1 qu8_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1647_MP0 (VDD dd13_b3_4 XI1647_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1648_MP1 (VDD qu8_b3_2 XI1648_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1648_MP5 (b24_14 XI1648_Bn XI1648_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1648_MP4 (XI1648_p1 XI1648_An b24_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1648_MP2 (VDD dd14_b3_4 XI1648_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1648_MP3 (XI1648_p1 qu8_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1648_MP0 (VDD dd14_b3_4 XI1648_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1649_MP1 (VDD qu8_b3_2 XI1649_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1649_MP5 (b24_15 XI1649_Bn XI1649_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1649_MP4 (XI1649_p1 XI1649_An b24_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1649_MP2 (VDD dd15_b3_4 XI1649_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1649_MP3 (XI1649_p1 qu8_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1649_MP0 (VDD dd15_b3_4 XI1649_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I215_MP1 (VDD I1620_G11_0n XI1620_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I215_MP5 (p23_12 XI1620_I215_Bn XI1620_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I215_MP4 (XI1620_I215_p1 XI1620_I215_An p23_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I215_MP2 (VDD I1620_pn12 XI1620_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I215_MP3 (XI1620_I215_p1 I1620_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I215_MP0 (VDD I1620_pn12 XI1620_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1602_MP1 (VDD qu9_b3_2 XI1602_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1602_MP5 (b23_14 XI1602_Bn XI1602_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1602_MP4 (XI1602_p1 XI1602_An b23_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1602_MP2 (VDD dd14_b3_4 XI1602_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1602_MP3 (XI1602_p1 qu9_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1602_MP0 (VDD dd14_b3_4 XI1602_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1555_MP1 (VDD qu10_b3_2 XI1555_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1555_MP5 (b22_13 XI1555_Bn XI1555_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1555_MP4 (XI1555_p1 XI1555_An b22_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1555_MP2 (VDD dd13_b3_4 XI1555_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1555_MP3 (XI1555_p1 qu10_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1555_MP0 (VDD dd13_b3_4 XI1555_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I215_MP1 (VDD I1574_G11_0n XI1574_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I215_MP5 (p22_12 XI1574_I215_Bn XI1574_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I215_MP4 (XI1574_I215_p1 XI1574_I215_An p22_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I215_MP2 (VDD I1574_pn12 XI1574_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I215_MP3 (XI1574_I215_p1 I1574_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I215_MP0 (VDD I1574_pn12 XI1574_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1066_MP1 (VDD qu21_b3_5 XI1066_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1066_MP5 (b11_30 XI1066_Bn XI1066_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1066_MP4 (XI1066_p1 XI1066_An b11_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1066_MP2 (VDD dd30_b3_2 XI1066_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1066_MP3 (XI1066_p1 qu21_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1066_MP0 (VDD dd30_b3_2 XI1066_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1060_MP1 (VDD qu21_b3_4 XI1060_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1060_MP5 (b11_24 XI1060_Bn XI1060_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1060_MP4 (XI1060_p1 XI1060_An b11_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1060_MP2 (VDD dd24_b3_2 XI1060_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1060_MP3 (XI1060_p1 qu21_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1060_MP0 (VDD dd24_b3_2 XI1060_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1055_MP1 (VDD qu21_b3_3 XI1055_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1055_MP5 (b11_19 XI1055_Bn XI1055_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1055_MP4 (XI1055_p1 XI1055_An b11_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1055_MP2 (VDD dd19_b3_2 XI1055_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1055_MP3 (XI1055_p1 qu21_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1055_MP0 (VDD dd19_b3_2 XI1055_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I218_MP1 (VDD I1068_G14_0n XI1068_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I218_MP5 (p11_15 XI1068_I218_Bn XI1068_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I218_MP4 (XI1068_I218_p1 XI1068_I218_An p11_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I218_MP2 (VDD I1068_pn15 XI1068_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I218_MP3 (XI1068_I218_p1 I1068_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I218_MP0 (VDD I1068_pn15 XI1068_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1051_MP1 (VDD qu21_b3_2 XI1051_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1051_MP5 (b11_15 XI1051_Bn XI1051_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1051_MP4 (XI1051_p1 XI1051_An b11_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1051_MP2 (VDD dd15_b3_2 XI1051_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1051_MP3 (XI1051_p1 qu21_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1051_MP0 (VDD dd15_b3_2 XI1051_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1050_MP1 (VDD qu21_b3_2 XI1050_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1050_MP5 (b11_14 XI1050_Bn XI1050_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1050_MP4 (XI1050_p1 XI1050_An b11_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1050_MP2 (VDD dd14_b3_2 XI1050_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1050_MP3 (XI1050_p1 qu21_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1050_MP0 (VDD dd14_b3_2 XI1050_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1049_MP1 (VDD qu21_b3_2 XI1049_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1049_MP5 (b11_13 XI1049_Bn XI1049_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1049_MP4 (XI1049_p1 XI1049_An b11_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1049_MP2 (VDD dd13_b3_2 XI1049_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1049_MP3 (XI1049_p1 qu21_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1049_MP0 (VDD dd13_b3_2 XI1049_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I217_MP1 (VDD I1022_G13_0n XI1022_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I217_MP5 (p10_14 XI1022_I217_Bn XI1022_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I217_MP4 (XI1022_I217_p1 XI1022_I217_An p10_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I217_MP2 (VDD I1022_pn14 XI1022_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I217_MP3 (XI1022_I217_p1 I1022_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I217_MP0 (VDD I1022_pn14 XI1022_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I216_MP1 (VDD I1022_G12_0n XI1022_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I216_MP5 (p10_13 XI1022_I216_Bn XI1022_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I216_MP4 (XI1022_I216_p1 XI1022_I216_An p10_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I216_MP2 (VDD I1022_pn13 XI1022_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I216_MP3 (XI1022_I216_p1 I1022_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I216_MP0 (VDD I1022_pn13 XI1022_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1006_MP1 (VDD qu22_b3_2 XI1006_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1006_MP5 (b10_16 XI1006_Bn XI1006_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1006_MP4 (XI1006_p1 XI1006_An b10_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1006_MP2 (VDD dd16_b3_1 XI1006_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1006_MP3 (XI1006_p1 qu22_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1006_MP0 (VDD dd16_b3_1 XI1006_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1005_MP1 (VDD qu22_b3_2 XI1005_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1005_MP5 (b10_15 XI1005_Bn XI1005_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1005_MP4 (XI1005_p1 XI1005_An b10_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1005_MP2 (VDD dd15_b3_1 XI1005_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1005_MP3 (XI1005_p1 qu22_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1005_MP0 (VDD dd15_b3_1 XI1005_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1007_MP1 (VDD qu22_b3_2 XI1007_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1007_MP5 (b10_17 XI1007_Bn XI1007_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1007_MP4 (XI1007_p1 XI1007_An b10_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1007_MP2 (VDD dd17_b3_1 XI1007_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1007_MP3 (XI1007_p1 qu22_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1007_MP0 (VDD dd17_b3_1 XI1007_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I215_MP1 (VDD I976_G11_0n XI976_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I215_MP5 (p9_12 XI976_I215_Bn XI976_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I215_MP4 (XI976_I215_p1 XI976_I215_An p9_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I215_MP2 (VDD I976_pn12 XI976_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I215_MP3 (XI976_I215_p1 I976_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I215_MP0 (VDD I976_pn12 XI976_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI960_MP1 (VDD qu23_b3_2 XI960_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI960_MP5 (b9_16 XI960_Bn XI960_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI960_MP4 (XI960_p1 XI960_An b9_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI960_MP2 (VDD dd16_b3_1 XI960_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI960_MP3 (XI960_p1 qu23_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI960_MP0 (VDD dd16_b3_1 XI960_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI915_MP1 (VDD qu24_b3_2 XI915_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI915_MP5 (b8_17 XI915_Bn XI915_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI915_MP4 (XI915_p1 XI915_An b8_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI915_MP2 (VDD dd17_b3_1 XI915_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI915_MP3 (XI915_p1 qu24_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI915_MP0 (VDD dd17_b3_1 XI915_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I216_MP1 (VDD I930_G12_0n XI930_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I216_MP5 (p8_13 XI930_I216_Bn XI930_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I216_MP4 (XI930_I216_p1 XI930_I216_An p8_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I216_MP2 (VDD I930_pn13 XI930_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I216_MP3 (XI930_I216_p1 I930_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I216_MP0 (VDD I930_pn13 XI930_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I215_MP1 (VDD I930_G11_0n XI930_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I215_MP5 (p8_12 XI930_I215_Bn XI930_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I215_MP4 (XI930_I215_p1 XI930_I215_An p8_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I215_MP2 (VDD I930_pn12 XI930_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I215_MP3 (XI930_I215_p1 I930_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I215_MP0 (VDD I930_pn12 XI930_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I218_MP1 (VDD I1666_G14_0n XI1666_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I218_MP5 (p24_15 XI1666_I218_Bn XI1666_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I218_MP4 (XI1666_I218_p1 XI1666_I218_An p24_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I218_MP2 (VDD I1666_pn15 XI1666_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I218_MP3 (XI1666_I218_p1 I1666_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I218_MP0 (VDD I1666_pn15 XI1666_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I217_MP1 (VDD I1666_G13_0n XI1666_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I217_MP5 (p24_14 XI1666_I217_Bn XI1666_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I217_MP4 (XI1666_I217_p1 XI1666_I217_An p24_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I217_MP2 (VDD I1666_pn14 XI1666_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I217_MP3 (XI1666_I217_p1 I1666_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I217_MP0 (VDD I1666_pn14 XI1666_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I219_MP1 (VDD I1666_G15_0n XI1666_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1666_I219_MP5 (p24_16 XI1666_I219_Bn XI1666_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1666_I219_MP4 (XI1666_I219_p1 XI1666_I219_An p24_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I219_MP2 (VDD I1666_pn16 XI1666_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1666_I219_MP3 (XI1666_I219_p1 I1666_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1666_I219_MP0 (VDD I1666_pn16 XI1666_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1650_MP1 (VDD qu8_b3_2 XI1650_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1650_MP5 (b24_16 XI1650_Bn XI1650_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1650_MP4 (XI1650_p1 XI1650_An b24_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1650_MP2 (VDD dd16_b3_4 XI1650_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1650_MP3 (XI1650_p1 qu8_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1650_MP0 (VDD dd16_b3_4 XI1650_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1651_MP1 (VDD qu8_b3_2 XI1651_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1651_MP5 (b24_17 XI1651_Bn XI1651_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1651_MP4 (XI1651_p1 XI1651_An b24_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1651_MP2 (VDD dd17_b3_4 XI1651_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1651_MP3 (XI1651_p1 qu8_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1651_MP0 (VDD dd17_b3_4 XI1651_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I217_MP1 (VDD I1620_G13_0n XI1620_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I217_MP5 (p23_14 XI1620_I217_Bn XI1620_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I217_MP4 (XI1620_I217_p1 XI1620_I217_An p23_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I217_MP2 (VDD I1620_pn14 XI1620_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I217_MP3 (XI1620_I217_p1 I1620_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I217_MP0 (VDD I1620_pn14 XI1620_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I216_MP1 (VDD I1620_G12_0n XI1620_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I216_MP5 (p23_13 XI1620_I216_Bn XI1620_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I216_MP4 (XI1620_I216_p1 XI1620_I216_An p23_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I216_MP2 (VDD I1620_pn13 XI1620_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I216_MP3 (XI1620_I216_p1 I1620_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I216_MP0 (VDD I1620_pn13 XI1620_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1603_MP1 (VDD qu9_b3_2 XI1603_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1603_MP5 (b23_15 XI1603_Bn XI1603_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1603_MP4 (XI1603_p1 XI1603_An b23_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1603_MP2 (VDD dd15_b3_4 XI1603_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1603_MP3 (XI1603_p1 qu9_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1603_MP0 (VDD dd15_b3_4 XI1603_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1604_MP1 (VDD qu9_b3_2 XI1604_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1604_MP5 (b23_16 XI1604_Bn XI1604_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1604_MP4 (XI1604_p1 XI1604_An b23_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1604_MP2 (VDD dd16_b3_4 XI1604_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1604_MP3 (XI1604_p1 qu9_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1604_MP0 (VDD dd16_b3_4 XI1604_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1557_MP1 (VDD qu10_b3_2 XI1557_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1557_MP5 (b22_15 XI1557_Bn XI1557_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1557_MP4 (XI1557_p1 XI1557_An b22_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1557_MP2 (VDD dd15_b3_4 XI1557_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1557_MP3 (XI1557_p1 qu10_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1557_MP0 (VDD dd15_b3_4 XI1557_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1558_MP1 (VDD qu10_b3_2 XI1558_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1558_MP5 (b22_16 XI1558_Bn XI1558_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1558_MP4 (XI1558_p1 XI1558_An b22_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1558_MP2 (VDD dd16_b3_4 XI1558_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1558_MP3 (XI1558_p1 qu10_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1558_MP0 (VDD dd16_b3_4 XI1558_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1556_MP1 (VDD qu10_b3_2 XI1556_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1556_MP5 (b22_14 XI1556_Bn XI1556_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1556_MP4 (XI1556_p1 XI1556_An b22_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1556_MP2 (VDD dd14_b3_4 XI1556_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1556_MP3 (XI1556_p1 qu10_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1556_MP0 (VDD dd14_b3_4 XI1556_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I217_MP1 (VDD I1574_G13_0n XI1574_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I217_MP5 (p22_14 XI1574_I217_Bn XI1574_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I217_MP4 (XI1574_I217_p1 XI1574_I217_An p22_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I217_MP2 (VDD I1574_pn14 XI1574_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I217_MP3 (XI1574_I217_p1 I1574_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I217_MP0 (VDD I1574_pn14 XI1574_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I216_MP1 (VDD I1574_G12_0n XI1574_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I216_MP5 (p22_13 XI1574_I216_Bn XI1574_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I216_MP4 (XI1574_I216_p1 XI1574_I216_An p22_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I216_MP2 (VDD I1574_pn13 XI1574_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I216_MP3 (XI1574_I216_p1 I1574_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I216_MP0 (VDD I1574_pn13 XI1574_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1109_MP1 (VDD qu20_b3_4 XI1109_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1109_MP5 (b12_27 XI1109_Bn XI1109_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1109_MP4 (XI1109_p1 XI1109_An b12_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1109_MP2 (VDD dd27_b3_2 XI1109_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1109_MP3 (XI1109_p1 qu20_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1109_MP0 (VDD dd27_b3_2 XI1109_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1067_MP1 (VDD qu21_b3_5 XI1067_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1067_MP5 (b11_31 XI1067_Bn XI1067_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1067_MP4 (XI1067_p1 XI1067_An b11_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1067_MP2 (VDD dd31_b3_2 XI1067_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1067_MP3 (XI1067_p1 qu21_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1067_MP0 (VDD dd31_b3_2 XI1067_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1108_MP1 (VDD qu20_b3_4 XI1108_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1108_MP5 (b12_26 XI1108_Bn XI1108_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1108_MP4 (XI1108_p1 XI1108_An b12_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1108_MP2 (VDD dd26_b3_2 XI1108_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1108_MP3 (XI1108_p1 qu20_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1108_MP0 (VDD dd26_b3_2 XI1108_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1059_MP1 (VDD qu21_b3_3 XI1059_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1059_MP5 (b11_23 XI1059_Bn XI1059_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1059_MP4 (XI1059_p1 XI1059_An b11_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1059_MP2 (VDD dd23_b3_2 XI1059_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1059_MP3 (XI1059_p1 qu21_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1059_MP0 (VDD dd23_b3_2 XI1059_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1057_MP1 (VDD qu21_b3_3 XI1057_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1057_MP5 (b11_21 XI1057_Bn XI1057_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1057_MP4 (XI1057_p1 XI1057_An b11_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1057_MP2 (VDD dd21_b3_2 XI1057_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1057_MP3 (XI1057_p1 qu21_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1057_MP0 (VDD dd21_b3_2 XI1057_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1058_MP1 (VDD qu21_b3_3 XI1058_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1058_MP5 (b11_22 XI1058_Bn XI1058_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1058_MP4 (XI1058_p1 XI1058_An b11_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1058_MP2 (VDD dd22_b3_2 XI1058_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1058_MP3 (XI1058_p1 qu21_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1058_MP0 (VDD dd22_b3_2 XI1058_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1101_MP1 (VDD qu20_b3_3 XI1101_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1101_MP5 (b12_19 XI1101_Bn XI1101_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1101_MP4 (XI1101_p1 XI1101_An b12_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1101_MP2 (VDD dd19_b3_2 XI1101_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1101_MP3 (XI1101_p1 qu20_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1101_MP0 (VDD dd19_b3_2 XI1101_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1054_MP1 (VDD qu21_b3_3 XI1054_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1054_MP5 (b11_18 XI1054_Bn XI1054_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1054_MP4 (XI1054_p1 XI1054_An b11_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1054_MP2 (VDD dd18_b3_2 XI1054_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1054_MP3 (XI1054_p1 qu21_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1054_MP0 (VDD dd18_b3_2 XI1054_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1056_MP1 (VDD qu21_b3_3 XI1056_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1056_MP5 (b11_20 XI1056_Bn XI1056_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1056_MP4 (XI1056_p1 XI1056_An b11_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1056_MP2 (VDD dd20_b3_2 XI1056_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1056_MP3 (XI1056_p1 qu21_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1056_MP0 (VDD dd20_b3_2 XI1056_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1100_MP1 (VDD qu20_b3_3 XI1100_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1100_MP5 (b12_18 XI1100_Bn XI1100_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1100_MP4 (XI1100_p1 XI1100_An b12_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1100_MP2 (VDD dd18_b3_2 XI1100_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1100_MP3 (XI1100_p1 qu20_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1100_MP0 (VDD dd18_b3_2 XI1100_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I219_MP1 (VDD I1068_G15_0n XI1068_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1068_I219_MP5 (p11_16 XI1068_I219_Bn XI1068_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1068_I219_MP4 (XI1068_I219_p1 XI1068_I219_An p11_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I219_MP2 (VDD I1068_pn16 XI1068_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1068_I219_MP3 (XI1068_I219_p1 I1068_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1068_I219_MP0 (VDD I1068_pn16 XI1068_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1052_MP1 (VDD qu21_b3_2 XI1052_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1052_MP5 (b11_16 XI1052_Bn XI1052_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1052_MP4 (XI1052_p1 XI1052_An b11_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1052_MP2 (VDD dd16_b3_2 XI1052_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1052_MP3 (XI1052_p1 qu21_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1052_MP0 (VDD dd16_b3_2 XI1052_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1096_MP1 (VDD qu20_b3_2 XI1096_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1096_MP5 (b12_14 XI1096_Bn XI1096_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1096_MP4 (XI1096_p1 XI1096_An b12_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1096_MP2 (VDD dd14_b3_2 XI1096_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1096_MP3 (XI1096_p1 qu20_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1096_MP0 (VDD dd14_b3_2 XI1096_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1053_MP1 (VDD qu21_b3_2 XI1053_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1053_MP5 (b11_17 XI1053_Bn XI1053_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1053_MP4 (XI1053_p1 XI1053_An b11_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1053_MP2 (VDD dd17_b3_2 XI1053_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1053_MP3 (XI1053_p1 qu21_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1053_MP0 (VDD dd17_b3_2 XI1053_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1070_MP1 (VDD c11_o XI1070_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1070_MP5 (p11_32 XI1070_Bn XI1070_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1070_MP4 (XI1070_p1 XI1070_An p11_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1070_MP2 (VDD h11 XI1070_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1070_MP3 (XI1070_p1 c11_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1070_MP0 (VDD h11 XI1070_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I219_MP1 (VDD I1022_G15_0n XI1022_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I219_MP5 (p10_16 XI1022_I219_Bn XI1022_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I219_MP4 (XI1022_I219_p1 XI1022_I219_An p10_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I219_MP2 (VDD I1022_pn16 XI1022_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I219_MP3 (XI1022_I219_p1 I1022_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I219_MP0 (VDD I1022_pn16 XI1022_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I218_MP1 (VDD I1022_G14_0n XI1022_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1022_I218_MP5 (p10_15 XI1022_I218_Bn XI1022_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1022_I218_MP4 (XI1022_I218_p1 XI1022_I218_An p10_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I218_MP2 (VDD I1022_pn15 XI1022_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1022_I218_MP3 (XI1022_I218_p1 I1022_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1022_I218_MP0 (VDD I1022_pn15 XI1022_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I218_MP1 (VDD I976_G14_0n XI976_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I218_MP5 (p9_15 XI976_I218_Bn XI976_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I218_MP4 (XI976_I218_p1 XI976_I218_An p9_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I218_MP2 (VDD I976_pn15 XI976_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I218_MP3 (XI976_I218_p1 I976_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I218_MP0 (VDD I976_pn15 XI976_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I216_MP1 (VDD I976_G12_0n XI976_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I216_MP5 (p9_13 XI976_I216_Bn XI976_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I216_MP4 (XI976_I216_p1 XI976_I216_An p9_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I216_MP2 (VDD I976_pn13 XI976_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I216_MP3 (XI976_I216_p1 I976_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I216_MP0 (VDD I976_pn13 XI976_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I217_MP1 (VDD I976_G13_0n XI976_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I217_MP5 (p9_14 XI976_I217_Bn XI976_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I217_MP4 (XI976_I217_p1 XI976_I217_An p9_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I217_MP2 (VDD I976_pn14 XI976_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I217_MP3 (XI976_I217_p1 I976_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I217_MP0 (VDD I976_pn14 XI976_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I219_MP1 (VDD I930_G15_0n XI930_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I219_MP5 (p8_16 XI930_I219_Bn XI930_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I219_MP4 (XI930_I219_p1 XI930_I219_An p8_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I219_MP2 (VDD I930_pn16 XI930_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I219_MP3 (XI930_I219_p1 I930_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I219_MP0 (VDD I930_pn16 XI930_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I217_MP1 (VDD I930_G13_0n XI930_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I217_MP5 (p8_14 XI930_I217_Bn XI930_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I217_MP4 (XI930_I217_p1 XI930_I217_An p8_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I217_MP2 (VDD I930_pn14 XI930_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I217_MP3 (XI930_I217_p1 I930_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I217_MP0 (VDD I930_pn14 XI930_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1652_MP1 (VDD qu8_b3_3 XI1652_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1652_MP5 (b24_18 XI1652_Bn XI1652_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1652_MP4 (XI1652_p1 XI1652_An b24_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1652_MP2 (VDD dd18_b3_4 XI1652_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1652_MP3 (XI1652_p1 qu8_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1652_MP0 (VDD dd18_b3_4 XI1652_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I218_MP1 (VDD I1620_G14_0n XI1620_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I218_MP5 (p23_15 XI1620_I218_Bn XI1620_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I218_MP4 (XI1620_I218_p1 XI1620_I218_An p23_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I218_MP2 (VDD I1620_pn15 XI1620_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I218_MP3 (XI1620_I218_p1 I1620_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I218_MP0 (VDD I1620_pn15 XI1620_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1605_MP1 (VDD qu9_b3_2 XI1605_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1605_MP5 (b23_17 XI1605_Bn XI1605_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1605_MP4 (XI1605_p1 XI1605_An b23_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1605_MP2 (VDD dd17_b3_4 XI1605_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1605_MP3 (XI1605_p1 qu9_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1605_MP0 (VDD dd17_b3_4 XI1605_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1559_MP1 (VDD qu10_b3_2 XI1559_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1559_MP5 (b22_17 XI1559_Bn XI1559_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1559_MP4 (XI1559_p1 XI1559_An b22_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1559_MP2 (VDD dd17_b3_4 XI1559_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1559_MP3 (XI1559_p1 qu10_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1559_MP0 (VDD dd17_b3_4 XI1559_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I219_MP1 (VDD I1574_G15_0n XI1574_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I219_MP5 (p22_16 XI1574_I219_Bn XI1574_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I219_MP4 (XI1574_I219_p1 XI1574_I219_An p22_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I219_MP2 (VDD I1574_pn16 XI1574_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I219_MP3 (XI1574_I219_p1 I1574_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I219_MP0 (VDD I1574_pn16 XI1574_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I218_MP1 (VDD I1574_G14_0n XI1574_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1574_I218_MP5 (p22_15 XI1574_I218_Bn XI1574_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1574_I218_MP4 (XI1574_I218_p1 XI1574_I218_An p22_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I218_MP2 (VDD I1574_pn15 XI1574_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1574_I218_MP3 (XI1574_I218_p1 I1574_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1574_I218_MP0 (VDD I1574_pn15 XI1574_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1110_MP1 (VDD qu20_b3_4 XI1110_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1110_MP5 (b12_28 XI1110_Bn XI1110_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1110_MP4 (XI1110_p1 XI1110_An b12_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1110_MP2 (VDD dd28_b3_2 XI1110_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1110_MP3 (XI1110_p1 qu20_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1110_MP0 (VDD dd28_b3_2 XI1110_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1107_MP1 (VDD qu20_b3_4 XI1107_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1107_MP5 (b12_25 XI1107_Bn XI1107_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1107_MP4 (XI1107_p1 XI1107_An b12_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1107_MP2 (VDD dd25_b3_2 XI1107_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1107_MP3 (XI1107_p1 qu20_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1107_MP0 (VDD dd25_b3_2 XI1107_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1103_MP1 (VDD qu20_b3_3 XI1103_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1103_MP5 (b12_21 XI1103_Bn XI1103_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1103_MP4 (XI1103_p1 XI1103_An b12_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1103_MP2 (VDD dd21_b3_2 XI1103_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1103_MP3 (XI1103_p1 qu20_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1103_MP0 (VDD dd21_b3_2 XI1103_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1104_MP1 (VDD qu20_b3_3 XI1104_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1104_MP5 (b12_22 XI1104_Bn XI1104_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1104_MP4 (XI1104_p1 XI1104_An b12_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1104_MP2 (VDD dd22_b3_2 XI1104_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1104_MP3 (XI1104_p1 qu20_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1104_MP0 (VDD dd22_b3_2 XI1104_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1094_MP1 (VDD qu20_b3_2 XI1094_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1094_MP5 (b12_12 XI1094_Bn XI1094_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1094_MP4 (XI1094_p1 XI1094_An b12_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1094_MP2 (VDD dd12_b3_2 XI1094_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1094_MP3 (XI1094_p1 qu20_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1094_MP0 (VDD dd12_b3_2 XI1094_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1098_MP1 (VDD qu20_b3_2 XI1098_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1098_MP5 (b12_16 XI1098_Bn XI1098_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1098_MP4 (XI1098_p1 XI1098_An b12_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1098_MP2 (VDD dd16_b3_2 XI1098_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1098_MP3 (XI1098_p1 qu20_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1098_MP0 (VDD dd16_b3_2 XI1098_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1097_MP1 (VDD qu20_b3_2 XI1097_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1097_MP5 (b12_15 XI1097_Bn XI1097_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1097_MP4 (XI1097_p1 XI1097_An b12_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1097_MP2 (VDD dd15_b3_2 XI1097_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1097_MP3 (XI1097_p1 qu20_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1097_MP0 (VDD dd15_b3_2 XI1097_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1095_MP1 (VDD qu20_b3_2 XI1095_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1095_MP5 (b12_13 XI1095_Bn XI1095_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1095_MP4 (XI1095_p1 XI1095_An b12_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1095_MP2 (VDD dd13_b3_2 XI1095_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1095_MP3 (XI1095_p1 qu20_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1095_MP0 (VDD dd13_b3_2 XI1095_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1069_MP1 (VDD qu21_b3_5 XI1069_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1069_MP5 (h11 XI1069_Bn XI1069_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1069_MP4 (XI1069_p1 XI1069_An h11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1069_MP2 (VDD p10_31 XI1069_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1069_MP3 (XI1069_p1 qu21_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1069_MP0 (VDD p10_31 XI1069_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1009_MP1 (VDD qu22_b3_3 XI1009_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1009_MP5 (b10_19 XI1009_Bn XI1009_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1009_MP4 (XI1009_p1 XI1009_An b10_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1009_MP2 (VDD dd19_b3_1 XI1009_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1009_MP3 (XI1009_p1 qu22_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1009_MP0 (VDD dd19_b3_1 XI1009_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1008_MP1 (VDD qu22_b3_3 XI1008_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1008_MP5 (b10_18 XI1008_Bn XI1008_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1008_MP4 (XI1008_p1 XI1008_An b10_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1008_MP2 (VDD dd18_b3_1 XI1008_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1008_MP3 (XI1008_p1 qu22_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1008_MP0 (VDD dd18_b3_1 XI1008_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I219_MP1 (VDD I976_G15_0n XI976_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI976_I219_MP5 (p9_16 XI976_I219_Bn XI976_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI976_I219_MP4 (XI976_I219_p1 XI976_I219_An p9_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I219_MP2 (VDD I976_pn16 XI976_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI976_I219_MP3 (XI976_I219_p1 I976_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI976_I219_MP0 (VDD I976_pn16 XI976_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI963_MP1 (VDD qu23_b3_3 XI963_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI963_MP5 (b9_19 XI963_Bn XI963_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI963_MP4 (XI963_p1 XI963_An b9_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI963_MP2 (VDD dd19_b3_1 XI963_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI963_MP3 (XI963_p1 qu23_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI963_MP0 (VDD dd19_b3_1 XI963_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI962_MP1 (VDD qu23_b3_3 XI962_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI962_MP5 (b9_18 XI962_Bn XI962_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI962_MP4 (XI962_p1 XI962_An b9_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI962_MP2 (VDD dd18_b3_1 XI962_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI962_MP3 (XI962_p1 qu23_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI962_MP0 (VDD dd18_b3_1 XI962_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI916_MP1 (VDD qu24_b3_3 XI916_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI916_MP5 (b8_18 XI916_Bn XI916_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI916_MP4 (XI916_p1 XI916_An b8_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI916_MP2 (VDD dd18_b3_1 XI916_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI916_MP3 (XI916_p1 qu24_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI916_MP0 (VDD dd18_b3_1 XI916_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI917_MP1 (VDD qu24_b3_3 XI917_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI917_MP5 (b8_19 XI917_Bn XI917_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI917_MP4 (XI917_p1 XI917_An b8_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI917_MP2 (VDD dd19_b3_1 XI917_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI917_MP3 (XI917_p1 qu24_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI917_MP0 (VDD dd19_b3_1 XI917_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I218_MP1 (VDD I930_G14_0n XI930_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI930_I218_MP5 (p8_15 XI930_I218_Bn XI930_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI930_I218_MP4 (XI930_I218_p1 XI930_I218_An p8_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I218_MP2 (VDD I930_pn15 XI930_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI930_I218_MP3 (XI930_I218_p1 I930_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI930_I218_MP0 (VDD I930_pn15 XI930_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1653_MP1 (VDD qu8_b3_3 XI1653_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1653_MP5 (b24_19 XI1653_Bn XI1653_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1653_MP4 (XI1653_p1 XI1653_An b24_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1653_MP2 (VDD dd19_b3_4 XI1653_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1653_MP3 (XI1653_p1 qu8_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1653_MP0 (VDD dd19_b3_4 XI1653_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I219_MP1 (VDD I1620_G15_0n XI1620_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1620_I219_MP5 (p23_16 XI1620_I219_Bn XI1620_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1620_I219_MP4 (XI1620_I219_p1 XI1620_I219_An p23_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I219_MP2 (VDD I1620_pn16 XI1620_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1620_I219_MP3 (XI1620_I219_p1 I1620_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1620_I219_MP0 (VDD I1620_pn16 XI1620_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1608_MP1 (VDD qu9_b3_3 XI1608_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1608_MP5 (b23_20 XI1608_Bn XI1608_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1608_MP4 (XI1608_p1 XI1608_An b23_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1608_MP2 (VDD dd20_b3_4 XI1608_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1608_MP3 (XI1608_p1 qu9_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1608_MP0 (VDD dd20_b3_4 XI1608_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1607_MP1 (VDD qu9_b3_3 XI1607_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1607_MP5 (b23_19 XI1607_Bn XI1607_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1607_MP4 (XI1607_p1 XI1607_An b23_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1607_MP2 (VDD dd19_b3_4 XI1607_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1607_MP3 (XI1607_p1 qu9_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1607_MP0 (VDD dd19_b3_4 XI1607_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1606_MP1 (VDD qu9_b3_3 XI1606_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1606_MP5 (b23_18 XI1606_Bn XI1606_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1606_MP4 (XI1606_p1 XI1606_An b23_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1606_MP2 (VDD dd18_b3_4 XI1606_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1606_MP3 (XI1606_p1 qu9_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1606_MP0 (VDD dd18_b3_4 XI1606_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1560_MP1 (VDD qu10_b3_3 XI1560_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1560_MP5 (b22_18 XI1560_Bn XI1560_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1560_MP4 (XI1560_p1 XI1560_An b22_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1560_MP2 (VDD dd18_b3_4 XI1560_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1560_MP3 (XI1560_p1 qu10_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1560_MP0 (VDD dd18_b3_4 XI1560_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1561_MP1 (VDD qu10_b3_3 XI1561_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1561_MP5 (b22_19 XI1561_Bn XI1561_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1561_MP4 (XI1561_p1 XI1561_An b22_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1561_MP2 (VDD dd19_b3_4 XI1561_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1561_MP3 (XI1561_p1 qu10_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1561_MP0 (VDD dd19_b3_4 XI1561_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1111_MP1 (VDD qu20_b3_4 XI1111_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1111_MP5 (b12_29 XI1111_Bn XI1111_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1111_MP4 (XI1111_p1 XI1111_An b12_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1111_MP2 (VDD dd29_b3_2 XI1111_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1111_MP3 (XI1111_p1 qu20_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1111_MP0 (VDD dd29_b3_2 XI1111_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1106_MP1 (VDD qu20_b3_4 XI1106_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1106_MP5 (b12_24 XI1106_Bn XI1106_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1106_MP4 (XI1106_p1 XI1106_An b12_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1106_MP2 (VDD dd24_b3_2 XI1106_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1106_MP3 (XI1106_p1 qu20_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1106_MP0 (VDD dd24_b3_2 XI1106_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1105_MP1 (VDD qu20_b3_3 XI1105_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1105_MP5 (b12_23 XI1105_Bn XI1105_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1105_MP4 (XI1105_p1 XI1105_An b12_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1105_MP2 (VDD dd23_b3_2 XI1105_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1105_MP3 (XI1105_p1 qu20_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1105_MP0 (VDD dd23_b3_2 XI1105_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1102_MP1 (VDD qu20_b3_3 XI1102_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1102_MP5 (b12_20 XI1102_Bn XI1102_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1102_MP4 (XI1102_p1 XI1102_An b12_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1102_MP2 (VDD dd20_b3_2 XI1102_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1102_MP3 (XI1102_p1 qu20_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1102_MP0 (VDD dd20_b3_2 XI1102_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1099_MP1 (VDD qu20_b3_2 XI1099_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1099_MP5 (b12_17 XI1099_Bn XI1099_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1099_MP4 (XI1099_p1 XI1099_An b12_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1099_MP2 (VDD dd17_b3_2 XI1099_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1099_MP3 (XI1099_p1 qu20_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1099_MP0 (VDD dd17_b3_2 XI1099_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1090_MP1 (VDD qu20_b3_1 XI1090_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1090_MP5 (b12_8 XI1090_Bn XI1090_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1090_MP4 (XI1090_p1 XI1090_An b12_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1090_MP2 (VDD dd8_b3_2 XI1090_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1090_MP3 (XI1090_p1 qu20_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1090_MP0 (VDD dd8_b3_2 XI1090_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1010_MP1 (VDD qu22_b3_3 XI1010_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1010_MP5 (b10_20 XI1010_Bn XI1010_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1010_MP4 (XI1010_p1 XI1010_An b10_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1010_MP2 (VDD dd20_b3_1 XI1010_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1010_MP3 (XI1010_p1 qu22_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1010_MP0 (VDD dd20_b3_1 XI1010_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1011_MP1 (VDD qu22_b3_3 XI1011_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1011_MP5 (b10_21 XI1011_Bn XI1011_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1011_MP4 (XI1011_p1 XI1011_An b10_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1011_MP2 (VDD dd21_b3_1 XI1011_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1011_MP3 (XI1011_p1 qu22_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1011_MP0 (VDD dd21_b3_1 XI1011_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI964_MP1 (VDD qu23_b3_3 XI964_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI964_MP5 (b9_20 XI964_Bn XI964_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI964_MP4 (XI964_p1 XI964_An b9_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI964_MP2 (VDD dd20_b3_1 XI964_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI964_MP3 (XI964_p1 qu23_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI964_MP0 (VDD dd20_b3_1 XI964_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI965_MP1 (VDD qu23_b3_3 XI965_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI965_MP5 (b9_21 XI965_Bn XI965_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI965_MP4 (XI965_p1 XI965_An b9_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI965_MP2 (VDD dd21_b3_1 XI965_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI965_MP3 (XI965_p1 qu23_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI965_MP0 (VDD dd21_b3_1 XI965_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI918_MP1 (VDD qu24_b3_3 XI918_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI918_MP5 (b8_20 XI918_Bn XI918_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI918_MP4 (XI918_p1 XI918_An b8_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI918_MP2 (VDD dd20_b3_1 XI918_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI918_MP3 (XI918_p1 qu24_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI918_MP0 (VDD dd20_b3_1 XI918_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI919_MP1 (VDD qu24_b3_3 XI919_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI919_MP5 (b8_21 XI919_Bn XI919_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI919_MP4 (XI919_p1 XI919_An b8_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI919_MP2 (VDD dd21_b3_1 XI919_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI919_MP3 (XI919_p1 qu24_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI919_MP0 (VDD dd21_b3_1 XI919_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1655_MP1 (VDD qu8_b3_3 XI1655_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1655_MP5 (b24_21 XI1655_Bn XI1655_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1655_MP4 (XI1655_p1 XI1655_An b24_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1655_MP2 (VDD dd21_b3_4 XI1655_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1655_MP3 (XI1655_p1 qu8_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1655_MP0 (VDD dd21_b3_4 XI1655_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1654_MP1 (VDD qu8_b3_3 XI1654_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1654_MP5 (b24_20 XI1654_Bn XI1654_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1654_MP4 (XI1654_p1 XI1654_An b24_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1654_MP2 (VDD dd20_b3_4 XI1654_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1654_MP3 (XI1654_p1 qu8_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1654_MP0 (VDD dd20_b3_4 XI1654_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1609_MP1 (VDD qu9_b3_3 XI1609_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1609_MP5 (b23_21 XI1609_Bn XI1609_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1609_MP4 (XI1609_p1 XI1609_An b23_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1609_MP2 (VDD dd21_b3_4 XI1609_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1609_MP3 (XI1609_p1 qu9_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1609_MP0 (VDD dd21_b3_4 XI1609_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1563_MP1 (VDD qu10_b3_3 XI1563_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1563_MP5 (b22_21 XI1563_Bn XI1563_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1563_MP4 (XI1563_p1 XI1563_An b22_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1563_MP2 (VDD dd21_b3_4 XI1563_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1563_MP3 (XI1563_p1 qu10_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1563_MP0 (VDD dd21_b3_4 XI1563_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1562_MP1 (VDD qu10_b3_3 XI1562_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1562_MP5 (b22_20 XI1562_Bn XI1562_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1562_MP4 (XI1562_p1 XI1562_An b22_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1562_MP2 (VDD dd20_b3_4 XI1562_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1562_MP3 (XI1562_p1 qu10_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1562_MP0 (VDD dd20_b3_4 XI1562_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1091_MP1 (VDD qu20_b3_1 XI1091_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1091_MP5 (b12_9 XI1091_Bn XI1091_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1091_MP4 (XI1091_p1 XI1091_An b12_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1091_MP2 (VDD dd9_b3_2 XI1091_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1091_MP3 (XI1091_p1 qu20_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1091_MP0 (VDD dd9_b3_2 XI1091_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1092_MP1 (VDD qu20_b3_1 XI1092_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1092_MP5 (b12_10 XI1092_Bn XI1092_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1092_MP4 (XI1092_p1 XI1092_An b12_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1092_MP2 (VDD dd10_b3_2 XI1092_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1092_MP3 (XI1092_p1 qu20_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1092_MP0 (VDD dd10_b3_2 XI1092_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1089_MP1 (VDD qu20_b3_1 XI1089_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1089_MP5 (b12_7 XI1089_Bn XI1089_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1089_MP4 (XI1089_p1 XI1089_An b12_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1089_MP2 (VDD dd7_b3_2 XI1089_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1089_MP3 (XI1089_p1 qu20_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1089_MP0 (VDD dd7_b3_2 XI1089_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1093_MP1 (VDD qu20_b3_1 XI1093_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1093_MP5 (b12_11 XI1093_Bn XI1093_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1093_MP4 (XI1093_p1 XI1093_An b12_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1093_MP2 (VDD dd11_b3_2 XI1093_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1093_MP3 (XI1093_p1 qu20_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1093_MP0 (VDD dd11_b3_2 XI1093_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1012_MP1 (VDD qu22_b3_3 XI1012_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1012_MP5 (b10_22 XI1012_Bn XI1012_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1012_MP4 (XI1012_p1 XI1012_An b10_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1012_MP2 (VDD dd22_b3_1 XI1012_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1012_MP3 (XI1012_p1 qu22_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1012_MP0 (VDD dd22_b3_1 XI1012_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI966_MP1 (VDD qu23_b3_3 XI966_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI966_MP5 (b9_22 XI966_Bn XI966_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI966_MP4 (XI966_p1 XI966_An b9_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI966_MP2 (VDD dd22_b3_1 XI966_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI966_MP3 (XI966_p1 qu23_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI966_MP0 (VDD dd22_b3_1 XI966_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI920_MP1 (VDD qu24_b3_3 XI920_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI920_MP5 (b8_22 XI920_Bn XI920_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI920_MP4 (XI920_p1 XI920_An b8_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI920_MP2 (VDD dd22_b3_1 XI920_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI920_MP3 (XI920_p1 qu24_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI920_MP0 (VDD dd22_b3_1 XI920_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI921_MP1 (VDD qu24_b3_3 XI921_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI921_MP5 (b8_23 XI921_Bn XI921_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI921_MP4 (XI921_p1 XI921_An b8_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI921_MP2 (VDD dd23_b3_1 XI921_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI921_MP3 (XI921_p1 qu24_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI921_MP0 (VDD dd23_b3_1 XI921_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1656_MP1 (VDD qu8_b3_3 XI1656_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1656_MP5 (b24_22 XI1656_Bn XI1656_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1656_MP4 (XI1656_p1 XI1656_An b24_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1656_MP2 (VDD dd22_b3_4 XI1656_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1656_MP3 (XI1656_p1 qu8_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1656_MP0 (VDD dd22_b3_4 XI1656_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1657_MP1 (VDD qu8_b3_3 XI1657_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1657_MP5 (b24_23 XI1657_Bn XI1657_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1657_MP4 (XI1657_p1 XI1657_An b24_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1657_MP2 (VDD dd23_b3_4 XI1657_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1657_MP3 (XI1657_p1 qu8_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1657_MP0 (VDD dd23_b3_4 XI1657_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1611_MP1 (VDD qu9_b3_3 XI1611_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1611_MP5 (b23_23 XI1611_Bn XI1611_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1611_MP4 (XI1611_p1 XI1611_An b23_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1611_MP2 (VDD dd23_b3_4 XI1611_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1611_MP3 (XI1611_p1 qu9_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1611_MP0 (VDD dd23_b3_4 XI1611_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1610_MP1 (VDD qu9_b3_3 XI1610_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1610_MP5 (b23_22 XI1610_Bn XI1610_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1610_MP4 (XI1610_p1 XI1610_An b23_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1610_MP2 (VDD dd22_b3_4 XI1610_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1610_MP3 (XI1610_p1 qu9_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1610_MP0 (VDD dd22_b3_4 XI1610_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1564_MP1 (VDD qu10_b3_3 XI1564_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1564_MP5 (b22_22 XI1564_Bn XI1564_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1564_MP4 (XI1564_p1 XI1564_An b22_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1564_MP2 (VDD dd22_b3_4 XI1564_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1564_MP3 (XI1564_p1 qu10_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1564_MP0 (VDD dd22_b3_4 XI1564_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1565_MP1 (VDD qu10_b3_3 XI1565_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1565_MP5 (b22_23 XI1565_Bn XI1565_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1565_MP4 (XI1565_p1 XI1565_An b22_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1565_MP2 (VDD dd23_b3_4 XI1565_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1565_MP3 (XI1565_p1 qu10_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1565_MP0 (VDD dd23_b3_4 XI1565_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1112_MP1 (VDD qu20_b3_5 XI1112_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1112_MP5 (b12_30 XI1112_Bn XI1112_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1112_MP4 (XI1112_p1 XI1112_An b12_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1112_MP2 (VDD dd30_b3_2 XI1112_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1112_MP3 (XI1112_p1 qu20_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1112_MP0 (VDD dd30_b3_2 XI1112_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1088_MP1 (VDD qu20_b3_1 XI1088_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1088_MP5 (b12_6 XI1088_Bn XI1088_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1088_MP4 (XI1088_p1 XI1088_An b12_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1088_MP2 (VDD dd6_b3_2 XI1088_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1088_MP3 (XI1088_p1 qu20_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1088_MP0 (VDD dd6_b3_2 XI1088_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1087_MP1 (VDD qu20_b3_0 XI1087_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1087_MP5 (b12_5 XI1087_Bn XI1087_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1087_MP4 (XI1087_p1 XI1087_An b12_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1087_MP2 (VDD dd5_b3_2 XI1087_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1087_MP3 (XI1087_p1 qu20_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1087_MP0 (VDD dd5_b3_2 XI1087_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1024_MP1 (VDD c10_o XI1024_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1024_MP5 (p10_32 XI1024_Bn XI1024_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1024_MP4 (XI1024_p1 XI1024_An p10_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1024_MP2 (VDD h10 XI1024_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1024_MP3 (XI1024_p1 c10_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1024_MP0 (VDD h10 XI1024_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1013_MP1 (VDD qu22_b3_3 XI1013_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1013_MP5 (b10_23 XI1013_Bn XI1013_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1013_MP4 (XI1013_p1 XI1013_An b10_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1013_MP2 (VDD dd23_b3_1 XI1013_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1013_MP3 (XI1013_p1 qu22_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1013_MP0 (VDD dd23_b3_1 XI1013_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1014_MP1 (VDD qu22_b3_4 XI1014_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1014_MP5 (b10_24 XI1014_Bn XI1014_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1014_MP4 (XI1014_p1 XI1014_An b10_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1014_MP2 (VDD dd24_b3_1 XI1014_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1014_MP3 (XI1014_p1 qu22_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1014_MP0 (VDD dd24_b3_1 XI1014_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI967_MP1 (VDD qu23_b3_3 XI967_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI967_MP5 (b9_23 XI967_Bn XI967_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI967_MP4 (XI967_p1 XI967_An b9_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI967_MP2 (VDD dd23_b3_1 XI967_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI967_MP3 (XI967_p1 qu23_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI967_MP0 (VDD dd23_b3_1 XI967_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI969_MP1 (VDD qu23_b3_4 XI969_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI969_MP5 (b9_25 XI969_Bn XI969_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI969_MP4 (XI969_p1 XI969_An b9_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI969_MP2 (VDD dd25_b3_1 XI969_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI969_MP3 (XI969_p1 qu23_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI969_MP0 (VDD dd25_b3_1 XI969_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI922_MP1 (VDD qu24_b3_4 XI922_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI922_MP5 (b8_24 XI922_Bn XI922_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI922_MP4 (XI922_p1 XI922_An b8_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI922_MP2 (VDD dd24_b3_1 XI922_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI922_MP3 (XI922_p1 qu24_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI922_MP0 (VDD dd24_b3_1 XI922_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1658_MP1 (VDD qu8_b3_4 XI1658_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1658_MP5 (b24_24 XI1658_Bn XI1658_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1658_MP4 (XI1658_p1 XI1658_An b24_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1658_MP2 (VDD dd24_b3_4 XI1658_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1658_MP3 (XI1658_p1 qu8_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1658_MP0 (VDD dd24_b3_4 XI1658_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1668_MP1 (VDD c24_o XI1668_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1668_MP5 (p24_32 XI1668_Bn XI1668_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1668_MP4 (XI1668_p1 XI1668_An p24_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1668_MP2 (VDD h24 XI1668_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1668_MP3 (XI1668_p1 c24_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1668_MP0 (VDD h24 XI1668_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1612_MP1 (VDD qu9_b3_4 XI1612_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1612_MP5 (b23_24 XI1612_Bn XI1612_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1612_MP4 (XI1612_p1 XI1612_An b23_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1612_MP2 (VDD dd24_b3_4 XI1612_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1612_MP3 (XI1612_p1 qu9_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1612_MP0 (VDD dd24_b3_4 XI1612_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1576_MP1 (VDD c22_o XI1576_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1576_MP5 (p22_32 XI1576_Bn XI1576_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1576_MP4 (XI1576_p1 XI1576_An p22_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1576_MP2 (VDD h22 XI1576_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1576_MP3 (XI1576_p1 c22_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1576_MP0 (VDD h22 XI1576_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1566_MP1 (VDD qu10_b3_4 XI1566_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1566_MP5 (b22_24 XI1566_Bn XI1566_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1566_MP4 (XI1566_p1 XI1566_An b22_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1566_MP2 (VDD dd24_b3_4 XI1566_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1566_MP3 (XI1566_p1 qu10_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1566_MP0 (VDD dd24_b3_4 XI1566_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1113_MP1 (VDD qu20_b3_5 XI1113_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1113_MP5 (b12_31 XI1113_Bn XI1113_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1113_MP4 (XI1113_p1 XI1113_An b12_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1113_MP2 (VDD dd31_b3_2 XI1113_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1113_MP3 (XI1113_p1 qu20_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1113_MP0 (VDD dd31_b3_2 XI1113_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1085_MP1 (VDD qu20_b3_0 XI1085_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1085_MP5 (b12_3 XI1085_Bn XI1085_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1085_MP4 (XI1085_p1 XI1085_An b12_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1085_MP2 (VDD dd3_b3_2 XI1085_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1085_MP3 (XI1085_p1 qu20_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1085_MP0 (VDD dd3_b3_2 XI1085_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1086_MP1 (VDD qu20_b3_0 XI1086_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1086_MP5 (b12_4 XI1086_Bn XI1086_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1086_MP4 (XI1086_p1 XI1086_An b12_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1086_MP2 (VDD dd4_b3_2 XI1086_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1086_MP3 (XI1086_p1 qu20_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1086_MP0 (VDD dd4_b3_2 XI1086_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1036_MP1 (VDD qu21_b3_0 XI1036_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1036_MP5 (b11_0 XI1036_Bn XI1036_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1036_MP4 (XI1036_p1 XI1036_An b11_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1036_MP2 (VDD B_0_b3_2 XI1036_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1036_MP3 (XI1036_p1 qu21_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1036_MP0 (VDD B_0_b3_2 XI1036_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1016_MP1 (VDD qu22_b3_4 XI1016_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1016_MP5 (b10_26 XI1016_Bn XI1016_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1016_MP4 (XI1016_p1 XI1016_An b10_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1016_MP2 (VDD dd26_b3_1 XI1016_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1016_MP3 (XI1016_p1 qu22_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1016_MP0 (VDD dd26_b3_1 XI1016_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1015_MP1 (VDD qu22_b3_4 XI1015_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1015_MP5 (b10_25 XI1015_Bn XI1015_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1015_MP4 (XI1015_p1 XI1015_An b10_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1015_MP2 (VDD dd25_b3_1 XI1015_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1015_MP3 (XI1015_p1 qu22_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1015_MP0 (VDD dd25_b3_1 XI1015_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI970_MP1 (VDD qu23_b3_4 XI970_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI970_MP5 (b9_26 XI970_Bn XI970_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI970_MP4 (XI970_p1 XI970_An b9_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI970_MP2 (VDD dd26_b3_1 XI970_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI970_MP3 (XI970_p1 qu23_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI970_MP0 (VDD dd26_b3_1 XI970_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI968_MP1 (VDD qu23_b3_4 XI968_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI968_MP5 (b9_24 XI968_Bn XI968_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI968_MP4 (XI968_p1 XI968_An b9_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI968_MP2 (VDD dd24_b3_1 XI968_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI968_MP3 (XI968_p1 qu23_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI968_MP0 (VDD dd24_b3_1 XI968_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI923_MP1 (VDD qu24_b3_4 XI923_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI923_MP5 (b8_25 XI923_Bn XI923_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI923_MP4 (XI923_p1 XI923_An b8_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI923_MP2 (VDD dd25_b3_1 XI923_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI923_MP3 (XI923_p1 qu24_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI923_MP0 (VDD dd25_b3_1 XI923_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI924_MP1 (VDD qu24_b3_4 XI924_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI924_MP5 (b8_26 XI924_Bn XI924_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI924_MP4 (XI924_p1 XI924_An b8_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI924_MP2 (VDD dd26_b3_1 XI924_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI924_MP3 (XI924_p1 qu24_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI924_MP0 (VDD dd26_b3_1 XI924_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1659_MP1 (VDD qu8_b3_4 XI1659_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1659_MP5 (b24_25 XI1659_Bn XI1659_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1659_MP4 (XI1659_p1 XI1659_An b24_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1659_MP2 (VDD dd25_b3_4 XI1659_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1659_MP3 (XI1659_p1 qu8_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1659_MP0 (VDD dd25_b3_4 XI1659_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1660_MP1 (VDD qu8_b3_4 XI1660_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1660_MP5 (b24_26 XI1660_Bn XI1660_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1660_MP4 (XI1660_p1 XI1660_An b24_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1660_MP2 (VDD dd26_b3_4 XI1660_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1660_MP3 (XI1660_p1 qu8_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1660_MP0 (VDD dd26_b3_4 XI1660_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1661_MP1 (VDD qu8_b3_4 XI1661_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1661_MP5 (b24_27 XI1661_Bn XI1661_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1661_MP4 (XI1661_p1 XI1661_An b24_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1661_MP2 (VDD dd27_b3_4 XI1661_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1661_MP3 (XI1661_p1 qu8_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1661_MP0 (VDD dd27_b3_4 XI1661_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1662_MP1 (VDD qu8_b3_4 XI1662_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1662_MP5 (b24_28 XI1662_Bn XI1662_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1662_MP4 (XI1662_p1 XI1662_An b24_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1662_MP2 (VDD dd28_b3_4 XI1662_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1662_MP3 (XI1662_p1 qu8_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1662_MP0 (VDD dd28_b3_4 XI1662_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1664_MP1 (VDD qu8_b3_5 XI1664_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1664_MP5 (b24_30 XI1664_Bn XI1664_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1664_MP4 (XI1664_p1 XI1664_An b24_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1664_MP2 (VDD dd30_b3_4 XI1664_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1664_MP3 (XI1664_p1 qu8_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1664_MP0 (VDD dd30_b3_4 XI1664_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1665_MP1 (VDD qu8_b3_5 XI1665_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1665_MP5 (b24_31 XI1665_Bn XI1665_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1665_MP4 (XI1665_p1 XI1665_An b24_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1665_MP2 (VDD dd31_b3_4 XI1665_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1665_MP3 (XI1665_p1 qu8_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1665_MP0 (VDD dd31_b3_4 XI1665_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1667_MP1 (VDD qu8_b3_5 XI1667_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1667_MP5 (h24 XI1667_Bn XI1667_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1667_MP4 (XI1667_p1 XI1667_An h24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1667_MP2 (VDD p23_31 XI1667_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1667_MP3 (XI1667_p1 qu8_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1667_MP0 (VDD p23_31 XI1667_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1622_MP1 (VDD c23_o XI1622_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1622_MP5 (p23_32 XI1622_Bn XI1622_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1622_MP4 (XI1622_p1 XI1622_An p23_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1622_MP2 (VDD h23 XI1622_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1622_MP3 (XI1622_p1 c23_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1622_MP0 (VDD h23 XI1622_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1619_MP1 (VDD qu9_b3_5 XI1619_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1619_MP5 (b23_31 XI1619_Bn XI1619_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1619_MP4 (XI1619_p1 XI1619_An b23_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1619_MP2 (VDD dd31_b3_4 XI1619_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1619_MP3 (XI1619_p1 qu9_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1619_MP0 (VDD dd31_b3_4 XI1619_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1618_MP1 (VDD qu9_b3_5 XI1618_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1618_MP5 (b23_30 XI1618_Bn XI1618_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1618_MP4 (XI1618_p1 XI1618_An b23_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1618_MP2 (VDD dd30_b3_4 XI1618_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1618_MP3 (XI1618_p1 qu9_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1618_MP0 (VDD dd30_b3_4 XI1618_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1615_MP1 (VDD qu9_b3_4 XI1615_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1615_MP5 (b23_27 XI1615_Bn XI1615_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1615_MP4 (XI1615_p1 XI1615_An b23_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1615_MP2 (VDD dd27_b3_4 XI1615_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1615_MP3 (XI1615_p1 qu9_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1615_MP0 (VDD dd27_b3_4 XI1615_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1614_MP1 (VDD qu9_b3_4 XI1614_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1614_MP5 (b23_26 XI1614_Bn XI1614_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1614_MP4 (XI1614_p1 XI1614_An b23_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1614_MP2 (VDD dd26_b3_4 XI1614_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1614_MP3 (XI1614_p1 qu9_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1614_MP0 (VDD dd26_b3_4 XI1614_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1613_MP1 (VDD qu9_b3_4 XI1613_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1613_MP5 (b23_25 XI1613_Bn XI1613_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1613_MP4 (XI1613_p1 XI1613_An b23_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1613_MP2 (VDD dd25_b3_4 XI1613_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1613_MP3 (XI1613_p1 qu9_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1613_MP0 (VDD dd25_b3_4 XI1613_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1621_MP1 (VDD qu9_b3_5 XI1621_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1621_MP5 (h23 XI1621_Bn XI1621_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1621_MP4 (XI1621_p1 XI1621_An h23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1621_MP2 (VDD p22_31 XI1621_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1621_MP3 (XI1621_p1 qu9_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1621_MP0 (VDD p22_31 XI1621_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1572_MP1 (VDD qu10_b3_5 XI1572_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1572_MP5 (b22_30 XI1572_Bn XI1572_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1572_MP4 (XI1572_p1 XI1572_An b22_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1572_MP2 (VDD dd30_b3_4 XI1572_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1572_MP3 (XI1572_p1 qu10_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1572_MP0 (VDD dd30_b3_4 XI1572_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1575_MP1 (VDD qu10_b3_5 XI1575_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1575_MP5 (h22 XI1575_Bn XI1575_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1575_MP4 (XI1575_p1 XI1575_An h22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1575_MP2 (VDD p21_31 XI1575_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1575_MP3 (XI1575_p1 qu10_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1575_MP0 (VDD p21_31 XI1575_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1567_MP1 (VDD qu10_b3_4 XI1567_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1567_MP5 (b22_25 XI1567_Bn XI1567_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1567_MP4 (XI1567_p1 XI1567_An b22_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1567_MP2 (VDD dd25_b3_4 XI1567_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1567_MP3 (XI1567_p1 qu10_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1567_MP0 (VDD dd25_b3_4 XI1567_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I218_MP1 (VDD I1114_G14_0n XI1114_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I218_MP5 (p12_15 XI1114_I218_Bn XI1114_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I218_MP4 (XI1114_I218_p1 XI1114_I218_An p12_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I218_MP2 (VDD I1114_pn15 XI1114_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I218_MP3 (XI1114_I218_p1 I1114_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I218_MP0 (VDD I1114_pn15 XI1114_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I216_MP1 (VDD I1114_G12_0n XI1114_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I216_MP5 (p12_13 XI1114_I216_Bn XI1114_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I216_MP4 (XI1114_I216_p1 XI1114_I216_An p12_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I216_MP2 (VDD I1114_pn13 XI1114_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I216_MP3 (XI1114_I216_p1 I1114_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I216_MP0 (VDD I1114_pn13 XI1114_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1084_MP1 (VDD qu20_b3_0 XI1084_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1084_MP5 (b12_2 XI1084_Bn XI1084_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1084_MP4 (XI1084_p1 XI1084_An b12_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1084_MP2 (VDD dd2_b3_2 XI1084_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1084_MP3 (XI1084_p1 qu20_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1084_MP0 (VDD dd2_b3_2 XI1084_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1017_MP1 (VDD qu22_b3_4 XI1017_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1017_MP5 (b10_27 XI1017_Bn XI1017_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1017_MP4 (XI1017_p1 XI1017_An b10_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1017_MP2 (VDD dd27_b3_1 XI1017_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1017_MP3 (XI1017_p1 qu22_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1017_MP0 (VDD dd27_b3_1 XI1017_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1018_MP1 (VDD qu22_b3_4 XI1018_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1018_MP5 (b10_28 XI1018_Bn XI1018_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1018_MP4 (XI1018_p1 XI1018_An b10_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1018_MP2 (VDD dd28_b3_1 XI1018_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1018_MP3 (XI1018_p1 qu22_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1018_MP0 (VDD dd28_b3_1 XI1018_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI929_MP1 (VDD qu24_b3_5 XI929_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI929_MP5 (b8_31 XI929_Bn XI929_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI929_MP4 (XI929_p1 XI929_An b8_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI929_MP2 (VDD dd31_b3_1 XI929_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI929_MP3 (XI929_p1 qu24_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI929_MP0 (VDD dd31_b3_1 XI929_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI971_MP1 (VDD qu23_b3_4 XI971_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI971_MP5 (b9_27 XI971_Bn XI971_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI971_MP4 (XI971_p1 XI971_An b9_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI971_MP2 (VDD dd27_b3_1 XI971_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI971_MP3 (XI971_p1 qu23_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI971_MP0 (VDD dd27_b3_1 XI971_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI972_MP1 (VDD qu23_b3_4 XI972_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI972_MP5 (b9_28 XI972_Bn XI972_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI972_MP4 (XI972_p1 XI972_An b9_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI972_MP2 (VDD dd28_b3_1 XI972_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI972_MP3 (XI972_p1 qu23_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI972_MP0 (VDD dd28_b3_1 XI972_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI925_MP1 (VDD qu24_b3_4 XI925_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI925_MP5 (b8_27 XI925_Bn XI925_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI925_MP4 (XI925_p1 XI925_An b8_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI925_MP2 (VDD dd27_b3_1 XI925_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI925_MP3 (XI925_p1 qu24_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI925_MP0 (VDD dd27_b3_1 XI925_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI926_MP1 (VDD qu24_b3_4 XI926_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI926_MP5 (b8_28 XI926_Bn XI926_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI926_MP4 (XI926_p1 XI926_An b8_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI926_MP2 (VDD dd28_b3_1 XI926_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI926_MP3 (XI926_p1 qu24_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI926_MP0 (VDD dd28_b3_1 XI926_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1663_MP1 (VDD qu8_b3_4 XI1663_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1663_MP5 (b24_29 XI1663_Bn XI1663_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1663_MP4 (XI1663_p1 XI1663_An b24_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1663_MP2 (VDD dd29_b3_4 XI1663_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1663_MP3 (XI1663_p1 qu8_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1663_MP0 (VDD dd29_b3_4 XI1663_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1617_MP1 (VDD qu9_b3_4 XI1617_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1617_MP5 (b23_29 XI1617_Bn XI1617_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1617_MP4 (XI1617_p1 XI1617_An b23_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1617_MP2 (VDD dd29_b3_4 XI1617_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1617_MP3 (XI1617_p1 qu9_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1617_MP0 (VDD dd29_b3_4 XI1617_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1616_MP1 (VDD qu9_b3_4 XI1616_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1616_MP5 (b23_28 XI1616_Bn XI1616_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1616_MP4 (XI1616_p1 XI1616_An b23_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1616_MP2 (VDD dd28_b3_4 XI1616_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1616_MP3 (XI1616_p1 qu9_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1616_MP0 (VDD dd28_b3_4 XI1616_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1496_MP1 (VDD qu11_b3_0 XI1496_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1496_MP5 (b21_0 XI1496_Bn XI1496_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1496_MP4 (XI1496_p1 XI1496_An b21_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1496_MP2 (VDD B_0_b3_3 XI1496_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1496_MP3 (XI1496_p1 qu11_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1496_MP0 (VDD B_0_b3_3 XI1496_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1573_MP1 (VDD qu10_b3_5 XI1573_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1573_MP5 (b22_31 XI1573_Bn XI1573_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1573_MP4 (XI1573_p1 XI1573_An b22_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1573_MP2 (VDD dd31_b3_4 XI1573_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1573_MP3 (XI1573_p1 qu10_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1573_MP0 (VDD dd31_b3_4 XI1573_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1568_MP1 (VDD qu10_b3_4 XI1568_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1568_MP5 (b22_26 XI1568_Bn XI1568_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1568_MP4 (XI1568_p1 XI1568_An b22_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1568_MP2 (VDD dd26_b3_4 XI1568_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1568_MP3 (XI1568_p1 qu10_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1568_MP0 (VDD dd26_b3_4 XI1568_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1569_MP1 (VDD qu10_b3_4 XI1569_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1569_MP5 (b22_27 XI1569_Bn XI1569_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1569_MP4 (XI1569_p1 XI1569_An b22_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1569_MP2 (VDD dd27_b3_4 XI1569_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1569_MP3 (XI1569_p1 qu10_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1569_MP0 (VDD dd27_b3_4 XI1569_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I214_MP1 (VDD I1114_G10_0n XI1114_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I214_MP5 (p12_11 XI1114_I214_Bn XI1114_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I214_MP4 (XI1114_I214_p1 XI1114_I214_An p12_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I214_MP2 (VDD I1114_pn11 XI1114_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I214_MP3 (XI1114_I214_p1 I1114_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I214_MP0 (VDD I1114_pn11 XI1114_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I212_MP1 (VDD I1114_G8_0n XI1114_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I212_MP5 (p12_9 XI1114_I212_Bn XI1114_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I212_MP4 (XI1114_I212_p1 XI1114_I212_An p12_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I212_MP2 (VDD I1114_pn9 XI1114_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I212_MP3 (XI1114_I212_p1 I1114_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I212_MP0 (VDD I1114_pn9 XI1114_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1083_MP1 (VDD qu20_b3_0 XI1083_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1083_MP5 (b12_1 XI1083_Bn XI1083_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1083_MP4 (XI1083_p1 XI1083_An b12_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1083_MP2 (VDD dd1_b3_2 XI1083_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1083_MP3 (XI1083_p1 qu20_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1083_MP0 (VDD dd1_b3_2 XI1083_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1082_MP1 (VDD qu20_b3_0 XI1082_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1082_MP5 (b12_0 XI1082_Bn XI1082_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1082_MP4 (XI1082_p1 XI1082_An b12_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1082_MP2 (VDD B_0_b3_2 XI1082_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1082_MP3 (XI1082_p1 qu20_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1082_MP0 (VDD B_0_b3_2 XI1082_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1023_MP1 (VDD qu22_b3_5 XI1023_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1023_MP5 (h10 XI1023_Bn XI1023_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1023_MP4 (XI1023_p1 XI1023_An h10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1023_MP2 (VDD p9_31 XI1023_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1023_MP3 (XI1023_p1 qu22_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1023_MP0 (VDD p9_31 XI1023_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1021_MP1 (VDD qu22_b3_5 XI1021_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1021_MP5 (b10_31 XI1021_Bn XI1021_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1021_MP4 (XI1021_p1 XI1021_An b10_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1021_MP2 (VDD dd31_b3_1 XI1021_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1021_MP3 (XI1021_p1 qu22_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1021_MP0 (VDD dd31_b3_1 XI1021_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1020_MP1 (VDD qu22_b3_5 XI1020_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1020_MP5 (b10_30 XI1020_Bn XI1020_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1020_MP4 (XI1020_p1 XI1020_An b10_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1020_MP2 (VDD dd30_b3_1 XI1020_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1020_MP3 (XI1020_p1 qu22_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1020_MP0 (VDD dd30_b3_1 XI1020_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1019_MP1 (VDD qu22_b3_4 XI1019_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1019_MP5 (b10_29 XI1019_Bn XI1019_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1019_MP4 (XI1019_p1 XI1019_An b10_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1019_MP2 (VDD dd29_b3_1 XI1019_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1019_MP3 (XI1019_p1 qu22_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1019_MP0 (VDD dd29_b3_1 XI1019_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI975_MP1 (VDD qu23_b3_5 XI975_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI975_MP5 (b9_31 XI975_Bn XI975_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI975_MP4 (XI975_p1 XI975_An b9_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI975_MP2 (VDD dd31_b3_1 XI975_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI975_MP3 (XI975_p1 qu23_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI975_MP0 (VDD dd31_b3_1 XI975_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI974_MP1 (VDD qu23_b3_5 XI974_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI974_MP5 (b9_30 XI974_Bn XI974_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI974_MP4 (XI974_p1 XI974_An b9_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI974_MP2 (VDD dd30_b3_1 XI974_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI974_MP3 (XI974_p1 qu23_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI974_MP0 (VDD dd30_b3_1 XI974_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI928_MP1 (VDD qu24_b3_5 XI928_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI928_MP5 (b8_30 XI928_Bn XI928_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI928_MP4 (XI928_p1 XI928_An b8_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI928_MP2 (VDD dd30_b3_1 XI928_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI928_MP3 (XI928_p1 qu24_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI928_MP0 (VDD dd30_b3_1 XI928_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI973_MP1 (VDD qu23_b3_4 XI973_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI973_MP5 (b9_29 XI973_Bn XI973_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI973_MP4 (XI973_p1 XI973_An b9_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI973_MP2 (VDD dd29_b3_1 XI973_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI973_MP3 (XI973_p1 qu23_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI973_MP0 (VDD dd29_b3_1 XI973_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI927_MP1 (VDD qu24_b3_4 XI927_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI927_MP5 (b8_29 XI927_Bn XI927_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI927_MP4 (XI927_p1 XI927_An b8_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI927_MP2 (VDD dd29_b3_1 XI927_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI927_MP3 (XI927_p1 qu24_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI927_MP0 (VDD dd29_b3_1 XI927_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1312_MP1 (VDD qu15_b3_0 XI1312_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1312_MP5 (b17_0 XI1312_Bn XI1312_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1312_MP4 (XI1312_p1 XI1312_An b17_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1312_MP2 (VDD B_0_b3_3 XI1312_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1312_MP3 (XI1312_p1 qu15_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1312_MP0 (VDD B_0_b3_3 XI1312_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1361_MP1 (VDD qu14_b3_0 XI1361_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1361_MP5 (b18_3 XI1361_Bn XI1361_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1361_MP4 (XI1361_p1 XI1361_An b18_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1361_MP2 (VDD dd3_b3_3 XI1361_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1361_MP3 (XI1361_p1 qu14_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1361_MP0 (VDD dd3_b3_3 XI1361_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1358_MP1 (VDD qu14_b3_0 XI1358_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1358_MP5 (b18_0 XI1358_Bn XI1358_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1358_MP4 (XI1358_p1 XI1358_An b18_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1358_MP2 (VDD B_0_b3_3 XI1358_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1358_MP3 (XI1358_p1 qu14_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1358_MP0 (VDD B_0_b3_3 XI1358_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1360_MP1 (VDD qu14_b3_0 XI1360_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1360_MP5 (b18_2 XI1360_Bn XI1360_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1360_MP4 (XI1360_p1 XI1360_An b18_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1360_MP2 (VDD dd2_b3_3 XI1360_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1360_MP3 (XI1360_p1 qu14_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1360_MP0 (VDD dd2_b3_3 XI1360_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1404_MP1 (VDD qu13_b3_0 XI1404_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1404_MP5 (b19_0 XI1404_Bn XI1404_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1404_MP4 (XI1404_p1 XI1404_An b19_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1404_MP2 (VDD B_0_b3_3 XI1404_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1404_MP3 (XI1404_p1 qu13_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1404_MP0 (VDD B_0_b3_3 XI1404_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1405_MP1 (VDD qu13_b3_0 XI1405_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1405_MP5 (b19_1 XI1405_Bn XI1405_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1405_MP4 (XI1405_p1 XI1405_An b19_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1405_MP2 (VDD dd1_b3_3 XI1405_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1405_MP3 (XI1405_p1 qu13_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1405_MP0 (VDD dd1_b3_3 XI1405_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1450_MP1 (VDD qu12_b3_0 XI1450_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1450_MP5 (b20_0 XI1450_Bn XI1450_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1450_MP4 (XI1450_p1 XI1450_An b20_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1450_MP2 (VDD B_0_b3_3 XI1450_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1450_MP3 (XI1450_p1 qu12_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1450_MP0 (VDD B_0_b3_3 XI1450_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1451_MP1 (VDD qu12_b3_0 XI1451_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1451_MP5 (b20_1 XI1451_Bn XI1451_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1451_MP4 (XI1451_p1 XI1451_An b20_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1451_MP2 (VDD dd1_b3_3 XI1451_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1451_MP3 (XI1451_p1 qu12_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1451_MP0 (VDD dd1_b3_3 XI1451_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1499_MP1 (VDD qu11_b3_0 XI1499_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1499_MP5 (b21_3 XI1499_Bn XI1499_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1499_MP4 (XI1499_p1 XI1499_An b21_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1499_MP2 (VDD dd3_b3_3 XI1499_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1499_MP3 (XI1499_p1 qu11_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1499_MP0 (VDD dd3_b3_3 XI1499_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1497_MP1 (VDD qu11_b3_0 XI1497_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1497_MP5 (b21_1 XI1497_Bn XI1497_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1497_MP4 (XI1497_p1 XI1497_An b21_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1497_MP2 (VDD dd1_b3_3 XI1497_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1497_MP3 (XI1497_p1 qu11_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1497_MP0 (VDD dd1_b3_3 XI1497_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1498_MP1 (VDD qu11_b3_0 XI1498_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1498_MP5 (b21_2 XI1498_Bn XI1498_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1498_MP4 (XI1498_p1 XI1498_An b21_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1498_MP2 (VDD dd2_b3_3 XI1498_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1498_MP3 (XI1498_p1 qu11_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1498_MP0 (VDD dd2_b3_3 XI1498_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I206_MP1 (VDD I1528_G2_0n XI1528_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I206_MP5 (p21_3 XI1528_I206_Bn XI1528_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I206_MP4 (XI1528_I206_p1 XI1528_I206_An p21_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I206_MP2 (VDD I1528_pn3 XI1528_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I206_MP3 (XI1528_I206_p1 I1528_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I206_MP0 (VDD I1528_pn3 XI1528_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1571_MP1 (VDD qu10_b3_4 XI1571_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1571_MP5 (b22_29 XI1571_Bn XI1571_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1571_MP4 (XI1571_p1 XI1571_An b22_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1571_MP2 (VDD dd29_b3_4 XI1571_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1571_MP3 (XI1571_p1 qu10_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1571_MP0 (VDD dd29_b3_4 XI1571_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1570_MP1 (VDD qu10_b3_4 XI1570_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1570_MP5 (b22_28 XI1570_Bn XI1570_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1570_MP4 (XI1570_p1 XI1570_An b22_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1570_MP2 (VDD dd28_b3_4 XI1570_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1570_MP3 (XI1570_p1 qu10_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1570_MP0 (VDD dd28_b3_4 XI1570_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I206_MP1 (VDD I1114_G2_0n XI1114_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I206_MP5 (p12_3 XI1114_I206_Bn XI1114_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I206_MP4 (XI1114_I206_p1 XI1114_I206_An p12_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I206_MP2 (VDD I1114_pn3 XI1114_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I206_MP3 (XI1114_I206_p1 I1114_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I206_MP0 (VDD I1114_pn3 XI1114_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1221_MP1 (VDD qu17_b3_0 XI1221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1221_MP5 (b15_1 XI1221_Bn XI1221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1221_MP4 (XI1221_p1 XI1221_An b15_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1221_MP2 (VDD dd1_b3_2 XI1221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1221_MP3 (XI1221_p1 qu17_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1221_MP0 (VDD dd1_b3_2 XI1221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1220_MP1 (VDD qu17_b3_0 XI1220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1220_MP5 (b15_0 XI1220_Bn XI1220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1220_MP4 (XI1220_p1 XI1220_An b15_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1220_MP2 (VDD B_0_b3_2 XI1220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1220_MP3 (XI1220_p1 qu17_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1220_MP0 (VDD B_0_b3_2 XI1220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI978_MP1 (VDD c9_o XI978_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI978_MP5 (p9_32 XI978_Bn XI978_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI978_MP4 (XI978_p1 XI978_An p9_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI978_MP2 (VDD h9 XI978_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI978_MP3 (XI978_p1 c9_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI978_MP0 (VDD h9 XI978_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI977_MP1 (VDD qu23_b3_5 XI977_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI977_MP5 (h9 XI977_Bn XI977_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI977_MP4 (XI977_p1 XI977_An h9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI977_MP2 (VDD p8_31 XI977_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI977_MP3 (XI977_p1 qu23_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI977_MP0 (VDD p8_31 XI977_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1316_MP1 (VDD qu15_b3_0 XI1316_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1316_MP5 (b17_4 XI1316_Bn XI1316_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1316_MP4 (XI1316_p1 XI1316_An b17_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1316_MP2 (VDD dd4_b3_3 XI1316_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1316_MP3 (XI1316_p1 qu15_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1316_MP0 (VDD dd4_b3_3 XI1316_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1315_MP1 (VDD qu15_b3_0 XI1315_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1315_MP5 (b17_3 XI1315_Bn XI1315_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1315_MP4 (XI1315_p1 XI1315_An b17_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1315_MP2 (VDD dd3_b3_3 XI1315_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1315_MP3 (XI1315_p1 qu15_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1315_MP0 (VDD dd3_b3_3 XI1315_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1314_MP1 (VDD qu15_b3_0 XI1314_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1314_MP5 (b17_2 XI1314_Bn XI1314_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1314_MP4 (XI1314_p1 XI1314_An b17_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1314_MP2 (VDD dd2_b3_3 XI1314_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1314_MP3 (XI1314_p1 qu15_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1314_MP0 (VDD dd2_b3_3 XI1314_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1313_MP1 (VDD qu15_b3_0 XI1313_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1313_MP5 (b17_1 XI1313_Bn XI1313_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1313_MP4 (XI1313_p1 XI1313_An b17_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1313_MP2 (VDD dd1_b3_3 XI1313_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1313_MP3 (XI1313_p1 qu15_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1313_MP0 (VDD dd1_b3_3 XI1313_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1362_MP1 (VDD qu14_b3_0 XI1362_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1362_MP5 (b18_4 XI1362_Bn XI1362_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1362_MP4 (XI1362_p1 XI1362_An b18_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1362_MP2 (VDD dd4_b3_3 XI1362_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1362_MP3 (XI1362_p1 qu14_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1362_MP0 (VDD dd4_b3_3 XI1362_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1359_MP1 (VDD qu14_b3_0 XI1359_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1359_MP5 (b18_1 XI1359_Bn XI1359_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1359_MP4 (XI1359_p1 XI1359_An b18_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1359_MP2 (VDD dd1_b3_3 XI1359_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1359_MP3 (XI1359_p1 qu14_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1359_MP0 (VDD dd1_b3_3 XI1359_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1408_MP1 (VDD qu13_b3_0 XI1408_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1408_MP5 (b19_4 XI1408_Bn XI1408_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1408_MP4 (XI1408_p1 XI1408_An b19_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1408_MP2 (VDD dd4_b3_3 XI1408_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1408_MP3 (XI1408_p1 qu13_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1408_MP0 (VDD dd4_b3_3 XI1408_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1407_MP1 (VDD qu13_b3_0 XI1407_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1407_MP5 (b19_3 XI1407_Bn XI1407_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1407_MP4 (XI1407_p1 XI1407_An b19_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1407_MP2 (VDD dd3_b3_3 XI1407_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1407_MP3 (XI1407_p1 qu13_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1407_MP0 (VDD dd3_b3_3 XI1407_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1409_MP1 (VDD qu13_b3_0 XI1409_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1409_MP5 (b19_5 XI1409_Bn XI1409_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1409_MP4 (XI1409_p1 XI1409_An b19_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1409_MP2 (VDD dd5_b3_3 XI1409_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1409_MP3 (XI1409_p1 qu13_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1409_MP0 (VDD dd5_b3_3 XI1409_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1406_MP1 (VDD qu13_b3_0 XI1406_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1406_MP5 (b19_2 XI1406_Bn XI1406_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1406_MP4 (XI1406_p1 XI1406_An b19_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1406_MP2 (VDD dd2_b3_3 XI1406_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1406_MP3 (XI1406_p1 qu13_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1406_MP0 (VDD dd2_b3_3 XI1406_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1454_MP1 (VDD qu12_b3_0 XI1454_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1454_MP5 (b20_4 XI1454_Bn XI1454_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1454_MP4 (XI1454_p1 XI1454_An b20_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1454_MP2 (VDD dd4_b3_3 XI1454_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1454_MP3 (XI1454_p1 qu12_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1454_MP0 (VDD dd4_b3_3 XI1454_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1453_MP1 (VDD qu12_b3_0 XI1453_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1453_MP5 (b20_3 XI1453_Bn XI1453_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1453_MP4 (XI1453_p1 XI1453_An b20_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1453_MP2 (VDD dd3_b3_3 XI1453_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1453_MP3 (XI1453_p1 qu12_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1453_MP0 (VDD dd3_b3_3 XI1453_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1452_MP1 (VDD qu12_b3_0 XI1452_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1452_MP5 (b20_2 XI1452_Bn XI1452_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1452_MP4 (XI1452_p1 XI1452_An b20_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1452_MP2 (VDD dd2_b3_3 XI1452_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1452_MP3 (XI1452_p1 qu12_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1452_MP0 (VDD dd2_b3_3 XI1452_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1500_MP1 (VDD qu11_b3_0 XI1500_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1500_MP5 (b21_4 XI1500_Bn XI1500_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1500_MP4 (XI1500_p1 XI1500_An b21_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1500_MP2 (VDD dd4_b3_3 XI1500_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1500_MP3 (XI1500_p1 qu11_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1500_MP0 (VDD dd4_b3_3 XI1500_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I212_MP1 (VDD I1528_G8_0n XI1528_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I212_MP5 (p21_9 XI1528_I212_Bn XI1528_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I212_MP4 (XI1528_I212_p1 XI1528_I212_An p21_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I212_MP2 (VDD I1528_pn9 XI1528_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I212_MP3 (XI1528_I212_p1 I1528_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I212_MP0 (VDD I1528_pn9 XI1528_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I207_MP1 (VDD I1528_G3_0n XI1528_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I207_MP5 (p21_4 XI1528_I207_Bn XI1528_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I207_MP4 (XI1528_I207_p1 XI1528_I207_An p21_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I207_MP2 (VDD I1528_pn4 XI1528_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I207_MP3 (XI1528_I207_p1 I1528_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I207_MP0 (VDD I1528_pn4 XI1528_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1115_MP1 (VDD qu20_b3_5 XI1115_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1115_MP5 (h12 XI1115_Bn XI1115_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1115_MP4 (XI1115_p1 XI1115_An h12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1115_MP2 (VDD p11_31 XI1115_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1115_MP3 (XI1115_p1 qu20_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1115_MP0 (VDD p11_31 XI1115_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I217_MP1 (VDD I1114_G13_0n XI1114_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I217_MP5 (p12_14 XI1114_I217_Bn XI1114_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I217_MP4 (XI1114_I217_p1 XI1114_I217_An p12_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I217_MP2 (VDD I1114_pn14 XI1114_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I217_MP3 (XI1114_I217_p1 I1114_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I217_MP0 (VDD I1114_pn14 XI1114_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I213_MP1 (VDD I1114_G9_0n XI1114_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I213_MP5 (p12_10 XI1114_I213_Bn XI1114_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I213_MP4 (XI1114_I213_p1 XI1114_I213_An p12_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I213_MP2 (VDD I1114_pn10 XI1114_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I213_MP3 (XI1114_I213_p1 I1114_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I213_MP0 (VDD I1114_pn10 XI1114_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I207_MP1 (VDD I1114_G3_0n XI1114_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I207_MP5 (p12_4 XI1114_I207_Bn XI1114_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I207_MP4 (XI1114_I207_p1 XI1114_I207_An p12_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I207_MP2 (VDD I1114_pn4 XI1114_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I207_MP3 (XI1114_I207_p1 I1114_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I207_MP0 (VDD I1114_pn4 XI1114_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1132_MP1 (VDD qu19_b3_0 XI1132_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1132_MP5 (b13_4 XI1132_Bn XI1132_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1132_MP4 (XI1132_p1 XI1132_An b13_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1132_MP2 (VDD dd4_b3_2 XI1132_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1132_MP3 (XI1132_p1 qu19_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1132_MP0 (VDD dd4_b3_2 XI1132_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1133_MP1 (VDD qu19_b3_0 XI1133_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1133_MP5 (b13_5 XI1133_Bn XI1133_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1133_MP4 (XI1133_p1 XI1133_An b13_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1133_MP2 (VDD dd5_b3_2 XI1133_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1133_MP3 (XI1133_p1 qu19_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1133_MP0 (VDD dd5_b3_2 XI1133_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1130_MP1 (VDD qu19_b3_0 XI1130_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1130_MP5 (b13_2 XI1130_Bn XI1130_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1130_MP4 (XI1130_p1 XI1130_An b13_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1130_MP2 (VDD dd2_b3_2 XI1130_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1130_MP3 (XI1130_p1 qu19_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1130_MP0 (VDD dd2_b3_2 XI1130_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1129_MP1 (VDD qu19_b3_0 XI1129_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1129_MP5 (b13_1 XI1129_Bn XI1129_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1129_MP4 (XI1129_p1 XI1129_An b13_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1129_MP2 (VDD dd1_b3_2 XI1129_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1129_MP3 (XI1129_p1 qu19_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1129_MP0 (VDD dd1_b3_2 XI1129_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1128_MP1 (VDD qu19_b3_0 XI1128_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1128_MP5 (b13_0 XI1128_Bn XI1128_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1128_MP4 (XI1128_p1 XI1128_An b13_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1128_MP2 (VDD B_0_b3_2 XI1128_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1128_MP3 (XI1128_p1 qu19_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1128_MP0 (VDD B_0_b3_2 XI1128_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1177_MP1 (VDD qu18_b3_0 XI1177_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1177_MP5 (b14_3 XI1177_Bn XI1177_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1177_MP4 (XI1177_p1 XI1177_An b14_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1177_MP2 (VDD dd3_b3_2 XI1177_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1177_MP3 (XI1177_p1 qu18_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1177_MP0 (VDD dd3_b3_2 XI1177_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1174_MP1 (VDD qu18_b3_0 XI1174_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1174_MP5 (b14_0 XI1174_Bn XI1174_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1174_MP4 (XI1174_p1 XI1174_An b14_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1174_MP2 (VDD B_0_b3_2 XI1174_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1174_MP3 (XI1174_p1 qu18_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1174_MP0 (VDD B_0_b3_2 XI1174_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1175_MP1 (VDD qu18_b3_0 XI1175_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1175_MP5 (b14_1 XI1175_Bn XI1175_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1175_MP4 (XI1175_p1 XI1175_An b14_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1175_MP2 (VDD dd1_b3_2 XI1175_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1175_MP3 (XI1175_p1 qu18_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1175_MP0 (VDD dd1_b3_2 XI1175_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1222_MP1 (VDD qu17_b3_0 XI1222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1222_MP5 (b15_2 XI1222_Bn XI1222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1222_MP4 (XI1222_p1 XI1222_An b15_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1222_MP2 (VDD dd2_b3_2 XI1222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1222_MP3 (XI1222_p1 qu17_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1222_MP0 (VDD dd2_b3_2 XI1222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1267_MP1 (VDD qu16_b3_0 XI1267_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1267_MP5 (b16_1 XI1267_Bn XI1267_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1267_MP4 (XI1267_p1 XI1267_An b16_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1267_MP2 (VDD dd1_b3_2 XI1267_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1267_MP3 (XI1267_p1 qu16_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1267_MP0 (VDD dd1_b3_2 XI1267_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1266_MP1 (VDD qu16_b3_0 XI1266_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1266_MP5 (b16_0 XI1266_Bn XI1266_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1266_MP4 (XI1266_p1 XI1266_An b16_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1266_MP2 (VDD B_0_b3_2 XI1266_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1266_MP3 (XI1266_p1 qu16_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1266_MP0 (VDD B_0_b3_2 XI1266_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1268_MP1 (VDD qu16_b3_0 XI1268_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1268_MP5 (b16_2 XI1268_Bn XI1268_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1268_MP4 (XI1268_p1 XI1268_An b16_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1268_MP2 (VDD dd2_b3_2 XI1268_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1268_MP3 (XI1268_p1 qu16_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1268_MP0 (VDD dd2_b3_2 XI1268_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I206_MP1 (VDD I1344_G2_0n XI1344_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I206_MP5 (p17_3 XI1344_I206_Bn XI1344_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I206_MP4 (XI1344_I206_p1 XI1344_I206_An p17_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I206_MP2 (VDD I1344_pn3 XI1344_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I206_MP3 (XI1344_I206_p1 I1344_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I206_MP0 (VDD I1344_pn3 XI1344_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1317_MP1 (VDD qu15_b3_0 XI1317_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1317_MP5 (b17_5 XI1317_Bn XI1317_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1317_MP4 (XI1317_p1 XI1317_An b17_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1317_MP2 (VDD dd5_b3_3 XI1317_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1317_MP3 (XI1317_p1 qu15_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1317_MP0 (VDD dd5_b3_3 XI1317_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1364_MP1 (VDD qu14_b3_1 XI1364_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1364_MP5 (b18_6 XI1364_Bn XI1364_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1364_MP4 (XI1364_p1 XI1364_An b18_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1364_MP2 (VDD dd6_b3_3 XI1364_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1364_MP3 (XI1364_p1 qu14_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1364_MP0 (VDD dd6_b3_3 XI1364_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1363_MP1 (VDD qu14_b3_0 XI1363_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1363_MP5 (b18_5 XI1363_Bn XI1363_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1363_MP4 (XI1363_p1 XI1363_An b18_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1363_MP2 (VDD dd5_b3_3 XI1363_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1363_MP3 (XI1363_p1 qu14_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1363_MP0 (VDD dd5_b3_3 XI1363_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I206_MP1 (VDD I1390_G2_0n XI1390_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I206_MP5 (p18_3 XI1390_I206_Bn XI1390_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I206_MP4 (XI1390_I206_p1 XI1390_I206_An p18_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I206_MP2 (VDD I1390_pn3 XI1390_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I206_MP3 (XI1390_I206_p1 I1390_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I206_MP0 (VDD I1390_pn3 XI1390_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1410_MP1 (VDD qu13_b3_1 XI1410_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1410_MP5 (b19_6 XI1410_Bn XI1410_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1410_MP4 (XI1410_p1 XI1410_An b19_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1410_MP2 (VDD dd6_b3_3 XI1410_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1410_MP3 (XI1410_p1 qu13_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1410_MP0 (VDD dd6_b3_3 XI1410_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I206_MP1 (VDD I1436_G2_0n XI1436_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I206_MP5 (p19_3 XI1436_I206_Bn XI1436_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I206_MP4 (XI1436_I206_p1 XI1436_I206_An p19_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I206_MP2 (VDD I1436_pn3 XI1436_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I206_MP3 (XI1436_I206_p1 I1436_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I206_MP0 (VDD I1436_pn3 XI1436_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1455_MP1 (VDD qu12_b3_0 XI1455_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1455_MP5 (b20_5 XI1455_Bn XI1455_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1455_MP4 (XI1455_p1 XI1455_An b20_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1455_MP2 (VDD dd5_b3_3 XI1455_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1455_MP3 (XI1455_p1 qu12_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1455_MP0 (VDD dd5_b3_3 XI1455_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1502_MP1 (VDD qu11_b3_1 XI1502_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1502_MP5 (b21_6 XI1502_Bn XI1502_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1502_MP4 (XI1502_p1 XI1502_An b21_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1502_MP2 (VDD dd6_b3_3 XI1502_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1502_MP3 (XI1502_p1 qu11_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1502_MP0 (VDD dd6_b3_3 XI1502_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1504_MP1 (VDD qu11_b3_1 XI1504_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1504_MP5 (b21_8 XI1504_Bn XI1504_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1504_MP4 (XI1504_p1 XI1504_An b21_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1504_MP2 (VDD dd8_b3_3 XI1504_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1504_MP3 (XI1504_p1 qu11_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1504_MP0 (VDD dd8_b3_3 XI1504_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1501_MP1 (VDD qu11_b3_0 XI1501_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1501_MP5 (b21_5 XI1501_Bn XI1501_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1501_MP4 (XI1501_p1 XI1501_An b21_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1501_MP2 (VDD dd5_b3_3 XI1501_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1501_MP3 (XI1501_p1 qu11_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1501_MP0 (VDD dd5_b3_3 XI1501_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I207_MP1 (VDD I1482_G3_0n XI1482_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I207_MP5 (p20_4 XI1482_I207_Bn XI1482_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I207_MP4 (XI1482_I207_p1 XI1482_I207_An p20_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I207_MP2 (VDD I1482_pn4 XI1482_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I207_MP3 (XI1482_I207_p1 I1482_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I207_MP0 (VDD I1482_pn4 XI1482_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I206_MP1 (VDD I1482_G2_0n XI1482_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I206_MP5 (p20_3 XI1482_I206_Bn XI1482_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I206_MP4 (XI1482_I206_p1 XI1482_I206_An p20_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I206_MP2 (VDD I1482_pn3 XI1482_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I206_MP3 (XI1482_I206_p1 I1482_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I206_MP0 (VDD I1482_pn3 XI1482_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I213_MP1 (VDD I1528_G9_0n XI1528_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I213_MP5 (p21_10 XI1528_I213_Bn XI1528_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I213_MP4 (XI1528_I213_p1 XI1528_I213_An p21_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I213_MP2 (VDD I1528_pn10 XI1528_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I213_MP3 (XI1528_I213_p1 I1528_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I213_MP0 (VDD I1528_pn10 XI1528_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1116_MP1 (VDD c12_o XI1116_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1116_MP5 (p12_32 XI1116_Bn XI1116_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1116_MP4 (XI1116_p1 XI1116_An p12_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1116_MP2 (VDD h12 XI1116_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1116_MP3 (XI1116_p1 c12_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1116_MP0 (VDD h12 XI1116_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1149_MP1 (VDD qu19_b3_3 XI1149_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1149_MP5 (b13_21 XI1149_Bn XI1149_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1149_MP4 (XI1149_p1 XI1149_An b13_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1149_MP2 (VDD dd21_b3_2 XI1149_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1149_MP3 (XI1149_p1 qu19_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1149_MP0 (VDD dd21_b3_2 XI1149_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1148_MP1 (VDD qu19_b3_3 XI1148_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1148_MP5 (b13_20 XI1148_Bn XI1148_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1148_MP4 (XI1148_p1 XI1148_An b13_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1148_MP2 (VDD dd20_b3_2 XI1148_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1148_MP3 (XI1148_p1 qu19_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1148_MP0 (VDD dd20_b3_2 XI1148_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1147_MP1 (VDD qu19_b3_3 XI1147_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1147_MP5 (b13_19 XI1147_Bn XI1147_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1147_MP4 (XI1147_p1 XI1147_An b13_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1147_MP2 (VDD dd19_b3_2 XI1147_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1147_MP3 (XI1147_p1 qu19_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1147_MP0 (VDD dd19_b3_2 XI1147_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I219_MP1 (VDD I1114_G15_0n XI1114_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I219_MP5 (p12_16 XI1114_I219_Bn XI1114_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I219_MP4 (XI1114_I219_p1 XI1114_I219_An p12_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I219_MP2 (VDD I1114_pn16 XI1114_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I219_MP3 (XI1114_I219_p1 I1114_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I219_MP0 (VDD I1114_pn16 XI1114_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I215_MP1 (VDD I1114_G11_0n XI1114_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1114_I215_MP5 (p12_12 XI1114_I215_Bn XI1114_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1114_I215_MP4 (XI1114_I215_p1 XI1114_I215_An p12_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I215_MP2 (VDD I1114_pn12 XI1114_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1114_I215_MP3 (XI1114_I215_p1 I1114_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1114_I215_MP0 (VDD I1114_pn12 XI1114_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1144_MP1 (VDD qu19_b3_2 XI1144_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1144_MP5 (b13_16 XI1144_Bn XI1144_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1144_MP4 (XI1144_p1 XI1144_An b13_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1144_MP2 (VDD dd16_b3_2 XI1144_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1144_MP3 (XI1144_p1 qu19_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1144_MP0 (VDD dd16_b3_2 XI1144_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1140_MP1 (VDD qu19_b3_2 XI1140_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1140_MP5 (b13_12 XI1140_Bn XI1140_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1140_MP4 (XI1140_p1 XI1140_An b13_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1140_MP2 (VDD dd12_b3_2 XI1140_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1140_MP3 (XI1140_p1 qu19_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1140_MP0 (VDD dd12_b3_2 XI1140_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1143_MP1 (VDD qu19_b3_2 XI1143_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1143_MP5 (b13_15 XI1143_Bn XI1143_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1143_MP4 (XI1143_p1 XI1143_An b13_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1143_MP2 (VDD dd15_b3_2 XI1143_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1143_MP3 (XI1143_p1 qu19_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1143_MP0 (VDD dd15_b3_2 XI1143_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1141_MP1 (VDD qu19_b3_2 XI1141_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1141_MP5 (b13_13 XI1141_Bn XI1141_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1141_MP4 (XI1141_p1 XI1141_An b13_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1141_MP2 (VDD dd13_b3_2 XI1141_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1141_MP3 (XI1141_p1 qu19_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1141_MP0 (VDD dd13_b3_2 XI1141_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1135_MP1 (VDD qu19_b3_1 XI1135_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1135_MP5 (b13_7 XI1135_Bn XI1135_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1135_MP4 (XI1135_p1 XI1135_An b13_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1135_MP2 (VDD dd7_b3_2 XI1135_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1135_MP3 (XI1135_p1 qu19_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1135_MP0 (VDD dd7_b3_2 XI1135_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1134_MP1 (VDD qu19_b3_1 XI1134_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1134_MP5 (b13_6 XI1134_Bn XI1134_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1134_MP4 (XI1134_p1 XI1134_An b13_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1134_MP2 (VDD dd6_b3_2 XI1134_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1134_MP3 (XI1134_p1 qu19_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1134_MP0 (VDD dd6_b3_2 XI1134_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1131_MP1 (VDD qu19_b3_0 XI1131_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1131_MP5 (b13_3 XI1131_Bn XI1131_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1131_MP4 (XI1131_p1 XI1131_An b13_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1131_MP2 (VDD dd3_b3_2 XI1131_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1131_MP3 (XI1131_p1 qu19_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1131_MP0 (VDD dd3_b3_2 XI1131_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1178_MP1 (VDD qu18_b3_0 XI1178_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1178_MP5 (b14_4 XI1178_Bn XI1178_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1178_MP4 (XI1178_p1 XI1178_An b14_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1178_MP2 (VDD dd4_b3_2 XI1178_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1178_MP3 (XI1178_p1 qu18_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1178_MP0 (VDD dd4_b3_2 XI1178_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1176_MP1 (VDD qu18_b3_0 XI1176_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1176_MP5 (b14_2 XI1176_Bn XI1176_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1176_MP4 (XI1176_p1 XI1176_An b14_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1176_MP2 (VDD dd2_b3_2 XI1176_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1176_MP3 (XI1176_p1 qu18_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1176_MP0 (VDD dd2_b3_2 XI1176_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1224_MP1 (VDD qu17_b3_0 XI1224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1224_MP5 (b15_4 XI1224_Bn XI1224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1224_MP4 (XI1224_p1 XI1224_An b15_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1224_MP2 (VDD dd4_b3_2 XI1224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1224_MP3 (XI1224_p1 qu17_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1224_MP0 (VDD dd4_b3_2 XI1224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1223_MP1 (VDD qu17_b3_0 XI1223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1223_MP5 (b15_3 XI1223_Bn XI1223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1223_MP4 (XI1223_p1 XI1223_An b15_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1223_MP2 (VDD dd3_b3_2 XI1223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1223_MP3 (XI1223_p1 qu17_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1223_MP0 (VDD dd3_b3_2 XI1223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1271_MP1 (VDD qu16_b3_0 XI1271_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1271_MP5 (b16_5 XI1271_Bn XI1271_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1271_MP4 (XI1271_p1 XI1271_An b16_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1271_MP2 (VDD dd5_b3_2 XI1271_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1271_MP3 (XI1271_p1 qu16_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1271_MP0 (VDD dd5_b3_2 XI1271_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1270_MP1 (VDD qu16_b3_0 XI1270_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1270_MP5 (b16_4 XI1270_Bn XI1270_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1270_MP4 (XI1270_p1 XI1270_An b16_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1270_MP2 (VDD dd4_b3_2 XI1270_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1270_MP3 (XI1270_p1 qu16_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1270_MP0 (VDD dd4_b3_2 XI1270_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1269_MP1 (VDD qu16_b3_0 XI1269_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1269_MP5 (b16_3 XI1269_Bn XI1269_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1269_MP4 (XI1269_p1 XI1269_An b16_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1269_MP2 (VDD dd3_b3_2 XI1269_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1269_MP3 (XI1269_p1 qu16_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1269_MP0 (VDD dd3_b3_2 XI1269_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I206_MP1 (VDD I1298_G2_0n XI1298_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I206_MP5 (p16_3 XI1298_I206_Bn XI1298_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I206_MP4 (XI1298_I206_p1 XI1298_I206_An p16_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I206_MP2 (VDD I1298_pn3 XI1298_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I206_MP3 (XI1298_I206_p1 I1298_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I206_MP0 (VDD I1298_pn3 XI1298_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I207_MP1 (VDD I1298_G3_0n XI1298_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I207_MP5 (p16_4 XI1298_I207_Bn XI1298_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I207_MP4 (XI1298_I207_p1 XI1298_I207_An p16_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I207_MP2 (VDD I1298_pn4 XI1298_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I207_MP3 (XI1298_I207_p1 I1298_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I207_MP0 (VDD I1298_pn4 XI1298_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I207_MP1 (VDD I1344_G3_0n XI1344_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I207_MP5 (p17_4 XI1344_I207_Bn XI1344_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I207_MP4 (XI1344_I207_p1 XI1344_I207_An p17_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I207_MP2 (VDD I1344_pn4 XI1344_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I207_MP3 (XI1344_I207_p1 I1344_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I207_MP0 (VDD I1344_pn4 XI1344_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1318_MP1 (VDD qu15_b3_1 XI1318_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1318_MP5 (b17_6 XI1318_Bn XI1318_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1318_MP4 (XI1318_p1 XI1318_An b17_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1318_MP2 (VDD dd6_b3_3 XI1318_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1318_MP3 (XI1318_p1 qu15_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1318_MP0 (VDD dd6_b3_3 XI1318_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1319_MP1 (VDD qu15_b3_1 XI1319_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1319_MP5 (b17_7 XI1319_Bn XI1319_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1319_MP4 (XI1319_p1 XI1319_An b17_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1319_MP2 (VDD dd7_b3_3 XI1319_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1319_MP3 (XI1319_p1 qu15_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1319_MP0 (VDD dd7_b3_3 XI1319_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1365_MP1 (VDD qu14_b3_1 XI1365_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1365_MP5 (b18_7 XI1365_Bn XI1365_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1365_MP4 (XI1365_p1 XI1365_An b18_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1365_MP2 (VDD dd7_b3_3 XI1365_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1365_MP3 (XI1365_p1 qu14_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1365_MP0 (VDD dd7_b3_3 XI1365_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I207_MP1 (VDD I1390_G3_0n XI1390_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I207_MP5 (p18_4 XI1390_I207_Bn XI1390_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I207_MP4 (XI1390_I207_p1 XI1390_I207_An p18_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I207_MP2 (VDD I1390_pn4 XI1390_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I207_MP3 (XI1390_I207_p1 I1390_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I207_MP0 (VDD I1390_pn4 XI1390_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1411_MP1 (VDD qu13_b3_1 XI1411_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1411_MP5 (b19_7 XI1411_Bn XI1411_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1411_MP4 (XI1411_p1 XI1411_An b19_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1411_MP2 (VDD dd7_b3_3 XI1411_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1411_MP3 (XI1411_p1 qu13_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1411_MP0 (VDD dd7_b3_3 XI1411_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I207_MP1 (VDD I1436_G3_0n XI1436_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I207_MP5 (p19_4 XI1436_I207_Bn XI1436_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I207_MP4 (XI1436_I207_p1 XI1436_I207_An p19_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I207_MP2 (VDD I1436_pn4 XI1436_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I207_MP3 (XI1436_I207_p1 I1436_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I207_MP0 (VDD I1436_pn4 XI1436_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1458_MP1 (VDD qu12_b3_1 XI1458_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1458_MP5 (b20_8 XI1458_Bn XI1458_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1458_MP4 (XI1458_p1 XI1458_An b20_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1458_MP2 (VDD dd8_b3_3 XI1458_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1458_MP3 (XI1458_p1 qu12_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1458_MP0 (VDD dd8_b3_3 XI1458_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1456_MP1 (VDD qu12_b3_1 XI1456_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1456_MP5 (b20_6 XI1456_Bn XI1456_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1456_MP4 (XI1456_p1 XI1456_An b20_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1456_MP2 (VDD dd6_b3_3 XI1456_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1456_MP3 (XI1456_p1 qu12_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1456_MP0 (VDD dd6_b3_3 XI1456_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1457_MP1 (VDD qu12_b3_1 XI1457_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1457_MP5 (b20_7 XI1457_Bn XI1457_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1457_MP4 (XI1457_p1 XI1457_An b20_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1457_MP2 (VDD dd7_b3_3 XI1457_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1457_MP3 (XI1457_p1 qu12_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1457_MP0 (VDD dd7_b3_3 XI1457_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1503_MP1 (VDD qu11_b3_1 XI1503_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1503_MP5 (b21_7 XI1503_Bn XI1503_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1503_MP4 (XI1503_p1 XI1503_An b21_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1503_MP2 (VDD dd7_b3_3 XI1503_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1503_MP3 (XI1503_p1 qu11_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1503_MP0 (VDD dd7_b3_3 XI1503_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1505_MP1 (VDD qu11_b3_1 XI1505_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1505_MP5 (b21_9 XI1505_Bn XI1505_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1505_MP4 (XI1505_p1 XI1505_An b21_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1505_MP2 (VDD dd9_b3_3 XI1505_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1505_MP3 (XI1505_p1 qu11_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1505_MP0 (VDD dd9_b3_3 XI1505_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1161_MP1 (VDD qu19_b3_5 XI1161_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1161_MP5 (h13 XI1161_Bn XI1161_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1161_MP4 (XI1161_p1 XI1161_An h13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1161_MP2 (VDD p12_31 XI1161_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1161_MP3 (XI1161_p1 qu19_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1161_MP0 (VDD p12_31 XI1161_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1151_MP1 (VDD qu19_b3_3 XI1151_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1151_MP5 (b13_23 XI1151_Bn XI1151_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1151_MP4 (XI1151_p1 XI1151_An b13_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1151_MP2 (VDD dd23_b3_2 XI1151_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1151_MP3 (XI1151_p1 qu19_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1151_MP0 (VDD dd23_b3_2 XI1151_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1150_MP1 (VDD qu19_b3_3 XI1150_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1150_MP5 (b13_22 XI1150_Bn XI1150_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1150_MP4 (XI1150_p1 XI1150_An b13_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1150_MP2 (VDD dd22_b3_2 XI1150_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1150_MP3 (XI1150_p1 qu19_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1150_MP0 (VDD dd22_b3_2 XI1150_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1146_MP1 (VDD qu19_b3_3 XI1146_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1146_MP5 (b13_18 XI1146_Bn XI1146_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1146_MP4 (XI1146_p1 XI1146_An b13_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1146_MP2 (VDD dd18_b3_2 XI1146_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1146_MP3 (XI1146_p1 qu19_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1146_MP0 (VDD dd18_b3_2 XI1146_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1142_MP1 (VDD qu19_b3_2 XI1142_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1142_MP5 (b13_14 XI1142_Bn XI1142_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1142_MP4 (XI1142_p1 XI1142_An b13_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1142_MP2 (VDD dd14_b3_2 XI1142_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1142_MP3 (XI1142_p1 qu19_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1142_MP0 (VDD dd14_b3_2 XI1142_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1145_MP1 (VDD qu19_b3_2 XI1145_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1145_MP5 (b13_17 XI1145_Bn XI1145_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1145_MP4 (XI1145_p1 XI1145_An b13_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1145_MP2 (VDD dd17_b3_2 XI1145_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1145_MP3 (XI1145_p1 qu19_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1145_MP0 (VDD dd17_b3_2 XI1145_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1139_MP1 (VDD qu19_b3_1 XI1139_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1139_MP5 (b13_11 XI1139_Bn XI1139_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1139_MP4 (XI1139_p1 XI1139_An b13_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1139_MP2 (VDD dd11_b3_2 XI1139_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1139_MP3 (XI1139_p1 qu19_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1139_MP0 (VDD dd11_b3_2 XI1139_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1179_MP1 (VDD qu18_b3_0 XI1179_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1179_MP5 (b14_5 XI1179_Bn XI1179_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1179_MP4 (XI1179_p1 XI1179_An b14_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1179_MP2 (VDD dd5_b3_2 XI1179_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1179_MP3 (XI1179_p1 qu18_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1179_MP0 (VDD dd5_b3_2 XI1179_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1226_MP1 (VDD qu17_b3_1 XI1226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1226_MP5 (b15_6 XI1226_Bn XI1226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1226_MP4 (XI1226_p1 XI1226_An b15_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1226_MP2 (VDD dd6_b3_2 XI1226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1226_MP3 (XI1226_p1 qu17_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1226_MP0 (VDD dd6_b3_2 XI1226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1225_MP1 (VDD qu17_b3_0 XI1225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1225_MP5 (b15_5 XI1225_Bn XI1225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1225_MP4 (XI1225_p1 XI1225_An b15_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1225_MP2 (VDD dd5_b3_2 XI1225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1225_MP3 (XI1225_p1 qu17_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1225_MP0 (VDD dd5_b3_2 XI1225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I206_MP1 (VDD I1252_G2_0n XI1252_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I206_MP5 (p15_3 XI1252_I206_Bn XI1252_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I206_MP4 (XI1252_I206_p1 XI1252_I206_An p15_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I206_MP2 (VDD I1252_pn3 XI1252_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I206_MP3 (XI1252_I206_p1 I1252_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I206_MP0 (VDD I1252_pn3 XI1252_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I207_MP1 (VDD I1252_G3_0n XI1252_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I207_MP5 (p15_4 XI1252_I207_Bn XI1252_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I207_MP4 (XI1252_I207_p1 XI1252_I207_An p15_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I207_MP2 (VDD I1252_pn4 XI1252_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I207_MP3 (XI1252_I207_p1 I1252_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I207_MP0 (VDD I1252_pn4 XI1252_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1273_MP1 (VDD qu16_b3_1 XI1273_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1273_MP5 (b16_7 XI1273_Bn XI1273_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1273_MP4 (XI1273_p1 XI1273_An b16_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1273_MP2 (VDD dd7_b3_2 XI1273_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1273_MP3 (XI1273_p1 qu16_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1273_MP0 (VDD dd7_b3_2 XI1273_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1272_MP1 (VDD qu16_b3_1 XI1272_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1272_MP5 (b16_6 XI1272_Bn XI1272_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1272_MP4 (XI1272_p1 XI1272_An b16_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1272_MP2 (VDD dd6_b3_2 XI1272_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1272_MP3 (XI1272_p1 qu16_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1272_MP0 (VDD dd6_b3_2 XI1272_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1320_MP1 (VDD qu15_b3_1 XI1320_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1320_MP5 (b17_8 XI1320_Bn XI1320_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1320_MP4 (XI1320_p1 XI1320_An b17_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1320_MP2 (VDD dd8_b3_3 XI1320_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1320_MP3 (XI1320_p1 qu15_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1320_MP0 (VDD dd8_b3_3 XI1320_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1321_MP1 (VDD qu15_b3_1 XI1321_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1321_MP5 (b17_9 XI1321_Bn XI1321_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1321_MP4 (XI1321_p1 XI1321_An b17_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1321_MP2 (VDD dd9_b3_3 XI1321_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1321_MP3 (XI1321_p1 qu15_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1321_MP0 (VDD dd9_b3_3 XI1321_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1366_MP1 (VDD qu14_b3_1 XI1366_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1366_MP5 (b18_8 XI1366_Bn XI1366_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1366_MP4 (XI1366_p1 XI1366_An b18_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1366_MP2 (VDD dd8_b3_3 XI1366_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1366_MP3 (XI1366_p1 qu14_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1366_MP0 (VDD dd8_b3_3 XI1366_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1368_MP1 (VDD qu14_b3_1 XI1368_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1368_MP5 (b18_10 XI1368_Bn XI1368_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1368_MP4 (XI1368_p1 XI1368_An b18_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1368_MP2 (VDD dd10_b3_3 XI1368_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1368_MP3 (XI1368_p1 qu14_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1368_MP0 (VDD dd10_b3_3 XI1368_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1367_MP1 (VDD qu14_b3_1 XI1367_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1367_MP5 (b18_9 XI1367_Bn XI1367_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1367_MP4 (XI1367_p1 XI1367_An b18_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1367_MP2 (VDD dd9_b3_3 XI1367_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1367_MP3 (XI1367_p1 qu14_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1367_MP0 (VDD dd9_b3_3 XI1367_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1412_MP1 (VDD qu13_b3_1 XI1412_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1412_MP5 (b19_8 XI1412_Bn XI1412_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1412_MP4 (XI1412_p1 XI1412_An b19_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1412_MP2 (VDD dd8_b3_3 XI1412_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1412_MP3 (XI1412_p1 qu13_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1412_MP0 (VDD dd8_b3_3 XI1412_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1413_MP1 (VDD qu13_b3_1 XI1413_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1413_MP5 (b19_9 XI1413_Bn XI1413_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1413_MP4 (XI1413_p1 XI1413_An b19_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1413_MP2 (VDD dd9_b3_3 XI1413_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1413_MP3 (XI1413_p1 qu13_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1413_MP0 (VDD dd9_b3_3 XI1413_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1507_MP1 (VDD qu11_b3_1 XI1507_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1507_MP5 (b21_11 XI1507_Bn XI1507_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1507_MP4 (XI1507_p1 XI1507_An b21_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1507_MP2 (VDD dd11_b3_3 XI1507_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1507_MP3 (XI1507_p1 qu11_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1507_MP0 (VDD dd11_b3_3 XI1507_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1506_MP1 (VDD qu11_b3_1 XI1506_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1506_MP5 (b21_10 XI1506_Bn XI1506_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1506_MP4 (XI1506_p1 XI1506_An b21_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1506_MP2 (VDD dd10_b3_3 XI1506_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1506_MP3 (XI1506_p1 qu11_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1506_MP0 (VDD dd10_b3_3 XI1506_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1459_MP1 (VDD qu12_b3_1 XI1459_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1459_MP5 (b20_9 XI1459_Bn XI1459_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1459_MP4 (XI1459_p1 XI1459_An b20_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1459_MP2 (VDD dd9_b3_3 XI1459_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1459_MP3 (XI1459_p1 qu12_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1459_MP0 (VDD dd9_b3_3 XI1459_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I214_MP1 (VDD I1528_G10_0n XI1528_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I214_MP5 (p21_11 XI1528_I214_Bn XI1528_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I214_MP4 (XI1528_I214_p1 XI1528_I214_An p21_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I214_MP2 (VDD I1528_pn11 XI1528_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I214_MP3 (XI1528_I214_p1 I1528_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I214_MP0 (VDD I1528_pn11 XI1528_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I216_MP1 (VDD I1528_G12_0n XI1528_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I216_MP5 (p21_13 XI1528_I216_Bn XI1528_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I216_MP4 (XI1528_I216_p1 XI1528_I216_An p21_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I216_MP2 (VDD I1528_pn13 XI1528_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I216_MP3 (XI1528_I216_p1 I1528_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I216_MP0 (VDD I1528_pn13 XI1528_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I215_MP1 (VDD I1528_G11_0n XI1528_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I215_MP5 (p21_12 XI1528_I215_Bn XI1528_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I215_MP4 (XI1528_I215_p1 XI1528_I215_An p21_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I215_MP2 (VDD I1528_pn12 XI1528_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I215_MP3 (XI1528_I215_p1 I1528_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I215_MP0 (VDD I1528_pn12 XI1528_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1158_MP1 (VDD qu19_b3_5 XI1158_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1158_MP5 (b13_30 XI1158_Bn XI1158_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1158_MP4 (XI1158_p1 XI1158_An b13_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1158_MP2 (VDD dd30_b3_2 XI1158_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1158_MP3 (XI1158_p1 qu19_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1158_MP0 (VDD dd30_b3_2 XI1158_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1159_MP1 (VDD qu19_b3_5 XI1159_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1159_MP5 (b13_31 XI1159_Bn XI1159_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1159_MP4 (XI1159_p1 XI1159_An b13_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1159_MP2 (VDD dd31_b3_2 XI1159_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1159_MP3 (XI1159_p1 qu19_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1159_MP0 (VDD dd31_b3_2 XI1159_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1137_MP1 (VDD qu19_b3_1 XI1137_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1137_MP5 (b13_9 XI1137_Bn XI1137_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1137_MP4 (XI1137_p1 XI1137_An b13_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1137_MP2 (VDD dd9_b3_2 XI1137_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1137_MP3 (XI1137_p1 qu19_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1137_MP0 (VDD dd9_b3_2 XI1137_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1138_MP1 (VDD qu19_b3_1 XI1138_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1138_MP5 (b13_10 XI1138_Bn XI1138_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1138_MP4 (XI1138_p1 XI1138_An b13_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1138_MP2 (VDD dd10_b3_2 XI1138_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1138_MP3 (XI1138_p1 qu19_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1138_MP0 (VDD dd10_b3_2 XI1138_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1136_MP1 (VDD qu19_b3_1 XI1136_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1136_MP5 (b13_8 XI1136_Bn XI1136_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1136_MP4 (XI1136_p1 XI1136_An b13_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1136_MP2 (VDD dd8_b3_2 XI1136_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1136_MP3 (XI1136_p1 qu19_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1136_MP0 (VDD dd8_b3_2 XI1136_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1185_MP1 (VDD qu18_b3_1 XI1185_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1185_MP5 (b14_11 XI1185_Bn XI1185_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1185_MP4 (XI1185_p1 XI1185_An b14_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1185_MP2 (VDD dd11_b3_2 XI1185_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1185_MP3 (XI1185_p1 qu18_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1185_MP0 (VDD dd11_b3_2 XI1185_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1182_MP1 (VDD qu18_b3_1 XI1182_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1182_MP5 (b14_8 XI1182_Bn XI1182_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1182_MP4 (XI1182_p1 XI1182_An b14_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1182_MP2 (VDD dd8_b3_2 XI1182_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1182_MP3 (XI1182_p1 qu18_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1182_MP0 (VDD dd8_b3_2 XI1182_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1180_MP1 (VDD qu18_b3_1 XI1180_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1180_MP5 (b14_6 XI1180_Bn XI1180_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1180_MP4 (XI1180_p1 XI1180_An b14_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1180_MP2 (VDD dd6_b3_2 XI1180_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1180_MP3 (XI1180_p1 qu18_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1180_MP0 (VDD dd6_b3_2 XI1180_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1181_MP1 (VDD qu18_b3_1 XI1181_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1181_MP5 (b14_7 XI1181_Bn XI1181_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1181_MP4 (XI1181_p1 XI1181_An b14_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1181_MP2 (VDD dd7_b3_2 XI1181_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1181_MP3 (XI1181_p1 qu18_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1181_MP0 (VDD dd7_b3_2 XI1181_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I207_MP1 (VDD I1206_G3_0n XI1206_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I207_MP5 (p14_4 XI1206_I207_Bn XI1206_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I207_MP4 (XI1206_I207_p1 XI1206_I207_An p14_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I207_MP2 (VDD I1206_pn4 XI1206_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I207_MP3 (XI1206_I207_p1 I1206_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I207_MP0 (VDD I1206_pn4 XI1206_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I206_MP1 (VDD I1206_G2_0n XI1206_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I206_MP5 (p14_3 XI1206_I206_Bn XI1206_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I206_MP4 (XI1206_I206_p1 XI1206_I206_An p14_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I206_MP2 (VDD I1206_pn3 XI1206_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I206_MP3 (XI1206_I206_p1 I1206_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I206_MP0 (VDD I1206_pn3 XI1206_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1227_MP1 (VDD qu17_b3_1 XI1227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1227_MP5 (b15_7 XI1227_Bn XI1227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1227_MP4 (XI1227_p1 XI1227_An b15_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1227_MP2 (VDD dd7_b3_2 XI1227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1227_MP3 (XI1227_p1 qu17_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1227_MP0 (VDD dd7_b3_2 XI1227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1231_MP1 (VDD qu17_b3_1 XI1231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1231_MP5 (b15_11 XI1231_Bn XI1231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1231_MP4 (XI1231_p1 XI1231_An b15_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1231_MP2 (VDD dd11_b3_2 XI1231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1231_MP3 (XI1231_p1 qu17_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1231_MP0 (VDD dd11_b3_2 XI1231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1228_MP1 (VDD qu17_b3_1 XI1228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1228_MP5 (b15_8 XI1228_Bn XI1228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1228_MP4 (XI1228_p1 XI1228_An b15_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1228_MP2 (VDD dd8_b3_2 XI1228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1228_MP3 (XI1228_p1 qu17_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1228_MP0 (VDD dd8_b3_2 XI1228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1274_MP1 (VDD qu16_b3_1 XI1274_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1274_MP5 (b16_8 XI1274_Bn XI1274_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1274_MP4 (XI1274_p1 XI1274_An b16_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1274_MP2 (VDD dd8_b3_2 XI1274_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1274_MP3 (XI1274_p1 qu16_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1274_MP0 (VDD dd8_b3_2 XI1274_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1277_MP1 (VDD qu16_b3_1 XI1277_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1277_MP5 (b16_11 XI1277_Bn XI1277_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1277_MP4 (XI1277_p1 XI1277_An b16_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1277_MP2 (VDD dd11_b3_2 XI1277_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1277_MP3 (XI1277_p1 qu16_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1277_MP0 (VDD dd11_b3_2 XI1277_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1275_MP1 (VDD qu16_b3_1 XI1275_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1275_MP5 (b16_9 XI1275_Bn XI1275_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1275_MP4 (XI1275_p1 XI1275_An b16_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1275_MP2 (VDD dd9_b3_2 XI1275_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1275_MP3 (XI1275_p1 qu16_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1275_MP0 (VDD dd9_b3_2 XI1275_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I212_MP1 (VDD I1298_G8_0n XI1298_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I212_MP5 (p16_9 XI1298_I212_Bn XI1298_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I212_MP4 (XI1298_I212_p1 XI1298_I212_An p16_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I212_MP2 (VDD I1298_pn9 XI1298_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I212_MP3 (XI1298_I212_p1 I1298_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I212_MP0 (VDD I1298_pn9 XI1298_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I212_MP1 (VDD I1344_G8_0n XI1344_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I212_MP5 (p17_9 XI1344_I212_Bn XI1344_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I212_MP4 (XI1344_I212_p1 XI1344_I212_An p17_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I212_MP2 (VDD I1344_pn9 XI1344_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I212_MP3 (XI1344_I212_p1 I1344_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I212_MP0 (VDD I1344_pn9 XI1344_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1322_MP1 (VDD qu15_b3_1 XI1322_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1322_MP5 (b17_10 XI1322_Bn XI1322_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1322_MP4 (XI1322_p1 XI1322_An b17_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
