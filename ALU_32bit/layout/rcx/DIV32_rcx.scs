    I_MXI1068_I89_XP_MN0 (I1068_P23_22 I1068_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I89_XP_MN1 (VSS I1068_pn22 I1068_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I88_XP_MN0 (I1068_P22_21 I1068_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I88_XP_MN1 (VSS I1068_pn21 I1068_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I87_XP_MN0 (I1068_P21_20 I1068_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I87_XP_MN1 (VSS I1068_pn20 I1068_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I86_XP_MN0 (I1068_P20_19 I1068_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I86_XP_MN1 (VSS I1068_pn19 I1068_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I85_XP_MN0 (I1068_P19_18 I1068_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I85_XP_MN1 (VSS I1068_pn18 I1068_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I79_XP_MN0 (I1068_P13_12 I1068_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I79_XP_MN1 (VSS I1068_pn12 I1068_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I80_XP_MN0 (I1068_P14_13 I1068_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I80_XP_MN1 (VSS I1068_pn13 I1068_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I136_XP_MN0 (I1022_P11_4 I1022_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I136_XP_MN1 (VSS I1022_P7_4n I1022_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I77_XP_MN0 (I1022_P11_10 I1022_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I77_XP_MN1 (VSS I1022_pn10 I1022_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I135_XP_MN0 (I1022_P10_3 I1022_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I135_XP_MN1 (VSS I1022_P6_3n I1022_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I141_XP_MN0 (I1022_P16_9 I1022_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I141_XP_MN1 (VSS I1022_P12_9n I1022_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I78_XP_MN0 (I1022_P12_11 I1022_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I78_XP_MN1 (VSS I1022_pn11 I1022_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I76_XP_MN0 (I976_P10_9 I976_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I76_XP_MN1 (VSS I976_pn9 I976_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I134_XP_MN0 (I976_P9_2 I976_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I134_XP_MN1 (VSS I976_P5_2n I976_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I75_XP_MN0 (I976_P9_8 I976_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I75_XP_MN1 (VSS I976_pn8 I976_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I141_XP_MN0 (I930_P16_9 I930_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I141_XP_MN1 (VSS I930_P12_9n I930_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I78_XP_MN0 (I930_P12_11 I930_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I78_XP_MN1 (VSS I930_pn11 I930_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I77_XP_MN0 (I930_P11_10 I930_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I77_XP_MN1 (VSS I930_pn10 I930_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I78_XP_MN0 (I1666_P12_11 I1666_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I78_XP_MN1 (VSS I1666_pn11 I1666_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I136_XP_MN0 (I1666_P11_4 I1666_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I136_XP_MN1 (VSS I1666_P7_4n I1666_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I77_XP_MN0 (I1666_P11_10 I1666_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I77_XP_MN1 (VSS I1666_pn10 I1666_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I77_XP_MN0 (I1620_P11_10 I1620_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I77_XP_MN1 (VSS I1620_pn10 I1620_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I78_XP_MN0 (I1620_P12_11 I1620_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I78_XP_MN1 (VSS I1620_pn11 I1620_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I136_XP_MN0 (I1574_P11_4 I1574_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I136_XP_MN1 (VSS I1574_P7_4n I1574_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I77_XP_MN0 (I1574_P11_10 I1574_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I77_XP_MN1 (VSS I1574_pn10 I1574_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I78_XP_MN0 (I1574_P12_11 I1574_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I78_XP_MN1 (VSS I1574_pn11 I1574_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I139_XP_MN0 (I1574_P14_7 I1574_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I139_XP_MN1 (VSS I1574_P10_7n I1574_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I84_XP_MN0 (I1068_P18_17 I1068_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I84_XP_MN1 (VSS I1068_pn17 I1068_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I83_XP_MN0 (I1068_P17_16 I1068_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I83_XP_MN1 (VSS I1068_pn16 I1068_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I81_XP_MN0 (I1068_P15_14 I1068_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I81_XP_MN1 (VSS I1068_pn14 I1068_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1068_I82_XP_MN0 (I1068_P16_15 I1068_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I82_XP_MN1 (VSS I1068_pn15 I1068_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I138_XP_MN0 (I1022_P13_6 I1022_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I138_XP_MN1 (VSS I1022_P9_6n I1022_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I142_XP_MN0 (I1022_P17_10 I1022_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I142_XP_MN1 (VSS I1022_P13_10n I1022_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I79_XP_MN0 (I1022_P13_12 I1022_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I79_XP_MN1 (VSS I1022_pn12 I1022_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I137_XP_MN0 (I1022_P12_5 I1022_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I137_XP_MN1 (VSS I1022_P8_5n I1022_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I135_XP_MN0 (I976_P10_3 I976_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I135_XP_MN1 (VSS I976_P6_3n I976_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I78_XP_MN0 (I976_P12_11 I976_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I78_XP_MN1 (VSS I976_pn11 I976_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I77_XP_MN0 (I976_P11_10 I976_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I77_XP_MN1 (VSS I976_pn10 I976_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I135_XP_MN0 (I930_P10_3 I930_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I135_XP_MN1 (VSS I930_P6_3n I930_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I80_XP_MN0 (I930_P14_13 I930_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I80_XP_MN1 (VSS I930_pn13 I930_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I79_XP_MN0 (I930_P13_12 I930_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I79_XP_MN1 (VSS I930_pn12 I930_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I136_XP_MN0 (I930_P11_4 I930_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I136_XP_MN1 (VSS I930_P7_4n I930_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I138_XP_MN0 (I930_P13_6 I930_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I138_XP_MN1 (VSS I930_P9_6n I930_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I145_XP_MN0 (I1666_P20_13 I1666_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I145_XP_MN1 (VSS I1666_P16_13n I1666_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I143_XP_MN0 (I1666_P18_11 I1666_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I143_XP_MN1 (VSS I1666_P14_11n I1666_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I139_XP_MN0 (I1666_P14_7 I1666_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I139_XP_MN1 (VSS I1666_P10_7n I1666_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I80_XP_MN0 (I1666_P14_13 I1666_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I80_XP_MN1 (VSS I1666_pn13 I1666_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I142_XP_MN0 (I1666_P17_10 I1666_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I142_XP_MN1 (VSS I1666_P13_10n I1666_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I138_XP_MN0 (I1666_P13_6 I1666_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I138_XP_MN1 (VSS I1666_P9_6n I1666_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I79_XP_MN0 (I1666_P13_12 I1666_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I79_XP_MN1 (VSS I1666_pn12 I1666_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I136_XP_MN0 (I1620_P11_4 I1620_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I136_XP_MN1 (VSS I1620_P7_4n I1620_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I138_XP_MN0 (I1620_P13_6 I1620_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I138_XP_MN1 (VSS I1620_P9_6n I1620_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I79_XP_MN0 (I1620_P13_12 I1620_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I79_XP_MN1 (VSS I1620_pn12 I1620_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I137_XP_MN0 (I1620_P12_5 I1620_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I137_XP_MN1 (VSS I1620_P8_5n I1620_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I141_XP_MN0 (I1620_P16_9 I1620_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I141_XP_MN1 (VSS I1620_P12_9n I1620_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I138_XP_MN0 (I1574_P13_6 I1574_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I138_XP_MN1 (VSS I1574_P9_6n I1574_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I142_XP_MN0 (I1574_P17_10 I1574_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I142_XP_MN1 (VSS I1574_P13_10n I1574_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I79_XP_MN0 (I1574_P13_12 I1574_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I79_XP_MN1 (VSS I1574_pn12 I1574_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I80_XP_MN0 (I1574_P14_13 I1574_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I80_XP_MN1 (VSS I1574_pn13 I1574_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I143_XP_MN0 (I1574_P18_11 I1574_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I143_XP_MN1 (VSS I1574_P14_11n I1574_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I81_XP_MN0 (I1022_P15_14 I1022_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I81_XP_MN1 (VSS I1022_pn14 I1022_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I139_XP_MN0 (I1022_P14_7 I1022_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I139_XP_MN1 (VSS I1022_P10_7n I1022_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I80_XP_MN0 (I1022_P14_13 I1022_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I80_XP_MN1 (VSS I1022_pn13 I1022_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I137_XP_MN0 (I976_P12_5 I976_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I137_XP_MN1 (VSS I976_P8_5n I976_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I136_XP_MN0 (I976_P11_4 I976_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I136_XP_MN1 (VSS I976_P7_4n I976_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I79_XP_MN0 (I976_P13_12 I976_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I79_XP_MN1 (VSS I976_pn12 I976_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I82_XP_MN0 (I930_P16_15 I930_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I82_XP_MN1 (VSS I930_pn15 I930_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I145_XP_MN0 (I930_P20_13 I930_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I145_XP_MN1 (VSS I930_P16_13n I930_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I139_XP_MN0 (I930_P14_7 I930_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I139_XP_MN1 (VSS I930_P10_7n I930_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I142_XP_MN0 (I930_P17_10 I930_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I142_XP_MN1 (VSS I930_P13_10n I930_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I82_XP_MN0 (I1666_P16_15 I1666_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I82_XP_MN1 (VSS I1666_pn15 I1666_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I83_XP_MN0 (I1666_P17_16 I1666_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I83_XP_MN1 (VSS I1666_pn16 I1666_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I140_XP_MN0 (I1666_P15_8 I1666_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I140_XP_MN1 (VSS I1666_P11_8n I1666_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I81_XP_MN0 (I1666_P15_14 I1666_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I81_XP_MN1 (VSS I1666_pn14 I1666_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I140_XP_MN0 (I1620_P15_8 I1620_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I140_XP_MN1 (VSS I1620_P11_8n I1620_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I142_XP_MN0 (I1620_P17_10 I1620_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I142_XP_MN1 (VSS I1620_P13_10n I1620_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I81_XP_MN0 (I1620_P15_14 I1620_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I81_XP_MN1 (VSS I1620_pn14 I1620_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I139_XP_MN0 (I1620_P14_7 I1620_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I139_XP_MN1 (VSS I1620_P10_7n I1620_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I143_XP_MN0 (I1620_P18_11 I1620_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I143_XP_MN1 (VSS I1620_P14_11n I1620_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I80_XP_MN0 (I1620_P14_13 I1620_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I80_XP_MN1 (VSS I1620_pn13 I1620_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I82_XP_MN0 (I1620_P16_15 I1620_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I82_XP_MN1 (VSS I1620_pn15 I1620_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I81_XP_MN0 (I1574_P15_14 I1574_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I81_XP_MN1 (VSS I1574_pn14 I1574_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I82_XP_MN0 (I1574_P16_15 I1574_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I82_XP_MN1 (VSS I1574_pn15 I1574_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I145_XP_MN0 (I1574_P20_13 I1574_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I145_XP_MN1 (VSS I1574_P16_13n I1574_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I149_XP_MN0 (I1574_P24_17 I1574_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I149_XP_MN1 (VSS I1574_P20_17n I1574_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I140_XP_MN0 (I1022_P15_8 I1022_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I140_XP_MN1 (VSS I1022_P11_8n I1022_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I83_XP_MN0 (I1022_P17_16 I1022_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I83_XP_MN1 (VSS I1022_pn16 I1022_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I143_XP_MN0 (I1022_P18_11 I1022_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I143_XP_MN1 (VSS I1022_P14_11n I1022_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I145_XP_MN0 (I1022_P20_13 I1022_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I145_XP_MN1 (VSS I1022_P16_13n I1022_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I82_XP_MN0 (I1022_P16_15 I1022_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I82_XP_MN1 (VSS I1022_pn15 I1022_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I84_XP_MN0 (I1022_P18_17 I1022_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I84_XP_MN1 (VSS I1022_pn17 I1022_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I141_XP_MN0 (I976_P16_9 I976_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I141_XP_MN1 (VSS I976_P12_9n I976_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I82_XP_MN0 (I976_P16_15 I976_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I82_XP_MN1 (VSS I976_pn15 I976_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I80_XP_MN0 (I976_P14_13 I976_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I80_XP_MN1 (VSS I976_pn13 I976_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I138_XP_MN0 (I976_P13_6 I976_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I138_XP_MN1 (VSS I976_P9_6n I976_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I142_XP_MN0 (I976_P17_10 I976_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I142_XP_MN1 (VSS I976_P13_10n I976_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I81_XP_MN0 (I976_P15_14 I976_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I81_XP_MN1 (VSS I976_pn14 I976_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I84_XP_MN0 (I930_P18_17 I930_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I84_XP_MN1 (VSS I930_pn17 I930_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I83_XP_MN0 (I930_P17_16 I930_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I83_XP_MN1 (VSS I930_pn16 I930_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I149_XP_MN0 (I930_P24_17 I930_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I149_XP_MN1 (VSS I930_P20_17n I930_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I143_XP_MN0 (I930_P18_11 I930_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I143_XP_MN1 (VSS I930_P14_11n I930_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I81_XP_MN0 (I930_P15_14 I930_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I81_XP_MN1 (VSS I930_pn14 I930_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I140_XP_MN0 (I930_P15_8 I930_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I140_XP_MN1 (VSS I930_P11_8n I930_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I144_XP_MN0 (I930_P19_12 I930_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I144_XP_MN1 (VSS I930_P15_12n I930_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I149_XP_MN0 (I1666_P24_17 I1666_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I149_XP_MN1 (VSS I1666_P20_17n I1666_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I86_XP_MN0 (I1666_P20_19 I1666_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I86_XP_MN1 (VSS I1666_pn19 I1666_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I84_XP_MN0 (I1666_P18_17 I1666_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I84_XP_MN1 (VSS I1666_pn17 I1666_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I150_XP_MN0 (I1666_P25_18 I1666_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I150_XP_MN1 (VSS I1666_P21_18n I1666_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I146_XP_MN0 (I1666_P21_14 I1666_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I146_XP_MN1 (VSS I1666_P17_14n I1666_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I85_XP_MN0 (I1666_P19_18 I1666_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I85_XP_MN1 (VSS I1666_pn18 I1666_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I144_XP_MN0 (I1666_P19_12 I1666_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I144_XP_MN1 (VSS I1666_P15_12n I1666_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I144_XP_MN0 (I1620_P19_12 I1620_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I144_XP_MN1 (VSS I1620_P15_12n I1620_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I83_XP_MN0 (I1620_P17_16 I1620_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I83_XP_MN1 (VSS I1620_pn16 I1620_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I149_XP_MN0 (I1620_P24_17 I1620_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I149_XP_MN1 (VSS I1620_P20_17n I1620_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I145_XP_MN0 (I1620_P20_13 I1620_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I145_XP_MN1 (VSS I1620_P16_13n I1620_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I84_XP_MN0 (I1620_P18_17 I1620_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I84_XP_MN1 (VSS I1620_pn17 I1620_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I140_XP_MN0 (I1574_P15_8 I1574_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I140_XP_MN1 (VSS I1574_P11_8n I1574_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I146_XP_MN0 (I1574_P21_14 I1574_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I146_XP_MN1 (VSS I1574_P17_14n I1574_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I83_XP_MN0 (I1574_P17_16 I1574_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I83_XP_MN1 (VSS I1574_pn16 I1574_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I84_XP_MN0 (I1574_P18_17 I1574_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I84_XP_MN1 (VSS I1574_pn17 I1574_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I150_XP_MN0 (I1022_P25_18 I1022_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I150_XP_MN1 (VSS I1022_P21_18n I1022_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I146_XP_MN0 (I1022_P21_14 I1022_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I146_XP_MN1 (VSS I1022_P17_14n I1022_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I144_XP_MN0 (I1022_P19_12 I1022_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I144_XP_MN1 (VSS I1022_P15_12n I1022_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I85_XP_MN0 (I1022_P19_18 I1022_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I85_XP_MN1 (VSS I1022_pn18 I1022_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I149_XP_MN0 (I1022_P24_17 I1022_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I149_XP_MN1 (VSS I1022_P20_17n I1022_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I86_XP_MN0 (I1022_P20_19 I1022_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I86_XP_MN1 (VSS I1022_pn19 I1022_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I139_XP_MN0 (I976_P14_7 I976_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I139_XP_MN1 (VSS I976_P10_7n I976_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I84_XP_MN0 (I976_P18_17 I976_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I84_XP_MN1 (VSS I976_pn17 I976_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I140_XP_MN0 (I976_P15_8 I976_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I140_XP_MN1 (VSS I976_P11_8n I976_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I83_XP_MN0 (I976_P17_16 I976_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I83_XP_MN1 (VSS I976_pn16 I976_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I85_XP_MN0 (I930_P19_18 I930_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I85_XP_MN1 (VSS I930_pn18 I930_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I148_XP_MN0 (I930_P23_16 I930_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I148_XP_MN1 (VSS I930_P19_16n I930_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I146_XP_MN0 (I930_P21_14 I930_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I146_XP_MN1 (VSS I930_P17_14n I930_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I153_XP_MN0 (I1666_P28_21 I1666_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I153_XP_MN1 (VSS I1666_P24_21n I1666_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I151_XP_MN0 (I1666_P26_19 I1666_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I151_XP_MN1 (VSS I1666_P22_19n I1666_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I147_XP_MN0 (I1666_P22_15 I1666_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I147_XP_MN1 (VSS I1666_P18_15n I1666_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I88_XP_MN0 (I1666_P22_21 I1666_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I88_XP_MN1 (VSS I1666_pn21 I1666_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I87_XP_MN0 (I1666_P21_20 I1666_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I87_XP_MN1 (VSS I1666_pn20 I1666_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I146_XP_MN0 (I1620_P21_14 I1620_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I146_XP_MN1 (VSS I1620_P17_14n I1620_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I85_XP_MN0 (I1620_P19_18 I1620_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I85_XP_MN1 (VSS I1620_pn18 I1620_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I147_XP_MN0 (I1620_P22_15 I1620_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I147_XP_MN1 (VSS I1620_P18_15n I1620_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I86_XP_MN0 (I1620_P20_19 I1620_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I86_XP_MN1 (VSS I1620_pn19 I1620_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I144_XP_MN0 (I1574_P19_12 I1574_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I144_XP_MN1 (VSS I1574_P15_12n I1574_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I150_XP_MN0 (I1574_P25_18 I1574_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I150_XP_MN1 (VSS I1574_P21_18n I1574_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I85_XP_MN0 (I1574_P19_18 I1574_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I85_XP_MN1 (VSS I1574_pn18 I1574_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I86_XP_MN0 (I1574_P20_19 I1574_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I86_XP_MN1 (VSS I1574_pn19 I1574_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I147_XP_MN0 (I1574_P22_15 I1574_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I147_XP_MN1 (VSS I1574_P18_15n I1574_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I151_XP_MN0 (I1574_P26_19 I1574_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I151_XP_MN1 (VSS I1574_P22_19n I1574_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I153_XP_MN0 (I1574_P28_21 I1574_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I153_XP_MN1 (VSS I1574_P24_21n I1574_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I154_XP_MN0 (I1022_P29_22 I1022_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I154_XP_MN1 (VSS I1022_P25_22n I1022_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I148_XP_MN0 (I1022_P23_16 I1022_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I148_XP_MN1 (VSS I1022_P19_16n I1022_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I152_XP_MN0 (I1022_P27_20 I1022_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I152_XP_MN1 (VSS I1022_P23_20n I1022_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I87_XP_MN0 (I1022_P21_20 I1022_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I87_XP_MN1 (VSS I1022_pn20 I1022_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I147_XP_MN0 (I1022_P22_15 I1022_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I147_XP_MN1 (VSS I1022_P18_15n I1022_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I151_XP_MN0 (I1022_P26_19 I1022_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I151_XP_MN1 (VSS I1022_P22_19n I1022_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I88_XP_MN0 (I1022_P22_21 I1022_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I88_XP_MN1 (VSS I1022_pn21 I1022_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I143_XP_MN0 (I976_P18_11 I976_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I143_XP_MN1 (VSS I976_P14_11n I976_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I145_XP_MN0 (I976_P20_13 I976_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I145_XP_MN1 (VSS I976_P16_13n I976_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I86_XP_MN0 (I976_P20_19 I976_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I86_XP_MN1 (VSS I976_pn19 I976_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I144_XP_MN0 (I976_P19_12 I976_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I144_XP_MN1 (VSS I976_P15_12n I976_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I85_XP_MN0 (I976_P19_18 I976_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I85_XP_MN1 (VSS I976_pn18 I976_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I86_XP_MN0 (I930_P20_19 I930_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I86_XP_MN1 (VSS I930_pn19 I930_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I147_XP_MN0 (I930_P22_15 I930_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I147_XP_MN1 (VSS I930_P18_15n I930_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I151_XP_MN0 (I930_P26_19 I930_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I151_XP_MN1 (VSS I930_P22_19n I930_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I87_XP_MN0 (I930_P21_20 I930_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I87_XP_MN1 (VSS I930_pn20 I930_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I150_XP_MN0 (I930_P25_18 I930_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I150_XP_MN1 (VSS I930_P21_18n I930_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I90_XP_MN0 (I1666_P24_23 I1666_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I90_XP_MN1 (VSS I1666_pn23 I1666_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I92_XP_MN0 (I1666_P26_25 I1666_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I92_XP_MN1 (VSS I1666_pn25 I1666_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I155_XP_MN0 (I1666_P30_23 I1666_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I155_XP_MN1 (VSS I1666_P26_23n I1666_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I94_XP_MN0 (I1666_P28_27 I1666_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I94_XP_MN1 (VSS I1666_pn27 I1666_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I89_XP_MN0 (I1666_P23_22 I1666_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I89_XP_MN1 (VSS I1666_pn22 I1666_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I154_XP_MN0 (I1666_P29_22 I1666_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I154_XP_MN1 (VSS I1666_P25_22n I1666_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I148_XP_MN0 (I1620_P23_16 I1620_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I148_XP_MN1 (VSS I1620_P19_16n I1620_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I150_XP_MN0 (I1620_P25_18 I1620_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I150_XP_MN1 (VSS I1620_P21_18n I1620_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I87_XP_MN0 (I1620_P21_20 I1620_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I87_XP_MN1 (VSS I1620_pn20 I1620_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I151_XP_MN0 (I1620_P26_19 I1620_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I151_XP_MN1 (VSS I1620_P22_19n I1620_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I153_XP_MN0 (I1620_P28_21 I1620_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I153_XP_MN1 (VSS I1620_P24_21n I1620_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I88_XP_MN0 (I1620_P22_21 I1620_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I88_XP_MN1 (VSS I1620_pn21 I1620_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I148_XP_MN0 (I1574_P23_16 I1574_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I148_XP_MN1 (VSS I1574_P19_16n I1574_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I87_XP_MN0 (I1574_P21_20 I1574_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I87_XP_MN1 (VSS I1574_pn20 I1574_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I88_XP_MN0 (I1574_P22_21 I1574_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I88_XP_MN1 (VSS I1574_pn21 I1574_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I89_XP_MN0 (I1022_P23_22 I1022_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I89_XP_MN1 (VSS I1022_pn22 I1022_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I90_XP_MN0 (I1022_P24_23 I1022_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I90_XP_MN1 (VSS I1022_pn23 I1022_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I153_XP_MN0 (I1022_P28_21 I1022_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I153_XP_MN1 (VSS I1022_P24_21n I1022_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I149_XP_MN0 (I976_P24_17 I976_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I149_XP_MN1 (VSS I976_P20_17n I976_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I150_XP_MN0 (I976_P25_18 I976_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I150_XP_MN1 (VSS I976_P21_18n I976_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I146_XP_MN0 (I976_P21_14 I976_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I146_XP_MN1 (VSS I976_P17_14n I976_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I87_XP_MN0 (I976_P21_20 I976_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I87_XP_MN1 (VSS I976_pn20 I976_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I153_XP_MN0 (I930_P28_21 I930_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I153_XP_MN1 (VSS I930_P24_21n I930_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I88_XP_MN0 (I930_P22_21 I930_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I88_XP_MN1 (VSS I930_pn21 I930_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I89_XP_MN0 (I930_P23_22 I930_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I89_XP_MN1 (VSS I930_pn22 I930_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I152_XP_MN0 (I930_P27_20 I930_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I152_XP_MN1 (VSS I930_P23_20n I930_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I156_XP_MN0 (I930_P31_24 I930_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I156_XP_MN1 (VSS I930_P27_24n I930_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I154_XP_MN0 (I930_P29_22 I930_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I154_XP_MN1 (VSS I930_P25_22n I930_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I91_XP_MN0 (I1666_P25_24 I1666_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I91_XP_MN1 (VSS I1666_pn24 I1666_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I93_XP_MN0 (I1666_P27_26 I1666_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I93_XP_MN1 (VSS I1666_pn26 I1666_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I152_XP_MN0 (I1666_P27_20 I1666_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I152_XP_MN1 (VSS I1666_P23_20n I1666_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I148_XP_MN0 (I1666_P23_16 I1666_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I148_XP_MN1 (VSS I1666_P19_16n I1666_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I152_XP_MN0 (I1620_P27_20 I1620_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I152_XP_MN1 (VSS I1620_P23_20n I1620_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I154_XP_MN0 (I1620_P29_22 I1620_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I154_XP_MN1 (VSS I1620_P25_22n I1620_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I89_XP_MN0 (I1620_P23_22 I1620_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I89_XP_MN1 (VSS I1620_pn22 I1620_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I90_XP_MN0 (I1620_P24_23 I1620_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I90_XP_MN1 (VSS I1620_pn23 I1620_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I152_XP_MN0 (I1574_P27_20 I1574_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I152_XP_MN1 (VSS I1574_P23_20n I1574_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I154_XP_MN0 (I1574_P29_22 I1574_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I154_XP_MN1 (VSS I1574_P25_22n I1574_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I89_XP_MN0 (I1574_P23_22 I1574_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I89_XP_MN1 (VSS I1574_pn22 I1574_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I90_XP_MN0 (I1574_P24_23 I1574_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I90_XP_MN1 (VSS I1574_pn23 I1574_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I155_XP_MN0 (I1574_P30_23 I1574_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I155_XP_MN1 (VSS I1574_P26_23n I1574_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I92_XP_MN0 (I1114_P26_25 I1114_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I92_XP_MN1 (VSS I1114_pn25 I1114_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I90_XP_MN0 (I1114_P24_23 I1114_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I90_XP_MN1 (VSS I1114_pn23 I1114_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I88_XP_MN0 (I1114_P22_21 I1114_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I88_XP_MN1 (VSS I1114_pn21 I1114_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I86_XP_MN0 (I1114_P20_19 I1114_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I86_XP_MN1 (VSS I1114_pn19 I1114_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I84_XP_MN0 (I1114_P18_17 I1114_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I84_XP_MN1 (VSS I1114_pn17 I1114_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I80_XP_MN0 (I1114_P14_13 I1114_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I80_XP_MN1 (VSS I1114_pn13 I1114_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I82_XP_MN0 (I1114_P16_15 I1114_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I82_XP_MN1 (VSS I1114_pn15 I1114_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I78_XP_MN0 (I1114_P12_11 I1114_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I78_XP_MN1 (VSS I1114_pn11 I1114_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I156_XP_MN0 (I1022_P31_24 I1022_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I156_XP_MN1 (VSS I1022_P27_24n I1022_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I91_XP_MN0 (I1022_P25_24 I1022_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I91_XP_MN1 (VSS I1022_pn24 I1022_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I93_XP_MN0 (I1022_P27_26 I1022_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I93_XP_MN1 (VSS I1022_pn26 I1022_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I155_XP_MN0 (I1022_P30_23 I1022_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I155_XP_MN1 (VSS I1022_P26_23n I1022_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I92_XP_MN0 (I1022_P26_25 I1022_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I92_XP_MN1 (VSS I1022_pn25 I1022_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I147_XP_MN0 (I976_P22_15 I976_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I147_XP_MN1 (VSS I976_P18_15n I976_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I88_XP_MN0 (I976_P22_21 I976_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I88_XP_MN1 (VSS I976_pn21 I976_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I148_XP_MN0 (I976_P23_16 I976_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I148_XP_MN1 (VSS I976_P19_16n I976_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I89_XP_MN0 (I976_P23_22 I976_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I89_XP_MN1 (VSS I976_pn22 I976_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I90_XP_MN0 (I930_P24_23 I930_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I90_XP_MN1 (VSS I930_pn23 I930_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I91_XP_MN0 (I930_P25_24 I930_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I91_XP_MN1 (VSS I930_pn24 I930_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I95_XP_MN0 (I1666_P29_28 I1666_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I95_XP_MN1 (VSS I1666_pn28 I1666_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I96_XP_MN0 (I1666_P30_29 I1666_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I96_XP_MN1 (VSS I1666_pn29 I1666_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I156_XP_MN0 (I1666_P31_24 I1666_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I156_XP_MN1 (VSS I1666_P27_24n I1666_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1666_I97_XP_MN0 (I1666_P31_30 I1666_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I97_XP_MN1 (VSS I1666_pn30 I1666_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I156_XP_MN0 (I1620_P31_24 I1620_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I156_XP_MN1 (VSS I1620_P27_24n I1620_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I91_XP_MN0 (I1620_P25_24 I1620_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I91_XP_MN1 (VSS I1620_pn24 I1620_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I155_XP_MN0 (I1620_P30_23 I1620_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I155_XP_MN1 (VSS I1620_P26_23n I1620_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I92_XP_MN0 (I1620_P26_25 I1620_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I92_XP_MN1 (VSS I1620_pn25 I1620_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I156_XP_MN0 (I1574_P31_24 I1574_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I156_XP_MN1 (VSS I1574_P27_24n I1574_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I91_XP_MN0 (I1574_P25_24 I1574_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I91_XP_MN1 (VSS I1574_pn24 I1574_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I92_XP_MN0 (I1574_P26_25 I1574_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I92_XP_MN1 (VSS I1574_pn25 I1574_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I96_XP_MN0 (I1114_P30_29 I1114_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I96_XP_MN1 (VSS I1114_pn29 I1114_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I94_XP_MN0 (I1114_P28_27 I1114_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I94_XP_MN1 (VSS I1114_pn27 I1114_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I155_XP_MN0 (I1114_P30_23 I1114_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I155_XP_MN1 (VSS I1114_P26_23n I1114_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I153_XP_MN0 (I1114_P28_21 I1114_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I153_XP_MN1 (VSS I1114_P24_21n I1114_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I151_XP_MN0 (I1114_P26_19 I1114_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I151_XP_MN1 (VSS I1114_P22_19n I1114_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I147_XP_MN0 (I1114_P22_15 I1114_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I147_XP_MN1 (VSS I1114_P18_15n I1114_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I149_XP_MN0 (I1114_P24_17 I1114_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I149_XP_MN1 (VSS I1114_P20_17n I1114_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I143_XP_MN0 (I1114_P18_11 I1114_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I143_XP_MN1 (VSS I1114_P14_11n I1114_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I145_XP_MN0 (I1114_P20_13 I1114_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I145_XP_MN1 (VSS I1114_P16_13n I1114_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I139_XP_MN0 (I1114_P14_7 I1114_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I139_XP_MN1 (VSS I1114_P10_7n I1114_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I141_XP_MN0 (I1114_P16_9 I1114_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I141_XP_MN1 (VSS I1114_P12_9n I1114_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I137_XP_MN0 (I1114_P12_5 I1114_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I137_XP_MN1 (VSS I1114_P8_5n I1114_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I76_XP_MN0 (I1114_P10_9 I1114_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I76_XP_MN1 (VSS I1114_pn9 I1114_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I74_XP_MN0 (I1114_P8_7 I1114_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I74_XP_MN1 (VSS I1114_pn7 I1114_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I95_XP_MN0 (I1022_P29_28 I1022_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I95_XP_MN1 (VSS I1022_pn28 I1022_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I97_XP_MN0 (I1022_P31_30 I1022_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I97_XP_MN1 (VSS I1022_pn30 I1022_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I94_XP_MN0 (I1022_P28_27 I1022_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I94_XP_MN1 (VSS I1022_pn27 I1022_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1022_I96_XP_MN0 (I1022_P30_29 I1022_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1022_I96_XP_MN1 (VSS I1022_pn29 I1022_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I151_XP_MN0 (I976_P26_19 I976_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I151_XP_MN1 (VSS I976_P22_19n I976_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I90_XP_MN0 (I976_P24_23 I976_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I90_XP_MN1 (VSS I976_pn23 I976_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I92_XP_MN0 (I976_P26_25 I976_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I92_XP_MN1 (VSS I976_pn25 I976_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I152_XP_MN0 (I976_P27_20 I976_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I152_XP_MN1 (VSS I976_P23_20n I976_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I91_XP_MN0 (I976_P25_24 I976_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I91_XP_MN1 (VSS I976_pn24 I976_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I155_XP_MN0 (I930_P30_23 I930_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I155_XP_MN1 (VSS I930_P26_23n I930_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I92_XP_MN0 (I930_P26_25 I930_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I92_XP_MN1 (VSS I930_pn25 I930_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I93_XP_MN0 (I930_P27_26 I930_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I93_XP_MN1 (VSS I930_pn26 I930_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I95_XP_MN0 (I1620_P29_28 I1620_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I95_XP_MN1 (VSS I1620_pn28 I1620_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I93_XP_MN0 (I1620_P27_26 I1620_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I93_XP_MN1 (VSS I1620_pn26 I1620_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I96_XP_MN0 (I1620_P30_29 I1620_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I96_XP_MN1 (VSS I1620_pn29 I1620_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I94_XP_MN0 (I1620_P28_27 I1620_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I94_XP_MN1 (VSS I1620_pn27 I1620_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I97_XP_MN0 (I1574_P31_30 I1574_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I97_XP_MN1 (VSS I1574_pn30 I1574_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I95_XP_MN0 (I1574_P29_28 I1574_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I95_XP_MN1 (VSS I1574_pn28 I1574_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I96_XP_MN0 (I1574_P30_29 I1574_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I96_XP_MN1 (VSS I1574_pn29 I1574_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I93_XP_MN0 (I1574_P27_26 I1574_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I93_XP_MN1 (VSS I1574_pn26 I1574_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1574_I94_XP_MN0 (I1574_P28_27 I1574_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I94_XP_MN1 (VSS I1574_pn27 I1574_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I93_XP_MN0 (I1114_P27_26 I1114_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I93_XP_MN1 (VSS I1114_pn26 I1114_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I91_XP_MN0 (I1114_P25_24 I1114_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I91_XP_MN1 (VSS I1114_pn24 I1114_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I89_XP_MN0 (I1114_P23_22 I1114_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I89_XP_MN1 (VSS I1114_pn22 I1114_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I87_XP_MN0 (I1114_P21_20 I1114_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I87_XP_MN1 (VSS I1114_pn20 I1114_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I135_XP_MN0 (I1114_P10_3 I1114_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I135_XP_MN1 (VSS I1114_P6_3n I1114_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I133_XP_MN0 (I1114_P8_1 I1114_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I133_XP_MN1 (VSS I1114_P4_1n I1114_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I72_XP_MN0 (I1114_P6_5 I1114_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I72_XP_MN1 (VSS I1114_pn5 I1114_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I70_XP_MN0 (I1114_P4_3 I1114_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I70_XP_MN1 (VSS I1114_pn3 I1114_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I153_XP_MN0 (I976_P28_21 I976_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I153_XP_MN1 (VSS I976_P24_21n I976_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I154_XP_MN0 (I976_P29_22 I976_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I154_XP_MN1 (VSS I976_P25_22n I976_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I93_XP_MN0 (I976_P27_26 I976_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I93_XP_MN1 (VSS I976_pn26 I976_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I94_XP_MN0 (I930_P28_27 I930_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I94_XP_MN1 (VSS I930_pn27 I930_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I95_XP_MN0 (I930_P29_28 I930_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I95_XP_MN1 (VSS I930_pn28 I930_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1620_I97_XP_MN0 (I1620_P31_30 I1620_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1620_I97_XP_MN1 (VSS I1620_pn30 I1620_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I97_XP_MN0 (I1114_P31_30 I1114_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I97_XP_MN1 (VSS I1114_pn30 I1114_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I95_XP_MN0 (I1114_P29_28 I1114_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I95_XP_MN1 (VSS I1114_pn28 I1114_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I154_XP_MN0 (I1114_P29_22 I1114_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I154_XP_MN1 (VSS I1114_P25_22n I1114_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I85_XP_MN0 (I1114_P19_18 I1114_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I85_XP_MN1 (VSS I1114_pn18 I1114_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I83_XP_MN0 (I1114_P17_16 I1114_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I83_XP_MN1 (VSS I1114_pn16 I1114_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I81_XP_MN0 (I1114_P15_14 I1114_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I81_XP_MN1 (VSS I1114_pn14 I1114_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I79_XP_MN0 (I1114_P13_12 I1114_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I79_XP_MN1 (VSS I1114_pn12 I1114_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I77_XP_MN0 (I1114_P11_10 I1114_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I77_XP_MN1 (VSS I1114_pn10 I1114_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I75_XP_MN0 (I1114_P9_8 I1114_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I75_XP_MN1 (VSS I1114_pn8 I1114_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I71_XP_MN0 (I1114_P5_4 I1114_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I71_XP_MN1 (VSS I1114_pn4 I1114_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I68_XP_MN0 (I1114_P2_1 I1114_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I68_XP_MN1 (VSS I1114_pn1 I1114_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I155_XP_MN0 (I976_P30_23 I976_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I155_XP_MN1 (VSS I976_P26_23n I976_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I94_XP_MN0 (I976_P28_27 I976_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I94_XP_MN1 (VSS I976_pn27 I976_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I156_XP_MN0 (I976_P31_24 I976_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I156_XP_MN1 (VSS I976_P27_24n I976_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I95_XP_MN0 (I976_P29_28 I976_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I95_XP_MN1 (VSS I976_pn28 I976_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I96_XP_MN0 (I930_P30_29 I930_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I96_XP_MN1 (VSS I930_pn29 I930_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI930_I97_XP_MN0 (I930_P31_30 I930_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI930_I97_XP_MN1 (VSS I930_pn30 I930_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I68_XP_MN0 (I1528_P2_1 I1528_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I68_XP_MN1 (VSS I1528_pn1 I1528_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I69_XP_MN0 (I1528_P3_2 I1528_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I69_XP_MN1 (VSS I1528_pn2 I1528_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I156_XP_MN0 (I1114_P31_24 I1114_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I156_XP_MN1 (VSS I1114_P27_24n I1114_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I152_XP_MN0 (I1114_P27_20 I1114_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I152_XP_MN1 (VSS I1114_P23_20n I1114_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I150_XP_MN0 (I1114_P25_18 I1114_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I150_XP_MN1 (VSS I1114_P21_18n I1114_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I146_XP_MN0 (I1114_P21_14 I1114_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I146_XP_MN1 (VSS I1114_P17_14n I1114_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I142_XP_MN0 (I1114_P17_10 I1114_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I142_XP_MN1 (VSS I1114_P13_10n I1114_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I138_XP_MN0 (I1114_P13_6 I1114_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I138_XP_MN1 (VSS I1114_P9_6n I1114_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I134_XP_MN0 (I1114_P9_2 I1114_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I134_XP_MN1 (VSS I1114_P5_2n I1114_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I73_XP_MN0 (I1114_P7_6 I1114_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I73_XP_MN1 (VSS I1114_pn6 I1114_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I69_XP_MN0 (I1114_P3_2 I1114_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I69_XP_MN1 (VSS I1114_pn2 I1114_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I96_XP_MN0 (I976_P30_29 I976_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I96_XP_MN1 (VSS I976_pn29 I976_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI976_I97_XP_MN0 (I976_P31_30 I976_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI976_I97_XP_MN1 (VSS I976_pn30 I976_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I68_XP_MN0 (I1482_P2_1 I1482_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I68_XP_MN1 (VSS I1482_pn1 I1482_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I70_XP_MN0 (I1528_P4_3 I1528_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I70_XP_MN1 (VSS I1528_pn3 I1528_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I72_XP_MN0 (I1528_P6_5 I1528_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I72_XP_MN1 (VSS I1528_pn5 I1528_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I133_XP_MN0 (I1528_P8_1 I1528_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I133_XP_MN1 (VSS I1528_P4_1n I1528_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I71_XP_MN0 (I1528_P5_4 I1528_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I71_XP_MN1 (VSS I1528_pn4 I1528_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I148_XP_MN0 (I1114_P23_16 I1114_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I148_XP_MN1 (VSS I1114_P19_16n I1114_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I144_XP_MN0 (I1114_P19_12 I1114_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I144_XP_MN1 (VSS I1114_P15_12n I1114_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I140_XP_MN0 (I1114_P15_8 I1114_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I140_XP_MN1 (VSS I1114_P11_8n I1114_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1114_I136_XP_MN0 (I1114_P11_4 I1114_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1114_I136_XP_MN1 (VSS I1114_P7_4n I1114_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I68_XP_MN0 (I1298_P2_1 I1298_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I68_XP_MN1 (VSS I1298_pn1 I1298_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I69_XP_MN0 (I1344_P3_2 I1344_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I69_XP_MN1 (VSS I1344_pn2 I1344_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I68_XP_MN0 (I1344_P2_1 I1344_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I68_XP_MN1 (VSS I1344_pn1 I1344_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I70_XP_MN0 (I1390_P4_3 I1390_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I70_XP_MN1 (VSS I1390_pn3 I1390_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I68_XP_MN0 (I1390_P2_1 I1390_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I68_XP_MN1 (VSS I1390_pn1 I1390_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I69_XP_MN0 (I1390_P3_2 I1390_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I69_XP_MN1 (VSS I1390_pn2 I1390_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I70_XP_MN0 (I1436_P4_3 I1436_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I70_XP_MN1 (VSS I1436_pn3 I1436_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I68_XP_MN0 (I1436_P2_1 I1436_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I68_XP_MN1 (VSS I1436_pn1 I1436_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I69_XP_MN0 (I1436_P3_2 I1436_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I69_XP_MN1 (VSS I1436_pn2 I1436_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I69_XP_MN0 (I1482_P3_2 I1482_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I69_XP_MN1 (VSS I1482_pn2 I1482_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I74_XP_MN0 (I1528_P8_7 I1528_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I74_XP_MN1 (VSS I1528_pn7 I1528_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I141_XP_MN0 (I1528_P16_9 I1528_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I141_XP_MN1 (VSS I1528_P12_9n I1528_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I73_XP_MN0 (I1528_P7_6 I1528_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I73_XP_MN1 (VSS I1528_pn6 I1528_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I134_XP_MN0 (I1528_P9_2 I1528_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I134_XP_MN1 (VSS I1528_P5_2n I1528_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I68_XP_MN0 (I1252_P2_1 I1252_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I68_XP_MN1 (VSS I1252_pn1 I1252_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I69_XP_MN0 (I1252_P3_2 I1252_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I69_XP_MN1 (VSS I1252_pn2 I1252_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I70_XP_MN0 (I1298_P4_3 I1298_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I70_XP_MN1 (VSS I1298_pn3 I1298_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I71_XP_MN0 (I1298_P5_4 I1298_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I71_XP_MN1 (VSS I1298_pn4 I1298_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I69_XP_MN0 (I1298_P3_2 I1298_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I69_XP_MN1 (VSS I1298_pn2 I1298_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I72_XP_MN0 (I1344_P6_5 I1344_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I72_XP_MN1 (VSS I1344_pn5 I1344_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I70_XP_MN0 (I1344_P4_3 I1344_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I70_XP_MN1 (VSS I1344_pn3 I1344_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I71_XP_MN0 (I1344_P5_4 I1344_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I71_XP_MN1 (VSS I1344_pn4 I1344_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I72_XP_MN0 (I1390_P6_5 I1390_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I72_XP_MN1 (VSS I1390_pn5 I1390_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I71_XP_MN0 (I1390_P5_4 I1390_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I71_XP_MN1 (VSS I1390_pn4 I1390_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I72_XP_MN0 (I1436_P6_5 I1436_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I72_XP_MN1 (VSS I1436_pn5 I1436_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I71_XP_MN0 (I1436_P5_4 I1436_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I71_XP_MN1 (VSS I1436_pn4 I1436_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I72_XP_MN0 (I1482_P6_5 I1482_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I72_XP_MN1 (VSS I1482_pn5 I1482_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I71_XP_MN0 (I1482_P5_4 I1482_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I71_XP_MN1 (VSS I1482_pn4 I1482_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I70_XP_MN0 (I1482_P4_3 I1482_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I70_XP_MN1 (VSS I1482_pn3 I1482_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I76_XP_MN0 (I1528_P10_9 I1528_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I76_XP_MN1 (VSS I1528_pn9 I1528_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I137_XP_MN0 (I1528_P12_5 I1528_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I137_XP_MN1 (VSS I1528_P8_5n I1528_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I75_XP_MN0 (I1528_P9_8 I1528_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I75_XP_MN1 (VSS I1528_pn8 I1528_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I68_XP_MN0 (I1160_P2_1 I1160_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I68_XP_MN1 (VSS I1160_pn1 I1160_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I68_XP_MN0 (I1206_P2_1 I1206_pn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I68_XP_MN1 (VSS I1206_pn1 I1206_P2_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I70_XP_MN0 (I1252_P4_3 I1252_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I70_XP_MN1 (VSS I1252_pn3 I1252_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I71_XP_MN0 (I1252_P5_4 I1252_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I71_XP_MN1 (VSS I1252_pn4 I1252_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I72_XP_MN0 (I1298_P6_5 I1298_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I72_XP_MN1 (VSS I1298_pn5 I1298_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I73_XP_MN0 (I1298_P7_6 I1298_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I73_XP_MN1 (VSS I1298_pn6 I1298_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I74_XP_MN0 (I1344_P8_7 I1344_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I74_XP_MN1 (VSS I1344_pn7 I1344_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I133_XP_MN0 (I1344_P8_1 I1344_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I133_XP_MN1 (VSS I1344_P4_1n I1344_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I73_XP_MN0 (I1344_P7_6 I1344_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I73_XP_MN1 (VSS I1344_pn6 I1344_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I75_XP_MN0 (I1344_P9_8 I1344_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I75_XP_MN1 (VSS I1344_pn8 I1344_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I134_XP_MN0 (I1344_P9_2 I1344_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I134_XP_MN1 (VSS I1344_P5_2n I1344_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I74_XP_MN0 (I1390_P8_7 I1390_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I74_XP_MN1 (VSS I1390_pn7 I1390_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I133_XP_MN0 (I1390_P8_1 I1390_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I133_XP_MN1 (VSS I1390_P4_1n I1390_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I75_XP_MN0 (I1390_P9_8 I1390_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I75_XP_MN1 (VSS I1390_pn8 I1390_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I73_XP_MN0 (I1390_P7_6 I1390_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I73_XP_MN1 (VSS I1390_pn6 I1390_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I74_XP_MN0 (I1436_P8_7 I1436_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I74_XP_MN1 (VSS I1436_pn7 I1436_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I133_XP_MN0 (I1436_P8_1 I1436_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I133_XP_MN1 (VSS I1436_P4_1n I1436_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I73_XP_MN0 (I1436_P7_6 I1436_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I73_XP_MN1 (VSS I1436_pn6 I1436_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I73_XP_MN0 (I1482_P7_6 I1482_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I73_XP_MN1 (VSS I1482_pn6 I1482_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I74_XP_MN0 (I1482_P8_7 I1482_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I74_XP_MN1 (VSS I1482_pn7 I1482_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I133_XP_MN0 (I1482_P8_1 I1482_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I133_XP_MN1 (VSS I1482_P4_1n I1482_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I135_XP_MN0 (I1528_P10_3 I1528_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I135_XP_MN1 (VSS I1528_P6_3n I1528_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I77_XP_MN0 (I1528_P11_10 I1528_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I77_XP_MN1 (VSS I1528_pn10 I1528_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I136_XP_MN0 (I1528_P11_4 I1528_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I136_XP_MN1 (VSS I1528_P7_4n I1528_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I138_XP_MN0 (I1528_P13_6 I1528_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I138_XP_MN1 (VSS I1528_P9_6n I1528_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I142_XP_MN0 (I1528_P17_10 I1528_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I142_XP_MN1 (VSS I1528_P13_10n I1528_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I87_XP_MN0 (I1160_P21_20 I1160_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I87_XP_MN1 (VSS I1160_pn20 I1160_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I69_XP_MN0 (I1160_P3_2 I1160_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I69_XP_MN1 (VSS I1160_pn2 I1160_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I69_XP_MN0 (I1206_P3_2 I1206_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I69_XP_MN1 (VSS I1206_pn2 I1206_P3_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I72_XP_MN0 (I1252_P6_5 I1252_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I72_XP_MN1 (VSS I1252_pn5 I1252_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I133_XP_MN0 (I1252_P8_1 I1252_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I133_XP_MN1 (VSS I1252_P4_1n I1252_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I73_XP_MN0 (I1252_P7_6 I1252_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I73_XP_MN1 (VSS I1252_pn6 I1252_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I74_XP_MN0 (I1298_P8_7 I1298_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I74_XP_MN1 (VSS I1298_pn7 I1298_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I133_XP_MN0 (I1298_P8_1 I1298_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I133_XP_MN1 (VSS I1298_P4_1n I1298_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I75_XP_MN0 (I1298_P9_8 I1298_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I75_XP_MN1 (VSS I1298_pn8 I1298_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I134_XP_MN0 (I1298_P9_2 I1298_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I134_XP_MN1 (VSS I1298_P5_2n I1298_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I135_XP_MN0 (I1344_P10_3 I1344_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I135_XP_MN1 (VSS I1344_P6_3n I1344_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I76_XP_MN0 (I1344_P10_9 I1344_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I76_XP_MN1 (VSS I1344_pn9 I1344_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I76_XP_MN0 (I1390_P10_9 I1390_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I76_XP_MN1 (VSS I1390_pn9 I1390_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I135_XP_MN0 (I1390_P10_3 I1390_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I135_XP_MN1 (VSS I1390_P6_3n I1390_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I134_XP_MN0 (I1390_P9_2 I1390_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I134_XP_MN1 (VSS I1390_P5_2n I1390_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I76_XP_MN0 (I1436_P10_9 I1436_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I76_XP_MN1 (VSS I1436_pn9 I1436_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I75_XP_MN0 (I1436_P9_8 I1436_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I75_XP_MN1 (VSS I1436_pn8 I1436_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I134_XP_MN0 (I1436_P9_2 I1436_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I134_XP_MN1 (VSS I1436_P5_2n I1436_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I75_XP_MN0 (I1482_P9_8 I1482_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I75_XP_MN1 (VSS I1482_pn8 I1482_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I134_XP_MN0 (I1482_P9_2 I1482_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I134_XP_MN1 (VSS I1482_P5_2n I1482_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I80_XP_MN0 (I1528_P14_13 I1528_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I80_XP_MN1 (VSS I1528_pn13 I1528_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I78_XP_MN0 (I1528_P12_11 I1528_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I78_XP_MN1 (VSS I1528_pn11 I1528_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I145_XP_MN0 (I1528_P20_13 I1528_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I145_XP_MN1 (VSS I1528_P16_13n I1528_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I79_XP_MN0 (I1528_P13_12 I1528_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I79_XP_MN1 (VSS I1528_pn12 I1528_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I148_XP_MN0 (I1160_P23_16 I1160_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I148_XP_MN1 (VSS I1160_P19_16n I1160_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I89_XP_MN0 (I1160_P23_22 I1160_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I89_XP_MN1 (VSS I1160_pn22 I1160_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I144_XP_MN0 (I1160_P19_12 I1160_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I144_XP_MN1 (VSS I1160_P15_12n I1160_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I85_XP_MN0 (I1160_P19_18 I1160_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I85_XP_MN1 (VSS I1160_pn18 I1160_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I83_XP_MN0 (I1160_P17_16 I1160_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I83_XP_MN1 (VSS I1160_pn16 I1160_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I140_XP_MN0 (I1160_P15_8 I1160_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I140_XP_MN1 (VSS I1160_P11_8n I1160_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I81_XP_MN0 (I1160_P15_14 I1160_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I81_XP_MN1 (VSS I1160_pn14 I1160_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I79_XP_MN0 (I1160_P13_12 I1160_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I79_XP_MN1 (VSS I1160_pn12 I1160_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I77_XP_MN0 (I1160_P11_10 I1160_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I77_XP_MN1 (VSS I1160_pn10 I1160_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I75_XP_MN0 (I1160_P9_8 I1160_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I75_XP_MN1 (VSS I1160_pn8 I1160_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I73_XP_MN0 (I1160_P7_6 I1160_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I73_XP_MN1 (VSS I1160_pn6 I1160_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I71_XP_MN0 (I1160_P5_4 I1160_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I71_XP_MN1 (VSS I1160_pn4 I1160_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I70_XP_MN0 (I1160_P4_3 I1160_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I70_XP_MN1 (VSS I1160_pn3 I1160_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I71_XP_MN0 (I1206_P5_4 I1206_pn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I71_XP_MN1 (VSS I1206_pn4 I1206_P5_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I70_XP_MN0 (I1206_P4_3 I1206_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I70_XP_MN1 (VSS I1206_pn3 I1206_P4_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I135_XP_MN0 (I1252_P10_3 I1252_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I135_XP_MN1 (VSS I1252_P6_3n I1252_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I74_XP_MN0 (I1252_P8_7 I1252_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I74_XP_MN1 (VSS I1252_pn7 I1252_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I75_XP_MN0 (I1252_P9_8 I1252_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I75_XP_MN1 (VSS I1252_pn8 I1252_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I134_XP_MN0 (I1252_P9_2 I1252_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I134_XP_MN1 (VSS I1252_P5_2n I1252_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I76_XP_MN0 (I1298_P10_9 I1298_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I76_XP_MN1 (VSS I1298_pn9 I1298_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I135_XP_MN0 (I1298_P10_3 I1298_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I135_XP_MN1 (VSS I1298_P6_3n I1298_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I77_XP_MN0 (I1298_P11_10 I1298_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I77_XP_MN1 (VSS I1298_pn10 I1298_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I141_XP_MN0 (I1344_P16_9 I1344_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I141_XP_MN1 (VSS I1344_P12_9n I1344_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I137_XP_MN0 (I1344_P12_5 I1344_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I137_XP_MN1 (VSS I1344_P8_5n I1344_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I78_XP_MN0 (I1344_P12_11 I1344_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I78_XP_MN1 (VSS I1344_pn11 I1344_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I77_XP_MN0 (I1344_P11_10 I1344_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I77_XP_MN1 (VSS I1344_pn10 I1344_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I136_XP_MN0 (I1344_P11_4 I1344_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I136_XP_MN1 (VSS I1344_P7_4n I1344_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I78_XP_MN0 (I1390_P12_11 I1390_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I78_XP_MN1 (VSS I1390_pn11 I1390_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I77_XP_MN0 (I1390_P11_10 I1390_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I77_XP_MN1 (VSS I1390_pn10 I1390_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I136_XP_MN0 (I1390_P11_4 I1390_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I136_XP_MN1 (VSS I1390_P7_4n I1390_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I78_XP_MN0 (I1436_P12_11 I1436_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I78_XP_MN1 (VSS I1436_pn11 I1436_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I135_XP_MN0 (I1436_P10_3 I1436_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I135_XP_MN1 (VSS I1436_P6_3n I1436_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I77_XP_MN0 (I1436_P11_10 I1436_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I77_XP_MN1 (VSS I1436_pn10 I1436_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I77_XP_MN0 (I1482_P11_10 I1482_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I77_XP_MN1 (VSS I1482_pn10 I1482_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I76_XP_MN0 (I1482_P10_9 I1482_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I76_XP_MN1 (VSS I1482_pn9 I1482_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I139_XP_MN0 (I1528_P14_7 I1528_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I139_XP_MN1 (VSS I1528_P10_7n I1528_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I143_XP_MN0 (I1528_P18_11 I1528_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I143_XP_MN1 (VSS I1528_P14_11n I1528_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I149_XP_MN0 (I1528_P24_17 I1528_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I149_XP_MN1 (VSS I1528_P20_17n I1528_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I81_XP_MN0 (I1528_P15_14 I1528_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I81_XP_MN1 (VSS I1528_pn14 I1528_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I140_XP_MN0 (I1528_P15_8 I1528_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I140_XP_MN1 (VSS I1528_P11_8n I1528_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I156_XP_MN0 (I1160_P31_24 I1160_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I156_XP_MN1 (VSS I1160_P27_24n I1160_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I152_XP_MN0 (I1160_P27_20 I1160_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I152_XP_MN1 (VSS I1160_P23_20n I1160_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I150_XP_MN0 (I1160_P25_18 I1160_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I150_XP_MN1 (VSS I1160_P21_18n I1160_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I146_XP_MN0 (I1160_P21_14 I1160_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I146_XP_MN1 (VSS I1160_P17_14n I1160_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I142_XP_MN0 (I1160_P17_10 I1160_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I142_XP_MN1 (VSS I1160_P13_10n I1160_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I138_XP_MN0 (I1160_P13_6 I1160_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I138_XP_MN1 (VSS I1160_P9_6n I1160_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I136_XP_MN0 (I1160_P11_4 I1160_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I136_XP_MN1 (VSS I1160_P7_4n I1160_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I134_XP_MN0 (I1160_P9_2 I1160_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I134_XP_MN1 (VSS I1160_P5_2n I1160_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I74_XP_MN0 (I1160_P8_7 I1160_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I74_XP_MN1 (VSS I1160_pn7 I1160_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I72_XP_MN0 (I1160_P6_5 I1160_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I72_XP_MN1 (VSS I1160_pn5 I1160_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I72_XP_MN0 (I1206_P6_5 I1206_pn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I72_XP_MN1 (VSS I1206_pn5 I1206_P6_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I76_XP_MN0 (I1252_P10_9 I1252_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I76_XP_MN1 (VSS I1252_pn9 I1252_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I77_XP_MN0 (I1252_P11_10 I1252_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I77_XP_MN1 (VSS I1252_pn10 I1252_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I78_XP_MN0 (I1298_P12_11 I1298_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I78_XP_MN1 (VSS I1298_pn11 I1298_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I137_XP_MN0 (I1298_P12_5 I1298_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I137_XP_MN1 (VSS I1298_P8_5n I1298_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I136_XP_MN0 (I1298_P11_4 I1298_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I136_XP_MN1 (VSS I1298_P7_4n I1298_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I79_XP_MN0 (I1344_P13_12 I1344_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I79_XP_MN1 (VSS I1344_pn12 I1344_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I141_XP_MN0 (I1390_P16_9 I1390_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I141_XP_MN1 (VSS I1390_P12_9n I1390_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I137_XP_MN0 (I1390_P12_5 I1390_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I137_XP_MN1 (VSS I1390_P8_5n I1390_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I79_XP_MN0 (I1390_P13_12 I1390_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I79_XP_MN1 (VSS I1390_pn12 I1390_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I141_XP_MN0 (I1436_P16_9 I1436_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I141_XP_MN1 (VSS I1436_P12_9n I1436_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I137_XP_MN0 (I1436_P12_5 I1436_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I137_XP_MN1 (VSS I1436_P8_5n I1436_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I136_XP_MN0 (I1436_P11_4 I1436_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I136_XP_MN1 (VSS I1436_P7_4n I1436_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I136_XP_MN0 (I1482_P11_4 I1482_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I136_XP_MN1 (VSS I1482_P7_4n I1482_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I78_XP_MN0 (I1482_P12_11 I1482_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I78_XP_MN1 (VSS I1482_pn11 I1482_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I137_XP_MN0 (I1482_P12_5 I1482_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I137_XP_MN1 (VSS I1482_P8_5n I1482_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I135_XP_MN0 (I1482_P10_3 I1482_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I135_XP_MN1 (VSS I1482_P6_3n I1482_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I82_XP_MN0 (I1528_P16_15 I1528_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I82_XP_MN1 (VSS I1528_pn15 I1528_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I144_XP_MN0 (I1528_P19_12 I1528_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I144_XP_MN1 (VSS I1528_P15_12n I1528_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I146_XP_MN0 (I1528_P21_14 I1528_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I146_XP_MN1 (VSS I1528_P17_14n I1528_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I97_XP_MN0 (I1160_P31_30 I1160_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I97_XP_MN1 (VSS I1160_pn30 I1160_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I154_XP_MN0 (I1160_P29_22 I1160_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I154_XP_MN1 (VSS I1160_P25_22n I1160_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I84_XP_MN0 (I1160_P18_17 I1160_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I84_XP_MN1 (VSS I1160_pn17 I1160_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I80_XP_MN0 (I1160_P14_13 I1160_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I80_XP_MN1 (VSS I1160_pn13 I1160_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I78_XP_MN0 (I1160_P12_11 I1160_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I78_XP_MN1 (VSS I1160_pn11 I1160_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I76_XP_MN0 (I1160_P10_9 I1160_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I76_XP_MN1 (VSS I1160_pn9 I1160_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I73_XP_MN0 (I1206_P7_6 I1206_pn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I73_XP_MN1 (VSS I1206_pn6 I1206_P7_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I74_XP_MN0 (I1206_P8_7 I1206_pn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I74_XP_MN1 (VSS I1206_pn7 I1206_P8_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I133_XP_MN0 (I1206_P8_1 I1206_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I133_XP_MN1 (VSS I1206_P4_1n I1206_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I78_XP_MN0 (I1252_P12_11 I1252_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I78_XP_MN1 (VSS I1252_pn11 I1252_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I141_XP_MN0 (I1252_P16_9 I1252_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I141_XP_MN1 (VSS I1252_P12_9n I1252_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I137_XP_MN0 (I1252_P12_5 I1252_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I137_XP_MN1 (VSS I1252_P8_5n I1252_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I79_XP_MN0 (I1252_P13_12 I1252_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I79_XP_MN1 (VSS I1252_pn12 I1252_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I136_XP_MN0 (I1252_P11_4 I1252_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I136_XP_MN1 (VSS I1252_P7_4n I1252_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I138_XP_MN0 (I1252_P13_6 I1252_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I138_XP_MN1 (VSS I1252_P9_6n I1252_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I80_XP_MN0 (I1298_P14_13 I1298_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I80_XP_MN1 (VSS I1298_pn13 I1298_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I141_XP_MN0 (I1298_P16_9 I1298_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I141_XP_MN1 (VSS I1298_P12_9n I1298_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I79_XP_MN0 (I1298_P13_12 I1298_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I79_XP_MN1 (VSS I1298_pn12 I1298_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I142_XP_MN0 (I1298_P17_10 I1298_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I142_XP_MN1 (VSS I1298_P13_10n I1298_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I138_XP_MN0 (I1298_P13_6 I1298_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I138_XP_MN1 (VSS I1298_P9_6n I1298_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I139_XP_MN0 (I1344_P14_7 I1344_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I139_XP_MN1 (VSS I1344_P10_7n I1344_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I80_XP_MN0 (I1344_P14_13 I1344_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I80_XP_MN1 (VSS I1344_pn13 I1344_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I142_XP_MN0 (I1344_P17_10 I1344_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I142_XP_MN1 (VSS I1344_P13_10n I1344_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I138_XP_MN0 (I1344_P13_6 I1344_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I138_XP_MN1 (VSS I1344_P9_6n I1344_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I80_XP_MN0 (I1390_P14_13 I1390_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I80_XP_MN1 (VSS I1390_pn13 I1390_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I143_XP_MN0 (I1390_P18_11 I1390_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I143_XP_MN1 (VSS I1390_P14_11n I1390_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I139_XP_MN0 (I1390_P14_7 I1390_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I139_XP_MN1 (VSS I1390_P10_7n I1390_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I142_XP_MN0 (I1390_P17_10 I1390_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I142_XP_MN1 (VSS I1390_P13_10n I1390_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I138_XP_MN0 (I1390_P13_6 I1390_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I138_XP_MN1 (VSS I1390_P9_6n I1390_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I80_XP_MN0 (I1436_P14_13 I1436_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I80_XP_MN1 (VSS I1436_pn13 I1436_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I139_XP_MN0 (I1436_P14_7 I1436_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I139_XP_MN1 (VSS I1436_P10_7n I1436_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I79_XP_MN0 (I1436_P13_12 I1436_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I79_XP_MN1 (VSS I1436_pn12 I1436_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I138_XP_MN0 (I1436_P13_6 I1436_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I138_XP_MN1 (VSS I1436_P9_6n I1436_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I79_XP_MN0 (I1482_P13_12 I1482_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I79_XP_MN1 (VSS I1482_pn12 I1482_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I80_XP_MN0 (I1482_P14_13 I1482_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I80_XP_MN1 (VSS I1482_pn13 I1482_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I141_XP_MN0 (I1482_P16_9 I1482_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I141_XP_MN1 (VSS I1482_P12_9n I1482_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I139_XP_MN0 (I1482_P14_7 I1482_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I139_XP_MN1 (VSS I1482_P10_7n I1482_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I84_XP_MN0 (I1528_P18_17 I1528_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I84_XP_MN1 (VSS I1528_pn17 I1528_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I147_XP_MN0 (I1528_P22_15 I1528_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I147_XP_MN1 (VSS I1528_P18_15n I1528_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I83_XP_MN0 (I1528_P17_16 I1528_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I83_XP_MN1 (VSS I1528_pn16 I1528_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I91_XP_MN0 (I1160_P25_24 I1160_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I91_XP_MN1 (VSS I1160_pn24 I1160_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I88_XP_MN0 (I1160_P22_21 I1160_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I88_XP_MN1 (VSS I1160_pn21 I1160_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I86_XP_MN0 (I1160_P20_19 I1160_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I86_XP_MN1 (VSS I1160_pn19 I1160_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I145_XP_MN0 (I1160_P20_13 I1160_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I145_XP_MN1 (VSS I1160_P16_13n I1160_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I82_XP_MN0 (I1160_P16_15 I1160_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I82_XP_MN1 (VSS I1160_pn15 I1160_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I141_XP_MN0 (I1160_P16_9 I1160_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I141_XP_MN1 (VSS I1160_P12_9n I1160_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I137_XP_MN0 (I1160_P12_5 I1160_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I137_XP_MN1 (VSS I1160_P8_5n I1160_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I133_XP_MN0 (I1160_P8_1 I1160_P8_5n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I133_XP_MN1 (VSS I1160_P4_1n I1160_P8_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I75_XP_MN0 (I1206_P9_8 I1206_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I75_XP_MN1 (VSS I1206_pn8 I1206_P9_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I76_XP_MN0 (I1206_P10_9 I1206_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I76_XP_MN1 (VSS I1206_pn9 I1206_P10_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I80_XP_MN0 (I1252_P14_13 I1252_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I80_XP_MN1 (VSS I1252_pn13 I1252_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I139_XP_MN0 (I1252_P14_7 I1252_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I139_XP_MN1 (VSS I1252_P10_7n I1252_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I142_XP_MN0 (I1252_P17_10 I1252_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I142_XP_MN1 (VSS I1252_P13_10n I1252_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I143_XP_MN0 (I1298_P18_11 I1298_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I143_XP_MN1 (VSS I1298_P14_11n I1298_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I139_XP_MN0 (I1298_P14_7 I1298_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I139_XP_MN1 (VSS I1298_P10_7n I1298_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I81_XP_MN0 (I1298_P15_14 I1298_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I81_XP_MN1 (VSS I1298_pn14 I1298_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I140_XP_MN0 (I1298_P15_8 I1298_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I140_XP_MN1 (VSS I1298_P11_8n I1298_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I143_XP_MN0 (I1344_P18_11 I1344_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I143_XP_MN1 (VSS I1344_P14_11n I1344_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I145_XP_MN0 (I1344_P20_13 I1344_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I145_XP_MN1 (VSS I1344_P16_13n I1344_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I149_XP_MN0 (I1344_P24_17 I1344_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I149_XP_MN1 (VSS I1344_P20_17n I1344_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I82_XP_MN0 (I1344_P16_15 I1344_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I82_XP_MN1 (VSS I1344_pn15 I1344_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I81_XP_MN0 (I1344_P15_14 I1344_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I81_XP_MN1 (VSS I1344_pn14 I1344_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I140_XP_MN0 (I1344_P15_8 I1344_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I140_XP_MN1 (VSS I1344_P11_8n I1344_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I82_XP_MN0 (I1390_P16_15 I1390_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I82_XP_MN1 (VSS I1390_pn15 I1390_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I145_XP_MN0 (I1390_P20_13 I1390_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I145_XP_MN1 (VSS I1390_P16_13n I1390_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I149_XP_MN0 (I1390_P24_17 I1390_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I149_XP_MN1 (VSS I1390_P20_17n I1390_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I81_XP_MN0 (I1390_P15_14 I1390_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I81_XP_MN1 (VSS I1390_pn14 I1390_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I140_XP_MN0 (I1390_P15_8 I1390_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I140_XP_MN1 (VSS I1390_P11_8n I1390_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I143_XP_MN0 (I1436_P18_11 I1436_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I143_XP_MN1 (VSS I1436_P14_11n I1436_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I81_XP_MN0 (I1436_P15_14 I1436_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I81_XP_MN1 (VSS I1436_pn14 I1436_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I142_XP_MN0 (I1436_P17_10 I1436_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I142_XP_MN1 (VSS I1436_P13_10n I1436_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I81_XP_MN0 (I1482_P15_14 I1482_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I81_XP_MN1 (VSS I1482_pn14 I1482_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I142_XP_MN0 (I1482_P17_10 I1482_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I142_XP_MN1 (VSS I1482_P13_10n I1482_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I138_XP_MN0 (I1482_P13_6 I1482_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I138_XP_MN1 (VSS I1482_P9_6n I1482_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I86_XP_MN0 (I1528_P20_19 I1528_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I86_XP_MN1 (VSS I1528_pn19 I1528_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I88_XP_MN0 (I1528_P22_21 I1528_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I88_XP_MN1 (VSS I1528_pn21 I1528_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I85_XP_MN0 (I1528_P19_18 I1528_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I85_XP_MN1 (VSS I1528_pn18 I1528_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I153_XP_MN0 (I1528_P28_21 I1528_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I153_XP_MN1 (VSS I1528_P24_21n I1528_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I151_XP_MN0 (I1528_P26_19 I1528_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I151_XP_MN1 (VSS I1528_P22_19n I1528_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I87_XP_MN0 (I1528_P21_20 I1528_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I87_XP_MN1 (VSS I1528_pn20 I1528_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I148_XP_MN0 (I1528_P23_16 I1528_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I148_XP_MN1 (VSS I1528_P19_16n I1528_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I150_XP_MN0 (I1528_P25_18 I1528_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I150_XP_MN1 (VSS I1528_P21_18n I1528_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I96_XP_MN0 (I1160_P30_29 I1160_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I96_XP_MN1 (VSS I1160_pn29 I1160_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I90_XP_MN0 (I1160_P24_23 I1160_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I90_XP_MN1 (VSS I1160_pn23 I1160_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I153_XP_MN0 (I1160_P28_21 I1160_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I153_XP_MN1 (VSS I1160_P24_21n I1160_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I149_XP_MN0 (I1160_P24_17 I1160_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I149_XP_MN1 (VSS I1160_P20_17n I1160_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I77_XP_MN0 (I1206_P11_10 I1206_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I77_XP_MN1 (VSS I1206_pn10 I1206_P11_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I78_XP_MN0 (I1206_P12_11 I1206_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I78_XP_MN1 (VSS I1206_pn11 I1206_P12_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I135_XP_MN0 (I1206_P10_3 I1206_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I135_XP_MN1 (VSS I1206_P6_3n I1206_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I143_XP_MN0 (I1252_P18_11 I1252_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I143_XP_MN1 (VSS I1252_P14_11n I1252_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I145_XP_MN0 (I1252_P20_13 I1252_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I145_XP_MN1 (VSS I1252_P16_13n I1252_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I81_XP_MN0 (I1252_P15_14 I1252_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I81_XP_MN1 (VSS I1252_pn14 I1252_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I140_XP_MN0 (I1252_P15_8 I1252_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I140_XP_MN1 (VSS I1252_P11_8n I1252_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I82_XP_MN0 (I1298_P16_15 I1298_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I82_XP_MN1 (VSS I1298_pn15 I1298_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I145_XP_MN0 (I1298_P20_13 I1298_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I145_XP_MN1 (VSS I1298_P16_13n I1298_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I149_XP_MN0 (I1298_P24_17 I1298_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I149_XP_MN1 (VSS I1298_P20_17n I1298_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I83_XP_MN0 (I1298_P17_16 I1298_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I83_XP_MN1 (VSS I1298_pn16 I1298_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I144_XP_MN0 (I1298_P19_12 I1298_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I144_XP_MN1 (VSS I1298_P15_12n I1298_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I83_XP_MN0 (I1344_P17_16 I1344_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I83_XP_MN1 (VSS I1344_pn16 I1344_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I144_XP_MN0 (I1344_P19_12 I1344_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I144_XP_MN1 (VSS I1344_P15_12n I1344_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I84_XP_MN0 (I1390_P18_17 I1390_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I84_XP_MN1 (VSS I1390_pn17 I1390_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I83_XP_MN0 (I1390_P17_16 I1390_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I83_XP_MN1 (VSS I1390_pn16 I1390_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I144_XP_MN0 (I1390_P19_12 I1390_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I144_XP_MN1 (VSS I1390_P15_12n I1390_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I82_XP_MN0 (I1436_P16_15 I1436_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I82_XP_MN1 (VSS I1436_pn15 I1436_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I145_XP_MN0 (I1436_P20_13 I1436_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I145_XP_MN1 (VSS I1436_P16_13n I1436_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I144_XP_MN0 (I1436_P19_12 I1436_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I144_XP_MN1 (VSS I1436_P15_12n I1436_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I140_XP_MN0 (I1436_P15_8 I1436_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I140_XP_MN1 (VSS I1436_P11_8n I1436_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I83_XP_MN0 (I1482_P17_16 I1482_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I83_XP_MN1 (VSS I1482_pn16 I1482_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I82_XP_MN0 (I1482_P16_15 I1482_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I82_XP_MN1 (VSS I1482_pn15 I1482_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I84_XP_MN0 (I1482_P18_17 I1482_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I84_XP_MN1 (VSS I1482_pn17 I1482_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I145_XP_MN0 (I1482_P20_13 I1482_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I145_XP_MN1 (VSS I1482_P16_13n I1482_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I143_XP_MN0 (I1482_P18_11 I1482_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I143_XP_MN1 (VSS I1482_P14_11n I1482_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I89_XP_MN0 (I1528_P23_22 I1528_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I89_XP_MN1 (VSS I1528_pn22 I1528_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I152_XP_MN0 (I1528_P27_20 I1528_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I152_XP_MN1 (VSS I1528_P23_20n I1528_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I154_XP_MN0 (I1528_P29_22 I1528_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I154_XP_MN1 (VSS I1528_P25_22n I1528_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I95_XP_MN0 (I1160_P29_28 I1160_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I95_XP_MN1 (VSS I1160_pn28 I1160_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I151_XP_MN0 (I1160_P26_19 I1160_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I151_XP_MN1 (VSS I1160_P22_19n I1160_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I147_XP_MN0 (I1160_P22_15 I1160_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I147_XP_MN1 (VSS I1160_P18_15n I1160_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I143_XP_MN0 (I1160_P18_11 I1160_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I143_XP_MN1 (VSS I1160_P14_11n I1160_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I139_XP_MN0 (I1160_P14_7 I1160_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I139_XP_MN1 (VSS I1160_P10_7n I1160_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I135_XP_MN0 (I1160_P10_3 I1160_P10_7n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I135_XP_MN1 (VSS I1160_P6_3n I1160_P10_3 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I81_XP_MN0 (I1206_P15_14 I1206_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I81_XP_MN1 (VSS I1206_pn14 I1206_P15_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I79_XP_MN0 (I1206_P13_12 I1206_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I79_XP_MN1 (VSS I1206_pn12 I1206_P13_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I80_XP_MN0 (I1206_P14_13 I1206_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I80_XP_MN1 (VSS I1206_pn13 I1206_P14_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I134_XP_MN0 (I1206_P9_2 I1206_P9_6n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I134_XP_MN1 (VSS I1206_P5_2n I1206_P9_2 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I137_XP_MN0 (I1206_P12_5 I1206_P12_9n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I137_XP_MN1 (VSS I1206_P8_5n I1206_P12_5 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I141_XP_MN0 (I1206_P16_9 I1206_P16_13n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I141_XP_MN1 (VSS I1206_P12_9n I1206_P16_9 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I84_XP_MN0 (I1252_P18_17 I1252_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I84_XP_MN1 (VSS I1252_pn17 I1252_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I82_XP_MN0 (I1252_P16_15 I1252_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I82_XP_MN1 (VSS I1252_pn15 I1252_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I149_XP_MN0 (I1252_P24_17 I1252_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I149_XP_MN1 (VSS I1252_P20_17n I1252_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I83_XP_MN0 (I1252_P17_16 I1252_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I83_XP_MN1 (VSS I1252_pn16 I1252_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I144_XP_MN0 (I1252_P19_12 I1252_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I144_XP_MN1 (VSS I1252_P15_12n I1252_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I84_XP_MN0 (I1298_P18_17 I1298_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I84_XP_MN1 (VSS I1298_pn17 I1298_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I151_XP_MN0 (I1298_P26_19 I1298_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I151_XP_MN1 (VSS I1298_P22_19n I1298_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I147_XP_MN0 (I1298_P22_15 I1298_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I147_XP_MN1 (VSS I1298_P18_15n I1298_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I85_XP_MN0 (I1298_P19_18 I1298_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I85_XP_MN1 (VSS I1298_pn18 I1298_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I146_XP_MN0 (I1298_P21_14 I1298_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I146_XP_MN1 (VSS I1298_P17_14n I1298_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I147_XP_MN0 (I1344_P22_15 I1344_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I147_XP_MN1 (VSS I1344_P18_15n I1344_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I84_XP_MN0 (I1344_P18_17 I1344_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I84_XP_MN1 (VSS I1344_pn17 I1344_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I85_XP_MN0 (I1344_P19_18 I1344_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I85_XP_MN1 (VSS I1344_pn18 I1344_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I146_XP_MN0 (I1344_P21_14 I1344_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I146_XP_MN1 (VSS I1344_P17_14n I1344_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I147_XP_MN0 (I1390_P22_15 I1390_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I147_XP_MN1 (VSS I1390_P18_15n I1390_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I151_XP_MN0 (I1390_P26_19 I1390_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I151_XP_MN1 (VSS I1390_P22_19n I1390_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I85_XP_MN0 (I1390_P19_18 I1390_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I85_XP_MN1 (VSS I1390_pn18 I1390_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I150_XP_MN0 (I1390_P25_18 I1390_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I150_XP_MN1 (VSS I1390_P21_18n I1390_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I146_XP_MN0 (I1390_P21_14 I1390_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I146_XP_MN1 (VSS I1390_P17_14n I1390_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I84_XP_MN0 (I1436_P18_17 I1436_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I84_XP_MN1 (VSS I1436_pn17 I1436_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I149_XP_MN0 (I1436_P24_17 I1436_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I149_XP_MN1 (VSS I1436_P20_17n I1436_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I85_XP_MN0 (I1436_P19_18 I1436_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I85_XP_MN1 (VSS I1436_pn18 I1436_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I83_XP_MN0 (I1436_P17_16 I1436_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I83_XP_MN1 (VSS I1436_pn16 I1436_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I146_XP_MN0 (I1436_P21_14 I1436_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I146_XP_MN1 (VSS I1436_P17_14n I1436_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I85_XP_MN0 (I1482_P19_18 I1482_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I85_XP_MN1 (VSS I1482_pn18 I1482_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I144_XP_MN0 (I1482_P19_12 I1482_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I144_XP_MN1 (VSS I1482_P15_12n I1482_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I140_XP_MN0 (I1482_P15_8 I1482_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I140_XP_MN1 (VSS I1482_P11_8n I1482_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I149_XP_MN0 (I1482_P24_17 I1482_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I149_XP_MN1 (VSS I1482_P20_17n I1482_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I90_XP_MN0 (I1528_P24_23 I1528_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I90_XP_MN1 (VSS I1528_pn23 I1528_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I155_XP_MN0 (I1528_P30_23 I1528_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I155_XP_MN1 (VSS I1528_P26_23n I1528_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I91_XP_MN0 (I1528_P25_24 I1528_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I91_XP_MN1 (VSS I1528_pn24 I1528_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I93_XP_MN0 (I1160_P27_26 I1160_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I93_XP_MN1 (VSS I1160_pn26 I1160_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I94_XP_MN0 (I1160_P28_27 I1160_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I94_XP_MN1 (VSS I1160_pn27 I1160_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I155_XP_MN0 (I1160_P30_23 I1160_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I155_XP_MN1 (VSS I1160_P26_23n I1160_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1160_I92_XP_MN0 (I1160_P26_25 I1160_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1160_I92_XP_MN1 (VSS I1160_pn25 I1160_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I82_XP_MN0 (I1206_P16_15 I1206_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I82_XP_MN1 (VSS I1206_pn15 I1206_P16_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I138_XP_MN0 (I1206_P13_6 I1206_P13_10n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I138_XP_MN1 (VSS I1206_P9_6n I1206_P13_6 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I136_XP_MN0 (I1206_P11_4 I1206_P11_8n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I136_XP_MN1 (VSS I1206_P7_4n I1206_P11_4 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I86_XP_MN0 (I1252_P20_19 I1252_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I86_XP_MN1 (VSS I1252_pn19 I1252_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I151_XP_MN0 (I1252_P26_19 I1252_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I151_XP_MN1 (VSS I1252_P22_19n I1252_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I147_XP_MN0 (I1252_P22_15 I1252_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I147_XP_MN1 (VSS I1252_P18_15n I1252_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I85_XP_MN0 (I1252_P19_18 I1252_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I85_XP_MN1 (VSS I1252_pn18 I1252_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I150_XP_MN0 (I1252_P25_18 I1252_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I150_XP_MN1 (VSS I1252_P21_18n I1252_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I146_XP_MN0 (I1252_P21_14 I1252_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I146_XP_MN1 (VSS I1252_P17_14n I1252_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I86_XP_MN0 (I1298_P20_19 I1298_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I86_XP_MN1 (VSS I1298_pn19 I1298_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I150_XP_MN0 (I1298_P25_18 I1298_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I150_XP_MN1 (VSS I1298_P21_18n I1298_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I151_XP_MN0 (I1344_P26_19 I1344_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I151_XP_MN1 (VSS I1344_P22_19n I1344_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I86_XP_MN0 (I1344_P20_19 I1344_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I86_XP_MN1 (VSS I1344_pn19 I1344_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I87_XP_MN0 (I1344_P21_20 I1344_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I87_XP_MN1 (VSS I1344_pn20 I1344_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I150_XP_MN0 (I1344_P25_18 I1344_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I150_XP_MN1 (VSS I1344_P21_18n I1344_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I86_XP_MN0 (I1390_P20_19 I1390_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I86_XP_MN1 (VSS I1390_pn19 I1390_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I87_XP_MN0 (I1390_P21_20 I1390_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I87_XP_MN1 (VSS I1390_pn20 I1390_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I86_XP_MN0 (I1436_P20_19 I1436_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I86_XP_MN1 (VSS I1436_pn19 I1436_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I147_XP_MN0 (I1436_P22_15 I1436_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I147_XP_MN1 (VSS I1436_P18_15n I1436_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I151_XP_MN0 (I1436_P26_19 I1436_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I151_XP_MN1 (VSS I1436_P22_19n I1436_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I87_XP_MN0 (I1436_P21_20 I1436_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I87_XP_MN1 (VSS I1436_pn20 I1436_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I87_XP_MN0 (I1482_P21_20 I1482_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I87_XP_MN1 (VSS I1482_pn20 I1482_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I146_XP_MN0 (I1482_P21_14 I1482_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I146_XP_MN1 (VSS I1482_P17_14n I1482_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I86_XP_MN0 (I1482_P20_19 I1482_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I86_XP_MN1 (VSS I1482_pn19 I1482_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I147_XP_MN0 (I1482_P22_15 I1482_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I147_XP_MN1 (VSS I1482_P18_15n I1482_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I151_XP_MN0 (I1482_P26_19 I1482_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I151_XP_MN1 (VSS I1482_P22_19n I1482_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I92_XP_MN0 (I1528_P26_25 I1528_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I92_XP_MN1 (VSS I1528_pn25 I1528_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I93_XP_MN0 (I1528_P27_26 I1528_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I93_XP_MN1 (VSS I1528_pn26 I1528_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I156_XP_MN0 (I1528_P31_24 I1528_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I156_XP_MN1 (VSS I1528_P27_24n I1528_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I83_XP_MN0 (I1206_P17_16 I1206_pn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I83_XP_MN1 (VSS I1206_pn16 I1206_P17_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I142_XP_MN0 (I1206_P17_10 I1206_P17_14n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I142_XP_MN1 (VSS I1206_P13_10n I1206_P17_10 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I84_XP_MN0 (I1206_P18_17 I1206_pn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I84_XP_MN1 (VSS I1206_pn17 I1206_P18_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I143_XP_MN0 (I1206_P18_11 I1206_P18_15n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I143_XP_MN1 (VSS I1206_P14_11n I1206_P18_11 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I139_XP_MN0 (I1206_P14_7 I1206_P14_11n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I139_XP_MN1 (VSS I1206_P10_7n I1206_P14_7 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I88_XP_MN0 (I1252_P22_21 I1252_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I88_XP_MN1 (VSS I1252_pn21 I1252_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I87_XP_MN0 (I1252_P21_20 I1252_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I87_XP_MN1 (VSS I1252_pn20 I1252_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I88_XP_MN0 (I1298_P22_21 I1298_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I88_XP_MN1 (VSS I1298_pn21 I1298_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I153_XP_MN0 (I1298_P28_21 I1298_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I153_XP_MN1 (VSS I1298_P24_21n I1298_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I87_XP_MN0 (I1298_P21_20 I1298_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I87_XP_MN1 (VSS I1298_pn20 I1298_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I148_XP_MN0 (I1298_P23_16 I1298_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I148_XP_MN1 (VSS I1298_P19_16n I1298_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I153_XP_MN0 (I1344_P28_21 I1344_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I153_XP_MN1 (VSS I1344_P24_21n I1344_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I88_XP_MN0 (I1344_P22_21 I1344_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I88_XP_MN1 (VSS I1344_pn21 I1344_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I152_XP_MN0 (I1344_P27_20 I1344_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I152_XP_MN1 (VSS I1344_P23_20n I1344_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I148_XP_MN0 (I1344_P23_16 I1344_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I148_XP_MN1 (VSS I1344_P19_16n I1344_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I88_XP_MN0 (I1390_P22_21 I1390_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I88_XP_MN1 (VSS I1390_pn21 I1390_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I153_XP_MN0 (I1390_P28_21 I1390_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I153_XP_MN1 (VSS I1390_P24_21n I1390_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I152_XP_MN0 (I1390_P27_20 I1390_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I152_XP_MN1 (VSS I1390_P23_20n I1390_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I148_XP_MN0 (I1390_P23_16 I1390_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I148_XP_MN1 (VSS I1390_P19_16n I1390_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I88_XP_MN0 (I1436_P22_21 I1436_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I88_XP_MN1 (VSS I1436_pn21 I1436_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I153_XP_MN0 (I1436_P28_21 I1436_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I153_XP_MN1 (VSS I1436_P24_21n I1436_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I150_XP_MN0 (I1436_P25_18 I1436_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I150_XP_MN1 (VSS I1436_P21_18n I1436_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I148_XP_MN0 (I1436_P23_16 I1436_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I148_XP_MN1 (VSS I1436_P19_16n I1436_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I150_XP_MN0 (I1482_P25_18 I1482_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I150_XP_MN1 (VSS I1482_P21_18n I1482_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I88_XP_MN0 (I1482_P22_21 I1482_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I88_XP_MN1 (VSS I1482_pn21 I1482_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I155_XP_MN0 (I1482_P30_23 I1482_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I155_XP_MN1 (VSS I1482_P26_23n I1482_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I96_XP_MN0 (I1528_P30_29 I1528_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I96_XP_MN1 (VSS I1528_pn29 I1528_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I97_XP_MN0 (I1528_P31_30 I1528_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I97_XP_MN1 (VSS I1528_pn30 I1528_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I94_XP_MN0 (I1528_P28_27 I1528_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I94_XP_MN1 (VSS I1528_pn27 I1528_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1528_I95_XP_MN0 (I1528_P29_28 I1528_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1528_I95_XP_MN1 (VSS I1528_pn28 I1528_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I87_XP_MN0 (I1206_P21_20 I1206_pn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I87_XP_MN1 (VSS I1206_pn20 I1206_P21_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I85_XP_MN0 (I1206_P19_18 I1206_pn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I85_XP_MN1 (VSS I1206_pn18 I1206_P19_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I144_XP_MN0 (I1206_P19_12 I1206_P19_16n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I144_XP_MN1 (VSS I1206_P15_12n I1206_P19_12 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I146_XP_MN0 (I1206_P21_14 I1206_P21_18n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I146_XP_MN1 (VSS I1206_P17_14n I1206_P21_14 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I140_XP_MN0 (I1206_P15_8 I1206_P15_12n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I140_XP_MN1 (VSS I1206_P11_8n I1206_P15_8 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I86_XP_MN0 (I1206_P20_19 I1206_pn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I86_XP_MN1 (VSS I1206_pn19 I1206_P20_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I149_XP_MN0 (I1206_P24_17 I1206_P24_21n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I149_XP_MN1 (VSS I1206_P20_17n I1206_P24_17 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I145_XP_MN0 (I1206_P20_13 I1206_P20_17n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I145_XP_MN1 (VSS I1206_P16_13n I1206_P20_13 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I153_XP_MN0 (I1252_P28_21 I1252_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I153_XP_MN1 (VSS I1252_P24_21n I1252_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I89_XP_MN0 (I1252_P23_22 I1252_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I89_XP_MN1 (VSS I1252_pn22 I1252_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I152_XP_MN0 (I1252_P27_20 I1252_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I152_XP_MN1 (VSS I1252_P23_20n I1252_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I148_XP_MN0 (I1252_P23_16 I1252_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I148_XP_MN1 (VSS I1252_P19_16n I1252_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I90_XP_MN0 (I1298_P24_23 I1298_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I90_XP_MN1 (VSS I1298_pn23 I1298_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I155_XP_MN0 (I1298_P30_23 I1298_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I155_XP_MN1 (VSS I1298_P26_23n I1298_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I89_XP_MN0 (I1298_P23_22 I1298_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I89_XP_MN1 (VSS I1298_pn22 I1298_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I152_XP_MN0 (I1298_P27_20 I1298_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I152_XP_MN1 (VSS I1298_P23_20n I1298_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I155_XP_MN0 (I1344_P30_23 I1344_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I155_XP_MN1 (VSS I1344_P26_23n I1344_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I90_XP_MN0 (I1344_P24_23 I1344_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I90_XP_MN1 (VSS I1344_pn23 I1344_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I89_XP_MN0 (I1344_P23_22 I1344_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I89_XP_MN1 (VSS I1344_pn22 I1344_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I154_XP_MN0 (I1344_P29_22 I1344_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I154_XP_MN1 (VSS I1344_P25_22n I1344_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I155_XP_MN0 (I1390_P30_23 I1390_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I155_XP_MN1 (VSS I1390_P26_23n I1390_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I90_XP_MN0 (I1390_P24_23 I1390_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I90_XP_MN1 (VSS I1390_pn23 I1390_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I89_XP_MN0 (I1390_P23_22 I1390_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I89_XP_MN1 (VSS I1390_pn22 I1390_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I154_XP_MN0 (I1390_P29_22 I1390_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I154_XP_MN1 (VSS I1390_P25_22n I1390_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I90_XP_MN0 (I1436_P24_23 I1436_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I90_XP_MN1 (VSS I1436_pn23 I1436_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I89_XP_MN0 (I1436_P23_22 I1436_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I89_XP_MN1 (VSS I1436_pn22 I1436_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I89_XP_MN0 (I1482_P23_22 I1482_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I89_XP_MN1 (VSS I1482_pn22 I1482_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I90_XP_MN0 (I1482_P24_23 I1482_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I90_XP_MN1 (VSS I1482_pn23 I1482_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I153_XP_MN0 (I1482_P28_21 I1482_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I153_XP_MN1 (VSS I1482_P24_21n I1482_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I89_XP_MN0 (I1206_P23_22 I1206_pn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I89_XP_MN1 (VSS I1206_pn22 I1206_P23_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I148_XP_MN0 (I1206_P23_16 I1206_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I148_XP_MN1 (VSS I1206_P19_16n I1206_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I150_XP_MN0 (I1206_P25_18 I1206_P25_22n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I150_XP_MN1 (VSS I1206_P21_18n I1206_P25_18 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I88_XP_MN0 (I1206_P22_21 I1206_pn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I88_XP_MN1 (VSS I1206_pn21 I1206_P22_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I147_XP_MN0 (I1206_P22_15 I1206_P22_19n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I147_XP_MN1 (VSS I1206_P18_15n I1206_P22_15 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I90_XP_MN0 (I1252_P24_23 I1252_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I90_XP_MN1 (VSS I1252_pn23 I1252_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I155_XP_MN0 (I1252_P30_23 I1252_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I155_XP_MN1 (VSS I1252_P26_23n I1252_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I91_XP_MN0 (I1252_P25_24 I1252_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I91_XP_MN1 (VSS I1252_pn24 I1252_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I154_XP_MN0 (I1252_P29_22 I1252_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I154_XP_MN1 (VSS I1252_P25_22n I1252_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I92_XP_MN0 (I1298_P26_25 I1298_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I92_XP_MN1 (VSS I1298_pn25 I1298_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I91_XP_MN0 (I1298_P25_24 I1298_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I91_XP_MN1 (VSS I1298_pn24 I1298_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I154_XP_MN0 (I1298_P29_22 I1298_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I154_XP_MN1 (VSS I1298_P25_22n I1298_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I92_XP_MN0 (I1344_P26_25 I1344_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I92_XP_MN1 (VSS I1344_pn25 I1344_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I91_XP_MN0 (I1344_P25_24 I1344_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I91_XP_MN1 (VSS I1344_pn24 I1344_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I156_XP_MN0 (I1344_P31_24 I1344_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I156_XP_MN1 (VSS I1344_P27_24n I1344_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I92_XP_MN0 (I1390_P26_25 I1390_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I92_XP_MN1 (VSS I1390_pn25 I1390_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I91_XP_MN0 (I1390_P25_24 I1390_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I91_XP_MN1 (VSS I1390_pn24 I1390_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I156_XP_MN0 (I1390_P31_24 I1390_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I156_XP_MN1 (VSS I1390_P27_24n I1390_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I92_XP_MN0 (I1436_P26_25 I1436_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I92_XP_MN1 (VSS I1436_pn25 I1436_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I155_XP_MN0 (I1436_P30_23 I1436_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I155_XP_MN1 (VSS I1436_P26_23n I1436_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I91_XP_MN0 (I1436_P25_24 I1436_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I91_XP_MN1 (VSS I1436_pn24 I1436_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I154_XP_MN0 (I1436_P29_22 I1436_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I154_XP_MN1 (VSS I1436_P25_22n I1436_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I152_XP_MN0 (I1436_P27_20 I1436_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I152_XP_MN1 (VSS I1436_P23_20n I1436_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I148_XP_MN0 (I1482_P23_16 I1482_P23_20n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I148_XP_MN1 (VSS I1482_P19_16n I1482_P23_16 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I152_XP_MN0 (I1482_P27_20 I1482_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I152_XP_MN1 (VSS I1482_P23_20n I1482_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I154_XP_MN0 (I1482_P29_22 I1482_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I154_XP_MN1 (VSS I1482_P25_22n I1482_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I91_XP_MN0 (I1482_P25_24 I1482_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I91_XP_MN1 (VSS I1482_pn24 I1482_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I92_XP_MN0 (I1482_P26_25 I1482_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I92_XP_MN1 (VSS I1482_pn25 I1482_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I94_XP_MN0 (I1482_P28_27 I1482_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I94_XP_MN1 (VSS I1482_pn27 I1482_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I93_XP_MN0 (I1206_P27_26 I1206_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I93_XP_MN1 (VSS I1206_pn26 I1206_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I156_XP_MN0 (I1206_P31_24 I1206_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I156_XP_MN1 (VSS I1206_P27_24n I1206_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I91_XP_MN0 (I1206_P25_24 I1206_pn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I91_XP_MN1 (VSS I1206_pn24 I1206_P25_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I152_XP_MN0 (I1206_P27_20 I1206_P27_24n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I152_XP_MN1 (VSS I1206_P23_20n I1206_P27_20 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I90_XP_MN0 (I1206_P24_23 I1206_pn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I90_XP_MN1 (VSS I1206_pn23 I1206_P24_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I92_XP_MN0 (I1206_P26_25 I1206_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I92_XP_MN1 (VSS I1206_pn25 I1206_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I151_XP_MN0 (I1206_P26_19 I1206_P26_23n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I151_XP_MN1 (VSS I1206_P22_19n I1206_P26_19 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I92_XP_MN0 (I1252_P26_25 I1252_pn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I92_XP_MN1 (VSS I1252_pn25 I1252_P26_25 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I93_XP_MN0 (I1252_P27_26 I1252_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I93_XP_MN1 (VSS I1252_pn26 I1252_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I156_XP_MN0 (I1252_P31_24 I1252_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I156_XP_MN1 (VSS I1252_P27_24n I1252_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I94_XP_MN0 (I1298_P28_27 I1298_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I94_XP_MN1 (VSS I1298_pn27 I1298_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I93_XP_MN0 (I1298_P27_26 I1298_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I93_XP_MN1 (VSS I1298_pn26 I1298_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I156_XP_MN0 (I1298_P31_24 I1298_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I156_XP_MN1 (VSS I1298_P27_24n I1298_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I93_XP_MN0 (I1344_P27_26 I1344_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I93_XP_MN1 (VSS I1344_pn26 I1344_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I94_XP_MN0 (I1390_P28_27 I1390_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I94_XP_MN1 (VSS I1390_pn27 I1390_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I93_XP_MN0 (I1390_P27_26 I1390_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I93_XP_MN1 (VSS I1390_pn26 I1390_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I94_XP_MN0 (I1436_P28_27 I1436_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I94_XP_MN1 (VSS I1436_pn27 I1436_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I93_XP_MN0 (I1436_P27_26 I1436_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I93_XP_MN1 (VSS I1436_pn26 I1436_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I156_XP_MN0 (I1436_P31_24 I1436_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I156_XP_MN1 (VSS I1436_P27_24n I1436_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I156_XP_MN0 (I1482_P31_24 I1482_P31_28n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I156_XP_MN1 (VSS I1482_P27_24n I1482_P31_24 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I93_XP_MN0 (I1482_P27_26 I1482_pn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I93_XP_MN1 (VSS I1482_pn26 I1482_P27_26 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I95_XP_MN0 (I1206_P29_28 I1206_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I95_XP_MN1 (VSS I1206_pn28 I1206_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I154_XP_MN0 (I1206_P29_22 I1206_P29_26n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I154_XP_MN1 (VSS I1206_P25_22n I1206_P29_22 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I155_XP_MN0 (I1206_P30_23 I1206_P30_27n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I155_XP_MN1 (VSS I1206_P26_23n I1206_P30_23 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I153_XP_MN0 (I1206_P28_21 I1206_P28_25n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I153_XP_MN1 (VSS I1206_P24_21n I1206_P28_21 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I94_XP_MN0 (I1252_P28_27 I1252_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I94_XP_MN1 (VSS I1252_pn27 I1252_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I96_XP_MN0 (I1252_P30_29 I1252_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I96_XP_MN1 (VSS I1252_pn29 I1252_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I95_XP_MN0 (I1252_P29_28 I1252_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I95_XP_MN1 (VSS I1252_pn28 I1252_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1252_I97_XP_MN0 (I1252_P31_30 I1252_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1252_I97_XP_MN1 (VSS I1252_pn30 I1252_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I95_XP_MN0 (I1298_P29_28 I1298_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I95_XP_MN1 (VSS I1298_pn28 I1298_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I94_XP_MN0 (I1344_P28_27 I1344_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I94_XP_MN1 (VSS I1344_pn27 I1344_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I95_XP_MN0 (I1344_P29_28 I1344_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I95_XP_MN1 (VSS I1344_pn28 I1344_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I96_XP_MN0 (I1344_P30_29 I1344_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I96_XP_MN1 (VSS I1344_pn29 I1344_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1344_I97_XP_MN0 (I1344_P31_30 I1344_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1344_I97_XP_MN1 (VSS I1344_pn30 I1344_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I96_XP_MN0 (I1390_P30_29 I1390_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I96_XP_MN1 (VSS I1390_pn29 I1390_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I95_XP_MN0 (I1390_P29_28 I1390_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I95_XP_MN1 (VSS I1390_pn28 I1390_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1390_I97_XP_MN0 (I1390_P31_30 I1390_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1390_I97_XP_MN1 (VSS I1390_pn30 I1390_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I96_XP_MN0 (I1436_P30_29 I1436_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I96_XP_MN1 (VSS I1436_pn29 I1436_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I95_XP_MN0 (I1436_P29_28 I1436_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I95_XP_MN1 (VSS I1436_pn28 I1436_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1436_I97_XP_MN0 (I1436_P31_30 I1436_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1436_I97_XP_MN1 (VSS I1436_pn30 I1436_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I97_XP_MN0 (I1482_P31_30 I1482_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I97_XP_MN1 (VSS I1482_pn30 I1482_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I95_XP_MN0 (I1482_P29_28 I1482_pn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I95_XP_MN1 (VSS I1482_pn28 I1482_P29_28 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1482_I96_XP_MN0 (I1482_P30_29 I1482_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1482_I96_XP_MN1 (VSS I1482_pn29 I1482_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I97_XP_MN0 (I1206_P31_30 I1206_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I97_XP_MN1 (VSS I1206_pn30 I1206_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I96_XP_MN0 (I1206_P30_29 I1206_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I96_XP_MN1 (VSS I1206_pn29 I1206_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1206_I94_XP_MN0 (I1206_P28_27 I1206_pn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1206_I94_XP_MN1 (VSS I1206_pn27 I1206_P28_27 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I96_XP_MN0 (I1298_P30_29 I1298_pn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I96_XP_MN1 (VSS I1298_pn29 I1298_P30_29 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI1298_I97_XP_MN0 (I1298_P31_30 I1298_pn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04079p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1298_I97_XP_MN1 (VSS I1298_pn30 I1298_P31_30 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.04079p pd=1.16u ps=0.68u
    I_MXI2065_MN0 (dm31 dmn31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI658_MN0 (qu29_b0 qu29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI0_MN0 (A_31_b0 A_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2232_MN0 (nrk21 nrkn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2235_MN0 (nrk22 nrkn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2238_MN0 (nrk23 nrkn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2241_MN0 (nrk24 nrkn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2250_MN0 (nrk27 nrkn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2247_MN0 (nrk26 nrkn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2253_MN0 (nrk28 nrkn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2256_MN0 (nrk29 nrkn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2259_MN0 (nrk30 nrkn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2061_MN0 (dm29 dmn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2059_MN0 (dm28 dmn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2063_MN0 (dm30 dmn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI612_MN0 (qu30_b0 qu30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2229_MN0 (nrk20 nrkn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2244_MN0 (nrk25 nrkn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2057_MN0 (dm27 dmn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1946_MN0 (qu1_b0 qu1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2226_MN0 (nrk19 nrkn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2220_MN0 (nrk17 nrkn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2055_MN0 (dm26 dmn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2053_MN0 (dm25 dmn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1991_MN0 (p31_32_b0 p31_32 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I191_MN0 (I1896_G6_0n I1896_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I193_MN0 (I654_G7_0n I654_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I193_MN0 (I608_G7_0n I608_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI566_MN0 (qu31_b0 qu31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2223_MN0 (nrk18 nrkn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2214_MN0 (nrk15 nrkn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2217_MN0 (nrk16 nrkn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2051_MN0 (dm24 dmn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2049_MN0 (dm23 dmn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI704_MN0 (qu28_b0 qu28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2211_MN0 (nrk14 nrkn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I193_MN0 (I2066_G7_0n I2066_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I191_MN0 (I2066_G6_0n I2066_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2045_MN0 (dm21 dmn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2047_MN0 (dm22 dmn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I191_MN0 (I1942_G6_0n I1942_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I193_MN0 (I1942_G7_0n I1942_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I159_MN0 (I1896_G2_0np I1896_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I187_MN0 (I1896_G4_0n I1896_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I189_MN0 (I654_G5_0n I654_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I191_MN0 (I654_G6_0n I654_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I189_MN0 (I608_G5_0n I608_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I191_MN0 (I608_G6_0n I608_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2205_MN0 (nrk12 nrkn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2208_MN0 (nrk13 nrkn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2041_MN0 (dm19 dmn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2043_MN0 (dm20 dmn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I193_MN0 (I1988_G7_0n I1988_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I189_MN0 (I1942_G5_0n I1942_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I189_MN0 (I1896_G5_0n I1896_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I161_MN0 (I654_G3_0np I654_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I187_MN0 (I654_G4_0n I654_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I191_MN0 (I562_G6_0n I562_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I189_MN0 (I562_G5_0n I562_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I193_MN0 (I562_G7_0n I562_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2202_MN0 (nrk11 nrkn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I189_MN0 (I2066_G5_0n I2066_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2039_MN0 (dm18 dmn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I191_MN0 (I1988_G6_0n I1988_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I187_MN0 (I608_G4_0n I608_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2199_MN0 (nrk10 nrkn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I161_MN0 (I2066_G3_0np I2066_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I187_MN0 (I2066_G4_0n I2066_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2037_MN0 (dm17 dmn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2035_MN0 (dm16 dmn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I187_MN0 (I1942_G4_0n I1942_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I129_MN0 (I1896_G1_0n I1896_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I161_MN0 (I1896_G3_0np I1896_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I193_MN0 (I1896_G7_0n I1896_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1900_MN0 (qu2_b0 qu2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I161_MN0 (I608_G3_0np I608_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I161_MN0 (I562_G3_0np I562_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2196_MN0 (nrk9 nrkn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I159_MN0 (I2066_G2_0np I2066_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2031_MN0 (dm14 dmn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2033_MN0 (dm15 dmn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I187_MN0 (I1988_G4_0n I1988_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I189_MN0 (I1988_G5_0n I1988_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I161_MN0 (I1942_G3_0np I1942_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1854_MN0 (qu3_b0 qu3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I193_MN0 (I700_G7_0n I700_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I129_MN0 (I654_G1_0n I654_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I159_MN0 (I654_G2_0np I654_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I159_MN0 (I608_G2_0np I608_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2193_MN0 (nrk8 nrkn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2029_MN0 (dm13 dmn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2027_MN0 (dm12 dmn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I161_MN0 (I1988_G3_0np I1988_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I159_MN0 (I1942_G2_0np I1942_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I193_MN0 (I1850_G7_0n I1850_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I129_MN0 (I608_G1_0n I608_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I187_MN0 (I562_G4_0n I562_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I159_MN0 (I562_G2_0np I562_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I129_MN0 (I562_G1_0n I562_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2187_MN0 (nrk6 nrkn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2190_MN0 (nrk7 nrkn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I129_MN0 (I2066_G1_0n I2066_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2025_MN0 (dm11 dmn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2023_MN0 (dm10 dmn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I159_MN0 (I1988_G2_0np I1988_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I129_MN0 (I1942_G1_0n I1942_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I66_MN0 (I1896_G0_0n I1896_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I161_MN0 (I1850_G3_0np I1850_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I189_MN0 (I700_G5_0n I700_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I161_MN0 (I700_G3_0np I700_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2184_MN0 (nrk5 nrkn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2021_MN0 (dm9 dmn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2019_MN0 (dm8 dmn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I129_MN0 (I1850_G1_0n I1850_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I189_MN0 (I1850_G5_0n I1850_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I66_MN0 (I608_G0_0n I608_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I66_MN0 (I562_G0_0n I562_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2181_MN0 (nrk4 nrkn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2178_MN0 (nrk3 nrkn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2175_MN0 (nrk2 nrkn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI16_MN0 (B_31_b0 B_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I66_MN0 (I2066_G0_0n I2066_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2017_MN0 (dm7 dmn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2015_MN0 (dm6 dmn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I66_MN0 (I1988_G0_0n I1988_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I129_MN0 (I1988_G1_0n I1988_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I129_MN0 (I700_G1_0n I700_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I66_MN0 (I654_G0_0n I654_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI179_MN0 (nbk4 nbkn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI192_MN0 (nbk5 nbkn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI205_MN0 (nbk6 nbkn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI218_MN0 (nbk7 nbkn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI231_MN0 (nbk8 nbkn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2172_MN0 (nrk1 nrkn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2013_MN0 (dm5 dmn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I66_MN0 (I1942_G0_0n I1942_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I66_MN0 (I1850_G0_0n I1850_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I159_MN0 (I1850_G2_0np I1850_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I187_MN0 (I1850_G4_0n I1850_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I191_MN0 (I1850_G6_0n I1850_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I191_MN0 (I700_G6_0n I700_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I64_MN0 (I654_cinn qu30_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2167_MN0 (nqk30 nqkn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2164_MN0 (nqk29 nqkn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2293_MN0 (sqn sq_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I64_MN0 (I608_cinn qu31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI125_MN0 (nak30 nakn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI182_MN0 (dd5_b0 dd5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI166_MN0 (nbk3 nbkn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI195_MN0 (dd6_b0 dd6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI244_MN0 (nbk9 nbkn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI309_MN0 (nbk14 nbkn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI322_MN0 (nbk15 nbkn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI26_MN0 (B_0_b0 B_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2011_MN0 (dm4 dmn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2007_MN0 (dm2 dmn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2009_MN0 (dm3 dmn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2001_MN0 (Q_0 p31_32_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2080_MN0 (nqk1 nqkn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2083_MN0 (nqk2 nqkn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I159_MN0 (I700_G2_0np I700_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI122_MN0 (nak29 nakn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I64_MN0 (I562_cinn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI140_MN0 (nbk1 nbkn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI153_MN0 (nbk2 nbkn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI156_MN0 (dd3_b0 dd3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI257_MN0 (nbk10 nbkn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI270_MN0 (nbk11 nbkn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI296_MN0 (nbk13 nbkn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI299_MN0 (dd14_b0 dd14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI335_MN0 (nbk16 nbkn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI348_MN0 (nbk17 nbkn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI361_MN0 (nbk18 nbkn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI374_MN0 (nbk19 nbkn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI387_MN0 (nbk20 nbkn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I64_MN0 (I2066_cinn VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI400_MN0 (nbk21 nbkn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2003_MN0 (dm0 dmn0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2005_MN0 (dm1 dmn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I64_MN0 (I1942_cinn qu2_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2086_MN0 (nqk3 nqkn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I66_MN0 (I700_G0_0n I700_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I64_MN0 (I700_cinn qu29_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI119_MN0 (nak28 nakn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI116_MN0 (nak27 nakn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI113_MN0 (nak26 nakn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI110_MN0 (nak25 nakn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI107_MN0 (nak24 nakn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI130_MN0 (dd1_b0 dd1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI169_MN0 (dd4_b0 dd4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI143_MN0 (dd2_b0 dd2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI208_MN0 (dd7_b0 dd7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI247_MN0 (dd10_b0 dd10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI260_MN0 (dd11_b0 dd11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI234_MN0 (dd9_b0 dd9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI283_MN0 (nbk12 nbkn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI325_MN0 (dd16_b0 dd16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI413_MN0 (nbk22 nbkn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI377_MN0 (dd20_b0 dd20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI390_MN0 (dd21_b0 dd21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I64_MN0 (I1988_cinn qu1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI38_MN0 (nak1 nakn1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I64_MN0 (I1896_cinn qu3_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I64_MN0 (I1850_cinn qu4_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2089_MN0 (nqk4 nqkn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I187_MN0 (I700_G4_0n I700_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2161_MN0 (nqk28 nqkn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I64_MN0 (I746_cinn qu28_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I64_MN0 (I792_cinn qu27_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I64_MN0 (I838_cinn qu26_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI221_MN0 (dd8_b0 dd8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI273_MN0 (dd12_b0 dd12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI312_MN0 (dd15_b0 dd15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI286_MN0 (dd13_b0 dd13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2068_MN0 (sq_b0 sq VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI517_MN0 (nbk30 nbkn30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI338_MN0 (dd17_b0 dd17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI504_MN0 (nbk29 nbkn29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI351_MN0 (dd18_b0 dd18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI364_MN0 (dd19_b0 dd19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI426_MN0 (nbk23 nbkn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI41_MN0 (nak2 nakn2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI44_MN0 (nak3 nakn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI47_MN0 (nak4 nakn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI50_MN0 (nak5 nakn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I64_MN0 (I1804_cinn qu5_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2158_MN0 (nqk27 nqkn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I66_MN0 (I792_G0_0n I792_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI494_MN0 (dd29_b0 dd29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI491_MN0 (nbk28 nbkn28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI439_MN0 (nbk24 nbkn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI416_MN0 (dd23_b0 dd23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI403_MN0 (dd22_b0 dd22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2092_MN0 (nqk5 nqkn5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI750_MN0 (qu27_b0 qu27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI520_MN0 (dd31_b0 dd31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI507_MN0 (dd30_b0 dd30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI481_MN0 (dd28_b0 dd28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI478_MN0 (nbk27 nbkn27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI465_MN0 (nbk26 nbkn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI452_MN0 (nbk25 nbkn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I66_MN0 (I1712_G0_0n I1712_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I64_MN0 (I1712_cinn qu7_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I64_MN0 (I1758_cinn qu6_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I66_MN0 (I1804_G0_0n I1804_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I66_MN0 (I746_G0_0n I746_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I66_MN0 (I838_G0_0n I838_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I64_MN0 (I884_cinn qu25_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I66_MN0 (I884_G0_0n I884_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI468_MN0 (dd27_b0 dd27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI455_MN0 (dd26_b0 dd26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI442_MN0 (dd25_b0 dd25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I66_MN0 (I1758_G0_0n I1758_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI53_MN0 (nak6 nakn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2095_MN0 (nqk6 nqkn6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I159_MN0 (I1804_G2_0np I1804_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I193_MN0 (I746_G7_0n I746_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I161_MN0 (I746_G3_0np I746_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I129_MN0 (I746_G1_0n I746_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I129_MN0 (I792_G1_0n I792_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I129_MN0 (I838_G1_0n I838_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I129_MN0 (I884_G1_0n I884_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI429_MN0 (dd24_b0 dd24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I129_MN0 (I1804_G1_0n I1804_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I187_MN0 (I1804_G4_0n I1804_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I159_MN0 (I838_G2_0np I838_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I187_MN0 (I1712_G4_0n I1712_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I129_MN0 (I1758_G1_0n I1758_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I189_MN0 (I746_G5_0n I746_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I159_MN0 (I792_G2_0np I792_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I187_MN0 (I838_G4_0n I838_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I159_MN0 (I884_G2_0np I884_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I159_MN0 (I1712_G2_0np I1712_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I129_MN0 (I1712_G1_0n I1712_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I159_MN0 (I1758_G2_0np I1758_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I161_MN0 (I1804_G3_0np I1804_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I191_MN0 (I1804_G6_0n I1804_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I187_MN0 (I746_G4_0n I746_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I159_MN0 (I746_G2_0np I746_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I161_MN0 (I792_G3_0np I792_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I187_MN0 (I792_G4_0n I792_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I161_MN0 (I838_G3_0np I838_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I189_MN0 (I838_G5_0n I838_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I191_MN0 (I1712_G6_0n I1712_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I161_MN0 (I1712_G3_0np I1712_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I187_MN0 (I1758_G4_0n I1758_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I161_MN0 (I1758_G3_0np I1758_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I191_MN0 (I884_G6_0n I884_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I187_MN0 (I884_G4_0n I884_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I189_MN0 (I884_G5_0n I884_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I189_MN0 (I1758_G5_0n I1758_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I189_MN0 (I1804_G5_0n I1804_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I191_MN0 (I746_G6_0n I746_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I189_MN0 (I792_G5_0n I792_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I191_MN0 (I792_G6_0n I792_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I191_MN0 (I838_G6_0n I838_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I189_MN0 (I1712_G5_0n I1712_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I193_MN0 (I1804_G7_0n I1804_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I193_MN0 (I838_G7_0n I838_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I161_MN0 (I884_G3_0np I884_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I191_MN0 (I1758_G6_0n I1758_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I193_MN0 (I1758_G7_0n I1758_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI842_MN0 (qu25_b0 qu25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I193_MN0 (I1712_G7_0n I1712_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1808_MN0 (qu4_b0 qu4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I193_MN0 (I792_G7_0n I792_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I189_MN0 (I1068_G5_0n I1068_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2155_MN0 (nqk26 nqkn26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI796_MN0 (qu26_b0 qu26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1762_MN0 (qu5_b0 qu5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I129_MN0 (I1068_G1_0n I1068_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2152_MN0 (nqk25 nqkn25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2149_MN0 (nqk24 nqkn24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI98_MN0 (nak21 nakn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI101_MN0 (nak22 nakn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I193_MN0 (I884_G7_0n I884_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1716_MN0 (qu6_b0 qu6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2098_MN0 (nqk7 nqkn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I193_MN0 (I1068_G7_0n I1068_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I161_MN0 (I1068_G3_0np I1068_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I64_MN0 (I976_cinn qu23_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI104_MN0 (nak23 nakn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I64_MN0 (I1666_cinn qu8_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI56_MN0 (nak7 nakn7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI59_MN0 (nak8 nakn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2101_MN0 (nqk8 nqkn8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2146_MN0 (nqk23 nqkn23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I64_MN0 (I1022_cinn qu22_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I64_MN0 (I930_cinn qu24_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I66_MN0 (I1666_G0_0n I1666_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1670_MN0 (qu7_b0 qu7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I64_MN0 (I1620_cinn qu9_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I66_MN0 (I1574_G0_0n I1574_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I159_MN0 (I1068_G2_0np I1068_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I66_MN0 (I1068_G0_0n I1068_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I66_MN0 (I1022_G0_0n I1022_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI888_MN0 (qu24_b0 qu24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I66_MN0 (I930_G0_0n I930_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I66_MN0 (I1620_G0_0n I1620_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I64_MN0 (I1574_cinn qu10_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2104_MN0 (nqk9 nqkn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I191_MN0 (I1068_G6_0n I1068_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI62_MN0 (nak9 nakn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2107_MN0 (nqk10 nqkn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I187_MN0 (I1574_G4_0n I1574_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I187_MN0 (I1068_G4_0n I1068_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I129_MN0 (I1022_G1_0n I1022_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I66_MN0 (I976_G0_0n I976_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I129_MN0 (I930_G1_0n I930_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I159_MN0 (I1666_G2_0np I1666_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I129_MN0 (I1666_G1_0n I1666_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I129_MN0 (I1574_G1_0n I1574_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I159_MN0 (I1574_G2_0np I1574_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I159_MN0 (I1022_G2_0np I1022_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I129_MN0 (I976_G1_0n I976_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI934_MN0 (qu23_b0 qu23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I187_MN0 (I1666_G4_0n I1666_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I161_MN0 (I1666_G3_0np I1666_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I129_MN0 (I1620_G1_0n I1620_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I159_MN0 (I1620_G2_0np I1620_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I161_MN0 (I1022_G3_0np I1022_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I187_MN0 (I1022_G4_0n I1022_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I187_MN0 (I930_G4_0n I930_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I161_MN0 (I930_G3_0np I930_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I161_MN0 (I1574_G3_0np I1574_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I159_MN0 (I976_G2_0np I976_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I159_MN0 (I930_G2_0np I930_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I189_MN0 (I1666_G5_0n I1666_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I161_MN0 (I1620_G3_0np I1620_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I187_MN0 (I1620_G4_0n I1620_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I189_MN0 (I1574_G5_0n I1574_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I191_MN0 (I1574_G6_0n I1574_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I189_MN0 (I1022_G5_0n I1022_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I193_MN0 (I930_G7_0n I930_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I189_MN0 (I930_G5_0n I930_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I191_MN0 (I1666_G6_0n I1666_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I189_MN0 (I1620_G5_0n I1620_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1072_MN0 (qu20_b0 qu20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I191_MN0 (I1022_G6_0n I1022_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I161_MN0 (I976_G3_0np I976_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI930_I191_MN0 (I930_G6_0n I930_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I193_MN0 (I1666_G7_0n I1666_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I191_MN0 (I1620_G6_0n I1620_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I193_MN0 (I1574_G7_0n I1574_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1026_MN0 (qu21_b0 qu21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1022_I193_MN0 (I1022_G7_0n I1022_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I187_MN0 (I976_G4_0n I976_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I189_MN0 (I976_G5_0n I976_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1620_I193_MN0 (I1620_G7_0n I1620_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2143_MN0 (nqk22 nqkn22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I191_MN0 (I976_G6_0n I976_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI976_I193_MN0 (I976_G7_0n I976_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1624_MN0 (qu8_b0 qu8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1578_MN0 (qu9_b0 qu9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I64_MN0 (I1068_cinn qu21_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2140_MN0 (nqk21 nqkn21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I191_MN0 (I1114_G6_0n I1114_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I187_MN0 (I1114_G4_0n I1114_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I159_MN0 (I1114_G2_0np I1114_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI65_MN0 (nak10 nakn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I64_MN0 (I1528_cinn qu11_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1532_MN0 (qu10_b0 qu10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I66_MN0 (I1114_G0_0n I1114_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2137_MN0 (nqk20 nqkn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI95_MN0 (nak20 nakn20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI92_MN0 (nak19 nakn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI980_MN0 (qu22_b0 qu22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI77_MN0 (nak14 nakn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI74_MN0 (nak13 nakn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I64_MN0 (I1390_cinn qu14_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI71_MN0 (nak12 nakn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I64_MN0 (I1436_cinn qu13_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI68_MN0 (nak11 nakn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I64_MN0 (I1482_cinn qu12_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2110_MN0 (nqk11 nqkn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I66_MN0 (I1528_G0_0n I1528_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I129_MN0 (I1114_G1_0n I1114_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I64_MN0 (I1114_cinn qu20_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI89_MN0 (nak18 nakn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI86_MN0 (nak17 nakn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI83_MN0 (nak16 nakn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI80_MN0 (nak15 nakn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I64_MN0 (I1344_cinn qu15_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2122_MN0 (nqk15 nqkn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2119_MN0 (nqk14 nqkn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2116_MN0 (nqk13 nqkn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2113_MN0 (nqk12 nqkn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I66_MN0 (I1482_G0_0n I1482_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I129_MN0 (I1528_G1_0n I1528_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I189_MN0 (I1114_G5_0n I1114_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I161_MN0 (I1114_G3_0np I1114_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I64_MN0 (I1160_cinn qu19_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2134_MN0 (nqk19 nqkn19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2131_MN0 (nqk18 nqkn18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I64_MN0 (I1206_cinn qu18_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2128_MN0 (nqk17 nqkn17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I64_MN0 (I1252_cinn qu17_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I66_MN0 (I1390_G0_0n I1390_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I66_MN0 (I1436_G0_0n I1436_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1118_MN0 (qu19_b0 qu19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1114_I193_MN0 (I1114_G7_0n I1114_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2125_MN0 (nqk16 nqkn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I66_MN0 (I1298_G0_0n I1298_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I64_MN0 (I1298_cinn qu16_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I66_MN0 (I1344_G0_0n I1344_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I187_MN0 (I1528_G4_0n I1528_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I66_MN0 (I1252_G0_0n I1252_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I129_MN0 (I1344_G1_0n I1344_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I159_MN0 (I1528_G2_0np I1528_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I161_MN0 (I1528_G3_0np I1528_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I66_MN0 (I1206_G0_0n I1206_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I129_MN0 (I1252_G1_0n I1252_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I129_MN0 (I1298_G1_0n I1298_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I129_MN0 (I1390_G1_0n I1390_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I129_MN0 (I1436_G1_0n I1436_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I129_MN0 (I1482_G1_0n I1482_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I189_MN0 (I1528_G5_0n I1528_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I159_MN0 (I1344_G2_0np I1344_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I159_MN0 (I1390_G2_0np I1390_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I159_MN0 (I1436_G2_0np I1436_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I193_MN0 (I1160_G7_0n I1160_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I161_MN0 (I1160_G3_0np I1160_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I129_MN0 (I1160_G1_0n I1160_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I159_MN0 (I1252_G2_0np I1252_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I159_MN0 (I1298_G2_0np I1298_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I187_MN0 (I1344_G4_0n I1344_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I161_MN0 (I1344_G3_0np I1344_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I191_MN0 (I1528_G6_0n I1528_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1164_MN0 (qu18_b0 qu18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I189_MN0 (I1160_G5_0n I1160_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I161_MN0 (I1252_G3_0np I1252_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I161_MN0 (I1298_G3_0np I1298_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I161_MN0 (I1390_G3_0np I1390_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I161_MN0 (I1436_G3_0np I1436_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I161_MN0 (I1482_G3_0np I1482_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I187_MN0 (I1482_G4_0n I1482_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I159_MN0 (I1482_G2_0np I1482_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I66_MN0 (I1160_G0_0n I1160_G0_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I187_MN0 (I1252_G4_0n I1252_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I187_MN0 (I1298_G4_0n I1298_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I187_MN0 (I1390_G4_0n I1390_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I187_MN0 (I1436_G4_0n I1436_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1528_I193_MN0 (I1528_G7_0n I1528_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I187_MN0 (I1160_G4_0n I1160_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I189_MN0 (I1298_G5_0n I1298_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I189_MN0 (I1344_G5_0n I1344_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I189_MN0 (I1390_G5_0n I1390_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I159_MN0 (I1160_G2_0np I1160_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I129_MN0 (I1206_G1_0n I1206_G1_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I189_MN0 (I1252_G5_0n I1252_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I191_MN0 (I1298_G6_0n I1298_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I191_MN0 (I1344_G6_0n I1344_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I191_MN0 (I1390_G6_0n I1390_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I191_MN0 (I1436_G6_0n I1436_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I189_MN0 (I1436_G5_0n I1436_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I189_MN0 (I1482_G5_0n I1482_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I191_MN0 (I1482_G6_0n I1482_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1160_I191_MN0 (I1160_G6_0n I1160_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I159_MN0 (I1206_G2_0np I1206_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I191_MN0 (I1252_G6_0n I1252_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I161_MN0 (I1206_G3_0np I1206_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I187_MN0 (I1206_G4_0n I1206_G4_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1252_I193_MN0 (I1252_G7_0n I1252_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1298_I193_MN0 (I1298_G7_0n I1298_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1344_I193_MN0 (I1344_G7_0n I1344_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1390_I193_MN0 (I1390_G7_0n I1390_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1436_I193_MN0 (I1436_G7_0n I1436_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I189_MN0 (I1206_G5_0n I1206_G5_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1482_I193_MN0 (I1482_G7_0n I1482_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I193_MN0 (I1206_G7_0n I1206_G7_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1206_I191_MN0 (I1206_G6_0n I1206_G6_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1210_MN0 (qu17_b0 qu17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1348_MN0 (qu14_b0 qu14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1394_MN0 (qu13_b0 qu13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1486_MN0 (qu11_b0 qu11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1256_MN0 (qu16_b0 qu16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1302_MN0 (qu15_b0 qu15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1440_MN0 (qu12_b0 qu12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI653_MN1 (XI653_Bn qu30_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI653_MN5 (XI653_n2 XI653_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI653_MN4 (b2_31 XI653_An XI653_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI653_MN2 (XI653_n1 dd31_b3_0 b2_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI653_MN3 (VSS qu30_b3_5 XI653_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI653_MN0 (XI653_An dd31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI610_MN1 (XI610_Bn c1_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI610_MN5 (XI610_n2 XI610_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI610_MN4 (p1_32 XI610_An XI610_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI610_MN2 (XI610_n1 h1 p1_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI610_MN3 (VSS c1_o XI610_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI610_MN0 (XI610_An h1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI607_MN1 (XI607_Bn qu31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI607_MN5 (XI607_n2 XI607_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI607_MN4 (b1_31 XI607_An XI607_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI607_MN2 (XI607_n1 dd31_b3_0 b1_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI607_MN3 (VSS qu31_b3_5 XI607_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI607_MN0 (XI607_An dd31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI606_MN1 (XI606_Bn qu31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI606_MN5 (XI606_n2 XI606_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI606_MN4 (b1_30 XI606_An XI606_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI606_MN2 (XI606_n1 dd30_b3_0 b1_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI606_MN3 (VSS qu31_b3_5 XI606_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI606_MN0 (XI606_An dd30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI609_MN1 (XI609_Bn qu31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI609_MN5 (XI609_n2 XI609_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI609_MN4 (h1 XI609_An XI609_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI609_MN2 (XI609_n1 p0_31 h1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI609_MN3 (VSS qu31_b3_5 XI609_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI609_MN0 (XI609_An p0_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI560_MN1 (XI560_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI560_MN5 (XI560_n2 XI560_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI560_MN4 (b0_30 XI560_An XI560_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI560_MN2 (XI560_n1 dd30_b3_0 b0_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI560_MN3 (VSS VDD XI560_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI560_MN0 (XI560_An dd30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI561_MN1 (XI561_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI561_MN5 (XI561_n2 XI561_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI561_MN4 (b0_31 XI561_An XI561_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI561_MN2 (XI561_n1 dd31_b3_0 b0_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI561_MN3 (VSS VDD XI561_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI561_MN0 (XI561_An dd31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI558_MN1 (XI558_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI558_MN5 (XI558_n2 XI558_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI558_MN4 (b0_28 XI558_An XI558_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI558_MN2 (XI558_n1 dd28_b3_0 b0_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI558_MN3 (VSS VDD XI558_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI558_MN0 (XI558_An dd28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1985_MN1 (XI1985_Bn qu1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1985_MN5 (XI1985_n2 XI1985_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1985_MN4 (b31_29 XI1985_An XI1985_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1985_MN2 (XI1985_n1 dd29_b3_5 b31_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1985_MN3 (VSS qu1_b3_4 XI1985_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1985_MN0 (XI1985_An dd29_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1939_MN1 (XI1939_Bn qu2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1939_MN5 (XI1939_n2 XI1939_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1939_MN4 (b30_29 XI1939_An XI1939_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1939_MN2 (XI1939_n1 dd29_b3_5 b30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1939_MN3 (VSS qu2_b3_4 XI1939_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1939_MN0 (XI1939_An dd29_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI699_MN1 (XI699_Bn qu29_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI699_MN5 (XI699_n2 XI699_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI699_MN4 (b3_31 XI699_An XI699_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI699_MN2 (XI699_n1 dd31_b3_0 b3_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI699_MN3 (VSS qu29_b3_5 XI699_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI699_MN0 (XI699_An dd31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI656_MN1 (XI656_Bn c2_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI656_MN5 (XI656_n2 XI656_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI656_MN4 (p2_32 XI656_An XI656_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI656_MN2 (XI656_n1 h2 p2_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI656_MN3 (VSS c2_o XI656_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI656_MN0 (XI656_An h2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI650_MN1 (XI650_Bn qu30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI650_MN5 (XI650_n2 XI650_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI650_MN4 (b2_28 XI650_An XI650_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI650_MN2 (XI650_n1 dd28_b3_0 b2_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI650_MN3 (VSS qu30_b3_4 XI650_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI650_MN0 (XI650_An dd28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI651_MN1 (XI651_Bn qu30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI651_MN5 (XI651_n2 XI651_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI651_MN4 (b2_29 XI651_An XI651_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI651_MN2 (XI651_n1 dd29_b3_0 b2_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI651_MN3 (VSS qu30_b3_4 XI651_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI651_MN0 (XI651_An dd29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI648_MN1 (XI648_Bn qu30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI648_MN5 (XI648_n2 XI648_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI648_MN4 (b2_26 XI648_An XI648_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI648_MN2 (XI648_n1 dd26_b3_0 b2_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI648_MN3 (VSS qu30_b3_4 XI648_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI648_MN0 (XI648_An dd26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI655_MN1 (XI655_Bn qu30_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI655_MN5 (XI655_n2 XI655_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI655_MN4 (h2 XI655_An XI655_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI655_MN2 (XI655_n1 p1_31 h2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI655_MN3 (VSS qu30_b3_5 XI655_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI655_MN0 (XI655_An p1_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI652_MN1 (XI652_Bn qu30_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI652_MN5 (XI652_n2 XI652_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI652_MN4 (b2_30 XI652_An XI652_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI652_MN2 (XI652_n1 dd30_b3_0 b2_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI652_MN3 (VSS qu30_b3_5 XI652_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI652_MN0 (XI652_An dd30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI602_MN1 (XI602_Bn qu31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI602_MN5 (XI602_n2 XI602_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI602_MN4 (b1_26 XI602_An XI602_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI602_MN2 (XI602_n1 dd26_b3_0 b1_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI602_MN3 (VSS qu31_b3_4 XI602_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI602_MN0 (XI602_An dd26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI604_MN1 (XI604_Bn qu31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI604_MN5 (XI604_n2 XI604_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI604_MN4 (b1_28 XI604_An XI604_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI604_MN2 (XI604_n1 dd28_b3_0 b1_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI604_MN3 (VSS qu31_b3_4 XI604_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI604_MN0 (XI604_An dd28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI605_MN1 (XI605_Bn qu31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI605_MN5 (XI605_n2 XI605_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI605_MN4 (b1_29 XI605_An XI605_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI605_MN2 (XI605_n1 dd29_b3_0 b1_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI605_MN3 (VSS qu31_b3_4 XI605_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI605_MN0 (XI605_An dd29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI559_MN1 (XI559_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI559_MN5 (XI559_n2 XI559_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI559_MN4 (b0_29 XI559_An XI559_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI559_MN2 (XI559_n1 dd29_b3_0 b0_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI559_MN3 (VSS VDD XI559_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI559_MN0 (XI559_An dd29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1986_MN1 (XI1986_Bn qu1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1986_MN5 (XI1986_n2 XI1986_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1986_MN4 (b31_30 XI1986_An XI1986_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1986_MN2 (XI1986_n1 dd30_b3_5 b31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1986_MN3 (VSS qu1_b3_5 XI1986_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1986_MN0 (XI1986_An dd30_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1987_MN1 (XI1987_Bn qu1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1987_MN5 (XI1987_n2 XI1987_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1987_MN4 (b31_31 XI1987_An XI1987_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1987_MN2 (XI1987_n1 dd31_b3_5 b31_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1987_MN3 (VSS qu1_b3_5 XI1987_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1987_MN0 (XI1987_An dd31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1984_MN1 (XI1984_Bn qu1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1984_MN5 (XI1984_n2 XI1984_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1984_MN4 (b31_28 XI1984_An XI1984_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1984_MN2 (XI1984_n1 dd28_b3_5 b31_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1984_MN3 (VSS qu1_b3_4 XI1984_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1984_MN0 (XI1984_An dd28_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1983_MN1 (XI1983_Bn qu1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1983_MN5 (XI1983_n2 XI1983_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1983_MN4 (b31_27 XI1983_An XI1983_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1983_MN2 (XI1983_n1 dd27_b3_5 b31_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1983_MN3 (VSS qu1_b3_4 XI1983_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1983_MN0 (XI1983_An dd27_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1989_MN1 (XI1989_Bn qu1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1989_MN5 (XI1989_n2 XI1989_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1989_MN4 (h31 XI1989_An XI1989_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1989_MN2 (XI1989_n1 p30_31 h31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1989_MN3 (VSS qu1_b3_5 XI1989_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1989_MN0 (XI1989_An p30_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1940_MN1 (XI1940_Bn qu2_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1940_MN5 (XI1940_n2 XI1940_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1940_MN4 (b30_30 XI1940_An XI1940_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1940_MN2 (XI1940_n1 dd30_b3_5 b30_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1940_MN3 (VSS qu2_b3_5 XI1940_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1940_MN0 (XI1940_An dd30_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1941_MN1 (XI1941_Bn qu2_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1941_MN5 (XI1941_n2 XI1941_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1941_MN4 (b30_31 XI1941_An XI1941_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1941_MN2 (XI1941_n1 dd31_b3_5 b30_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1941_MN3 (VSS qu2_b3_5 XI1941_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1941_MN0 (XI1941_An dd31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1943_MN1 (XI1943_Bn qu2_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1943_MN5 (XI1943_n2 XI1943_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1943_MN4 (h30 XI1943_An XI1943_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1943_MN2 (XI1943_n1 p29_31 h30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1943_MN3 (VSS qu2_b3_5 XI1943_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1943_MN0 (XI1943_An p29_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1938_MN1 (XI1938_Bn qu2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1938_MN5 (XI1938_n2 XI1938_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1938_MN4 (b30_28 XI1938_An XI1938_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1938_MN2 (XI1938_n1 dd28_b3_5 b30_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1938_MN3 (VSS qu2_b3_4 XI1938_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1938_MN0 (XI1938_An dd28_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1937_MN1 (XI1937_Bn qu2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1937_MN5 (XI1937_n2 XI1937_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1937_MN4 (b30_27 XI1937_An XI1937_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1937_MN2 (XI1937_n1 dd27_b3_5 b30_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1937_MN3 (VSS qu2_b3_4 XI1937_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1937_MN0 (XI1937_An dd27_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1890_MN1 (XI1890_Bn qu3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1890_MN5 (XI1890_n2 XI1890_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1890_MN4 (b29_26 XI1890_An XI1890_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1890_MN2 (XI1890_n1 dd26_b3_5 b29_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1890_MN3 (VSS qu3_b3_4 XI1890_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1890_MN0 (XI1890_An dd26_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1891_MN1 (XI1891_Bn qu3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1891_MN5 (XI1891_n2 XI1891_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1891_MN4 (b29_27 XI1891_An XI1891_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1891_MN2 (XI1891_n1 dd27_b3_5 b29_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1891_MN3 (VSS qu3_b3_4 XI1891_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1891_MN0 (XI1891_An dd27_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1892_MN1 (XI1892_Bn qu3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1892_MN5 (XI1892_n2 XI1892_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1892_MN4 (b29_28 XI1892_An XI1892_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1892_MN2 (XI1892_n1 dd28_b3_5 b29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1892_MN3 (VSS qu3_b3_4 XI1892_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1892_MN0 (XI1892_An dd28_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1893_MN1 (XI1893_Bn qu3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1893_MN5 (XI1893_n2 XI1893_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1893_MN4 (b29_29 XI1893_An XI1893_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1893_MN2 (XI1893_n1 dd29_b3_5 b29_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1893_MN3 (VSS qu3_b3_4 XI1893_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1893_MN0 (XI1893_An dd29_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI695_MN1 (XI695_Bn qu29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI695_MN5 (XI695_n2 XI695_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI695_MN4 (b3_27 XI695_An XI695_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI695_MN2 (XI695_n1 dd27_b3_0 b3_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI695_MN3 (VSS qu29_b3_4 XI695_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI695_MN0 (XI695_An dd27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI697_MN1 (XI697_Bn qu29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI697_MN5 (XI697_n2 XI697_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI697_MN4 (b3_29 XI697_An XI697_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI697_MN2 (XI697_n1 dd29_b3_0 b3_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI697_MN3 (VSS qu29_b3_4 XI697_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI697_MN0 (XI697_An dd29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI696_MN1 (XI696_Bn qu29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI696_MN5 (XI696_n2 XI696_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI696_MN4 (b3_28 XI696_An XI696_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI696_MN2 (XI696_n1 dd28_b3_0 b3_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI696_MN3 (VSS qu29_b3_4 XI696_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI696_MN0 (XI696_An dd28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI698_MN1 (XI698_Bn qu29_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI698_MN5 (XI698_n2 XI698_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI698_MN4 (b3_30 XI698_An XI698_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI698_MN2 (XI698_n1 dd30_b3_0 b3_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI698_MN3 (VSS qu29_b3_5 XI698_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI698_MN0 (XI698_An dd30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI649_MN1 (XI649_Bn qu30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI649_MN5 (XI649_n2 XI649_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI649_MN4 (b2_27 XI649_An XI649_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI649_MN2 (XI649_n1 dd27_b3_0 b2_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI649_MN3 (VSS qu30_b3_4 XI649_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI649_MN0 (XI649_An dd27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI647_MN1 (XI647_Bn qu30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI647_MN5 (XI647_n2 XI647_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI647_MN4 (b2_25 XI647_An XI647_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI647_MN2 (XI647_n1 dd25_b3_0 b2_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI647_MN3 (VSS qu30_b3_4 XI647_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI647_MN0 (XI647_An dd25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI601_MN1 (XI601_Bn qu31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI601_MN5 (XI601_n2 XI601_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI601_MN4 (b1_25 XI601_An XI601_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI601_MN2 (XI601_n1 dd25_b3_0 b1_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI601_MN3 (VSS qu31_b3_4 XI601_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI601_MN0 (XI601_An dd25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI603_MN1 (XI603_Bn qu31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI603_MN5 (XI603_n2 XI603_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI603_MN4 (b1_27 XI603_An XI603_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI603_MN2 (XI603_n1 dd27_b3_0 b1_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI603_MN3 (VSS qu31_b3_4 XI603_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI603_MN0 (XI603_An dd27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI556_MN1 (XI556_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI556_MN5 (XI556_n2 XI556_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI556_MN4 (b0_26 XI556_An XI556_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI556_MN2 (XI556_n1 dd26_b3_0 b0_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI556_MN3 (VSS VDD XI556_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI556_MN0 (XI556_An dd26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI557_MN1 (XI557_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI557_MN5 (XI557_n2 XI557_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI557_MN4 (b0_27 XI557_An XI557_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI557_MN2 (XI557_n1 dd27_b3_0 b0_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI557_MN3 (VSS VDD XI557_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI557_MN0 (XI557_An dd27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI555_MN1 (XI555_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI555_MN5 (XI555_n2 XI555_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI555_MN4 (b0_25 XI555_An XI555_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI555_MN2 (XI555_n1 dd25_b3_0 b0_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI555_MN3 (VSS VDD XI555_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI555_MN0 (XI555_An dd25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1990_MN1 (XI1990_Bn c31_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1990_MN5 (XI1990_n2 XI1990_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1990_MN4 (p31_32 XI1990_An XI1990_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1990_MN2 (XI1990_n1 h31 p31_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1990_MN3 (VSS c31_o XI1990_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1990_MN0 (XI1990_An h31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1982_MN1 (XI1982_Bn qu1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1982_MN5 (XI1982_n2 XI1982_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1982_MN4 (b31_26 XI1982_An XI1982_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1982_MN2 (XI1982_n1 dd26_b3_5 b31_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1982_MN3 (VSS qu1_b3_4 XI1982_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1982_MN0 (XI1982_An dd26_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1944_MN1 (XI1944_Bn c30_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1944_MN5 (XI1944_n2 XI1944_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1944_MN4 (p30_32 XI1944_An XI1944_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1944_MN2 (XI1944_n1 h30 p30_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1944_MN3 (VSS c30_o XI1944_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1944_MN0 (XI1944_An h30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1935_MN1 (XI1935_Bn qu2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1935_MN5 (XI1935_n2 XI1935_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1935_MN4 (b30_25 XI1935_An XI1935_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1935_MN2 (XI1935_n1 dd25_b3_5 b30_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1935_MN3 (VSS qu2_b3_4 XI1935_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1935_MN0 (XI1935_An dd25_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1936_MN1 (XI1936_Bn qu2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1936_MN5 (XI1936_n2 XI1936_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1936_MN4 (b30_26 XI1936_An XI1936_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1936_MN2 (XI1936_n1 dd26_b3_5 b30_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1936_MN3 (VSS qu2_b3_4 XI1936_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1936_MN0 (XI1936_An dd26_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1889_MN1 (XI1889_Bn qu3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1889_MN5 (XI1889_n2 XI1889_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1889_MN4 (b29_25 XI1889_An XI1889_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1889_MN2 (XI1889_n1 dd25_b3_5 b29_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1889_MN3 (VSS qu3_b3_4 XI1889_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1889_MN0 (XI1889_An dd25_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI692_MN1 (XI692_Bn qu29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI692_MN5 (XI692_n2 XI692_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI692_MN4 (b3_24 XI692_An XI692_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI692_MN2 (XI692_n1 dd24_b3_0 b3_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI692_MN3 (VSS qu29_b3_4 XI692_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI692_MN0 (XI692_An dd24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI694_MN1 (XI694_Bn qu29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI694_MN5 (XI694_n2 XI694_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI694_MN4 (b3_26 XI694_An XI694_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI694_MN2 (XI694_n1 dd26_b3_0 b3_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI694_MN3 (VSS qu29_b3_4 XI694_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI694_MN0 (XI694_An dd26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI693_MN1 (XI693_Bn qu29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI693_MN5 (XI693_n2 XI693_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI693_MN4 (b3_25 XI693_An XI693_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI693_MN2 (XI693_n1 dd25_b3_0 b3_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI693_MN3 (VSS qu29_b3_4 XI693_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI693_MN0 (XI693_An dd25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI701_MN1 (XI701_Bn qu29_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI701_MN5 (XI701_n2 XI701_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI701_MN4 (h3 XI701_An XI701_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI701_MN2 (XI701_n1 p2_31 h3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI701_MN3 (VSS qu29_b3_5 XI701_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI701_MN0 (XI701_An p2_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI646_MN1 (XI646_Bn qu30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI646_MN5 (XI646_n2 XI646_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI646_MN4 (b2_24 XI646_An XI646_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI646_MN2 (XI646_n1 dd24_b3_0 b2_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI646_MN3 (VSS qu30_b3_4 XI646_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI646_MN0 (XI646_An dd24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI645_MN1 (XI645_Bn qu30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI645_MN5 (XI645_n2 XI645_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI645_MN4 (b2_23 XI645_An XI645_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI645_MN2 (XI645_n1 dd23_b3_0 b2_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI645_MN3 (VSS qu30_b3_3 XI645_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI645_MN0 (XI645_An dd23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI599_MN1 (XI599_Bn qu31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI599_MN5 (XI599_n2 XI599_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI599_MN4 (b1_23 XI599_An XI599_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI599_MN2 (XI599_n1 dd23_b3_0 b1_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI599_MN3 (VSS qu31_b3_3 XI599_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI599_MN0 (XI599_An dd23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI600_MN1 (XI600_Bn qu31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI600_MN5 (XI600_n2 XI600_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI600_MN4 (b1_24 XI600_An XI600_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI600_MN2 (XI600_n1 dd24_b3_0 b1_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI600_MN3 (VSS qu31_b3_4 XI600_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI600_MN0 (XI600_An dd24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI553_MN1 (XI553_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI553_MN5 (XI553_n2 XI553_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI553_MN4 (b0_23 XI553_An XI553_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI553_MN2 (XI553_n1 dd23_b3_0 b0_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI553_MN3 (VSS VDD XI553_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI553_MN0 (XI553_An dd23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI554_MN1 (XI554_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI554_MN5 (XI554_n2 XI554_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI554_MN4 (b0_24 XI554_An XI554_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI554_MN2 (XI554_n1 dd24_b3_0 b0_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI554_MN3 (VSS VDD XI554_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI554_MN0 (XI554_An dd24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI564_MN1 (XI564_Bn c0_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI564_MN5 (XI564_n2 XI564_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI564_MN4 (p0_32 XI564_An XI564_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI564_MN2 (XI564_n1 h0 p0_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI564_MN3 (VSS c0_o XI564_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI564_MN0 (XI564_An h0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I219_MN1 (XI2066_I219_Bn I2066_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I219_MN5 (XI2066_I219_n2 XI2066_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I219_MN4 (ru16 XI2066_I219_An XI2066_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I219_MN2 (XI2066_I219_n1 I2066_pn16 ru16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I219_MN3 (VSS I2066_G15_0n XI2066_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I219_MN0 (XI2066_I219_An I2066_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1980_MN1 (XI1980_Bn qu1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1980_MN5 (XI1980_n2 XI1980_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1980_MN4 (b31_24 XI1980_An XI1980_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1980_MN2 (XI1980_n1 dd24_b3_5 b31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1980_MN3 (VSS qu1_b3_4 XI1980_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1980_MN0 (XI1980_An dd24_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1981_MN1 (XI1981_Bn qu1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1981_MN5 (XI1981_n2 XI1981_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1981_MN4 (b31_25 XI1981_An XI1981_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1981_MN2 (XI1981_n1 dd25_b3_5 b31_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1981_MN3 (VSS qu1_b3_4 XI1981_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1981_MN0 (XI1981_An dd25_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1934_MN1 (XI1934_Bn qu2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1934_MN5 (XI1934_n2 XI1934_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1934_MN4 (b30_24 XI1934_An XI1934_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1934_MN2 (XI1934_n1 dd24_b3_5 b30_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1934_MN3 (VSS qu2_b3_4 XI1934_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1934_MN0 (XI1934_An dd24_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1888_MN1 (XI1888_Bn qu3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1888_MN5 (XI1888_n2 XI1888_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1888_MN4 (b29_24 XI1888_An XI1888_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1888_MN2 (XI1888_n1 dd24_b3_5 b29_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1888_MN3 (VSS qu3_b3_4 XI1888_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1888_MN0 (XI1888_An dd24_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI690_MN1 (XI690_Bn qu29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI690_MN5 (XI690_n2 XI690_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI690_MN4 (b3_22 XI690_An XI690_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI690_MN2 (XI690_n1 dd22_b3_0 b3_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI690_MN3 (VSS qu29_b3_3 XI690_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI690_MN0 (XI690_An dd22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI702_MN1 (XI702_Bn c3_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI702_MN5 (XI702_n2 XI702_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI702_MN4 (p3_32 XI702_An XI702_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI702_MN2 (XI702_n1 h3 p3_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI702_MN3 (VSS c3_o XI702_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI702_MN0 (XI702_An h3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI644_MN1 (XI644_Bn qu30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI644_MN5 (XI644_n2 XI644_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI644_MN4 (b2_22 XI644_An XI644_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI644_MN2 (XI644_n1 dd22_b3_0 b2_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI644_MN3 (VSS qu30_b3_3 XI644_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI644_MN0 (XI644_An dd22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI598_MN1 (XI598_Bn qu31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI598_MN5 (XI598_n2 XI598_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI598_MN4 (b1_22 XI598_An XI598_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI598_MN2 (XI598_n1 dd22_b3_0 b1_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI598_MN3 (VSS qu31_b3_3 XI598_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI598_MN0 (XI598_An dd22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI552_MN1 (XI552_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI552_MN5 (XI552_n2 XI552_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI552_MN4 (b0_22 XI552_An XI552_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI552_MN2 (XI552_n1 dd22_b3_0 b0_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI552_MN3 (VSS VDD XI552_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI552_MN0 (XI552_An dd22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI563_MN1 (XI563_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI563_MN5 (XI563_n2 XI563_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI563_MN4 (h0 XI563_An XI563_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI563_MN2 (XI563_n1 VSS h0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI563_MN3 (VSS VDD XI563_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI563_MN0 (XI563_An VSS VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I218_MN1 (XI2066_I218_Bn I2066_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I218_MN5 (XI2066_I218_n2 XI2066_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I218_MN4 (ru15 XI2066_I218_An XI2066_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I218_MN2 (XI2066_I218_n1 I2066_pn15 ru15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I218_MN3 (VSS I2066_G14_0n XI2066_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I218_MN0 (XI2066_I218_An I2066_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1978_MN1 (XI1978_Bn qu1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1978_MN5 (XI1978_n2 XI1978_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1978_MN4 (b31_22 XI1978_An XI1978_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1978_MN2 (XI1978_n1 dd22_b3_5 b31_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1978_MN3 (VSS qu1_b3_3 XI1978_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1978_MN0 (XI1978_An dd22_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1979_MN1 (XI1979_Bn qu1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1979_MN5 (XI1979_n2 XI1979_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1979_MN4 (b31_23 XI1979_An XI1979_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1979_MN2 (XI1979_n1 dd23_b3_5 b31_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1979_MN3 (VSS qu1_b3_3 XI1979_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1979_MN0 (XI1979_An dd23_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1933_MN1 (XI1933_Bn qu2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1933_MN5 (XI1933_n2 XI1933_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1933_MN4 (b30_23 XI1933_An XI1933_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1933_MN2 (XI1933_n1 dd23_b3_5 b30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1933_MN3 (VSS qu2_b3_3 XI1933_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1933_MN0 (XI1933_An dd23_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1932_MN1 (XI1932_Bn qu2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1932_MN5 (XI1932_n2 XI1932_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1932_MN4 (b30_22 XI1932_An XI1932_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1932_MN2 (XI1932_n1 dd22_b3_5 b30_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1932_MN3 (VSS qu2_b3_3 XI1932_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1932_MN0 (XI1932_An dd22_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI689_MN1 (XI689_Bn qu29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI689_MN5 (XI689_n2 XI689_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI689_MN4 (b3_21 XI689_An XI689_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI689_MN2 (XI689_n1 dd21_b3_0 b3_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI689_MN3 (VSS qu29_b3_3 XI689_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI689_MN0 (XI689_An dd21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI691_MN1 (XI691_Bn qu29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI691_MN5 (XI691_n2 XI691_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI691_MN4 (b3_23 XI691_An XI691_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI691_MN2 (XI691_n1 dd23_b3_0 b3_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI691_MN3 (VSS qu29_b3_3 XI691_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI691_MN0 (XI691_An dd23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI642_MN1 (XI642_Bn qu30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI642_MN5 (XI642_n2 XI642_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI642_MN4 (b2_20 XI642_An XI642_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI642_MN2 (XI642_n1 dd20_b3_0 b2_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI642_MN3 (VSS qu30_b3_3 XI642_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI642_MN0 (XI642_An dd20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI643_MN1 (XI643_Bn qu30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI643_MN5 (XI643_n2 XI643_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI643_MN4 (b2_21 XI643_An XI643_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI643_MN2 (XI643_n1 dd21_b3_0 b2_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI643_MN3 (VSS qu30_b3_3 XI643_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI643_MN0 (XI643_An dd21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI596_MN1 (XI596_Bn qu31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI596_MN5 (XI596_n2 XI596_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI596_MN4 (b1_20 XI596_An XI596_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI596_MN2 (XI596_n1 dd20_b3_0 b1_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI596_MN3 (VSS qu31_b3_3 XI596_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI596_MN0 (XI596_An dd20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI597_MN1 (XI597_Bn qu31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI597_MN5 (XI597_n2 XI597_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI597_MN4 (b1_21 XI597_An XI597_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI597_MN2 (XI597_n1 dd21_b3_0 b1_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI597_MN3 (VSS qu31_b3_3 XI597_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI597_MN0 (XI597_An dd21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI551_MN1 (XI551_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI551_MN5 (XI551_n2 XI551_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI551_MN4 (b0_21 XI551_An XI551_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI551_MN2 (XI551_n1 dd21_b3_0 b0_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI551_MN3 (VSS VDD XI551_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI551_MN0 (XI551_An dd21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI550_MN1 (XI550_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI550_MN5 (XI550_n2 XI550_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI550_MN4 (b0_20 XI550_An XI550_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI550_MN2 (XI550_n1 dd20_b3_0 b0_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI550_MN3 (VSS VDD XI550_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI550_MN0 (XI550_An dd20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1977_MN1 (XI1977_Bn qu1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1977_MN5 (XI1977_n2 XI1977_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1977_MN4 (b31_21 XI1977_An XI1977_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1977_MN2 (XI1977_n1 dd21_b3_5 b31_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1977_MN3 (VSS qu1_b3_3 XI1977_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1977_MN0 (XI1977_An dd21_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1931_MN1 (XI1931_Bn qu2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1931_MN5 (XI1931_n2 XI1931_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1931_MN4 (b30_21 XI1931_An XI1931_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1931_MN2 (XI1931_n1 dd21_b3_5 b30_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1931_MN3 (VSS qu2_b3_3 XI1931_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1931_MN0 (XI1931_An dd21_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1885_MN1 (XI1885_Bn qu3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1885_MN5 (XI1885_n2 XI1885_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1885_MN4 (b29_21 XI1885_An XI1885_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1885_MN2 (XI1885_n1 dd21_b3_5 b29_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1885_MN3 (VSS qu3_b3_3 XI1885_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1885_MN0 (XI1885_An dd21_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1887_MN1 (XI1887_Bn qu3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1887_MN5 (XI1887_n2 XI1887_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1887_MN4 (b29_23 XI1887_An XI1887_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1887_MN2 (XI1887_n1 dd23_b3_5 b29_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1887_MN3 (VSS qu3_b3_3 XI1887_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1887_MN0 (XI1887_An dd23_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1894_MN1 (XI1894_Bn qu3_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1894_MN5 (XI1894_n2 XI1894_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1894_MN4 (b29_30 XI1894_An XI1894_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1894_MN2 (XI1894_n1 dd30_b3_5 b29_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1894_MN3 (VSS qu3_b3_5 XI1894_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1894_MN0 (XI1894_An dd30_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1895_MN1 (XI1895_Bn qu3_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1895_MN5 (XI1895_n2 XI1895_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1895_MN4 (b29_31 XI1895_An XI1895_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1895_MN2 (XI1895_n1 dd31_b3_5 b29_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1895_MN3 (VSS qu3_b3_5 XI1895_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1895_MN0 (XI1895_An dd31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI688_MN1 (XI688_Bn qu29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI688_MN5 (XI688_n2 XI688_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI688_MN4 (b3_20 XI688_An XI688_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI688_MN2 (XI688_n1 dd20_b3_0 b3_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI688_MN3 (VSS qu29_b3_3 XI688_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI688_MN0 (XI688_An dd20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI686_MN1 (XI686_Bn qu29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI686_MN5 (XI686_n2 XI686_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI686_MN4 (b3_18 XI686_An XI686_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI686_MN2 (XI686_n1 dd18_b3_0 b3_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI686_MN3 (VSS qu29_b3_3 XI686_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI686_MN0 (XI686_An dd18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI687_MN1 (XI687_Bn qu29_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI687_MN5 (XI687_n2 XI687_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI687_MN4 (b3_19 XI687_An XI687_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI687_MN2 (XI687_n1 dd19_b3_0 b3_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI687_MN3 (VSS qu29_b3_3 XI687_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI687_MN0 (XI687_An dd19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI640_MN1 (XI640_Bn qu30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI640_MN5 (XI640_n2 XI640_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI640_MN4 (b2_18 XI640_An XI640_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI640_MN2 (XI640_n1 dd18_b3_0 b2_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI640_MN3 (VSS qu30_b3_3 XI640_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI640_MN0 (XI640_An dd18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI641_MN1 (XI641_Bn qu30_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI641_MN5 (XI641_n2 XI641_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI641_MN4 (b2_19 XI641_An XI641_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI641_MN2 (XI641_n1 dd19_b3_0 b2_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI641_MN3 (VSS qu30_b3_3 XI641_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI641_MN0 (XI641_An dd19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I219_MN1 (XI608_I219_Bn I608_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I219_MN5 (XI608_I219_n2 XI608_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I219_MN4 (p1_16 XI608_I219_An XI608_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I219_MN2 (XI608_I219_n1 I608_pn16 p1_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I219_MN3 (VSS I608_G15_0n XI608_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I219_MN0 (XI608_I219_An I608_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI594_MN1 (XI594_Bn qu31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI594_MN5 (XI594_n2 XI594_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI594_MN4 (b1_18 XI594_An XI594_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI594_MN2 (XI594_n1 dd18_b3_0 b1_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI594_MN3 (VSS qu31_b3_3 XI594_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI594_MN0 (XI594_An dd18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI595_MN1 (XI595_Bn qu31_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI595_MN5 (XI595_n2 XI595_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI595_MN4 (b1_19 XI595_An XI595_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI595_MN2 (XI595_n1 dd19_b3_0 b1_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI595_MN3 (VSS qu31_b3_3 XI595_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI595_MN0 (XI595_An dd19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI549_MN1 (XI549_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI549_MN5 (XI549_n2 XI549_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI549_MN4 (b0_19 XI549_An XI549_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI549_MN2 (XI549_n1 dd19_b3_0 b0_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI549_MN3 (VSS VDD XI549_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI549_MN0 (XI549_An dd19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I217_MN1 (XI2066_I217_Bn I2066_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I217_MN5 (XI2066_I217_n2 XI2066_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I217_MN4 (ru14 XI2066_I217_An XI2066_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I217_MN2 (XI2066_I217_n1 I2066_pn14 ru14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I217_MN3 (VSS I2066_G13_0n XI2066_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I217_MN0 (XI2066_I217_An I2066_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1976_MN1 (XI1976_Bn qu1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1976_MN5 (XI1976_n2 XI1976_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1976_MN4 (b31_20 XI1976_An XI1976_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1976_MN2 (XI1976_n1 dd20_b3_5 b31_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1976_MN3 (VSS qu1_b3_3 XI1976_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1976_MN0 (XI1976_An dd20_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1975_MN1 (XI1975_Bn qu1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1975_MN5 (XI1975_n2 XI1975_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1975_MN4 (b31_19 XI1975_An XI1975_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1975_MN2 (XI1975_n1 dd19_b3_5 b31_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1975_MN3 (VSS qu1_b3_3 XI1975_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1975_MN0 (XI1975_An dd19_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1928_MN1 (XI1928_Bn qu2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1928_MN5 (XI1928_n2 XI1928_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1928_MN4 (b30_18 XI1928_An XI1928_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1928_MN2 (XI1928_n1 dd18_b3_5 b30_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1928_MN3 (VSS qu2_b3_3 XI1928_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1928_MN0 (XI1928_An dd18_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1930_MN1 (XI1930_Bn qu2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1930_MN5 (XI1930_n2 XI1930_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1930_MN4 (b30_20 XI1930_An XI1930_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1930_MN2 (XI1930_n1 dd20_b3_5 b30_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1930_MN3 (VSS qu2_b3_3 XI1930_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1930_MN0 (XI1930_An dd20_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1929_MN1 (XI1929_Bn qu2_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1929_MN5 (XI1929_n2 XI1929_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1929_MN4 (b30_19 XI1929_An XI1929_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1929_MN2 (XI1929_n1 dd19_b3_5 b30_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1929_MN3 (VSS qu2_b3_3 XI1929_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1929_MN0 (XI1929_An dd19_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1882_MN1 (XI1882_Bn qu3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1882_MN5 (XI1882_n2 XI1882_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1882_MN4 (b29_18 XI1882_An XI1882_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1882_MN2 (XI1882_n1 dd18_b3_5 b29_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1882_MN3 (VSS qu3_b3_3 XI1882_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1882_MN0 (XI1882_An dd18_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1883_MN1 (XI1883_Bn qu3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1883_MN5 (XI1883_n2 XI1883_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1883_MN4 (b29_19 XI1883_An XI1883_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1883_MN2 (XI1883_n1 dd19_b3_5 b29_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1883_MN3 (VSS qu3_b3_3 XI1883_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1883_MN0 (XI1883_An dd19_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1884_MN1 (XI1884_Bn qu3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1884_MN5 (XI1884_n2 XI1884_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1884_MN4 (b29_20 XI1884_An XI1884_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1884_MN2 (XI1884_n1 dd20_b3_5 b29_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1884_MN3 (VSS qu3_b3_3 XI1884_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1884_MN0 (XI1884_An dd20_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1886_MN1 (XI1886_Bn qu3_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1886_MN5 (XI1886_n2 XI1886_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1886_MN4 (b29_22 XI1886_An XI1886_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1886_MN2 (XI1886_n1 dd22_b3_5 b29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1886_MN3 (VSS qu3_b3_3 XI1886_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1886_MN0 (XI1886_An dd22_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I219_MN1 (XI654_I219_Bn I654_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I219_MN5 (XI654_I219_n2 XI654_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I219_MN4 (p2_16 XI654_I219_An XI654_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I219_MN2 (XI654_I219_n1 I654_pn16 p2_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I219_MN3 (VSS I654_G15_0n XI654_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I219_MN0 (XI654_I219_An I654_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I218_MN1 (XI608_I218_Bn I608_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I218_MN5 (XI608_I218_n2 XI608_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I218_MN4 (p1_15 XI608_I218_An XI608_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I218_MN2 (XI608_I218_n1 I608_pn15 p1_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I218_MN3 (VSS I608_G14_0n XI608_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I218_MN0 (XI608_I218_An I608_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI548_MN1 (XI548_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI548_MN5 (XI548_n2 XI548_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI548_MN4 (b0_18 XI548_An XI548_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI548_MN2 (XI548_n1 dd18_b3_0 b0_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI548_MN3 (VSS VDD XI548_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI548_MN0 (XI548_An dd18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I219_MN1 (XI562_I219_Bn I562_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I219_MN5 (XI562_I219_n2 XI562_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I219_MN4 (p0_16 XI562_I219_An XI562_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I219_MN2 (XI562_I219_n1 I562_pn16 p0_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I219_MN3 (VSS I562_G15_0n XI562_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I219_MN0 (XI562_I219_An I562_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1974_MN1 (XI1974_Bn qu1_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1974_MN5 (XI1974_n2 XI1974_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1974_MN4 (b31_18 XI1974_An XI1974_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1974_MN2 (XI1974_n1 dd18_b3_5 b31_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1974_MN3 (VSS qu1_b3_3 XI1974_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1974_MN0 (XI1974_An dd18_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I219_MN1 (XI1942_I219_Bn I1942_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I219_MN5 (XI1942_I219_n2 XI1942_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I219_MN4 (p30_16 XI1942_I219_An XI1942_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I219_MN2 (XI1942_I219_n1 I1942_pn16 p30_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I219_MN3 (VSS I1942_G15_0n XI1942_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I219_MN0 (XI1942_I219_An I1942_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I216_MN1 (XI1896_I216_Bn I1896_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I216_MN5 (XI1896_I216_n2 XI1896_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I216_MN4 (p29_13 XI1896_I216_An XI1896_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I216_MN2 (XI1896_I216_n1 I1896_pn13 p29_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I216_MN3 (VSS I1896_G12_0n XI1896_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I216_MN0 (XI1896_I216_An I1896_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I218_MN1 (XI1896_I218_Bn I1896_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I218_MN5 (XI1896_I218_n2 XI1896_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I218_MN4 (p29_15 XI1896_I218_An XI1896_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I218_MN2 (XI1896_I218_n1 I1896_pn15 p29_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I218_MN3 (VSS I1896_G14_0n XI1896_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I218_MN0 (XI1896_I218_An I1896_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I217_MN1 (XI1896_I217_Bn I1896_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I217_MN5 (XI1896_I217_n2 XI1896_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I217_MN4 (p29_14 XI1896_I217_An XI1896_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I217_MN2 (XI1896_I217_n1 I1896_pn14 p29_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I217_MN3 (VSS I1896_G13_0n XI1896_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I217_MN0 (XI1896_I217_An I1896_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I219_MN1 (XI1896_I219_Bn I1896_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I219_MN5 (XI1896_I219_n2 XI1896_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I219_MN4 (p29_16 XI1896_I219_An XI1896_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I219_MN2 (XI1896_I219_n1 I1896_pn16 p29_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I219_MN3 (VSS I1896_G15_0n XI1896_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I219_MN0 (XI1896_I219_An I1896_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1898_MN1 (XI1898_Bn c29_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1898_MN5 (XI1898_n2 XI1898_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1898_MN4 (p29_32 XI1898_An XI1898_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1898_MN2 (XI1898_n1 h29 p29_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1898_MN3 (VSS c29_o XI1898_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1898_MN0 (XI1898_An h29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI685_MN1 (XI685_Bn qu29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI685_MN5 (XI685_n2 XI685_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI685_MN4 (b3_17 XI685_An XI685_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI685_MN2 (XI685_n1 dd17_b3_0 b3_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI685_MN3 (VSS qu29_b3_2 XI685_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI685_MN0 (XI685_An dd17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI684_MN1 (XI684_Bn qu29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI684_MN5 (XI684_n2 XI684_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI684_MN4 (b3_16 XI684_An XI684_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI684_MN2 (XI684_n1 dd16_b3_0 b3_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI684_MN3 (VSS qu29_b3_2 XI684_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI684_MN0 (XI684_An dd16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I217_MN1 (XI654_I217_Bn I654_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I217_MN5 (XI654_I217_n2 XI654_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I217_MN4 (p2_14 XI654_I217_An XI654_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I217_MN2 (XI654_I217_n1 I654_pn14 p2_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I217_MN3 (VSS I654_G13_0n XI654_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I217_MN0 (XI654_I217_An I654_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I218_MN1 (XI654_I218_Bn I654_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I218_MN5 (XI654_I218_n2 XI654_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I218_MN4 (p2_15 XI654_I218_An XI654_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I218_MN2 (XI654_I218_n1 I654_pn15 p2_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I218_MN3 (VSS I654_G14_0n XI654_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I218_MN0 (XI654_I218_An I654_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI638_MN1 (XI638_Bn qu30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI638_MN5 (XI638_n2 XI638_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI638_MN4 (b2_16 XI638_An XI638_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI638_MN2 (XI638_n1 dd16_b3_0 b2_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI638_MN3 (VSS qu30_b3_2 XI638_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI638_MN0 (XI638_An dd16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI639_MN1 (XI639_Bn qu30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI639_MN5 (XI639_n2 XI639_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI639_MN4 (b2_17 XI639_An XI639_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI639_MN2 (XI639_n1 dd17_b3_0 b2_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI639_MN3 (VSS qu30_b3_2 XI639_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI639_MN0 (XI639_An dd17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I217_MN1 (XI608_I217_Bn I608_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I217_MN5 (XI608_I217_n2 XI608_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I217_MN4 (p1_14 XI608_I217_An XI608_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I217_MN2 (XI608_I217_n1 I608_pn14 p1_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I217_MN3 (VSS I608_G13_0n XI608_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I217_MN0 (XI608_I217_An I608_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI593_MN1 (XI593_Bn qu31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI593_MN5 (XI593_n2 XI593_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI593_MN4 (b1_17 XI593_An XI593_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI593_MN2 (XI593_n1 dd17_b3_0 b1_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI593_MN3 (VSS qu31_b3_2 XI593_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI593_MN0 (XI593_An dd17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI592_MN1 (XI592_Bn qu31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI592_MN5 (XI592_n2 XI592_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI592_MN4 (b1_16 XI592_An XI592_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI592_MN2 (XI592_n1 dd16_b3_0 b1_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI592_MN3 (VSS qu31_b3_2 XI592_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI592_MN0 (XI592_An dd16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI547_MN1 (XI547_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI547_MN5 (XI547_n2 XI547_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI547_MN4 (b0_17 XI547_An XI547_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI547_MN2 (XI547_n1 dd17_b3_0 b0_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI547_MN3 (VSS VDD XI547_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI547_MN0 (XI547_An dd17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I218_MN1 (XI562_I218_Bn I562_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I218_MN5 (XI562_I218_n2 XI562_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I218_MN4 (p0_15 XI562_I218_An XI562_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I218_MN2 (XI562_I218_n1 I562_pn15 p0_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I218_MN3 (VSS I562_G14_0n XI562_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I218_MN0 (XI562_I218_An I562_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I217_MN1 (XI562_I217_Bn I562_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I217_MN5 (XI562_I217_n2 XI562_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I217_MN4 (p0_14 XI562_I217_An XI562_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I217_MN2 (XI562_I217_n1 I562_pn14 p0_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I217_MN3 (VSS I562_G13_0n XI562_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I217_MN0 (XI562_I217_An I562_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I215_MN1 (XI2066_I215_Bn I2066_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I215_MN5 (XI2066_I215_n2 XI2066_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I215_MN4 (ru12 XI2066_I215_An XI2066_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I215_MN2 (XI2066_I215_n1 I2066_pn12 ru12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I215_MN3 (VSS I2066_G11_0n XI2066_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I215_MN0 (XI2066_I215_An I2066_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I216_MN1 (XI2066_I216_Bn I2066_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I216_MN5 (XI2066_I216_n2 XI2066_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I216_MN4 (ru13 XI2066_I216_An XI2066_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I216_MN2 (XI2066_I216_n1 I2066_pn13 ru13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I216_MN3 (VSS I2066_G12_0n XI2066_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I216_MN0 (XI2066_I216_An I2066_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I218_MN1 (XI1988_I218_Bn I1988_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I218_MN5 (XI1988_I218_n2 XI1988_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I218_MN4 (p31_15 XI1988_I218_An XI1988_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I218_MN2 (XI1988_I218_n1 I1988_pn15 p31_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I218_MN3 (VSS I1988_G14_0n XI1988_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I218_MN0 (XI1988_I218_An I1988_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I219_MN1 (XI1988_I219_Bn I1988_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I219_MN5 (XI1988_I219_n2 XI1988_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I219_MN4 (p31_16 XI1988_I219_An XI1988_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I219_MN2 (XI1988_I219_n1 I1988_pn16 p31_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I219_MN3 (VSS I1988_G15_0n XI1988_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I219_MN0 (XI1988_I219_An I1988_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1972_MN1 (XI1972_Bn qu1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1972_MN5 (XI1972_n2 XI1972_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1972_MN4 (b31_16 XI1972_An XI1972_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1972_MN2 (XI1972_n1 dd16_b3_5 b31_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1972_MN3 (VSS qu1_b3_2 XI1972_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1972_MN0 (XI1972_An dd16_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1973_MN1 (XI1973_Bn qu1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1973_MN5 (XI1973_n2 XI1973_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1973_MN4 (b31_17 XI1973_An XI1973_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1973_MN2 (XI1973_n1 dd17_b3_5 b31_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1973_MN3 (VSS qu1_b3_2 XI1973_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1973_MN0 (XI1973_An dd17_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I218_MN1 (XI1942_I218_Bn I1942_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I218_MN5 (XI1942_I218_n2 XI1942_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I218_MN4 (p30_15 XI1942_I218_An XI1942_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I218_MN2 (XI1942_I218_n1 I1942_pn15 p30_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I218_MN3 (VSS I1942_G14_0n XI1942_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I218_MN0 (XI1942_I218_An I1942_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I217_MN1 (XI1942_I217_Bn I1942_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I217_MN5 (XI1942_I217_n2 XI1942_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I217_MN4 (p30_14 XI1942_I217_An XI1942_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I217_MN2 (XI1942_I217_n1 I1942_pn14 p30_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I217_MN3 (VSS I1942_G13_0n XI1942_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I217_MN0 (XI1942_I217_An I1942_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1926_MN1 (XI1926_Bn qu2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1926_MN5 (XI1926_n2 XI1926_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1926_MN4 (b30_16 XI1926_An XI1926_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1926_MN2 (XI1926_n1 dd16_b3_5 b30_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1926_MN3 (VSS qu2_b3_2 XI1926_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1926_MN0 (XI1926_An dd16_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1927_MN1 (XI1927_Bn qu2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1927_MN5 (XI1927_n2 XI1927_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1927_MN4 (b30_17 XI1927_An XI1927_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1927_MN2 (XI1927_n1 dd17_b3_5 b30_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1927_MN3 (VSS qu2_b3_2 XI1927_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1927_MN0 (XI1927_An dd17_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I214_MN1 (XI1896_I214_Bn I1896_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I214_MN5 (XI1896_I214_n2 XI1896_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I214_MN4 (p29_11 XI1896_I214_An XI1896_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I214_MN2 (XI1896_I214_n1 I1896_pn11 p29_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I214_MN3 (VSS I1896_G10_0n XI1896_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I214_MN0 (XI1896_I214_An I1896_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I215_MN1 (XI1896_I215_Bn I1896_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I215_MN5 (XI1896_I215_n2 XI1896_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I215_MN4 (p29_12 XI1896_I215_An XI1896_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I215_MN2 (XI1896_I215_n1 I1896_pn12 p29_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I215_MN3 (VSS I1896_G11_0n XI1896_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I215_MN0 (XI1896_I215_An I1896_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1881_MN1 (XI1881_Bn qu3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1881_MN5 (XI1881_n2 XI1881_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1881_MN4 (b29_17 XI1881_An XI1881_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1881_MN2 (XI1881_n1 dd17_b3_5 b29_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1881_MN3 (VSS qu3_b3_2 XI1881_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1881_MN0 (XI1881_An dd17_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1897_MN1 (XI1897_Bn qu3_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1897_MN5 (XI1897_n2 XI1897_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1897_MN4 (h29 XI1897_An XI1897_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1897_MN2 (XI1897_n1 p28_31 h29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1897_MN3 (VSS qu3_b3_5 XI1897_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1897_MN0 (XI1897_An p28_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I215_MN1 (XI654_I215_Bn I654_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I215_MN5 (XI654_I215_n2 XI654_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I215_MN4 (p2_12 XI654_I215_An XI654_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I215_MN2 (XI654_I215_n1 I654_pn12 p2_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I215_MN3 (VSS I654_G11_0n XI654_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I215_MN0 (XI654_I215_An I654_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI682_MN1 (XI682_Bn qu29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI682_MN5 (XI682_n2 XI682_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI682_MN4 (b3_14 XI682_An XI682_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI682_MN2 (XI682_n1 dd14_b3_0 b3_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI682_MN3 (VSS qu29_b3_2 XI682_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI682_MN0 (XI682_An dd14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI683_MN1 (XI683_Bn qu29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI683_MN5 (XI683_n2 XI683_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI683_MN4 (b3_15 XI683_An XI683_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI683_MN2 (XI683_n1 dd15_b3_0 b3_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI683_MN3 (VSS qu29_b3_2 XI683_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI683_MN0 (XI683_An dd15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I216_MN1 (XI654_I216_Bn I654_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I216_MN5 (XI654_I216_n2 XI654_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I216_MN4 (p2_13 XI654_I216_An XI654_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I216_MN2 (XI654_I216_n1 I654_pn13 p2_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I216_MN3 (VSS I654_G12_0n XI654_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I216_MN0 (XI654_I216_An I654_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI637_MN1 (XI637_Bn qu30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI637_MN5 (XI637_n2 XI637_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI637_MN4 (b2_15 XI637_An XI637_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI637_MN2 (XI637_n1 dd15_b3_0 b2_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI637_MN3 (VSS qu30_b3_2 XI637_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI637_MN0 (XI637_An dd15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI636_MN1 (XI636_Bn qu30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI636_MN5 (XI636_n2 XI636_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI636_MN4 (b2_14 XI636_An XI636_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI636_MN2 (XI636_n1 dd14_b3_0 b2_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI636_MN3 (VSS qu30_b3_2 XI636_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI636_MN0 (XI636_An dd14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I215_MN1 (XI608_I215_Bn I608_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I215_MN5 (XI608_I215_n2 XI608_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I215_MN4 (p1_12 XI608_I215_An XI608_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I215_MN2 (XI608_I215_n1 I608_pn12 p1_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I215_MN3 (VSS I608_G11_0n XI608_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I215_MN0 (XI608_I215_An I608_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I216_MN1 (XI608_I216_Bn I608_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I216_MN5 (XI608_I216_n2 XI608_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I216_MN4 (p1_13 XI608_I216_An XI608_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I216_MN2 (XI608_I216_n1 I608_pn13 p1_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I216_MN3 (VSS I608_G12_0n XI608_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I216_MN0 (XI608_I216_An I608_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI591_MN1 (XI591_Bn qu31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI591_MN5 (XI591_n2 XI591_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI591_MN4 (b1_15 XI591_An XI591_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI591_MN2 (XI591_n1 dd15_b3_0 b1_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI591_MN3 (VSS qu31_b3_2 XI591_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI591_MN0 (XI591_An dd15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI545_MN1 (XI545_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI545_MN5 (XI545_n2 XI545_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI545_MN4 (b0_15 XI545_An XI545_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI545_MN2 (XI545_n1 dd15_b3_0 b0_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI545_MN3 (VSS VDD XI545_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI545_MN0 (XI545_An dd15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI546_MN1 (XI546_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI546_MN5 (XI546_n2 XI546_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI546_MN4 (b0_16 XI546_An XI546_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI546_MN2 (XI546_n1 dd16_b3_0 b0_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI546_MN3 (VSS VDD XI546_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI546_MN0 (XI546_An dd16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I216_MN1 (XI562_I216_Bn I562_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I216_MN5 (XI562_I216_n2 XI562_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I216_MN4 (p0_13 XI562_I216_An XI562_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I216_MN2 (XI562_I216_n1 I562_pn13 p0_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I216_MN3 (VSS I562_G12_0n XI562_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I216_MN0 (XI562_I216_An I562_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I215_MN1 (XI562_I215_Bn I562_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I215_MN5 (XI562_I215_n2 XI562_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I215_MN4 (p0_12 XI562_I215_An XI562_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I215_MN2 (XI562_I215_n1 I562_pn12 p0_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I215_MN3 (VSS I562_G11_0n XI562_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I215_MN0 (XI562_I215_An I562_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I217_MN1 (XI1988_I217_Bn I1988_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I217_MN5 (XI1988_I217_n2 XI1988_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I217_MN4 (p31_14 XI1988_I217_An XI1988_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I217_MN2 (XI1988_I217_n1 I1988_pn14 p31_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I217_MN3 (VSS I1988_G13_0n XI1988_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I217_MN0 (XI1988_I217_An I1988_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1970_MN1 (XI1970_Bn qu1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1970_MN5 (XI1970_n2 XI1970_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1970_MN4 (b31_14 XI1970_An XI1970_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1970_MN2 (XI1970_n1 dd14_b3_5 b31_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1970_MN3 (VSS qu1_b3_2 XI1970_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1970_MN0 (XI1970_An dd14_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1971_MN1 (XI1971_Bn qu1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1971_MN5 (XI1971_n2 XI1971_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1971_MN4 (b31_15 XI1971_An XI1971_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1971_MN2 (XI1971_n1 dd15_b3_5 b31_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1971_MN3 (VSS qu1_b3_2 XI1971_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1971_MN0 (XI1971_An dd15_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I216_MN1 (XI1942_I216_Bn I1942_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I216_MN5 (XI1942_I216_n2 XI1942_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I216_MN4 (p30_13 XI1942_I216_An XI1942_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I216_MN2 (XI1942_I216_n1 I1942_pn13 p30_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I216_MN3 (VSS I1942_G12_0n XI1942_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I216_MN0 (XI1942_I216_An I1942_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I215_MN1 (XI1942_I215_Bn I1942_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I215_MN5 (XI1942_I215_n2 XI1942_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I215_MN4 (p30_12 XI1942_I215_An XI1942_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I215_MN2 (XI1942_I215_n1 I1942_pn12 p30_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I215_MN3 (VSS I1942_G11_0n XI1942_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I215_MN0 (XI1942_I215_An I1942_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1925_MN1 (XI1925_Bn qu2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1925_MN5 (XI1925_n2 XI1925_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1925_MN4 (b30_15 XI1925_An XI1925_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1925_MN2 (XI1925_n1 dd15_b3_5 b30_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1925_MN3 (VSS qu2_b3_2 XI1925_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1925_MN0 (XI1925_An dd15_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1924_MN1 (XI1924_Bn qu2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1924_MN5 (XI1924_n2 XI1924_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1924_MN4 (b30_14 XI1924_An XI1924_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1924_MN2 (XI1924_n1 dd14_b3_5 b30_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1924_MN3 (VSS qu2_b3_2 XI1924_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1924_MN0 (XI1924_An dd14_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I212_MN1 (XI1896_I212_Bn I1896_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I212_MN5 (XI1896_I212_n2 XI1896_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I212_MN4 (p29_9 XI1896_I212_An XI1896_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I212_MN2 (XI1896_I212_n1 I1896_pn9 p29_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I212_MN3 (VSS I1896_G8_0n XI1896_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I212_MN0 (XI1896_I212_An I1896_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I213_MN1 (XI1896_I213_Bn I1896_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I213_MN5 (XI1896_I213_n2 XI1896_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I213_MN4 (p29_10 XI1896_I213_An XI1896_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I213_MN2 (XI1896_I213_n1 I1896_pn10 p29_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I213_MN3 (VSS I1896_G9_0n XI1896_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I213_MN0 (XI1896_I213_An I1896_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1878_MN1 (XI1878_Bn qu3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1878_MN5 (XI1878_n2 XI1878_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1878_MN4 (b29_14 XI1878_An XI1878_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1878_MN2 (XI1878_n1 dd14_b3_5 b29_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1878_MN3 (VSS qu3_b3_2 XI1878_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1878_MN0 (XI1878_An dd14_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1880_MN1 (XI1880_Bn qu3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
