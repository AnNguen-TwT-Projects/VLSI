    I_MXI2066_I156_XG_MN2 (XI2066_I156_XG_n1 I2066_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I156_XG_MN0 (I2066_G31_24 I2066_P31_28n XI2066_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I156_XG_MN1 (XI2066_I156_XG_n1 I2066_G27_24n I2066_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I93_XG_MN2 (XI2066_I93_XG_n1 I2066_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I93_XG_MN0 (I2066_G27_26 I2066_pn27 XI2066_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I93_XG_MN1 (XI2066_I93_XG_n1 I2066_gn26 I2066_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I94_XG_MN2 (XI2066_I94_XG_n1 I2066_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I94_XG_MN0 (I2066_G28_27 I2066_pn28 XI2066_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I94_XG_MN1 (XI2066_I94_XG_n1 I2066_gn27 I2066_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I94_XG_MN2 (XI1988_I94_XG_n1 I1988_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I94_XG_MN0 (I1988_G28_27 I1988_pn28 XI1988_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I94_XG_MN1 (XI1988_I94_XG_n1 I1988_gn27 I1988_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I93_XG_MN2 (XI1988_I93_XG_n1 I1988_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I93_XG_MN0 (I1988_G27_26 I1988_pn27 XI1988_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I93_XG_MN1 (XI1988_I93_XG_n1 I1988_gn26 I1988_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I201_XG_MN2 (XI1942_I201_XG_n1 I1942_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I201_XG_MN0 (c30_m I1942_P30_15n XI1942_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I201_XG_MN1 (XI1942_I201_XG_n1 I1942_G14_0n c30_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I155_XG_MN2 (XI1942_I155_XG_n1 I1942_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I155_XG_MN0 (I1942_G30_23 I1942_P30_27n XI1942_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I155_XG_MN1 (XI1942_I155_XG_n1 I1942_G26_23n I1942_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I202_XG_MN2 (XI1942_I202_XG_n1 I1942_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I202_XG_MN0 (c30_o I1942_P31_16n XI1942_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I202_XG_MN1 (XI1942_I202_XG_n1 I1942_G15_0n c30_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I156_XG_MN2 (XI1942_I156_XG_n1 I1942_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I156_XG_MN0 (I1942_G31_24 I1942_P31_28n XI1942_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I156_XG_MN1 (XI1942_I156_XG_n1 I1942_G27_24n I1942_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I91_XG_MN2 (XI1942_I91_XG_n1 I1942_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I91_XG_MN0 (I1942_G25_24 I1942_pn25 XI1942_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I91_XG_MN1 (XI1942_I91_XG_n1 I1942_gn24 I1942_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I92_XG_MN2 (XI1942_I92_XG_n1 I1942_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I92_XG_MN0 (I1942_G26_25 I1942_pn26 XI1942_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I92_XG_MN1 (XI1942_I92_XG_n1 I1942_gn25 I1942_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I93_XG_MN2 (XI1942_I93_XG_n1 I1942_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I93_XG_MN0 (I1942_G27_26 I1942_pn27 XI1942_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I93_XG_MN1 (XI1942_I93_XG_n1 I1942_gn26 I1942_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I197_XG_MN2 (XI1896_I197_XG_n1 I1896_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I197_XG_MN0 (I1896_G26_0 I1896_P26_11n XI1896_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I197_XG_MN1 (XI1896_I197_XG_n1 I1896_G10_0n I1896_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I199_XG_MN2 (XI1896_I199_XG_n1 I1896_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I199_XG_MN0 (I1896_G28_0 I1896_P28_13n XI1896_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I199_XG_MN1 (XI1896_I199_XG_n1 I1896_G12_0n I1896_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I151_XG_MN2 (XI1896_I151_XG_n1 I1896_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I151_XG_MN0 (I1896_G26_19 I1896_P26_23n XI1896_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I151_XG_MN1 (XI1896_I151_XG_n1 I1896_G22_19n I1896_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I153_XG_MN2 (XI1896_I153_XG_n1 I1896_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I153_XG_MN0 (I1896_G28_21 I1896_P28_25n XI1896_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I153_XG_MN1 (XI1896_I153_XG_n1 I1896_G24_21n I1896_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I92_XG_MN2 (XI1896_I92_XG_n1 I1896_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I92_XG_MN0 (I1896_G26_25 I1896_pn26 XI1896_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I92_XG_MN1 (XI1896_I92_XG_n1 I1896_gn25 I1896_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I91_XG_MN2 (XI1896_I91_XG_n1 I1896_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I91_XG_MN0 (I1896_G25_24 I1896_pn25 XI1896_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I91_XG_MN1 (XI1896_I91_XG_n1 I1896_gn24 I1896_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I95_XG_MN2 (XI1896_I95_XG_n1 I1896_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I95_XG_MN0 (I1896_G29_28 I1896_pn29 XI1896_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I95_XG_MN1 (XI1896_I95_XG_n1 I1896_gn28 I1896_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I96_XG_MN2 (XI1896_I96_XG_n1 I1896_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I96_XG_MN0 (I1896_G30_29 I1896_pn30 XI1896_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I96_XG_MN1 (XI1896_I96_XG_n1 I1896_gn29 I1896_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I95_XG_MN2 (XI700_I95_XG_n1 I700_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I95_XG_MN0 (I700_G29_28 I700_pn29 XI700_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I95_XG_MN1 (XI700_I95_XG_n1 I700_gn28 I700_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I94_XG_MN2 (XI700_I94_XG_n1 I700_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I94_XG_MN0 (I700_G28_27 I700_pn28 XI700_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I94_XG_MN1 (XI700_I94_XG_n1 I700_gn27 I700_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I198_XG_MN2 (XI654_I198_XG_n1 I654_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I198_XG_MN0 (I654_G27_0 I654_P27_12n XI654_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I198_XG_MN1 (XI654_I198_XG_n1 I654_G11_0n I654_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I154_XG_MN2 (XI654_I154_XG_n1 I654_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I154_XG_MN0 (I654_G29_22 I654_P29_26n XI654_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I154_XG_MN1 (XI654_I154_XG_n1 I654_G25_22n I654_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I201_XG_MN2 (XI654_I201_XG_n1 I654_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I201_XG_MN0 (c2_m I654_P30_15n XI654_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I201_XG_MN1 (XI654_I201_XG_n1 I654_G14_0n c2_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I155_XG_MN2 (XI654_I155_XG_n1 I654_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I155_XG_MN0 (I654_G30_23 I654_P30_27n XI654_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I155_XG_MN1 (XI654_I155_XG_n1 I654_G26_23n I654_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I153_XG_MN2 (XI654_I153_XG_n1 I654_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I153_XG_MN0 (I654_G28_21 I654_P28_25n XI654_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I153_XG_MN1 (XI654_I153_XG_n1 I654_G24_21n I654_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I91_XG_MN2 (XI654_I91_XG_n1 I654_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I91_XG_MN0 (I654_G25_24 I654_pn25 XI654_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I91_XG_MN1 (XI654_I91_XG_n1 I654_gn24 I654_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I90_XG_MN2 (XI654_I90_XG_n1 I654_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I90_XG_MN0 (I654_G24_23 I654_pn24 XI654_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I90_XG_MN1 (XI654_I90_XG_n1 I654_gn23 I654_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I194_XG_MN2 (XI608_I194_XG_n1 I608_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I194_XG_MN0 (I608_G23_0 I608_P23_8n XI608_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I194_XG_MN1 (XI608_I194_XG_n1 I608_G7_0n I608_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I148_XG_MN2 (XI608_I148_XG_n1 I608_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I148_XG_MN0 (I608_G23_16 I608_P23_20n XI608_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I148_XG_MN1 (XI608_I148_XG_n1 I608_G19_16n I608_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I152_XG_MN2 (XI608_I152_XG_n1 I608_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I152_XG_MN0 (I608_G27_20 I608_P27_24n XI608_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I152_XG_MN1 (XI608_I152_XG_n1 I608_G23_20n I608_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I154_XG_MN2 (XI608_I154_XG_n1 I608_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I154_XG_MN0 (I608_G29_22 I608_P29_26n XI608_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I154_XG_MN1 (XI608_I154_XG_n1 I608_G25_22n I608_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I155_XG_MN2 (XI608_I155_XG_n1 I608_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I155_XG_MN0 (I608_G30_23 I608_P30_27n XI608_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I155_XG_MN1 (XI608_I155_XG_n1 I608_G26_23n I608_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I90_XG_MN2 (XI608_I90_XG_n1 I608_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I90_XG_MN0 (I608_G24_23 I608_pn24 XI608_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I90_XG_MN1 (XI608_I90_XG_n1 I608_gn23 I608_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I90_XG_MN2 (XI562_I90_XG_n1 I562_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I90_XG_MN0 (I562_G24_23 I562_pn24 XI562_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I90_XG_MN1 (XI562_I90_XG_n1 I562_gn23 I562_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I91_XG_MN2 (XI562_I91_XG_n1 I562_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I91_XG_MN0 (I562_G25_24 I562_pn25 XI562_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I91_XG_MN1 (XI562_I91_XG_n1 I562_gn24 I562_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I92_XG_MN2 (XI562_I92_XG_n1 I562_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I92_XG_MN0 (I562_G26_25 I562_pn26 XI562_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I92_XG_MN1 (XI562_I92_XG_n1 I562_gn25 I562_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I156_XG_MN2 (XI562_I156_XG_n1 I562_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I156_XG_MN0 (I562_G31_24 I562_P31_28n XI562_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I156_XG_MN1 (XI562_I156_XG_n1 I562_G27_24n I562_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I202_XG_MN2 (XI2066_I202_XG_n1 I2066_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I202_XG_MN0 (rco I2066_P31_16n XI2066_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I202_XG_MN1 (XI2066_I202_XG_n1 I2066_G15_0n rco VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I200_XG_MN2 (XI2066_I200_XG_n1 I2066_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I200_XG_MN0 (I2066_G29_0 I2066_P29_14n XI2066_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I200_XG_MN1 (XI2066_I200_XG_n1 I2066_G13_0n I2066_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I154_XG_MN2 (XI2066_I154_XG_n1 I2066_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I154_XG_MN0 (I2066_G29_22 I2066_P29_26n XI2066_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I154_XG_MN1 (XI2066_I154_XG_n1 I2066_G25_22n I2066_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I155_XG_MN2 (XI2066_I155_XG_n1 I2066_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I155_XG_MN0 (I2066_G30_23 I2066_P30_27n XI2066_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I155_XG_MN1 (XI2066_I155_XG_n1 I2066_G26_23n I2066_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I91_XG_MN2 (XI2066_I91_XG_n1 I2066_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I91_XG_MN0 (I2066_G25_24 I2066_pn25 XI2066_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I91_XG_MN1 (XI2066_I91_XG_n1 I2066_gn24 I2066_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I92_XG_MN2 (XI2066_I92_XG_n1 I2066_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I92_XG_MN0 (I2066_G26_25 I2066_pn26 XI2066_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I92_XG_MN1 (XI2066_I92_XG_n1 I2066_gn25 I2066_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I155_XG_MN2 (XI1988_I155_XG_n1 I1988_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I155_XG_MN0 (I1988_G30_23 I1988_P30_27n XI1988_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I155_XG_MN1 (XI1988_I155_XG_n1 I1988_G26_23n I1988_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I202_XG_MN2 (XI1988_I202_XG_n1 I1988_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I202_XG_MN0 (c31_o I1988_P31_16n XI1988_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I202_XG_MN1 (XI1988_I202_XG_n1 I1988_G15_0n c31_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I156_XG_MN2 (XI1988_I156_XG_n1 I1988_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I156_XG_MN0 (I1988_G31_24 I1988_P31_28n XI1988_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I156_XG_MN1 (XI1988_I156_XG_n1 I1988_G27_24n I1988_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I92_XG_MN2 (XI1988_I92_XG_n1 I1988_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I92_XG_MN0 (I1988_G26_25 I1988_pn26 XI1988_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I92_XG_MN1 (XI1988_I92_XG_n1 I1988_gn25 I1988_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I91_XG_MN2 (XI1988_I91_XG_n1 I1988_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I91_XG_MN0 (I1988_G25_24 I1988_pn25 XI1988_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I91_XG_MN1 (XI1988_I91_XG_n1 I1988_gn24 I1988_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I199_XG_MN2 (XI1942_I199_XG_n1 I1942_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I199_XG_MN0 (I1942_G28_0 I1942_P28_13n XI1942_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I199_XG_MN1 (XI1942_I199_XG_n1 I1942_G12_0n I1942_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I153_XG_MN2 (XI1942_I153_XG_n1 I1942_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I153_XG_MN0 (I1942_G28_21 I1942_P28_25n XI1942_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I153_XG_MN1 (XI1942_I153_XG_n1 I1942_G24_21n I1942_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I200_XG_MN2 (XI1942_I200_XG_n1 I1942_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I200_XG_MN0 (I1942_G29_0 I1942_P29_14n XI1942_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I200_XG_MN1 (XI1942_I200_XG_n1 I1942_G13_0n I1942_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I154_XG_MN2 (XI1942_I154_XG_n1 I1942_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I154_XG_MN0 (I1942_G29_22 I1942_P29_26n XI1942_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I154_XG_MN1 (XI1942_I154_XG_n1 I1942_G25_22n I1942_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I89_XG_MN2 (XI1942_I89_XG_n1 I1942_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I89_XG_MN0 (I1942_G23_22 I1942_pn23 XI1942_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I89_XG_MN1 (XI1942_I89_XG_n1 I1942_gn22 I1942_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I90_XG_MN2 (XI1942_I90_XG_n1 I1942_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I90_XG_MN0 (I1942_G24_23 I1942_pn24 XI1942_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I90_XG_MN1 (XI1942_I90_XG_n1 I1942_gn23 I1942_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I195_XG_MN2 (XI1896_I195_XG_n1 I1896_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I195_XG_MN0 (I1896_G24_0 I1896_P24_9n XI1896_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I195_XG_MN1 (XI1896_I195_XG_n1 I1896_G8_0n I1896_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I192_XG_MN2 (XI1896_I192_XG_n1 I1896_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I192_XG_MN0 (I1896_G22_0 I1896_P22_7n XI1896_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I192_XG_MN1 (XI1896_I192_XG_n1 I1896_G6_0n I1896_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I149_XG_MN2 (XI1896_I149_XG_n1 I1896_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I149_XG_MN0 (I1896_G24_17 I1896_P24_21n XI1896_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I149_XG_MN1 (XI1896_I149_XG_n1 I1896_G20_17n I1896_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I147_XG_MN2 (XI1896_I147_XG_n1 I1896_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I147_XG_MN0 (I1896_G22_15 I1896_P22_19n XI1896_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I147_XG_MN1 (XI1896_I147_XG_n1 I1896_G18_15n I1896_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I200_XG_MN2 (XI1896_I200_XG_n1 I1896_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I200_XG_MN0 (I1896_G29_0 I1896_P29_14n XI1896_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I200_XG_MN1 (XI1896_I200_XG_n1 I1896_G13_0n I1896_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I154_XG_MN2 (XI1896_I154_XG_n1 I1896_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I154_XG_MN0 (I1896_G29_22 I1896_P29_26n XI1896_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I154_XG_MN1 (XI1896_I154_XG_n1 I1896_G25_22n I1896_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I90_XG_MN2 (XI1896_I90_XG_n1 I1896_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I90_XG_MN0 (I1896_G24_23 I1896_pn24 XI1896_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I90_XG_MN1 (XI1896_I90_XG_n1 I1896_gn23 I1896_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I93_XG_MN2 (XI700_I93_XG_n1 I700_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I93_XG_MN0 (I700_G27_26 I700_pn27 XI700_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I93_XG_MN1 (XI700_I93_XG_n1 I700_gn26 I700_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I194_XG_MN2 (XI654_I194_XG_n1 I654_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I194_XG_MN0 (I654_G23_0 I654_P23_8n XI654_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I194_XG_MN1 (XI654_I194_XG_n1 I654_G7_0n I654_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I148_XG_MN2 (XI654_I148_XG_n1 I654_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I148_XG_MN0 (I654_G23_16 I654_P23_20n XI654_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I148_XG_MN1 (XI654_I148_XG_n1 I654_G19_16n I654_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I200_XG_MN2 (XI654_I200_XG_n1 I654_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I200_XG_MN0 (I654_G29_0 I654_P29_14n XI654_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I200_XG_MN1 (XI654_I200_XG_n1 I654_G13_0n I654_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I199_XG_MN2 (XI654_I199_XG_n1 I654_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I199_XG_MN0 (I654_G28_0 I654_P28_13n XI654_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I199_XG_MN1 (XI654_I199_XG_n1 I654_G12_0n I654_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I151_XG_MN2 (XI654_I151_XG_n1 I654_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I151_XG_MN0 (I654_G26_19 I654_P26_23n XI654_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I151_XG_MN1 (XI654_I151_XG_n1 I654_G22_19n I654_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I88_XG_MN2 (XI654_I88_XG_n1 I654_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I88_XG_MN0 (I654_G22_21 I654_pn22 XI654_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I88_XG_MN1 (XI654_I88_XG_n1 I654_gn21 I654_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I89_XG_MN2 (XI654_I89_XG_n1 I654_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I89_XG_MN0 (I654_G23_22 I654_pn23 XI654_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I89_XG_MN1 (XI654_I89_XG_n1 I654_gn22 I654_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I200_XG_MN2 (XI608_I200_XG_n1 I608_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I200_XG_MN0 (I608_G29_0 I608_P29_14n XI608_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I200_XG_MN1 (XI608_I200_XG_n1 I608_G13_0n I608_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I201_XG_MN2 (XI608_I201_XG_n1 I608_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I201_XG_MN0 (c1_m I608_P30_15n XI608_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I201_XG_MN1 (XI608_I201_XG_n1 I608_G14_0n c1_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I153_XG_MN2 (XI608_I153_XG_n1 I608_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I153_XG_MN0 (I608_G28_21 I608_P28_25n XI608_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I153_XG_MN1 (XI608_I153_XG_n1 I608_G24_21n I608_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I89_XG_MN2 (XI608_I89_XG_n1 I608_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I89_XG_MN0 (I608_G23_22 I608_pn23 XI608_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I89_XG_MN1 (XI608_I89_XG_n1 I608_gn22 I608_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I88_XG_MN2 (XI608_I88_XG_n1 I608_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I88_XG_MN0 (I608_G22_21 I608_pn22 XI608_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I88_XG_MN1 (XI608_I88_XG_n1 I608_gn21 I608_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I89_XG_MN2 (XI562_I89_XG_n1 I562_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I89_XG_MN0 (I562_G23_22 I562_pn23 XI562_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I89_XG_MN1 (XI562_I89_XG_n1 I562_gn22 I562_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I155_XG_MN2 (XI562_I155_XG_n1 I562_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I155_XG_MN0 (I562_G30_23 I562_P30_27n XI562_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I155_XG_MN1 (XI562_I155_XG_n1 I562_G26_23n I562_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I154_XG_MN2 (XI562_I154_XG_n1 I562_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I154_XG_MN0 (I562_G29_22 I562_P29_26n XI562_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I154_XG_MN1 (XI562_I154_XG_n1 I562_G25_22n I562_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I194_XG_MN2 (XI2066_I194_XG_n1 I2066_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I194_XG_MN0 (I2066_G23_0 I2066_P23_8n XI2066_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I194_XG_MN1 (XI2066_I194_XG_n1 I2066_G7_0n I2066_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I148_XG_MN2 (XI2066_I148_XG_n1 I2066_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I148_XG_MN0 (I2066_G23_16 I2066_P23_20n XI2066_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I148_XG_MN1 (XI2066_I148_XG_n1 I2066_G19_16n I2066_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I152_XG_MN2 (XI2066_I152_XG_n1 I2066_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I152_XG_MN0 (I2066_G27_20 I2066_P27_24n XI2066_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I152_XG_MN1 (XI2066_I152_XG_n1 I2066_G23_20n I2066_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I201_XG_MN2 (XI2066_I201_XG_n1 I2066_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I201_XG_MN0 (rcm I2066_P30_15n XI2066_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I201_XG_MN1 (XI2066_I201_XG_n1 I2066_G14_0n rcm VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I90_XG_MN2 (XI2066_I90_XG_n1 I2066_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I90_XG_MN0 (I2066_G24_23 I2066_pn24 XI2066_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I90_XG_MN1 (XI2066_I90_XG_n1 I2066_gn23 I2066_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I89_XG_MN2 (XI2066_I89_XG_n1 I2066_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I89_XG_MN0 (I2066_G23_22 I2066_pn23 XI2066_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I89_XG_MN1 (XI2066_I89_XG_n1 I2066_gn22 I2066_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I201_XG_MN2 (XI1988_I201_XG_n1 I1988_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I201_XG_MN0 (c31_m I1988_P30_15n XI1988_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I201_XG_MN1 (XI1988_I201_XG_n1 I1988_G14_0n c31_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I200_XG_MN2 (XI1988_I200_XG_n1 I1988_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I200_XG_MN0 (I1988_G29_0 I1988_P29_14n XI1988_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I200_XG_MN1 (XI1988_I200_XG_n1 I1988_G13_0n I1988_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I154_XG_MN2 (XI1988_I154_XG_n1 I1988_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I154_XG_MN0 (I1988_G29_22 I1988_P29_26n XI1988_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I154_XG_MN1 (XI1988_I154_XG_n1 I1988_G25_22n I1988_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I89_XG_MN2 (XI1988_I89_XG_n1 I1988_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I89_XG_MN0 (I1988_G23_22 I1988_pn23 XI1988_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I89_XG_MN1 (XI1988_I89_XG_n1 I1988_gn22 I1988_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I90_XG_MN2 (XI1988_I90_XG_n1 I1988_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I90_XG_MN0 (I1988_G24_23 I1988_pn24 XI1988_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I90_XG_MN1 (XI1988_I90_XG_n1 I1988_gn23 I1988_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I197_XG_MN2 (XI1942_I197_XG_n1 I1942_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I197_XG_MN0 (I1942_G26_0 I1942_P26_11n XI1942_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I197_XG_MN1 (XI1942_I197_XG_n1 I1942_G10_0n I1942_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I192_XG_MN2 (XI1942_I192_XG_n1 I1942_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I192_XG_MN0 (I1942_G22_0 I1942_P22_7n XI1942_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I192_XG_MN1 (XI1942_I192_XG_n1 I1942_G6_0n I1942_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I147_XG_MN2 (XI1942_I147_XG_n1 I1942_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I147_XG_MN0 (I1942_G22_15 I1942_P22_19n XI1942_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I147_XG_MN1 (XI1942_I147_XG_n1 I1942_G18_15n I1942_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I151_XG_MN2 (XI1942_I151_XG_n1 I1942_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I151_XG_MN0 (I1942_G26_19 I1942_P26_23n XI1942_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I151_XG_MN1 (XI1942_I151_XG_n1 I1942_G22_19n I1942_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I198_XG_MN2 (XI1942_I198_XG_n1 I1942_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I198_XG_MN0 (I1942_G27_0 I1942_P27_12n XI1942_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I198_XG_MN1 (XI1942_I198_XG_n1 I1942_G11_0n I1942_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I194_XG_MN2 (XI1942_I194_XG_n1 I1942_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I194_XG_MN0 (I1942_G23_0 I1942_P23_8n XI1942_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I194_XG_MN1 (XI1942_I194_XG_n1 I1942_G7_0n I1942_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I152_XG_MN2 (XI1942_I152_XG_n1 I1942_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I152_XG_MN0 (I1942_G27_20 I1942_P27_24n XI1942_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I152_XG_MN1 (XI1942_I152_XG_n1 I1942_G23_20n I1942_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I148_XG_MN2 (XI1942_I148_XG_n1 I1942_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I148_XG_MN0 (I1942_G23_16 I1942_P23_20n XI1942_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I148_XG_MN1 (XI1942_I148_XG_n1 I1942_G19_16n I1942_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I88_XG_MN2 (XI1942_I88_XG_n1 I1942_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I88_XG_MN0 (I1942_G22_21 I1942_pn22 XI1942_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I88_XG_MN1 (XI1942_I88_XG_n1 I1942_gn21 I1942_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I188_XG_MN2 (XI1896_I188_XG_n1 I1896_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I188_XG_MN0 (I1896_G20_0 I1896_P20_5n XI1896_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I188_XG_MN1 (XI1896_I188_XG_n1 I1896_G4_0n I1896_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I196_XG_MN2 (XI1896_I196_XG_n1 I1896_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I196_XG_MN0 (I1896_G25_0 I1896_P25_10n XI1896_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I196_XG_MN1 (XI1896_I196_XG_n1 I1896_G9_0n I1896_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I145_XG_MN2 (XI1896_I145_XG_n1 I1896_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I145_XG_MN0 (I1896_G20_13 I1896_P20_17n XI1896_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I145_XG_MN1 (XI1896_I145_XG_n1 I1896_G16_13n I1896_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I150_XG_MN2 (XI1896_I150_XG_n1 I1896_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I150_XG_MN0 (I1896_G25_18 I1896_P25_22n XI1896_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I150_XG_MN1 (XI1896_I150_XG_n1 I1896_G21_18n I1896_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I87_XG_MN2 (XI1896_I87_XG_n1 I1896_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I87_XG_MN0 (I1896_G21_20 I1896_pn21 XI1896_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I87_XG_MN1 (XI1896_I87_XG_n1 I1896_gn20 I1896_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I88_XG_MN2 (XI1896_I88_XG_n1 I1896_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I88_XG_MN0 (I1896_G22_21 I1896_pn22 XI1896_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I88_XG_MN1 (XI1896_I88_XG_n1 I1896_gn21 I1896_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I89_XG_MN2 (XI1896_I89_XG_n1 I1896_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I89_XG_MN0 (I1896_G23_22 I1896_pn23 XI1896_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I89_XG_MN1 (XI1896_I89_XG_n1 I1896_gn22 I1896_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I97_XG_MN2 (XI1896_I97_XG_n1 I1896_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I97_XG_MN0 (I1896_G31_30 I1896_pn31 XI1896_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I97_XG_MN1 (XI1896_I97_XG_n1 I1896_gn30 I1896_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I92_XG_MN2 (XI700_I92_XG_n1 I700_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I92_XG_MN0 (I700_G26_25 I700_pn26 XI700_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I92_XG_MN1 (XI700_I92_XG_n1 I700_gn25 I700_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I91_XG_MN2 (XI700_I91_XG_n1 I700_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I91_XG_MN0 (I700_G25_24 I700_pn25 XI700_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I91_XG_MN1 (XI700_I91_XG_n1 I700_gn24 I700_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I90_XG_MN2 (XI700_I90_XG_n1 I700_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I90_XG_MN0 (I700_G24_23 I700_pn24 XI700_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I90_XG_MN1 (XI700_I90_XG_n1 I700_gn23 I700_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I144_XG_MN2 (XI654_I144_XG_n1 I654_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I144_XG_MN0 (I654_G19_12 I654_P19_16n XI654_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I144_XG_MN1 (XI654_I144_XG_n1 I654_G15_12n I654_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I150_XG_MN2 (XI654_I150_XG_n1 I654_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I150_XG_MN0 (I654_G25_18 I654_P25_22n XI654_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I150_XG_MN1 (XI654_I150_XG_n1 I654_G21_18n I654_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I146_XG_MN2 (XI654_I146_XG_n1 I654_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I146_XG_MN0 (I654_G21_14 I654_P21_18n XI654_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I146_XG_MN1 (XI654_I146_XG_n1 I654_G17_14n I654_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I192_XG_MN2 (XI654_I192_XG_n1 I654_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I192_XG_MN0 (I654_G22_0 I654_P22_7n XI654_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I192_XG_MN1 (XI654_I192_XG_n1 I654_G6_0n I654_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I147_XG_MN2 (XI654_I147_XG_n1 I654_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I147_XG_MN0 (I654_G22_15 I654_P22_19n XI654_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I147_XG_MN1 (XI654_I147_XG_n1 I654_G18_15n I654_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I86_XG_MN2 (XI654_I86_XG_n1 I654_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I86_XG_MN0 (I654_G20_19 I654_pn20 XI654_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I86_XG_MN1 (XI654_I86_XG_n1 I654_gn19 I654_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I87_XG_MN2 (XI654_I87_XG_n1 I654_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I87_XG_MN0 (I654_G21_20 I654_pn21 XI654_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I87_XG_MN1 (XI654_I87_XG_n1 I654_gn20 I654_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I190_XG_MN2 (XI608_I190_XG_n1 I608_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I190_XG_MN0 (I608_G21_0 I608_P21_6n XI608_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I190_XG_MN1 (XI608_I190_XG_n1 I608_G5_0n I608_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I146_XG_MN2 (XI608_I146_XG_n1 I608_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I146_XG_MN0 (I608_G21_14 I608_P21_18n XI608_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I146_XG_MN1 (XI608_I146_XG_n1 I608_G17_14n I608_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I150_XG_MN2 (XI608_I150_XG_n1 I608_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I150_XG_MN0 (I608_G25_18 I608_P25_22n XI608_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I150_XG_MN1 (XI608_I150_XG_n1 I608_G21_18n I608_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I199_XG_MN2 (XI608_I199_XG_n1 I608_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I199_XG_MN0 (I608_G28_0 I608_P28_13n XI608_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I199_XG_MN1 (XI608_I199_XG_n1 I608_G12_0n I608_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I151_XG_MN2 (XI608_I151_XG_n1 I608_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I151_XG_MN0 (I608_G26_19 I608_P26_23n XI608_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I151_XG_MN1 (XI608_I151_XG_n1 I608_G22_19n I608_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I147_XG_MN2 (XI608_I147_XG_n1 I608_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I147_XG_MN0 (I608_G22_15 I608_P22_19n XI608_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I147_XG_MN1 (XI608_I147_XG_n1 I608_G18_15n I608_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I86_XG_MN2 (XI608_I86_XG_n1 I608_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I86_XG_MN0 (I608_G20_19 I608_pn20 XI608_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I86_XG_MN1 (XI608_I86_XG_n1 I608_gn19 I608_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I87_XG_MN2 (XI608_I87_XG_n1 I608_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I87_XG_MN0 (I608_G21_20 I608_pn21 XI608_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I87_XG_MN1 (XI608_I87_XG_n1 I608_gn20 I608_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I87_XG_MN2 (XI562_I87_XG_n1 I562_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I87_XG_MN0 (I562_G21_20 I562_pn21 XI562_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I87_XG_MN1 (XI562_I87_XG_n1 I562_gn20 I562_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I88_XG_MN2 (XI562_I88_XG_n1 I562_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I88_XG_MN0 (I562_G22_21 I562_pn22 XI562_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I88_XG_MN1 (XI562_I88_XG_n1 I562_gn21 I562_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I201_XG_MN2 (XI562_I201_XG_n1 I562_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I201_XG_MN0 (c0_m I562_P30_15n XI562_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I201_XG_MN1 (XI562_I201_XG_n1 I562_G14_0n c0_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I200_XG_MN2 (XI562_I200_XG_n1 I562_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I200_XG_MN0 (I562_G29_0 I562_P29_14n XI562_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I200_XG_MN1 (XI562_I200_XG_n1 I562_G13_0n I562_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I150_XG_MN2 (XI562_I150_XG_n1 I562_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I150_XG_MN0 (I562_G25_18 I562_P25_22n XI562_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I150_XG_MN1 (XI562_I150_XG_n1 I562_G21_18n I562_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I148_XG_MN2 (XI562_I148_XG_n1 I562_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I148_XG_MN0 (I562_G23_16 I562_P23_20n XI562_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I148_XG_MN1 (XI562_I148_XG_n1 I562_G19_16n I562_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I152_XG_MN2 (XI562_I152_XG_n1 I562_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I152_XG_MN0 (I562_G27_20 I562_P27_24n XI562_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I152_XG_MN1 (XI562_I152_XG_n1 I562_G23_20n I562_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I202_XG_MN2 (XI562_I202_XG_n1 I562_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I202_XG_MN0 (c0_o I562_P31_16n XI562_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I202_XG_MN1 (XI562_I202_XG_n1 I562_G15_0n c0_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I194_XG_MN2 (XI562_I194_XG_n1 I562_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I194_XG_MN0 (I562_G23_0 I562_P23_8n XI562_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I194_XG_MN1 (XI562_I194_XG_n1 I562_G7_0n I562_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I198_XG_MN2 (XI2066_I198_XG_n1 I2066_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I198_XG_MN0 (I2066_G27_0 I2066_P27_12n XI2066_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I198_XG_MN1 (XI2066_I198_XG_n1 I2066_G11_0n I2066_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I150_XG_MN2 (XI2066_I150_XG_n1 I2066_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I150_XG_MN0 (I2066_G25_18 I2066_P25_22n XI2066_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I150_XG_MN1 (XI2066_I150_XG_n1 I2066_G21_18n I2066_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I192_XG_MN2 (XI2066_I192_XG_n1 I2066_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I192_XG_MN0 (I2066_G22_0 I2066_P22_7n XI2066_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I192_XG_MN1 (XI2066_I192_XG_n1 I2066_G6_0n I2066_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I151_XG_MN2 (XI2066_I151_XG_n1 I2066_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I151_XG_MN0 (I2066_G26_19 I2066_P26_23n XI2066_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I151_XG_MN1 (XI2066_I151_XG_n1 I2066_G22_19n I2066_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I153_XG_MN2 (XI2066_I153_XG_n1 I2066_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I153_XG_MN0 (I2066_G28_21 I2066_P28_25n XI2066_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I153_XG_MN1 (XI2066_I153_XG_n1 I2066_G24_21n I2066_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I88_XG_MN2 (XI2066_I88_XG_n1 I2066_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I88_XG_MN0 (I2066_G22_21 I2066_pn22 XI2066_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I88_XG_MN1 (XI2066_I88_XG_n1 I2066_gn21 I2066_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I87_XG_MN2 (XI2066_I87_XG_n1 I2066_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I87_XG_MN0 (I2066_G21_20 I2066_pn21 XI2066_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I87_XG_MN1 (XI2066_I87_XG_n1 I2066_gn20 I2066_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I199_XG_MN2 (XI1988_I199_XG_n1 I1988_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I199_XG_MN0 (I1988_G28_0 I1988_P28_13n XI1988_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I199_XG_MN1 (XI1988_I199_XG_n1 I1988_G12_0n I1988_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I151_XG_MN2 (XI1988_I151_XG_n1 I1988_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I151_XG_MN0 (I1988_G26_19 I1988_P26_23n XI1988_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I151_XG_MN1 (XI1988_I151_XG_n1 I1988_G22_19n I1988_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I153_XG_MN2 (XI1988_I153_XG_n1 I1988_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I153_XG_MN0 (I1988_G28_21 I1988_P28_25n XI1988_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I153_XG_MN1 (XI1988_I153_XG_n1 I1988_G24_21n I1988_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I194_XG_MN2 (XI1988_I194_XG_n1 I1988_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I194_XG_MN0 (I1988_G23_0 I1988_P23_8n XI1988_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I194_XG_MN1 (XI1988_I194_XG_n1 I1988_G7_0n I1988_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I152_XG_MN2 (XI1988_I152_XG_n1 I1988_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I152_XG_MN0 (I1988_G27_20 I1988_P27_24n XI1988_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I152_XG_MN1 (XI1988_I152_XG_n1 I1988_G23_20n I1988_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I148_XG_MN2 (XI1988_I148_XG_n1 I1988_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I148_XG_MN0 (I1988_G23_16 I1988_P23_20n XI1988_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I148_XG_MN1 (XI1988_I148_XG_n1 I1988_G19_16n I1988_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I87_XG_MN2 (XI1988_I87_XG_n1 I1988_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I87_XG_MN0 (I1988_G21_20 I1988_pn21 XI1988_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I87_XG_MN1 (XI1988_I87_XG_n1 I1988_gn20 I1988_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I88_XG_MN2 (XI1988_I88_XG_n1 I1988_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I88_XG_MN0 (I1988_G22_21 I1988_pn22 XI1988_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I88_XG_MN1 (XI1988_I88_XG_n1 I1988_gn21 I1988_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I149_XG_MN2 (XI1942_I149_XG_n1 I1942_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I149_XG_MN0 (I1942_G24_17 I1942_P24_21n XI1942_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I149_XG_MN1 (XI1942_I149_XG_n1 I1942_G20_17n I1942_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I196_XG_MN2 (XI1942_I196_XG_n1 I1942_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I196_XG_MN0 (I1942_G25_0 I1942_P25_10n XI1942_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I196_XG_MN1 (XI1942_I196_XG_n1 I1942_G9_0n I1942_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I150_XG_MN2 (XI1942_I150_XG_n1 I1942_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I150_XG_MN0 (I1942_G25_18 I1942_P25_22n XI1942_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I150_XG_MN1 (XI1942_I150_XG_n1 I1942_G21_18n I1942_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I86_XG_MN2 (XI1942_I86_XG_n1 I1942_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I86_XG_MN0 (I1942_G20_19 I1942_pn20 XI1942_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I86_XG_MN1 (XI1942_I86_XG_n1 I1942_gn19 I1942_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I87_XG_MN2 (XI1942_I87_XG_n1 I1942_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I87_XG_MN0 (I1942_G21_20 I1942_pn21 XI1942_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I87_XG_MN1 (XI1942_I87_XG_n1 I1942_gn20 I1942_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I185_XG_MN2 (XI1896_I185_XG_n1 I1896_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I185_XG_MN0 (I1896_G18_0 I1896_P18_3n XI1896_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I185_XG_MN1 (XI1896_I185_XG_n1 I1896_G2_0n I1896_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I139_XG_MN2 (XI1896_I139_XG_n1 I1896_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I139_XG_MN0 (I1896_G14_7 I1896_P14_11n XI1896_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I139_XG_MN1 (XI1896_I139_XG_n1 I1896_G10_7n I1896_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I143_XG_MN2 (XI1896_I143_XG_n1 I1896_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I143_XG_MN0 (I1896_G18_11 I1896_P18_15n XI1896_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I143_XG_MN1 (XI1896_I143_XG_n1 I1896_G14_11n I1896_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I190_XG_MN2 (XI1896_I190_XG_n1 I1896_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I190_XG_MN0 (I1896_G21_0 I1896_P21_6n XI1896_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I190_XG_MN1 (XI1896_I190_XG_n1 I1896_G5_0n I1896_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I84_XG_MN2 (XI1896_I84_XG_n1 I1896_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I84_XG_MN0 (I1896_G18_17 I1896_pn18 XI1896_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I84_XG_MN1 (XI1896_I84_XG_n1 I1896_gn17 I1896_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I85_XG_MN2 (XI1896_I85_XG_n1 I1896_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I85_XG_MN0 (I1896_G19_18 I1896_pn19 XI1896_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I85_XG_MN1 (XI1896_I85_XG_n1 I1896_gn18 I1896_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I146_XG_MN2 (XI1896_I146_XG_n1 I1896_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I146_XG_MN0 (I1896_G21_14 I1896_P21_18n XI1896_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I146_XG_MN1 (XI1896_I146_XG_n1 I1896_G17_14n I1896_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I86_XG_MN2 (XI1896_I86_XG_n1 I1896_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I86_XG_MN0 (I1896_G20_19 I1896_pn20 XI1896_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I86_XG_MN1 (XI1896_I86_XG_n1 I1896_gn19 I1896_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I152_XG_MN2 (XI1896_I152_XG_n1 I1896_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I152_XG_MN0 (I1896_G27_20 I1896_P27_24n XI1896_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I152_XG_MN1 (XI1896_I152_XG_n1 I1896_G23_20n I1896_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I156_XG_MN2 (XI1896_I156_XG_n1 I1896_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I156_XG_MN0 (I1896_G31_24 I1896_P31_28n XI1896_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I156_XG_MN1 (XI1896_I156_XG_n1 I1896_G27_24n I1896_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I156_XG_MN2 (XI700_I156_XG_n1 I700_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I156_XG_MN0 (I700_G31_24 I700_P31_28n XI700_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I156_XG_MN1 (XI700_I156_XG_n1 I700_G27_24n I700_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I89_XG_MN2 (XI700_I89_XG_n1 I700_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I89_XG_MN0 (I700_G23_22 I700_pn23 XI700_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I89_XG_MN1 (XI700_I89_XG_n1 I700_gn22 I700_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I88_XG_MN2 (XI700_I88_XG_n1 I700_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I88_XG_MN0 (I700_G22_21 I700_pn22 XI700_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I88_XG_MN1 (XI700_I88_XG_n1 I700_gn21 I700_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I87_XG_MN2 (XI700_I87_XG_n1 I700_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I87_XG_MN0 (I700_G21_20 I700_pn21 XI700_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I87_XG_MN1 (XI700_I87_XG_n1 I700_gn20 I700_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I186_XG_MN2 (XI654_I186_XG_n1 I654_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I186_XG_MN0 (I654_G19_0 I654_P19_4n XI654_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I186_XG_MN1 (XI654_I186_XG_n1 I654_G3_0n I654_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I190_XG_MN2 (XI654_I190_XG_n1 I654_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I190_XG_MN0 (I654_G21_0 I654_P21_6n XI654_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I190_XG_MN1 (XI654_I190_XG_n1 I654_G5_0n I654_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I196_XG_MN2 (XI654_I196_XG_n1 I654_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I196_XG_MN0 (I654_G25_0 I654_P25_10n XI654_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I196_XG_MN1 (XI654_I196_XG_n1 I654_G9_0n I654_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I197_XG_MN2 (XI654_I197_XG_n1 I654_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I197_XG_MN0 (I654_G26_0 I654_P26_11n XI654_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I197_XG_MN1 (XI654_I197_XG_n1 I654_G10_0n I654_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I195_XG_MN2 (XI654_I195_XG_n1 I654_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I195_XG_MN0 (I654_G24_0 I654_P24_9n XI654_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I195_XG_MN1 (XI654_I195_XG_n1 I654_G8_0n I654_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I149_XG_MN2 (XI654_I149_XG_n1 I654_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I149_XG_MN0 (I654_G24_17 I654_P24_21n XI654_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I149_XG_MN1 (XI654_I149_XG_n1 I654_G20_17n I654_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I85_XG_MN2 (XI654_I85_XG_n1 I654_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I85_XG_MN0 (I654_G19_18 I654_pn19 XI654_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I85_XG_MN1 (XI654_I85_XG_n1 I654_gn18 I654_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I84_XG_MN2 (XI654_I84_XG_n1 I654_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I84_XG_MN0 (I654_G18_17 I654_pn18 XI654_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I84_XG_MN1 (XI654_I84_XG_n1 I654_gn17 I654_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I196_XG_MN2 (XI608_I196_XG_n1 I608_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I196_XG_MN0 (I608_G25_0 I608_P25_10n XI608_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I196_XG_MN1 (XI608_I196_XG_n1 I608_G9_0n I608_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I192_XG_MN2 (XI608_I192_XG_n1 I608_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I192_XG_MN0 (I608_G22_0 I608_P22_7n XI608_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I192_XG_MN1 (XI608_I192_XG_n1 I608_G6_0n I608_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I197_XG_MN2 (XI608_I197_XG_n1 I608_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I197_XG_MN0 (I608_G26_0 I608_P26_11n XI608_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I197_XG_MN1 (XI608_I197_XG_n1 I608_G10_0n I608_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I149_XG_MN2 (XI608_I149_XG_n1 I608_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I149_XG_MN0 (I608_G24_17 I608_P24_21n XI608_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I149_XG_MN1 (XI608_I149_XG_n1 I608_G20_17n I608_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I85_XG_MN2 (XI608_I85_XG_n1 I608_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I85_XG_MN0 (I608_G19_18 I608_pn19 XI608_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I85_XG_MN1 (XI608_I85_XG_n1 I608_gn18 I608_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I85_XG_MN2 (XI562_I85_XG_n1 I562_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I85_XG_MN0 (I562_G19_18 I562_pn19 XI562_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I85_XG_MN1 (XI562_I85_XG_n1 I562_gn18 I562_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I86_XG_MN2 (XI562_I86_XG_n1 I562_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I86_XG_MN0 (I562_G20_19 I562_pn20 XI562_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I86_XG_MN1 (XI562_I86_XG_n1 I562_gn19 I562_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I192_XG_MN2 (XI562_I192_XG_n1 I562_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I192_XG_MN0 (I562_G22_0 I562_P22_7n XI562_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I192_XG_MN1 (XI562_I192_XG_n1 I562_G6_0n I562_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I153_XG_MN2 (XI562_I153_XG_n1 I562_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I153_XG_MN0 (I562_G28_21 I562_P28_25n XI562_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I153_XG_MN1 (XI562_I153_XG_n1 I562_G24_21n I562_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I147_XG_MN2 (XI562_I147_XG_n1 I562_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I147_XG_MN0 (I562_G22_15 I562_P22_19n XI562_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I147_XG_MN1 (XI562_I147_XG_n1 I562_G18_15n I562_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I151_XG_MN2 (XI562_I151_XG_n1 I562_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I151_XG_MN0 (I562_G26_19 I562_P26_23n XI562_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I151_XG_MN1 (XI562_I151_XG_n1 I562_G22_19n I562_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I190_XG_MN2 (XI562_I190_XG_n1 I562_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I190_XG_MN0 (I562_G21_0 I562_P21_6n XI562_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I190_XG_MN1 (XI562_I190_XG_n1 I562_G5_0n I562_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I146_XG_MN2 (XI562_I146_XG_n1 I562_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I146_XG_MN0 (I562_G21_14 I562_P21_18n XI562_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I146_XG_MN1 (XI562_I146_XG_n1 I562_G17_14n I562_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I198_XG_MN2 (XI562_I198_XG_n1 I562_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I198_XG_MN0 (I562_G27_0 I562_P27_12n XI562_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I198_XG_MN1 (XI562_I198_XG_n1 I562_G11_0n I562_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I190_XG_MN2 (XI2066_I190_XG_n1 I2066_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I190_XG_MN0 (I2066_G21_0 I2066_P21_6n XI2066_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I190_XG_MN1 (XI2066_I190_XG_n1 I2066_G5_0n I2066_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I146_XG_MN2 (XI2066_I146_XG_n1 I2066_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I146_XG_MN0 (I2066_G21_14 I2066_P21_18n XI2066_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I146_XG_MN1 (XI2066_I146_XG_n1 I2066_G17_14n I2066_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I197_XG_MN2 (XI2066_I197_XG_n1 I2066_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I197_XG_MN0 (I2066_G26_0 I2066_P26_11n XI2066_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I197_XG_MN1 (XI2066_I197_XG_n1 I2066_G10_0n I2066_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I199_XG_MN2 (XI2066_I199_XG_n1 I2066_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I199_XG_MN0 (I2066_G28_0 I2066_P28_13n XI2066_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I199_XG_MN1 (XI2066_I199_XG_n1 I2066_G12_0n I2066_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I149_XG_MN2 (XI2066_I149_XG_n1 I2066_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I149_XG_MN0 (I2066_G24_17 I2066_P24_21n XI2066_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I149_XG_MN1 (XI2066_I149_XG_n1 I2066_G20_17n I2066_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I147_XG_MN2 (XI2066_I147_XG_n1 I2066_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I147_XG_MN0 (I2066_G22_15 I2066_P22_19n XI2066_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I147_XG_MN1 (XI2066_I147_XG_n1 I2066_G18_15n I2066_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I86_XG_MN2 (XI2066_I86_XG_n1 I2066_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I86_XG_MN0 (I2066_G20_19 I2066_pn20 XI2066_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I86_XG_MN1 (XI2066_I86_XG_n1 I2066_gn19 I2066_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I85_XG_MN2 (XI2066_I85_XG_n1 I2066_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I85_XG_MN0 (I2066_G19_18 I2066_pn19 XI2066_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I85_XG_MN1 (XI2066_I85_XG_n1 I2066_gn18 I2066_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I197_XG_MN2 (XI1988_I197_XG_n1 I1988_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I197_XG_MN0 (I1988_G26_0 I1988_P26_11n XI1988_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I197_XG_MN1 (XI1988_I197_XG_n1 I1988_G10_0n I1988_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I147_XG_MN2 (XI1988_I147_XG_n1 I1988_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I147_XG_MN0 (I1988_G22_15 I1988_P22_19n XI1988_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I147_XG_MN1 (XI1988_I147_XG_n1 I1988_G18_15n I1988_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I198_XG_MN2 (XI1988_I198_XG_n1 I1988_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I198_XG_MN0 (I1988_G27_0 I1988_P27_12n XI1988_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I198_XG_MN1 (XI1988_I198_XG_n1 I1988_G11_0n I1988_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I150_XG_MN2 (XI1988_I150_XG_n1 I1988_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I150_XG_MN0 (I1988_G25_18 I1988_P25_22n XI1988_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I150_XG_MN1 (XI1988_I150_XG_n1 I1988_G21_18n I1988_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I146_XG_MN2 (XI1988_I146_XG_n1 I1988_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I146_XG_MN0 (I1988_G21_14 I1988_P21_18n XI1988_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I146_XG_MN1 (XI1988_I146_XG_n1 I1988_G17_14n I1988_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I86_XG_MN2 (XI1988_I86_XG_n1 I1988_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I86_XG_MN0 (I1988_G20_19 I1988_pn20 XI1988_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I86_XG_MN1 (XI1988_I86_XG_n1 I1988_gn19 I1988_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I85_XG_MN2 (XI1988_I85_XG_n1 I1988_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I85_XG_MN0 (I1988_G19_18 I1988_pn19 XI1988_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I85_XG_MN1 (XI1988_I85_XG_n1 I1988_gn18 I1988_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I188_XG_MN2 (XI1942_I188_XG_n1 I1942_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I188_XG_MN0 (I1942_G20_0 I1942_P20_5n XI1942_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I188_XG_MN1 (XI1942_I188_XG_n1 I1942_G4_0n I1942_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I195_XG_MN2 (XI1942_I195_XG_n1 I1942_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I195_XG_MN0 (I1942_G24_0 I1942_P24_9n XI1942_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I195_XG_MN1 (XI1942_I195_XG_n1 I1942_G8_0n I1942_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I145_XG_MN2 (XI1942_I145_XG_n1 I1942_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I145_XG_MN0 (I1942_G20_13 I1942_P20_17n XI1942_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I145_XG_MN1 (XI1942_I145_XG_n1 I1942_G16_13n I1942_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I190_XG_MN2 (XI1942_I190_XG_n1 I1942_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I190_XG_MN0 (I1942_G21_0 I1942_P21_6n XI1942_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I190_XG_MN1 (XI1942_I190_XG_n1 I1942_G5_0n I1942_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I144_XG_MN2 (XI1942_I144_XG_n1 I1942_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I144_XG_MN0 (I1942_G19_12 I1942_P19_16n XI1942_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I144_XG_MN1 (XI1942_I144_XG_n1 I1942_G15_12n I1942_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I146_XG_MN2 (XI1942_I146_XG_n1 I1942_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I146_XG_MN0 (I1942_G21_14 I1942_P21_18n XI1942_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I146_XG_MN1 (XI1942_I146_XG_n1 I1942_G17_14n I1942_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I85_XG_MN2 (XI1942_I85_XG_n1 I1942_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I85_XG_MN0 (I1942_G19_18 I1942_pn19 XI1942_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I85_XG_MN1 (XI1942_I85_XG_n1 I1942_gn18 I1942_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I84_XG_MN2 (XI1942_I84_XG_n1 I1942_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I84_XG_MN0 (I1942_G18_17 I1942_pn18 XI1942_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I84_XG_MN1 (XI1942_I84_XG_n1 I1942_gn17 I1942_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I131_XG_MN2 (XI1896_I131_XG_n1 I1896_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I131_XG_MN0 (I1896_G6_0 I1896_P6_3n XI1896_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I131_XG_MN1 (XI1896_I131_XG_n1 I1896_G2_0n I1896_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I135_XG_MN2 (XI1896_I135_XG_n1 I1896_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I135_XG_MN0 (I1896_G10_3 I1896_P10_7n XI1896_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I135_XG_MN1 (XI1896_I135_XG_n1 I1896_G6_3n I1896_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I141_XG_MN2 (XI1896_I141_XG_n1 I1896_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I141_XG_MN0 (I1896_G16_9 I1896_P16_13n XI1896_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I141_XG_MN1 (XI1896_I141_XG_n1 I1896_G12_9n I1896_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I198_XG_MN2 (XI1896_I198_XG_n1 I1896_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I198_XG_MN0 (I1896_G27_0 I1896_P27_12n XI1896_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I198_XG_MN1 (XI1896_I198_XG_n1 I1896_G11_0n I1896_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I148_XG_MN2 (XI1896_I148_XG_n1 I1896_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I148_XG_MN0 (I1896_G23_16 I1896_P23_20n XI1896_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I148_XG_MN1 (XI1896_I148_XG_n1 I1896_G19_16n I1896_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I86_XG_MN2 (XI700_I86_XG_n1 I700_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I86_XG_MN0 (I700_G20_19 I700_pn20 XI700_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I86_XG_MN1 (XI700_I86_XG_n1 I700_gn19 I700_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I202_XG_MN2 (XI700_I202_XG_n1 I700_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I202_XG_MN0 (c3_o I700_P31_16n XI700_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I202_XG_MN1 (XI700_I202_XG_n1 I700_G15_0n c3_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I85_XG_MN2 (XI700_I85_XG_n1 I700_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I85_XG_MN0 (I700_G19_18 I700_pn19 XI700_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I85_XG_MN1 (XI700_I85_XG_n1 I700_gn18 I700_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I140_XG_MN2 (XI654_I140_XG_n1 I654_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I140_XG_MN0 (I654_G15_8 I654_P15_12n XI654_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I140_XG_MN1 (XI654_I140_XG_n1 I654_G11_8n I654_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I136_XG_MN2 (XI654_I136_XG_n1 I654_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I136_XG_MN0 (I654_G11_4 I654_P11_8n XI654_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I136_XG_MN1 (XI654_I136_XG_n1 I654_G7_4n I654_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I142_XG_MN2 (XI654_I142_XG_n1 I654_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I142_XG_MN0 (I654_G17_10 I654_P17_14n XI654_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I142_XG_MN1 (XI654_I142_XG_n1 I654_G13_10n I654_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I188_XG_MN2 (XI654_I188_XG_n1 I654_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I188_XG_MN0 (I654_G20_0 I654_P20_5n XI654_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I188_XG_MN1 (XI654_I188_XG_n1 I654_G4_0n I654_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I145_XG_MN2 (XI654_I145_XG_n1 I654_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I145_XG_MN0 (I654_G20_13 I654_P20_17n XI654_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I145_XG_MN1 (XI654_I145_XG_n1 I654_G16_13n I654_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I83_XG_MN2 (XI654_I83_XG_n1 I654_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I83_XG_MN0 (I654_G17_16 I654_pn17 XI654_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I83_XG_MN1 (XI654_I83_XG_n1 I654_gn16 I654_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I82_XG_MN2 (XI654_I82_XG_n1 I654_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I82_XG_MN0 (I654_G16_15 I654_pn16 XI654_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I82_XG_MN1 (XI654_I82_XG_n1 I654_gn15 I654_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I144_XG_MN2 (XI608_I144_XG_n1 I608_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I144_XG_MN0 (I608_G19_12 I608_P19_16n XI608_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I144_XG_MN1 (XI608_I144_XG_n1 I608_G15_12n I608_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I145_XG_MN2 (XI608_I145_XG_n1 I608_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I145_XG_MN0 (I608_G20_13 I608_P20_17n XI608_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I145_XG_MN1 (XI608_I145_XG_n1 I608_G16_13n I608_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I84_XG_MN2 (XI608_I84_XG_n1 I608_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I84_XG_MN0 (I608_G18_17 I608_pn18 XI608_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I84_XG_MN1 (XI608_I84_XG_n1 I608_gn17 I608_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I83_XG_MN2 (XI608_I83_XG_n1 I608_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I83_XG_MN0 (I608_G17_16 I608_pn17 XI608_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I83_XG_MN1 (XI608_I83_XG_n1 I608_gn16 I608_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I199_XG_MN2 (XI562_I199_XG_n1 I562_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I199_XG_MN0 (I562_G28_0 I562_P28_13n XI562_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I199_XG_MN1 (XI562_I199_XG_n1 I562_G12_0n I562_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I197_XG_MN2 (XI562_I197_XG_n1 I562_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I197_XG_MN0 (I562_G26_0 I562_P26_11n XI562_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I197_XG_MN1 (XI562_I197_XG_n1 I562_G10_0n I562_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I196_XG_MN2 (XI562_I196_XG_n1 I562_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I196_XG_MN0 (I562_G25_0 I562_P25_10n XI562_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I196_XG_MN1 (XI562_I196_XG_n1 I562_G9_0n I562_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I144_XG_MN2 (XI562_I144_XG_n1 I562_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I144_XG_MN0 (I562_G19_12 I562_P19_16n XI562_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I144_XG_MN1 (XI562_I144_XG_n1 I562_G15_12n I562_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I140_XG_MN2 (XI562_I140_XG_n1 I562_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I140_XG_MN0 (I562_G15_8 I562_P15_12n XI562_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I140_XG_MN1 (XI562_I140_XG_n1 I562_G11_8n I562_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I186_XG_MN2 (XI2066_I186_XG_n1 I2066_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I186_XG_MN0 (I2066_G19_0 I2066_P19_4n XI2066_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I186_XG_MN1 (XI2066_I186_XG_n1 I2066_G3_0n I2066_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I144_XG_MN2 (XI2066_I144_XG_n1 I2066_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I144_XG_MN0 (I2066_G19_12 I2066_P19_16n XI2066_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I144_XG_MN1 (XI2066_I144_XG_n1 I2066_G15_12n I2066_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I188_XG_MN2 (XI2066_I188_XG_n1 I2066_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I188_XG_MN0 (I2066_G20_0 I2066_P20_5n XI2066_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I188_XG_MN1 (XI2066_I188_XG_n1 I2066_G4_0n I2066_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I145_XG_MN2 (XI2066_I145_XG_n1 I2066_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I145_XG_MN0 (I2066_G20_13 I2066_P20_17n XI2066_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I145_XG_MN1 (XI2066_I145_XG_n1 I2066_G16_13n I2066_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I83_XG_MN2 (XI2066_I83_XG_n1 I2066_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I83_XG_MN0 (I2066_G17_16 I2066_pn17 XI2066_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I83_XG_MN1 (XI2066_I83_XG_n1 I2066_gn16 I2066_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I84_XG_MN2 (XI2066_I84_XG_n1 I2066_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I84_XG_MN0 (I2066_G18_17 I2066_pn18 XI2066_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I84_XG_MN1 (XI2066_I84_XG_n1 I2066_gn17 I2066_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I192_XG_MN2 (XI1988_I192_XG_n1 I1988_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I192_XG_MN0 (I1988_G22_0 I1988_P22_7n XI1988_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I192_XG_MN1 (XI1988_I192_XG_n1 I1988_G6_0n I1988_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I149_XG_MN2 (XI1988_I149_XG_n1 I1988_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I149_XG_MN0 (I1988_G24_17 I1988_P24_21n XI1988_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I149_XG_MN1 (XI1988_I149_XG_n1 I1988_G20_17n I1988_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I190_XG_MN2 (XI1988_I190_XG_n1 I1988_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I190_XG_MN0 (I1988_G21_0 I1988_P21_6n XI1988_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I190_XG_MN1 (XI1988_I190_XG_n1 I1988_G5_0n I1988_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I144_XG_MN2 (XI1988_I144_XG_n1 I1988_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I144_XG_MN0 (I1988_G19_12 I1988_P19_16n XI1988_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I144_XG_MN1 (XI1988_I144_XG_n1 I1988_G15_12n I1988_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I84_XG_MN2 (XI1988_I84_XG_n1 I1988_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I84_XG_MN0 (I1988_G18_17 I1988_pn18 XI1988_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I84_XG_MN1 (XI1988_I84_XG_n1 I1988_gn17 I1988_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I83_XG_MN2 (XI1988_I83_XG_n1 I1988_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I83_XG_MN0 (I1988_G17_16 I1988_pn17 XI1988_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I83_XG_MN1 (XI1988_I83_XG_n1 I1988_gn16 I1988_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I143_XG_MN2 (XI1942_I143_XG_n1 I1942_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I143_XG_MN0 (I1942_G18_11 I1942_P18_15n XI1942_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I143_XG_MN1 (XI1942_I143_XG_n1 I1942_G14_11n I1942_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I140_XG_MN2 (XI1942_I140_XG_n1 I1942_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I140_XG_MN0 (I1942_G15_8 I1942_P15_12n XI1942_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I140_XG_MN1 (XI1942_I140_XG_n1 I1942_G11_8n I1942_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I142_XG_MN2 (XI1942_I142_XG_n1 I1942_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I142_XG_MN0 (I1942_G17_10 I1942_P17_14n XI1942_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I142_XG_MN1 (XI1942_I142_XG_n1 I1942_G13_10n I1942_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I82_XG_MN2 (XI1942_I82_XG_n1 I1942_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I82_XG_MN0 (I1942_G16_15 I1942_pn16 XI1942_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I82_XG_MN1 (XI1942_I82_XG_n1 I1942_gn15 I1942_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I83_XG_MN2 (XI1942_I83_XG_n1 I1942_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I83_XG_MN0 (I1942_G17_16 I1942_pn17 XI1942_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I83_XG_MN1 (XI1942_I83_XG_n1 I1942_gn16 I1942_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I183_XG_MN2 (XI1896_I183_XG_n1 I1896_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I183_XG_MN0 (I1896_G16_0 I1896_P16_1n XI1896_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I183_XG_MN1 (XI1896_I183_XG_n1 I1896_G0_0n I1896_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I184_XG_MN2 (XI1896_I184_XG_n1 I1896_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I184_XG_MN0 (I1896_G17_0 I1896_P17_2n XI1896_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I184_XG_MN1 (XI1896_I184_XG_n1 I1896_G1_0n I1896_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I137_XG_MN2 (XI1896_I137_XG_n1 I1896_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I137_XG_MN0 (I1896_G12_5 I1896_P12_9n XI1896_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I137_XG_MN1 (XI1896_I137_XG_n1 I1896_G8_5n I1896_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I138_XG_MN2 (XI1896_I138_XG_n1 I1896_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I138_XG_MN0 (I1896_G13_6 I1896_P13_10n XI1896_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I138_XG_MN1 (XI1896_I138_XG_n1 I1896_G9_6n I1896_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I142_XG_MN2 (XI1896_I142_XG_n1 I1896_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I142_XG_MN0 (I1896_G17_10 I1896_P17_14n XI1896_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I142_XG_MN1 (XI1896_I142_XG_n1 I1896_G13_10n I1896_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I82_XG_MN2 (XI1896_I82_XG_n1 I1896_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I82_XG_MN0 (I1896_G16_15 I1896_pn16 XI1896_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I82_XG_MN1 (XI1896_I82_XG_n1 I1896_gn15 I1896_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I83_XG_MN2 (XI1896_I83_XG_n1 I1896_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I83_XG_MN0 (I1896_G17_16 I1896_pn17 XI1896_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I83_XG_MN1 (XI1896_I83_XG_n1 I1896_gn16 I1896_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I144_XG_MN2 (XI1896_I144_XG_n1 I1896_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I144_XG_MN0 (I1896_G19_12 I1896_P19_16n XI1896_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I144_XG_MN1 (XI1896_I144_XG_n1 I1896_G15_12n I1896_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I202_XG_MN2 (XI1896_I202_XG_n1 I1896_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I202_XG_MN0 (c29_o I1896_P31_16n XI1896_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I202_XG_MN1 (XI1896_I202_XG_n1 I1896_G15_0n c29_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I154_XG_MN2 (XI700_I154_XG_n1 I700_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I154_XG_MN0 (I700_G29_22 I700_P29_26n XI700_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I154_XG_MN1 (XI700_I154_XG_n1 I700_G25_22n I700_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I152_XG_MN2 (XI700_I152_XG_n1 I700_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I152_XG_MN0 (I700_G27_20 I700_P27_24n XI700_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I152_XG_MN1 (XI700_I152_XG_n1 I700_G23_20n I700_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I148_XG_MN2 (XI700_I148_XG_n1 I700_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I148_XG_MN0 (I700_G23_16 I700_P23_20n XI700_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I148_XG_MN1 (XI700_I148_XG_n1 I700_G19_16n I700_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I84_XG_MN2 (XI700_I84_XG_n1 I700_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I84_XG_MN0 (I700_G18_17 I700_pn18 XI700_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I84_XG_MN1 (XI700_I84_XG_n1 I700_gn17 I700_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I83_XG_MN2 (XI700_I83_XG_n1 I700_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I83_XG_MN0 (I700_G17_16 I700_pn17 XI700_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I83_XG_MN1 (XI700_I83_XG_n1 I700_gn16 I700_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I132_XG_MN2 (XI654_I132_XG_n1 I654_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I132_XG_MN0 (I654_G7_0 I654_P7_4n XI654_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I132_XG_MN1 (XI654_I132_XG_n1 I654_G3_0n I654_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I138_XG_MN2 (XI654_I138_XG_n1 I654_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I138_XG_MN0 (I654_G13_6 I654_P13_10n XI654_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I138_XG_MN1 (XI654_I138_XG_n1 I654_G9_6n I654_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I139_XG_MN2 (XI654_I139_XG_n1 I654_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I139_XG_MN0 (I654_G14_7 I654_P14_11n XI654_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I139_XG_MN1 (XI654_I139_XG_n1 I654_G10_7n I654_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I143_XG_MN2 (XI654_I143_XG_n1 I654_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I143_XG_MN0 (I654_G18_11 I654_P18_15n XI654_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I143_XG_MN1 (XI654_I143_XG_n1 I654_G14_11n I654_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I141_XG_MN2 (XI654_I141_XG_n1 I654_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I141_XG_MN0 (I654_G16_9 I654_P16_13n XI654_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I141_XG_MN1 (XI654_I141_XG_n1 I654_G12_9n I654_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I80_XG_MN2 (XI654_I80_XG_n1 I654_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I80_XG_MN0 (I654_G14_13 I654_pn14 XI654_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I80_XG_MN1 (XI654_I80_XG_n1 I654_gn13 I654_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I81_XG_MN2 (XI654_I81_XG_n1 I654_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I81_XG_MN0 (I654_G15_14 I654_pn15 XI654_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I81_XG_MN1 (XI654_I81_XG_n1 I654_gn14 I654_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I186_XG_MN2 (XI608_I186_XG_n1 I608_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I186_XG_MN0 (I608_G19_0 I608_P19_4n XI608_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I186_XG_MN1 (XI608_I186_XG_n1 I608_G3_0n I608_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I140_XG_MN2 (XI608_I140_XG_n1 I608_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I140_XG_MN0 (I608_G15_8 I608_P15_12n XI608_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I140_XG_MN1 (XI608_I140_XG_n1 I608_G11_8n I608_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I142_XG_MN2 (XI608_I142_XG_n1 I608_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I142_XG_MN0 (I608_G17_10 I608_P17_14n XI608_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I142_XG_MN1 (XI608_I142_XG_n1 I608_G13_10n I608_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I188_XG_MN2 (XI608_I188_XG_n1 I608_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I188_XG_MN0 (I608_G20_0 I608_P20_5n XI608_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I188_XG_MN1 (XI608_I188_XG_n1 I608_G4_0n I608_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I143_XG_MN2 (XI608_I143_XG_n1 I608_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I143_XG_MN0 (I608_G18_11 I608_P18_15n XI608_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I143_XG_MN1 (XI608_I143_XG_n1 I608_G14_11n I608_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I81_XG_MN2 (XI608_I81_XG_n1 I608_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I81_XG_MN0 (I608_G15_14 I608_pn15 XI608_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I81_XG_MN1 (XI608_I81_XG_n1 I608_gn14 I608_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I82_XG_MN2 (XI608_I82_XG_n1 I608_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I82_XG_MN0 (I608_G16_15 I608_pn16 XI608_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I82_XG_MN1 (XI608_I82_XG_n1 I608_gn15 I608_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I84_XG_MN2 (XI562_I84_XG_n1 I562_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I84_XG_MN0 (I562_G18_17 I562_pn18 XI562_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I84_XG_MN1 (XI562_I84_XG_n1 I562_gn17 I562_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I83_XG_MN2 (XI562_I83_XG_n1 I562_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I83_XG_MN0 (I562_G17_16 I562_pn17 XI562_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I83_XG_MN1 (XI562_I83_XG_n1 I562_gn16 I562_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I142_XG_MN2 (XI562_I142_XG_n1 I562_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I142_XG_MN0 (I562_G17_10 I562_P17_14n XI562_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I142_XG_MN1 (XI562_I142_XG_n1 I562_G13_10n I562_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I186_XG_MN2 (XI562_I186_XG_n1 I562_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I186_XG_MN0 (I562_G19_0 I562_P19_4n XI562_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I186_XG_MN1 (XI562_I186_XG_n1 I562_G3_0n I562_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I140_XG_MN2 (XI2066_I140_XG_n1 I2066_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I140_XG_MN0 (I2066_G15_8 I2066_P15_12n XI2066_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I140_XG_MN1 (XI2066_I140_XG_n1 I2066_G11_8n I2066_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I196_XG_MN2 (XI2066_I196_XG_n1 I2066_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I196_XG_MN0 (I2066_G25_0 I2066_P25_10n XI2066_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I196_XG_MN1 (XI2066_I196_XG_n1 I2066_G9_0n I2066_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I142_XG_MN2 (XI2066_I142_XG_n1 I2066_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I142_XG_MN0 (I2066_G17_10 I2066_P17_14n XI2066_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I142_XG_MN1 (XI2066_I142_XG_n1 I2066_G13_10n I2066_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I143_XG_MN2 (XI2066_I143_XG_n1 I2066_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I143_XG_MN0 (I2066_G18_11 I2066_P18_15n XI2066_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I143_XG_MN1 (XI2066_I143_XG_n1 I2066_G14_11n I2066_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I82_XG_MN2 (XI2066_I82_XG_n1 I2066_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I82_XG_MN0 (I2066_G16_15 I2066_pn16 XI2066_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I82_XG_MN1 (XI2066_I82_XG_n1 I2066_gn15 I2066_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I81_XG_MN2 (XI2066_I81_XG_n1 I2066_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I81_XG_MN0 (I2066_G15_14 I2066_pn15 XI2066_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I81_XG_MN1 (XI2066_I81_XG_n1 I2066_gn14 I2066_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I143_XG_MN2 (XI1988_I143_XG_n1 I1988_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I143_XG_MN0 (I1988_G18_11 I1988_P18_15n XI1988_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I143_XG_MN1 (XI1988_I143_XG_n1 I1988_G14_11n I1988_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I145_XG_MN2 (XI1988_I145_XG_n1 I1988_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I145_XG_MN0 (I1988_G20_13 I1988_P20_17n XI1988_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I145_XG_MN1 (XI1988_I145_XG_n1 I1988_G16_13n I1988_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I140_XG_MN2 (XI1988_I140_XG_n1 I1988_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I140_XG_MN0 (I1988_G15_8 I1988_P15_12n XI1988_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I140_XG_MN1 (XI1988_I140_XG_n1 I1988_G11_8n I1988_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I82_XG_MN2 (XI1988_I82_XG_n1 I1988_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I82_XG_MN0 (I1988_G16_15 I1988_pn16 XI1988_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I82_XG_MN1 (XI1988_I82_XG_n1 I1988_gn15 I1988_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I139_XG_MN2 (XI1942_I139_XG_n1 I1942_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I139_XG_MN0 (I1942_G14_7 I1942_P14_11n XI1942_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I139_XG_MN1 (XI1942_I139_XG_n1 I1942_G10_7n I1942_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I141_XG_MN2 (XI1942_I141_XG_n1 I1942_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I141_XG_MN0 (I1942_G16_9 I1942_P16_13n XI1942_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I141_XG_MN1 (XI1942_I141_XG_n1 I1942_G12_9n I1942_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I186_XG_MN2 (XI1942_I186_XG_n1 I1942_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I186_XG_MN0 (I1942_G19_0 I1942_P19_4n XI1942_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I186_XG_MN1 (XI1942_I186_XG_n1 I1942_G3_0n I1942_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I138_XG_MN2 (XI1942_I138_XG_n1 I1942_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I138_XG_MN0 (I1942_G13_6 I1942_P13_10n XI1942_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I138_XG_MN1 (XI1942_I138_XG_n1 I1942_G9_6n I1942_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I79_XG_MN2 (XI1942_I79_XG_n1 I1942_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I79_XG_MN0 (I1942_G13_12 I1942_pn13 XI1942_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I79_XG_MN1 (XI1942_I79_XG_n1 I1942_gn12 I1942_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I80_XG_MN2 (XI1942_I80_XG_n1 I1942_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I80_XG_MN0 (I1942_G14_13 I1942_pn14 XI1942_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I80_XG_MN1 (XI1942_I80_XG_n1 I1942_gn13 I1942_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I81_XG_MN2 (XI1942_I81_XG_n1 I1942_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I81_XG_MN0 (I1942_G15_14 I1942_pn15 XI1942_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I81_XG_MN1 (XI1942_I81_XG_n1 I1942_gn14 I1942_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I130_XG_MN2 (XI1896_I130_XG_n1 I1896_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I130_XG_MN0 (I1896_G5_0 I1896_P5_2n XI1896_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I130_XG_MN1 (XI1896_I130_XG_n1 I1896_G1_0n I1896_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I134_XG_MN2 (XI1896_I134_XG_n1 I1896_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I134_XG_MN0 (I1896_G9_2 I1896_P9_6n XI1896_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I134_XG_MN1 (XI1896_I134_XG_n1 I1896_G5_2n I1896_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I80_XG_MN2 (XI1896_I80_XG_n1 I1896_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I80_XG_MN0 (I1896_G14_13 I1896_pn14 XI1896_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I80_XG_MN1 (XI1896_I80_XG_n1 I1896_gn13 I1896_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I81_XG_MN2 (XI1896_I81_XG_n1 I1896_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I81_XG_MN0 (I1896_G15_14 I1896_pn15 XI1896_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I81_XG_MN1 (XI1896_I81_XG_n1 I1896_gn14 I1896_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I186_XG_MN2 (XI1896_I186_XG_n1 I1896_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I186_XG_MN0 (I1896_G19_0 I1896_P19_4n XI1896_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I186_XG_MN1 (XI1896_I186_XG_n1 I1896_G3_0n I1896_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I140_XG_MN2 (XI1896_I140_XG_n1 I1896_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I140_XG_MN0 (I1896_G15_8 I1896_P15_12n XI1896_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I140_XG_MN1 (XI1896_I140_XG_n1 I1896_G11_8n I1896_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I136_XG_MN2 (XI1896_I136_XG_n1 I1896_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I136_XG_MN0 (I1896_G11_4 I1896_P11_8n XI1896_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I136_XG_MN1 (XI1896_I136_XG_n1 I1896_G7_4n I1896_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I194_XG_MN2 (XI1896_I194_XG_n1 I1896_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I194_XG_MN0 (I1896_G23_0 I1896_P23_8n XI1896_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I194_XG_MN1 (XI1896_I194_XG_n1 I1896_G7_0n I1896_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I150_XG_MN2 (XI700_I150_XG_n1 I700_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I150_XG_MN0 (I700_G25_18 I700_P25_22n XI700_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I150_XG_MN1 (XI700_I150_XG_n1 I700_G21_18n I700_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I146_XG_MN2 (XI700_I146_XG_n1 I700_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I146_XG_MN0 (I700_G21_14 I700_P21_18n XI700_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I146_XG_MN1 (XI700_I146_XG_n1 I700_G17_14n I700_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I144_XG_MN2 (XI700_I144_XG_n1 I700_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I144_XG_MN0 (I700_G19_12 I700_P19_16n XI700_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I144_XG_MN1 (XI700_I144_XG_n1 I700_G15_12n I700_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I82_XG_MN2 (XI700_I82_XG_n1 I700_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I82_XG_MN0 (I700_G16_15 I700_pn16 XI700_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I82_XG_MN1 (XI700_I82_XG_n1 I700_gn15 I700_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I81_XG_MN2 (XI700_I81_XG_n1 I700_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I81_XG_MN0 (I700_G15_14 I700_pn15 XI700_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I81_XG_MN1 (XI700_I81_XG_n1 I700_gn14 I700_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I184_XG_MN2 (XI654_I184_XG_n1 I654_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I184_XG_MN0 (I654_G17_0 I654_P17_2n XI654_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I184_XG_MN1 (XI654_I184_XG_n1 I654_G1_0n I654_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I185_XG_MN2 (XI654_I185_XG_n1 I654_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I185_XG_MN0 (I654_G18_0 I654_P18_3n XI654_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I185_XG_MN1 (XI654_I185_XG_n1 I654_G2_0n I654_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I137_XG_MN2 (XI654_I137_XG_n1 I654_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I137_XG_MN0 (I654_G12_5 I654_P12_9n XI654_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I137_XG_MN1 (XI654_I137_XG_n1 I654_G8_5n I654_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I78_XG_MN2 (XI654_I78_XG_n1 I654_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I78_XG_MN0 (I654_G12_11 I654_pn12 XI654_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I78_XG_MN1 (XI654_I78_XG_n1 I654_gn11 I654_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I79_XG_MN2 (XI654_I79_XG_n1 I654_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I79_XG_MN0 (I654_G13_12 I654_pn13 XI654_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I79_XG_MN1 (XI654_I79_XG_n1 I654_gn12 I654_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I138_XG_MN2 (XI608_I138_XG_n1 I608_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I138_XG_MN0 (I608_G13_6 I608_P13_10n XI608_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I138_XG_MN1 (XI608_I138_XG_n1 I608_G9_6n I608_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I185_XG_MN2 (XI608_I185_XG_n1 I608_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I185_XG_MN0 (I608_G18_0 I608_P18_3n XI608_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I185_XG_MN1 (XI608_I185_XG_n1 I608_G2_0n I608_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I195_XG_MN2 (XI608_I195_XG_n1 I608_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I195_XG_MN0 (I608_G24_0 I608_P24_9n XI608_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I195_XG_MN1 (XI608_I195_XG_n1 I608_G8_0n I608_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I139_XG_MN2 (XI608_I139_XG_n1 I608_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I139_XG_MN0 (I608_G14_7 I608_P14_11n XI608_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I139_XG_MN1 (XI608_I139_XG_n1 I608_G10_7n I608_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I141_XG_MN2 (XI608_I141_XG_n1 I608_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I141_XG_MN0 (I608_G16_9 I608_P16_13n XI608_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I141_XG_MN1 (XI608_I141_XG_n1 I608_G12_9n I608_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I79_XG_MN2 (XI608_I79_XG_n1 I608_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I79_XG_MN0 (I608_G13_12 I608_pn13 XI608_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I79_XG_MN1 (XI608_I79_XG_n1 I608_gn12 I608_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I80_XG_MN2 (XI608_I80_XG_n1 I608_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I80_XG_MN0 (I608_G14_13 I608_pn14 XI608_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I80_XG_MN1 (XI608_I80_XG_n1 I608_gn13 I608_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I149_XG_MN2 (XI562_I149_XG_n1 I562_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I149_XG_MN0 (I562_G24_17 I562_P24_21n XI562_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I149_XG_MN1 (XI562_I149_XG_n1 I562_G20_17n I562_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I145_XG_MN2 (XI562_I145_XG_n1 I562_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I145_XG_MN0 (I562_G20_13 I562_P20_17n XI562_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I145_XG_MN1 (XI562_I145_XG_n1 I562_G16_13n I562_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I82_XG_MN2 (XI562_I82_XG_n1 I562_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I82_XG_MN0 (I562_G16_15 I562_pn16 XI562_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I82_XG_MN1 (XI562_I82_XG_n1 I562_gn15 I562_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I143_XG_MN2 (XI562_I143_XG_n1 I562_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I143_XG_MN0 (I562_G18_11 I562_P18_15n XI562_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I143_XG_MN1 (XI562_I143_XG_n1 I562_G14_11n I562_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I81_XG_MN2 (XI562_I81_XG_n1 I562_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I81_XG_MN0 (I562_G15_14 I562_pn15 XI562_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I81_XG_MN1 (XI562_I81_XG_n1 I562_gn14 I562_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I80_XG_MN2 (XI562_I80_XG_n1 I562_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I80_XG_MN0 (I562_G14_13 I562_pn14 XI562_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I80_XG_MN1 (XI562_I80_XG_n1 I562_gn13 I562_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I138_XG_MN2 (XI562_I138_XG_n1 I562_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I138_XG_MN0 (I562_G13_6 I562_P13_10n XI562_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I138_XG_MN1 (XI562_I138_XG_n1 I562_G9_6n I562_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I132_XG_MN2 (XI2066_I132_XG_n1 I2066_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I132_XG_MN0 (I2066_G7_0 I2066_P7_4n XI2066_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I132_XG_MN1 (XI2066_I132_XG_n1 I2066_G3_0n I2066_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I136_XG_MN2 (XI2066_I136_XG_n1 I2066_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I136_XG_MN0 (I2066_G11_4 I2066_P11_8n XI2066_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I136_XG_MN1 (XI2066_I136_XG_n1 I2066_G7_4n I2066_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I184_XG_MN2 (XI2066_I184_XG_n1 I2066_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I184_XG_MN0 (I2066_G17_0 I2066_P17_2n XI2066_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I184_XG_MN1 (XI2066_I184_XG_n1 I2066_G1_0n I2066_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I138_XG_MN2 (XI2066_I138_XG_n1 I2066_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I138_XG_MN0 (I2066_G13_6 I2066_P13_10n XI2066_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I138_XG_MN1 (XI2066_I138_XG_n1 I2066_G9_6n I2066_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I185_XG_MN2 (XI2066_I185_XG_n1 I2066_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I185_XG_MN0 (I2066_G18_0 I2066_P18_3n XI2066_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I185_XG_MN1 (XI2066_I185_XG_n1 I2066_G2_0n I2066_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I195_XG_MN2 (XI2066_I195_XG_n1 I2066_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I195_XG_MN0 (I2066_G24_0 I2066_P24_9n XI2066_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I195_XG_MN1 (XI2066_I195_XG_n1 I2066_G8_0n I2066_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I141_XG_MN2 (XI2066_I141_XG_n1 I2066_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I141_XG_MN0 (I2066_G16_9 I2066_P16_13n XI2066_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I141_XG_MN1 (XI2066_I141_XG_n1 I2066_G12_9n I2066_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I139_XG_MN2 (XI2066_I139_XG_n1 I2066_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I139_XG_MN0 (I2066_G14_7 I2066_P14_11n XI2066_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I139_XG_MN1 (XI2066_I139_XG_n1 I2066_G10_7n I2066_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I80_XG_MN2 (XI2066_I80_XG_n1 I2066_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I80_XG_MN0 (I2066_G14_13 I2066_pn14 XI2066_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I80_XG_MN1 (XI2066_I80_XG_n1 I2066_gn13 I2066_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I79_XG_MN2 (XI2066_I79_XG_n1 I2066_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I79_XG_MN0 (I2066_G13_12 I2066_pn13 XI2066_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I79_XG_MN1 (XI2066_I79_XG_n1 I2066_gn12 I2066_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I188_XG_MN2 (XI1988_I188_XG_n1 I1988_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I188_XG_MN0 (I1988_G20_0 I1988_P20_5n XI1988_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I188_XG_MN1 (XI1988_I188_XG_n1 I1988_G4_0n I1988_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I139_XG_MN2 (XI1988_I139_XG_n1 I1988_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I139_XG_MN0 (I1988_G14_7 I1988_P14_11n XI1988_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I139_XG_MN1 (XI1988_I139_XG_n1 I1988_G10_7n I1988_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I196_XG_MN2 (XI1988_I196_XG_n1 I1988_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I196_XG_MN0 (I1988_G25_0 I1988_P25_10n XI1988_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I196_XG_MN1 (XI1988_I196_XG_n1 I1988_G9_0n I1988_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I142_XG_MN2 (XI1988_I142_XG_n1 I1988_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I142_XG_MN0 (I1988_G17_10 I1988_P17_14n XI1988_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I142_XG_MN1 (XI1988_I142_XG_n1 I1988_G13_10n I1988_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I80_XG_MN2 (XI1988_I80_XG_n1 I1988_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I80_XG_MN0 (I1988_G14_13 I1988_pn14 XI1988_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I80_XG_MN1 (XI1988_I80_XG_n1 I1988_gn13 I1988_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I81_XG_MN2 (XI1988_I81_XG_n1 I1988_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I81_XG_MN0 (I1988_G15_14 I1988_pn15 XI1988_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I81_XG_MN1 (XI1988_I81_XG_n1 I1988_gn14 I1988_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I185_XG_MN2 (XI1942_I185_XG_n1 I1942_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I185_XG_MN0 (I1942_G18_0 I1942_P18_3n XI1942_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I185_XG_MN1 (XI1942_I185_XG_n1 I1942_G2_0n I1942_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I137_XG_MN2 (XI1942_I137_XG_n1 I1942_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I137_XG_MN0 (I1942_G12_5 I1942_P12_9n XI1942_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I137_XG_MN1 (XI1942_I137_XG_n1 I1942_G8_5n I1942_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I136_XG_MN2 (XI1942_I136_XG_n1 I1942_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I136_XG_MN0 (I1942_G11_4 I1942_P11_8n XI1942_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I136_XG_MN1 (XI1942_I136_XG_n1 I1942_G7_4n I1942_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I78_XG_MN2 (XI1942_I78_XG_n1 I1942_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I78_XG_MN0 (I1942_G12_11 I1942_pn12 XI1942_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I78_XG_MN1 (XI1942_I78_XG_n1 I1942_gn11 I1942_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I133_XG_MN2 (XI1896_I133_XG_n1 I1896_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I133_XG_MN0 (I1896_G8_1 I1896_P8_5n XI1896_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I133_XG_MN1 (XI1896_I133_XG_n1 I1896_G4_1n I1896_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I78_XG_MN2 (XI1896_I78_XG_n1 I1896_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I78_XG_MN0 (I1896_G12_11 I1896_pn12 XI1896_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I78_XG_MN1 (XI1896_I78_XG_n1 I1896_gn11 I1896_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I79_XG_MN2 (XI1896_I79_XG_n1 I1896_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I79_XG_MN0 (I1896_G13_12 I1896_pn13 XI1896_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I79_XG_MN1 (XI1896_I79_XG_n1 I1896_gn12 I1896_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I132_XG_MN2 (XI1896_I132_XG_n1 I1896_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I132_XG_MN0 (I1896_G7_0 I1896_P7_4n XI1896_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I132_XG_MN1 (XI1896_I132_XG_n1 I1896_G3_0n I1896_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I200_XG_MN2 (XI700_I200_XG_n1 I700_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I200_XG_MN0 (I700_G29_0 I700_P29_14n XI700_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I200_XG_MN1 (XI700_I200_XG_n1 I700_G13_0n I700_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I198_XG_MN2 (XI700_I198_XG_n1 I700_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I198_XG_MN0 (I700_G27_0 I700_P27_12n XI700_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I198_XG_MN1 (XI700_I198_XG_n1 I700_G11_0n I700_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I194_XG_MN2 (XI700_I194_XG_n1 I700_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I194_XG_MN0 (I700_G23_0 I700_P23_8n XI700_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I194_XG_MN1 (XI700_I194_XG_n1 I700_G7_0n I700_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I140_XG_MN2 (XI700_I140_XG_n1 I700_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I140_XG_MN0 (I700_G15_8 I700_P15_12n XI700_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I140_XG_MN1 (XI700_I140_XG_n1 I700_G11_8n I700_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I130_XG_MN2 (XI654_I130_XG_n1 I654_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I130_XG_MN0 (I654_G5_0 I654_P5_2n XI654_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I130_XG_MN1 (XI654_I130_XG_n1 I654_G1_0n I654_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I134_XG_MN2 (XI654_I134_XG_n1 I654_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I134_XG_MN0 (I654_G9_2 I654_P9_6n XI654_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I134_XG_MN1 (XI654_I134_XG_n1 I654_G5_2n I654_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I135_XG_MN2 (XI654_I135_XG_n1 I654_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I135_XG_MN0 (I654_G10_3 I654_P10_7n XI654_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I135_XG_MN1 (XI654_I135_XG_n1 I654_G6_3n I654_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I183_XG_MN2 (XI654_I183_XG_n1 I654_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I183_XG_MN0 (I654_G16_0 I654_P16_1n XI654_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I183_XG_MN1 (XI654_I183_XG_n1 I654_G0_0n I654_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I76_XG_MN2 (XI654_I76_XG_n1 I654_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I76_XG_MN0 (I654_G10_9 I654_pn10 XI654_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I76_XG_MN1 (XI654_I76_XG_n1 I654_gn9 I654_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I77_XG_MN2 (XI654_I77_XG_n1 I654_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I77_XG_MN0 (I654_G11_10 I654_pn11 XI654_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I77_XG_MN1 (XI654_I77_XG_n1 I654_gn10 I654_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I184_XG_MN2 (XI608_I184_XG_n1 I608_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I184_XG_MN0 (I608_G17_0 I608_P17_2n XI608_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I184_XG_MN1 (XI608_I184_XG_n1 I608_G1_0n I608_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I136_XG_MN2 (XI608_I136_XG_n1 I608_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I136_XG_MN0 (I608_G11_4 I608_P11_8n XI608_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I136_XG_MN1 (XI608_I136_XG_n1 I608_G7_4n I608_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I137_XG_MN2 (XI608_I137_XG_n1 I608_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I137_XG_MN0 (I608_G12_5 I608_P12_9n XI608_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I137_XG_MN1 (XI608_I137_XG_n1 I608_G8_5n I608_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I78_XG_MN2 (XI608_I78_XG_n1 I608_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I78_XG_MN0 (I608_G12_11 I608_pn12 XI608_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I78_XG_MN1 (XI608_I78_XG_n1 I608_gn11 I608_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I188_XG_MN2 (XI562_I188_XG_n1 I562_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I188_XG_MN0 (I562_G20_0 I562_P20_5n XI562_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I188_XG_MN1 (XI562_I188_XG_n1 I562_G4_0n I562_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I185_XG_MN2 (XI562_I185_XG_n1 I562_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I185_XG_MN0 (I562_G18_0 I562_P18_3n XI562_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I185_XG_MN1 (XI562_I185_XG_n1 I562_G2_0n I562_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I139_XG_MN2 (XI562_I139_XG_n1 I562_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I139_XG_MN0 (I562_G14_7 I562_P14_11n XI562_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I139_XG_MN1 (XI562_I139_XG_n1 I562_G10_7n I562_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I184_XG_MN2 (XI562_I184_XG_n1 I562_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I184_XG_MN0 (I562_G17_0 I562_P17_2n XI562_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I184_XG_MN1 (XI562_I184_XG_n1 I562_G1_0n I562_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I79_XG_MN2 (XI562_I79_XG_n1 I562_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I79_XG_MN0 (I562_G13_12 I562_pn13 XI562_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I79_XG_MN1 (XI562_I79_XG_n1 I562_gn12 I562_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I78_XG_MN2 (XI562_I78_XG_n1 I562_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I78_XG_MN0 (I562_G12_11 I562_pn12 XI562_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I78_XG_MN1 (XI562_I78_XG_n1 I562_gn11 I562_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I136_XG_MN2 (XI562_I136_XG_n1 I562_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I136_XG_MN0 (I562_G11_4 I562_P11_8n XI562_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I136_XG_MN1 (XI562_I136_XG_n1 I562_G7_4n I562_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I134_XG_MN2 (XI2066_I134_XG_n1 I2066_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I134_XG_MN0 (I2066_G9_2 I2066_P9_6n XI2066_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I134_XG_MN1 (XI2066_I134_XG_n1 I2066_G5_2n I2066_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I135_XG_MN2 (XI2066_I135_XG_n1 I2066_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I135_XG_MN0 (I2066_G10_3 I2066_P10_7n XI2066_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I135_XG_MN1 (XI2066_I135_XG_n1 I2066_G6_3n I2066_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I137_XG_MN2 (XI2066_I137_XG_n1 I2066_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I137_XG_MN0 (I2066_G12_5 I2066_P12_9n XI2066_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I137_XG_MN1 (XI2066_I137_XG_n1 I2066_G8_5n I2066_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I77_XG_MN2 (XI2066_I77_XG_n1 I2066_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I77_XG_MN0 (I2066_G11_10 I2066_pn11 XI2066_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I77_XG_MN1 (XI2066_I77_XG_n1 I2066_gn10 I2066_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I78_XG_MN2 (XI2066_I78_XG_n1 I2066_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I78_XG_MN0 (I2066_G12_11 I2066_pn12 XI2066_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I78_XG_MN1 (XI2066_I78_XG_n1 I2066_gn11 I2066_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I185_XG_MN2 (XI1988_I185_XG_n1 I1988_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I185_XG_MN0 (I1988_G18_0 I1988_P18_3n XI1988_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I185_XG_MN1 (XI1988_I185_XG_n1 I1988_G2_0n I1988_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I195_XG_MN2 (XI1988_I195_XG_n1 I1988_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I195_XG_MN0 (I1988_G24_0 I1988_P24_9n XI1988_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I195_XG_MN1 (XI1988_I195_XG_n1 I1988_G8_0n I1988_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I141_XG_MN2 (XI1988_I141_XG_n1 I1988_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I141_XG_MN0 (I1988_G16_9 I1988_P16_13n XI1988_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I141_XG_MN1 (XI1988_I141_XG_n1 I1988_G12_9n I1988_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I186_XG_MN2 (XI1988_I186_XG_n1 I1988_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I186_XG_MN0 (I1988_G19_0 I1988_P19_4n XI1988_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I186_XG_MN1 (XI1988_I186_XG_n1 I1988_G3_0n I1988_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I138_XG_MN2 (XI1988_I138_XG_n1 I1988_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I138_XG_MN0 (I1988_G13_6 I1988_P13_10n XI1988_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I138_XG_MN1 (XI1988_I138_XG_n1 I1988_G9_6n I1988_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I78_XG_MN2 (XI1988_I78_XG_n1 I1988_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I78_XG_MN0 (I1988_G12_11 I1988_pn12 XI1988_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I78_XG_MN1 (XI1988_I78_XG_n1 I1988_gn11 I1988_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I79_XG_MN2 (XI1988_I79_XG_n1 I1988_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I79_XG_MN0 (I1988_G13_12 I1988_pn13 XI1988_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I79_XG_MN1 (XI1988_I79_XG_n1 I1988_gn12 I1988_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I135_XG_MN2 (XI1942_I135_XG_n1 I1942_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I135_XG_MN0 (I1942_G10_3 I1942_P10_7n XI1942_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I135_XG_MN1 (XI1942_I135_XG_n1 I1942_G6_3n I1942_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I184_XG_MN2 (XI1942_I184_XG_n1 I1942_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I184_XG_MN0 (I1942_G17_0 I1942_P17_2n XI1942_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I184_XG_MN1 (XI1942_I184_XG_n1 I1942_G1_0n I1942_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I132_XG_MN2 (XI1942_I132_XG_n1 I1942_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I132_XG_MN0 (I1942_G7_0 I1942_P7_4n XI1942_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I132_XG_MN1 (XI1942_I132_XG_n1 I1942_G3_0n I1942_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I77_XG_MN2 (XI1942_I77_XG_n1 I1942_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I77_XG_MN0 (I1942_G11_10 I1942_pn11 XI1942_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I77_XG_MN1 (XI1942_I77_XG_n1 I1942_gn10 I1942_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I76_XG_MN2 (XI1942_I76_XG_n1 I1942_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I76_XG_MN0 (I1942_G10_9 I1942_pn10 XI1942_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I76_XG_MN1 (XI1942_I76_XG_n1 I1942_gn9 I1942_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I128_XG_MN2 (XI1896_I128_XG_n1 I1896_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I128_XG_MN0 (I1896_G4_0 I1896_P4_1n XI1896_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I128_XG_MN1 (XI1896_I128_XG_n1 I1896_G0_0n I1896_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I75_XG_MN2 (XI1896_I75_XG_n1 I1896_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I75_XG_MN0 (I1896_G9_8 I1896_pn9 XI1896_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I75_XG_MN1 (XI1896_I75_XG_n1 I1896_gn8 I1896_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I76_XG_MN2 (XI1896_I76_XG_n1 I1896_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I76_XG_MN0 (I1896_G10_9 I1896_pn10 XI1896_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I76_XG_MN1 (XI1896_I76_XG_n1 I1896_gn9 I1896_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I77_XG_MN2 (XI1896_I77_XG_n1 I1896_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I77_XG_MN0 (I1896_G11_10 I1896_pn11 XI1896_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I77_XG_MN1 (XI1896_I77_XG_n1 I1896_gn10 I1896_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I186_XG_MN2 (XI1850_I186_XG_n1 I1850_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I186_XG_MN0 (I1850_G19_0 I1850_P19_4n XI1850_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I186_XG_MN1 (XI1850_I186_XG_n1 I1850_G3_0n I1850_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I194_XG_MN2 (XI1850_I194_XG_n1 I1850_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I194_XG_MN0 (I1850_G23_0 I1850_P23_8n XI1850_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I194_XG_MN1 (XI1850_I194_XG_n1 I1850_G7_0n I1850_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I198_XG_MN2 (XI1850_I198_XG_n1 I1850_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I198_XG_MN0 (I1850_G27_0 I1850_P27_12n XI1850_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I198_XG_MN1 (XI1850_I198_XG_n1 I1850_G11_0n I1850_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I202_XG_MN2 (XI1850_I202_XG_n1 I1850_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I202_XG_MN0 (c28_o I1850_P31_16n XI1850_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I202_XG_MN1 (XI1850_I202_XG_n1 I1850_G15_0n c28_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I142_XG_MN2 (XI700_I142_XG_n1 I700_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I142_XG_MN0 (I700_G17_10 I700_P17_14n XI700_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I142_XG_MN1 (XI700_I142_XG_n1 I700_G13_10n I700_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I138_XG_MN2 (XI700_I138_XG_n1 I700_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I138_XG_MN0 (I700_G13_6 I700_P13_10n XI700_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I138_XG_MN1 (XI700_I138_XG_n1 I700_G9_6n I700_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I80_XG_MN2 (XI700_I80_XG_n1 I700_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I80_XG_MN0 (I700_G14_13 I700_pn14 XI700_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I80_XG_MN1 (XI700_I80_XG_n1 I700_gn13 I700_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I79_XG_MN2 (XI700_I79_XG_n1 I700_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I79_XG_MN0 (I700_G13_12 I700_pn13 XI700_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I79_XG_MN1 (XI700_I79_XG_n1 I700_gn12 I700_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I78_XG_MN2 (XI700_I78_XG_n1 I700_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I78_XG_MN0 (I700_G12_11 I700_pn12 XI700_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I78_XG_MN1 (XI700_I78_XG_n1 I700_gn11 I700_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I133_XG_MN2 (XI654_I133_XG_n1 I654_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I133_XG_MN0 (I654_G8_1 I654_P8_5n XI654_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I133_XG_MN1 (XI654_I133_XG_n1 I654_G4_1n I654_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I74_XG_MN2 (XI654_I74_XG_n1 I654_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I74_XG_MN0 (I654_G8_7 I654_pn8 XI654_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I74_XG_MN1 (XI654_I74_XG_n1 I654_gn7 I654_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I75_XG_MN2 (XI654_I75_XG_n1 I654_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I75_XG_MN0 (I654_G9_8 I654_pn9 XI654_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I75_XG_MN1 (XI654_I75_XG_n1 I654_gn8 I654_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I132_XG_MN2 (XI608_I132_XG_n1 I608_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I132_XG_MN0 (I608_G7_0 I608_P7_4n XI608_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I132_XG_MN1 (XI608_I132_XG_n1 I608_G3_0n I608_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I130_XG_MN2 (XI608_I130_XG_n1 I608_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I130_XG_MN0 (I608_G5_0 I608_P5_2n XI608_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I130_XG_MN1 (XI608_I130_XG_n1 I608_G1_0n I608_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I134_XG_MN2 (XI608_I134_XG_n1 I608_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I134_XG_MN0 (I608_G9_2 I608_P9_6n XI608_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I134_XG_MN1 (XI608_I134_XG_n1 I608_G5_2n I608_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I183_XG_MN2 (XI608_I183_XG_n1 I608_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I183_XG_MN0 (I608_G16_0 I608_P16_1n XI608_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I183_XG_MN1 (XI608_I183_XG_n1 I608_G0_0n I608_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I131_XG_MN2 (XI608_I131_XG_n1 I608_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I131_XG_MN0 (I608_G6_0 I608_P6_3n XI608_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I131_XG_MN1 (XI608_I131_XG_n1 I608_G2_0n I608_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I135_XG_MN2 (XI608_I135_XG_n1 I608_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I135_XG_MN0 (I608_G10_3 I608_P10_7n XI608_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I135_XG_MN1 (XI608_I135_XG_n1 I608_G6_3n I608_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I76_XG_MN2 (XI608_I76_XG_n1 I608_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I76_XG_MN0 (I608_G10_9 I608_pn10 XI608_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I76_XG_MN1 (XI608_I76_XG_n1 I608_gn9 I608_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I75_XG_MN2 (XI608_I75_XG_n1 I608_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I75_XG_MN0 (I608_G9_8 I608_pn9 XI608_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I75_XG_MN1 (XI608_I75_XG_n1 I608_gn8 I608_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I77_XG_MN2 (XI608_I77_XG_n1 I608_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I77_XG_MN0 (I608_G11_10 I608_pn11 XI608_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I77_XG_MN1 (XI608_I77_XG_n1 I608_gn10 I608_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I195_XG_MN2 (XI562_I195_XG_n1 I562_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I195_XG_MN0 (I562_G24_0 I562_P24_9n XI562_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I195_XG_MN1 (XI562_I195_XG_n1 I562_G8_0n I562_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I141_XG_MN2 (XI562_I141_XG_n1 I562_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I141_XG_MN0 (I562_G16_9 I562_P16_13n XI562_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I141_XG_MN1 (XI562_I141_XG_n1 I562_G12_9n I562_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I137_XG_MN2 (XI562_I137_XG_n1 I562_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I137_XG_MN0 (I562_G12_5 I562_P12_9n XI562_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I137_XG_MN1 (XI562_I137_XG_n1 I562_G8_5n I562_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I130_XG_MN2 (XI562_I130_XG_n1 I562_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I130_XG_MN0 (I562_G5_0 I562_P5_2n XI562_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I130_XG_MN1 (XI562_I130_XG_n1 I562_G1_0n I562_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I134_XG_MN2 (XI562_I134_XG_n1 I562_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I134_XG_MN0 (I562_G9_2 I562_P9_6n XI562_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I134_XG_MN1 (XI562_I134_XG_n1 I562_G5_2n I562_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I77_XG_MN2 (XI562_I77_XG_n1 I562_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I77_XG_MN0 (I562_G11_10 I562_pn11 XI562_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I77_XG_MN1 (XI562_I77_XG_n1 I562_gn10 I562_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I130_XG_MN2 (XI2066_I130_XG_n1 I2066_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I130_XG_MN0 (I2066_G5_0 I2066_P5_2n XI2066_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I130_XG_MN1 (XI2066_I130_XG_n1 I2066_G1_0n I2066_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I183_XG_MN2 (XI2066_I183_XG_n1 I2066_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I183_XG_MN0 (I2066_G16_0 I2066_P16_1n XI2066_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I183_XG_MN1 (XI2066_I183_XG_n1 I2066_G0_0n I2066_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I131_XG_MN2 (XI2066_I131_XG_n1 I2066_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I131_XG_MN0 (I2066_G6_0 I2066_P6_3n XI2066_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I131_XG_MN1 (XI2066_I131_XG_n1 I2066_G2_0n I2066_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I75_XG_MN2 (XI2066_I75_XG_n1 I2066_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I75_XG_MN0 (I2066_G9_8 I2066_pn9 XI2066_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I75_XG_MN1 (XI2066_I75_XG_n1 I2066_gn8 I2066_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I76_XG_MN2 (XI2066_I76_XG_n1 I2066_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I76_XG_MN0 (I2066_G10_9 I2066_pn10 XI2066_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I76_XG_MN1 (XI2066_I76_XG_n1 I2066_gn9 I2066_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I135_XG_MN2 (XI1988_I135_XG_n1 I1988_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I135_XG_MN0 (I1988_G10_3 I1988_P10_7n XI1988_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I135_XG_MN1 (XI1988_I135_XG_n1 I1988_G6_3n I1988_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I137_XG_MN2 (XI1988_I137_XG_n1 I1988_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I137_XG_MN0 (I1988_G12_5 I1988_P12_9n XI1988_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I137_XG_MN1 (XI1988_I137_XG_n1 I1988_G8_5n I1988_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I184_XG_MN2 (XI1988_I184_XG_n1 I1988_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I184_XG_MN0 (I1988_G17_0 I1988_P17_2n XI1988_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I184_XG_MN1 (XI1988_I184_XG_n1 I1988_G1_0n I1988_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I136_XG_MN2 (XI1988_I136_XG_n1 I1988_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I136_XG_MN0 (I1988_G11_4 I1988_P11_8n XI1988_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I136_XG_MN1 (XI1988_I136_XG_n1 I1988_G7_4n I1988_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I76_XG_MN2 (XI1988_I76_XG_n1 I1988_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I76_XG_MN0 (I1988_G10_9 I1988_pn10 XI1988_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I76_XG_MN1 (XI1988_I76_XG_n1 I1988_gn9 I1988_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I77_XG_MN2 (XI1988_I77_XG_n1 I1988_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I77_XG_MN0 (I1988_G11_10 I1988_pn11 XI1988_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I77_XG_MN1 (XI1988_I77_XG_n1 I1988_gn10 I1988_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I183_XG_MN2 (XI1942_I183_XG_n1 I1942_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I183_XG_MN0 (I1942_G16_0 I1942_P16_1n XI1942_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I183_XG_MN1 (XI1942_I183_XG_n1 I1942_G0_0n I1942_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I133_XG_MN2 (XI1942_I133_XG_n1 I1942_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I133_XG_MN0 (I1942_G8_1 I1942_P8_5n XI1942_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I133_XG_MN1 (XI1942_I133_XG_n1 I1942_G4_1n I1942_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I130_XG_MN2 (XI1942_I130_XG_n1 I1942_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I130_XG_MN0 (I1942_G5_0 I1942_P5_2n XI1942_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I130_XG_MN1 (XI1942_I130_XG_n1 I1942_G1_0n I1942_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I134_XG_MN2 (XI1942_I134_XG_n1 I1942_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I134_XG_MN0 (I1942_G9_2 I1942_P9_6n XI1942_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I134_XG_MN1 (XI1942_I134_XG_n1 I1942_G5_2n I1942_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I74_XG_MN2 (XI1942_I74_XG_n1 I1942_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I74_XG_MN0 (I1942_G8_7 I1942_pn8 XI1942_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I74_XG_MN1 (XI1942_I74_XG_n1 I1942_gn7 I1942_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I75_XG_MN2 (XI1942_I75_XG_n1 I1942_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I75_XG_MN0 (I1942_G9_8 I1942_pn9 XI1942_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I75_XG_MN1 (XI1942_I75_XG_n1 I1942_gn8 I1942_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I73_XG_MN2 (XI1896_I73_XG_n1 I1896_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I73_XG_MN0 (I1896_G7_6 I1896_pn7 XI1896_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I73_XG_MN1 (XI1896_I73_XG_n1 I1896_gn6 I1896_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I74_XG_MN2 (XI1896_I74_XG_n1 I1896_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I74_XG_MN0 (I1896_G8_7 I1896_pn8 XI1896_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I74_XG_MN1 (XI1896_I74_XG_n1 I1896_gn7 I1896_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I132_XG_MN2 (XI1850_I132_XG_n1 I1850_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I132_XG_MN0 (I1850_G7_0 I1850_P7_4n XI1850_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I132_XG_MN1 (XI1850_I132_XG_n1 I1850_G3_0n I1850_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I136_XG_MN2 (XI1850_I136_XG_n1 I1850_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I136_XG_MN0 (I1850_G11_4 I1850_P11_8n XI1850_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I136_XG_MN1 (XI1850_I136_XG_n1 I1850_G7_4n I1850_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I140_XG_MN2 (XI1850_I140_XG_n1 I1850_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I140_XG_MN0 (I1850_G15_8 I1850_P15_12n XI1850_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I140_XG_MN1 (XI1850_I140_XG_n1 I1850_G11_8n I1850_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I190_XG_MN2 (XI1850_I190_XG_n1 I1850_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I190_XG_MN0 (I1850_G21_0 I1850_P21_6n XI1850_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I190_XG_MN1 (XI1850_I190_XG_n1 I1850_G5_0n I1850_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I144_XG_MN2 (XI1850_I144_XG_n1 I1850_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I144_XG_MN0 (I1850_G19_12 I1850_P19_16n XI1850_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I144_XG_MN1 (XI1850_I144_XG_n1 I1850_G15_12n I1850_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I148_XG_MN2 (XI1850_I148_XG_n1 I1850_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I148_XG_MN0 (I1850_G23_16 I1850_P23_20n XI1850_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I148_XG_MN1 (XI1850_I148_XG_n1 I1850_G19_16n I1850_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I196_XG_MN2 (XI1850_I196_XG_n1 I1850_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I196_XG_MN0 (I1850_G25_0 I1850_P25_10n XI1850_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I196_XG_MN1 (XI1850_I196_XG_n1 I1850_G9_0n I1850_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I152_XG_MN2 (XI1850_I152_XG_n1 I1850_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I152_XG_MN0 (I1850_G27_20 I1850_P27_24n XI1850_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I152_XG_MN1 (XI1850_I152_XG_n1 I1850_G23_20n I1850_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I200_XG_MN2 (XI1850_I200_XG_n1 I1850_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I200_XG_MN0 (I1850_G29_0 I1850_P29_14n XI1850_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I200_XG_MN1 (XI1850_I200_XG_n1 I1850_G13_0n I1850_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I156_XG_MN2 (XI1850_I156_XG_n1 I1850_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I156_XG_MN0 (I1850_G31_24 I1850_P31_28n XI1850_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I156_XG_MN1 (XI1850_I156_XG_n1 I1850_G27_24n I1850_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I190_XG_MN2 (XI700_I190_XG_n1 I700_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I190_XG_MN0 (I700_G21_0 I700_P21_6n XI700_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I190_XG_MN1 (XI700_I190_XG_n1 I700_G5_0n I700_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I196_XG_MN2 (XI700_I196_XG_n1 I700_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I196_XG_MN0 (I700_G25_0 I700_P25_10n XI700_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I196_XG_MN1 (XI700_I196_XG_n1 I700_G9_0n I700_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I136_XG_MN2 (XI700_I136_XG_n1 I700_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I136_XG_MN0 (I700_G11_4 I700_P11_8n XI700_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I136_XG_MN1 (XI700_I136_XG_n1 I700_G7_4n I700_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I77_XG_MN2 (XI700_I77_XG_n1 I700_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I77_XG_MN0 (I700_G11_10 I700_pn11 XI700_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I77_XG_MN1 (XI700_I77_XG_n1 I700_gn10 I700_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I131_XG_MN2 (XI654_I131_XG_n1 I654_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I131_XG_MN0 (I654_G6_0 I654_P6_3n XI654_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I131_XG_MN1 (XI654_I131_XG_n1 I654_G2_0n I654_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I128_XG_MN2 (XI654_I128_XG_n1 I654_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I128_XG_MN0 (I654_G4_0 I654_P4_1n XI654_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I128_XG_MN1 (XI654_I128_XG_n1 I654_G0_0n I654_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I72_XG_MN2 (XI654_I72_XG_n1 I654_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I72_XG_MN0 (I654_G6_5 I654_pn6 XI654_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I72_XG_MN1 (XI654_I72_XG_n1 I654_gn5 I654_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I73_XG_MN2 (XI654_I73_XG_n1 I654_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I73_XG_MN0 (I654_G7_6 I654_pn7 XI654_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I73_XG_MN1 (XI654_I73_XG_n1 I654_gn6 I654_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I128_XG_MN2 (XI608_I128_XG_n1 I608_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I128_XG_MN0 (I608_G4_0 I608_P4_1n XI608_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I128_XG_MN1 (XI608_I128_XG_n1 I608_G0_0n I608_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I133_XG_MN2 (XI608_I133_XG_n1 I608_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I133_XG_MN0 (I608_G8_1 I608_P8_5n XI608_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I133_XG_MN1 (XI608_I133_XG_n1 I608_G4_1n I608_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I73_XG_MN2 (XI608_I73_XG_n1 I608_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I73_XG_MN0 (I608_G7_6 I608_pn7 XI608_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I73_XG_MN1 (XI608_I73_XG_n1 I608_gn6 I608_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I74_XG_MN2 (XI608_I74_XG_n1 I608_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I74_XG_MN0 (I608_G8_7 I608_pn8 XI608_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I74_XG_MN1 (XI608_I74_XG_n1 I608_gn7 I608_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I183_XG_MN2 (XI562_I183_XG_n1 I562_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I183_XG_MN0 (I562_G16_0 I562_P16_1n XI562_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I183_XG_MN1 (XI562_I183_XG_n1 I562_G0_0n I562_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I133_XG_MN2 (XI562_I133_XG_n1 I562_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I133_XG_MN0 (I562_G8_1 I562_P8_5n XI562_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I133_XG_MN1 (XI562_I133_XG_n1 I562_G4_1n I562_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I131_XG_MN2 (XI562_I131_XG_n1 I562_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I131_XG_MN0 (I562_G6_0 I562_P6_3n XI562_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I131_XG_MN1 (XI562_I131_XG_n1 I562_G2_0n I562_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I135_XG_MN2 (XI562_I135_XG_n1 I562_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I135_XG_MN0 (I562_G10_3 I562_P10_7n XI562_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I135_XG_MN1 (XI562_I135_XG_n1 I562_G6_3n I562_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I76_XG_MN2 (XI562_I76_XG_n1 I562_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I76_XG_MN0 (I562_G10_9 I562_pn10 XI562_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I76_XG_MN1 (XI562_I76_XG_n1 I562_gn9 I562_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I132_XG_MN2 (XI562_I132_XG_n1 I562_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I132_XG_MN0 (I562_G7_0 I562_P7_4n XI562_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I132_XG_MN1 (XI562_I132_XG_n1 I562_G3_0n I562_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I128_XG_MN2 (XI2066_I128_XG_n1 I2066_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I128_XG_MN0 (I2066_G4_0 I2066_P4_1n XI2066_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I128_XG_MN1 (XI2066_I128_XG_n1 I2066_G0_0n I2066_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I133_XG_MN2 (XI2066_I133_XG_n1 I2066_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I133_XG_MN0 (I2066_G8_1 I2066_P8_5n XI2066_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I133_XG_MN1 (XI2066_I133_XG_n1 I2066_G4_1n I2066_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I73_XG_MN2 (XI2066_I73_XG_n1 I2066_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I73_XG_MN0 (I2066_G7_6 I2066_pn7 XI2066_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I73_XG_MN1 (XI2066_I73_XG_n1 I2066_gn6 I2066_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I74_XG_MN2 (XI2066_I74_XG_n1 I2066_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I74_XG_MN0 (I2066_G8_7 I2066_pn8 XI2066_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I74_XG_MN1 (XI2066_I74_XG_n1 I2066_gn7 I2066_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I183_XG_MN2 (XI1988_I183_XG_n1 I1988_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I183_XG_MN0 (I1988_G16_0 I1988_P16_1n XI1988_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I183_XG_MN1 (XI1988_I183_XG_n1 I1988_G0_0n I1988_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I131_XG_MN2 (XI1988_I131_XG_n1 I1988_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I131_XG_MN0 (I1988_G6_0 I1988_P6_3n XI1988_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I131_XG_MN1 (XI1988_I131_XG_n1 I1988_G2_0n I1988_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I134_XG_MN2 (XI1988_I134_XG_n1 I1988_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I134_XG_MN0 (I1988_G9_2 I1988_P9_6n XI1988_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I134_XG_MN1 (XI1988_I134_XG_n1 I1988_G5_2n I1988_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I74_XG_MN2 (XI1988_I74_XG_n1 I1988_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I74_XG_MN0 (I1988_G8_7 I1988_pn8 XI1988_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I74_XG_MN1 (XI1988_I74_XG_n1 I1988_gn7 I1988_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I75_XG_MN2 (XI1988_I75_XG_n1 I1988_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I75_XG_MN0 (I1988_G9_8 I1988_pn9 XI1988_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I75_XG_MN1 (XI1988_I75_XG_n1 I1988_gn8 I1988_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I131_XG_MN2 (XI1942_I131_XG_n1 I1942_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I131_XG_MN0 (I1942_G6_0 I1942_P6_3n XI1942_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I131_XG_MN1 (XI1942_I131_XG_n1 I1942_G2_0n I1942_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I73_XG_MN2 (XI1942_I73_XG_n1 I1942_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I73_XG_MN0 (I1942_G7_6 I1942_pn7 XI1942_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I73_XG_MN1 (XI1942_I73_XG_n1 I1942_gn6 I1942_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I70_XG_MN2 (XI1896_I70_XG_n1 I1896_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I70_XG_MN0 (I1896_G4_3 I1896_pn4 XI1896_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I70_XG_MN1 (XI1896_I70_XG_n1 I1896_gn3 I1896_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I71_XG_MN2 (XI1896_I71_XG_n1 I1896_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I71_XG_MN0 (I1896_G5_4 I1896_pn5 XI1896_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I71_XG_MN1 (XI1896_I71_XG_n1 I1896_gn4 I1896_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I72_XG_MN2 (XI1896_I72_XG_n1 I1896_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I72_XG_MN0 (I1896_G6_5 I1896_pn6 XI1896_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I72_XG_MN1 (XI1896_I72_XG_n1 I1896_gn5 I1896_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I130_XG_MN2 (XI1850_I130_XG_n1 I1850_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I130_XG_MN0 (I1850_G5_0 I1850_P5_2n XI1850_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I130_XG_MN1 (XI1850_I130_XG_n1 I1850_G1_0n I1850_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I134_XG_MN2 (XI1850_I134_XG_n1 I1850_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I134_XG_MN0 (I1850_G9_2 I1850_P9_6n XI1850_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I134_XG_MN1 (XI1850_I134_XG_n1 I1850_G5_2n I1850_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I184_XG_MN2 (XI1850_I184_XG_n1 I1850_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I184_XG_MN0 (I1850_G17_0 I1850_P17_2n XI1850_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I184_XG_MN1 (XI1850_I184_XG_n1 I1850_G1_0n I1850_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I138_XG_MN2 (XI1850_I138_XG_n1 I1850_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I138_XG_MN0 (I1850_G13_6 I1850_P13_10n XI1850_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I138_XG_MN1 (XI1850_I138_XG_n1 I1850_G9_6n I1850_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I142_XG_MN2 (XI1850_I142_XG_n1 I1850_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I142_XG_MN0 (I1850_G17_10 I1850_P17_14n XI1850_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I142_XG_MN1 (XI1850_I142_XG_n1 I1850_G13_10n I1850_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I146_XG_MN2 (XI1850_I146_XG_n1 I1850_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I146_XG_MN0 (I1850_G21_14 I1850_P21_18n XI1850_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I146_XG_MN1 (XI1850_I146_XG_n1 I1850_G17_14n I1850_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I150_XG_MN2 (XI1850_I150_XG_n1 I1850_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I150_XG_MN0 (I1850_G25_18 I1850_P25_22n XI1850_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I150_XG_MN1 (XI1850_I150_XG_n1 I1850_G21_18n I1850_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I155_XG_MN2 (XI700_I155_XG_n1 I700_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I155_XG_MN0 (I700_G30_23 I700_P30_27n XI700_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I155_XG_MN1 (XI700_I155_XG_n1 I700_G26_23n I700_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I186_XG_MN2 (XI700_I186_XG_n1 I700_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I186_XG_MN0 (I700_G19_0 I700_P19_4n XI700_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I186_XG_MN1 (XI700_I186_XG_n1 I700_G3_0n I700_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I184_XG_MN2 (XI700_I184_XG_n1 I700_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I184_XG_MN0 (I700_G17_0 I700_P17_2n XI700_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I184_XG_MN1 (XI700_I184_XG_n1 I700_G1_0n I700_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I134_XG_MN2 (XI700_I134_XG_n1 I700_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I134_XG_MN0 (I700_G9_2 I700_P9_6n XI700_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I134_XG_MN1 (XI700_I134_XG_n1 I700_G5_2n I700_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I76_XG_MN2 (XI700_I76_XG_n1 I700_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I76_XG_MN0 (I700_G10_9 I700_pn10 XI700_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I76_XG_MN1 (XI700_I76_XG_n1 I700_gn9 I700_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I75_XG_MN2 (XI700_I75_XG_n1 I700_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I75_XG_MN0 (I700_G9_8 I700_pn9 XI700_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I75_XG_MN1 (XI700_I75_XG_n1 I700_gn8 I700_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I71_XG_MN2 (XI654_I71_XG_n1 I654_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I71_XG_MN0 (I654_G5_4 I654_pn5 XI654_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I71_XG_MN1 (XI654_I71_XG_n1 I654_gn4 I654_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I70_XG_MN2 (XI654_I70_XG_n1 I654_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I70_XG_MN0 (I654_G4_3 I654_pn4 XI654_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I70_XG_MN1 (XI654_I70_XG_n1 I654_gn3 I654_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I71_XG_MN2 (XI608_I71_XG_n1 I608_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I71_XG_MN0 (I608_G5_4 I608_pn5 XI608_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I71_XG_MN1 (XI608_I71_XG_n1 I608_gn4 I608_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I72_XG_MN2 (XI608_I72_XG_n1 I608_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I72_XG_MN0 (I608_G6_5 I608_pn6 XI608_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I72_XG_MN1 (XI608_I72_XG_n1 I608_gn5 I608_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I128_XG_MN2 (XI562_I128_XG_n1 I562_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I128_XG_MN0 (I562_G4_0 I562_P4_1n XI562_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I128_XG_MN1 (XI562_I128_XG_n1 I562_G0_0n I562_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I75_XG_MN2 (XI562_I75_XG_n1 I562_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I75_XG_MN0 (I562_G9_8 I562_pn9 XI562_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I75_XG_MN1 (XI562_I75_XG_n1 I562_gn8 I562_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I67_XG_MN2 (XI2066_I67_XG_n1 I2066_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I67_XG_MN0 (I2066_G1_0 I2066_pn1 XI2066_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I67_XG_MN1 (XI2066_I67_XG_n1 I2066_G0_0n I2066_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I72_XG_MN2 (XI2066_I72_XG_n1 I2066_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I72_XG_MN0 (I2066_G6_5 I2066_pn6 XI2066_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I72_XG_MN1 (XI2066_I72_XG_n1 I2066_gn5 I2066_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I71_XG_MN2 (XI2066_I71_XG_n1 I2066_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I71_XG_MN0 (I2066_G5_4 I2066_pn5 XI2066_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I71_XG_MN1 (XI2066_I71_XG_n1 I2066_gn4 I2066_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I133_XG_MN2 (XI1988_I133_XG_n1 I1988_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I133_XG_MN0 (I1988_G8_1 I1988_P8_5n XI1988_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I133_XG_MN1 (XI1988_I133_XG_n1 I1988_G4_1n I1988_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I130_XG_MN2 (XI1988_I130_XG_n1 I1988_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I130_XG_MN0 (I1988_G5_0 I1988_P5_2n XI1988_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I130_XG_MN1 (XI1988_I130_XG_n1 I1988_G1_0n I1988_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I132_XG_MN2 (XI1988_I132_XG_n1 I1988_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I132_XG_MN0 (I1988_G7_0 I1988_P7_4n XI1988_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I132_XG_MN1 (XI1988_I132_XG_n1 I1988_G3_0n I1988_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I73_XG_MN2 (XI1988_I73_XG_n1 I1988_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I73_XG_MN0 (I1988_G7_6 I1988_pn7 XI1988_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I73_XG_MN1 (XI1988_I73_XG_n1 I1988_gn6 I1988_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I128_XG_MN2 (XI1942_I128_XG_n1 I1942_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I128_XG_MN0 (I1942_G4_0 I1942_P4_1n XI1942_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I128_XG_MN1 (XI1942_I128_XG_n1 I1942_G0_0n I1942_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I71_XG_MN2 (XI1942_I71_XG_n1 I1942_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I71_XG_MN0 (I1942_G5_4 I1942_pn5 XI1942_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I71_XG_MN1 (XI1942_I71_XG_n1 I1942_gn4 I1942_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I72_XG_MN2 (XI1942_I72_XG_n1 I1942_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I72_XG_MN0 (I1942_G6_5 I1942_pn6 XI1942_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I72_XG_MN1 (XI1942_I72_XG_n1 I1942_gn5 I1942_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I67_XG_MN2 (XI1896_I67_XG_n1 I1896_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I67_XG_MN0 (I1896_G1_0 I1896_pn1 XI1896_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I67_XG_MN1 (XI1896_I67_XG_n1 I1896_G0_0n I1896_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I68_XG_MN2 (XI1896_I68_XG_n1 I1896_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I68_XG_MN0 (I1896_G2_1 I1896_pn2 XI1896_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I68_XG_MN1 (XI1896_I68_XG_n1 I1896_gn1 I1896_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I69_XG_MN2 (XI1896_I69_XG_n1 I1896_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I69_XG_MN0 (I1896_G3_2 I1896_pn3 XI1896_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I69_XG_MN1 (XI1896_I69_XG_n1 I1896_gn2 I1896_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I154_XG_MN2 (XI1850_I154_XG_n1 I1850_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I154_XG_MN0 (I1850_G29_22 I1850_P29_26n XI1850_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I154_XG_MN1 (XI1850_I154_XG_n1 I1850_G25_22n I1850_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I153_XG_MN2 (XI700_I153_XG_n1 I700_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I153_XG_MN0 (I700_G28_21 I700_P28_25n XI700_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I153_XG_MN1 (XI700_I153_XG_n1 I700_G24_21n I700_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I151_XG_MN2 (XI700_I151_XG_n1 I700_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I151_XG_MN0 (I700_G26_19 I700_P26_23n XI700_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I151_XG_MN1 (XI700_I151_XG_n1 I700_G22_19n I700_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I147_XG_MN2 (XI700_I147_XG_n1 I700_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I147_XG_MN0 (I700_G22_15 I700_P22_19n XI700_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I147_XG_MN1 (XI700_I147_XG_n1 I700_G18_15n I700_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I132_XG_MN2 (XI700_I132_XG_n1 I700_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I132_XG_MN0 (I700_G7_0 I700_P7_4n XI700_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I132_XG_MN1 (XI700_I132_XG_n1 I700_G3_0n I700_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I130_XG_MN2 (XI700_I130_XG_n1 I700_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I130_XG_MN0 (I700_G5_0 I700_P5_2n XI700_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I130_XG_MN1 (XI700_I130_XG_n1 I700_G1_0n I700_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I74_XG_MN2 (XI700_I74_XG_n1 I700_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I74_XG_MN0 (I700_G8_7 I700_pn8 XI700_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I74_XG_MN1 (XI700_I74_XG_n1 I700_gn7 I700_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I73_XG_MN2 (XI700_I73_XG_n1 I700_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I73_XG_MN0 (I700_G7_6 I700_pn7 XI700_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I73_XG_MN1 (XI700_I73_XG_n1 I700_gn6 I700_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I67_XG_MN2 (XI654_I67_XG_n1 I654_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I67_XG_MN0 (I654_G1_0 I654_pn1 XI654_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I67_XG_MN1 (XI654_I67_XG_n1 I654_G0_0n I654_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I69_XG_MN2 (XI654_I69_XG_n1 I654_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I69_XG_MN0 (I654_G3_2 I654_pn3 XI654_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I69_XG_MN1 (XI654_I69_XG_n1 I654_gn2 I654_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I68_XG_MN2 (XI654_I68_XG_n1 I654_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I68_XG_MN0 (I654_G2_1 I654_pn2 XI654_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I68_XG_MN1 (XI654_I68_XG_n1 I654_gn1 I654_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I67_XG_MN2 (XI608_I67_XG_n1 I608_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I67_XG_MN0 (I608_G1_0 I608_pn1 XI608_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I67_XG_MN1 (XI608_I67_XG_n1 I608_G0_0n I608_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I68_XG_MN2 (XI608_I68_XG_n1 I608_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I68_XG_MN0 (I608_G2_1 I608_pn2 XI608_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I68_XG_MN1 (XI608_I68_XG_n1 I608_gn1 I608_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I69_XG_MN2 (XI608_I69_XG_n1 I608_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I69_XG_MN0 (I608_G3_2 I608_pn3 XI608_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I69_XG_MN1 (XI608_I69_XG_n1 I608_gn2 I608_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I70_XG_MN2 (XI608_I70_XG_n1 I608_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I70_XG_MN0 (I608_G4_3 I608_pn4 XI608_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I70_XG_MN1 (XI608_I70_XG_n1 I608_gn3 I608_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I67_XG_MN2 (XI562_I67_XG_n1 I562_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I67_XG_MN0 (I562_G1_0 I562_pn1 XI562_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I67_XG_MN1 (XI562_I67_XG_n1 I562_G0_0n I562_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I68_XG_MN2 (XI562_I68_XG_n1 I562_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I68_XG_MN0 (I562_G2_1 I562_pn2 XI562_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I68_XG_MN1 (XI562_I68_XG_n1 I562_gn1 I562_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I69_XG_MN2 (XI562_I69_XG_n1 I562_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I69_XG_MN0 (I562_G3_2 I562_pn3 XI562_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I69_XG_MN1 (XI562_I69_XG_n1 I562_gn2 I562_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I72_XG_MN2 (XI562_I72_XG_n1 I562_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I72_XG_MN0 (I562_G6_5 I562_pn6 XI562_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I72_XG_MN1 (XI562_I72_XG_n1 I562_gn5 I562_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I73_XG_MN2 (XI562_I73_XG_n1 I562_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I73_XG_MN0 (I562_G7_6 I562_pn7 XI562_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I73_XG_MN1 (XI562_I73_XG_n1 I562_gn6 I562_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I74_XG_MN2 (XI562_I74_XG_n1 I562_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I74_XG_MN0 (I562_G8_7 I562_pn8 XI562_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I74_XG_MN1 (XI562_I74_XG_n1 I562_gn7 I562_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I68_XG_MN2 (XI2066_I68_XG_n1 I2066_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I68_XG_MN0 (I2066_G2_1 I2066_pn2 XI2066_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I68_XG_MN1 (XI2066_I68_XG_n1 I2066_gn1 I2066_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I69_XG_MN2 (XI2066_I69_XG_n1 I2066_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I69_XG_MN0 (I2066_G3_2 I2066_pn3 XI2066_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I69_XG_MN1 (XI2066_I69_XG_n1 I2066_gn2 I2066_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I70_XG_MN2 (XI2066_I70_XG_n1 I2066_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I70_XG_MN0 (I2066_G4_3 I2066_pn4 XI2066_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I70_XG_MN1 (XI2066_I70_XG_n1 I2066_gn3 I2066_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I128_XG_MN2 (XI1988_I128_XG_n1 I1988_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I128_XG_MN0 (I1988_G4_0 I1988_P4_1n XI1988_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I128_XG_MN1 (XI1988_I128_XG_n1 I1988_G0_0n I1988_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I70_XG_MN2 (XI1988_I70_XG_n1 I1988_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I70_XG_MN0 (I1988_G4_3 I1988_pn4 XI1988_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I70_XG_MN1 (XI1988_I70_XG_n1 I1988_gn3 I1988_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I71_XG_MN2 (XI1988_I71_XG_n1 I1988_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I71_XG_MN0 (I1988_G5_4 I1988_pn5 XI1988_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I71_XG_MN1 (XI1988_I71_XG_n1 I1988_gn4 I1988_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I72_XG_MN2 (XI1988_I72_XG_n1 I1988_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I72_XG_MN0 (I1988_G6_5 I1988_pn6 XI1988_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I72_XG_MN1 (XI1988_I72_XG_n1 I1988_gn5 I1988_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I69_XG_MN2 (XI1942_I69_XG_n1 I1942_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I69_XG_MN0 (I1942_G3_2 I1942_pn3 XI1942_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I69_XG_MN1 (XI1942_I69_XG_n1 I1942_gn2 I1942_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I70_XG_MN2 (XI1942_I70_XG_n1 I1942_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I70_XG_MN0 (I1942_G4_3 I1942_pn4 XI1942_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I70_XG_MN1 (XI1942_I70_XG_n1 I1942_gn3 I1942_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I183_XG_MN2 (XI1850_I183_XG_n1 I1850_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I183_XG_MN0 (I1850_G16_0 I1850_P16_1n XI1850_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I183_XG_MN1 (XI1850_I183_XG_n1 I1850_G0_0n I1850_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I185_XG_MN2 (XI1850_I185_XG_n1 I1850_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I185_XG_MN0 (I1850_G18_0 I1850_P18_3n XI1850_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I185_XG_MN1 (XI1850_I185_XG_n1 I1850_G2_0n I1850_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I195_XG_MN2 (XI1850_I195_XG_n1 I1850_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I195_XG_MN0 (I1850_G24_0 I1850_P24_9n XI1850_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I195_XG_MN1 (XI1850_I195_XG_n1 I1850_G8_0n I1850_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I188_XG_MN2 (XI1850_I188_XG_n1 I1850_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I188_XG_MN0 (I1850_G20_0 I1850_P20_5n XI1850_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I188_XG_MN1 (XI1850_I188_XG_n1 I1850_G4_0n I1850_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I192_XG_MN2 (XI1850_I192_XG_n1 I1850_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I192_XG_MN0 (I1850_G22_0 I1850_P22_7n XI1850_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I192_XG_MN1 (XI1850_I192_XG_n1 I1850_G6_0n I1850_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I197_XG_MN2 (XI1850_I197_XG_n1 I1850_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I197_XG_MN0 (I1850_G26_0 I1850_P26_11n XI1850_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I197_XG_MN1 (XI1850_I197_XG_n1 I1850_G10_0n I1850_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I201_XG_MN2 (XI700_I201_XG_n1 I700_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I201_XG_MN0 (c3_m I700_P30_15n XI700_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I201_XG_MN1 (XI700_I201_XG_n1 I700_G14_0n c3_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I192_XG_MN2 (XI700_I192_XG_n1 I700_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I192_XG_MN0 (I700_G22_0 I700_P22_7n XI700_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I192_XG_MN1 (XI700_I192_XG_n1 I700_G6_0n I700_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I149_XG_MN2 (XI700_I149_XG_n1 I700_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I149_XG_MN0 (I700_G24_17 I700_P24_21n XI700_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I149_XG_MN1 (XI700_I149_XG_n1 I700_G20_17n I700_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I145_XG_MN2 (XI700_I145_XG_n1 I700_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I145_XG_MN0 (I700_G20_13 I700_P20_17n XI700_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I145_XG_MN1 (XI700_I145_XG_n1 I700_G16_13n I700_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I143_XG_MN2 (XI700_I143_XG_n1 I700_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I143_XG_MN0 (I700_G18_11 I700_P18_15n XI700_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I143_XG_MN1 (XI700_I143_XG_n1 I700_G14_11n I700_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I139_XG_MN2 (XI700_I139_XG_n1 I700_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I139_XG_MN0 (I700_G14_7 I700_P14_11n XI700_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I139_XG_MN1 (XI700_I139_XG_n1 I700_G10_7n I700_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I72_XG_MN2 (XI700_I72_XG_n1 I700_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I72_XG_MN0 (I700_G6_5 I700_pn6 XI700_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I72_XG_MN1 (XI700_I72_XG_n1 I700_gn5 I700_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I71_XG_MN2 (XI700_I71_XG_n1 I700_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I71_XG_MN0 (I700_G5_4 I700_pn5 XI700_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I71_XG_MN1 (XI700_I71_XG_n1 I700_gn4 I700_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I65_XG_MN2 (XI654_I65_XG_n1 I654_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I65_XG_MN0 (I654_G0_0 I654_pn0 XI654_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I65_XG_MN1 (XI654_I65_XG_n1 I654_cinn I654_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I65_XG_MN2 (XI608_I65_XG_n1 I608_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I65_XG_MN0 (I608_G0_0 I608_pn0 XI608_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I65_XG_MN1 (XI608_I65_XG_n1 I608_cinn I608_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I70_XG_MN2 (XI562_I70_XG_n1 I562_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I70_XG_MN0 (I562_G4_3 I562_pn4 XI562_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I70_XG_MN1 (XI562_I70_XG_n1 I562_gn3 I562_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I71_XG_MN2 (XI562_I71_XG_n1 I562_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I71_XG_MN0 (I562_G5_4 I562_pn5 XI562_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I71_XG_MN1 (XI562_I71_XG_n1 I562_gn4 I562_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I67_XG_MN2 (XI1988_I67_XG_n1 I1988_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I67_XG_MN0 (I1988_G1_0 I1988_pn1 XI1988_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I67_XG_MN1 (XI1988_I67_XG_n1 I1988_G0_0n I1988_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I68_XG_MN2 (XI1988_I68_XG_n1 I1988_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I68_XG_MN0 (I1988_G2_1 I1988_pn2 XI1988_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I68_XG_MN1 (XI1988_I68_XG_n1 I1988_gn1 I1988_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I69_XG_MN2 (XI1988_I69_XG_n1 I1988_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I69_XG_MN0 (I1988_G3_2 I1988_pn3 XI1988_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I69_XG_MN1 (XI1988_I69_XG_n1 I1988_gn2 I1988_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I67_XG_MN2 (XI1942_I67_XG_n1 I1942_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I67_XG_MN0 (I1942_G1_0 I1942_pn1 XI1942_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I67_XG_MN1 (XI1942_I67_XG_n1 I1942_G0_0n I1942_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I68_XG_MN2 (XI1942_I68_XG_n1 I1942_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I68_XG_MN0 (I1942_G2_1 I1942_pn2 XI1942_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I68_XG_MN1 (XI1942_I68_XG_n1 I1942_gn1 I1942_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I67_XG_MN2 (XI1850_I67_XG_n1 I1850_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I67_XG_MN0 (I1850_G1_0 I1850_pn1 XI1850_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I67_XG_MN1 (XI1850_I67_XG_n1 I1850_G0_0n I1850_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I128_XG_MN2 (XI1850_I128_XG_n1 I1850_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I128_XG_MN0 (I1850_G4_0 I1850_P4_1n XI1850_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I128_XG_MN1 (XI1850_I128_XG_n1 I1850_G0_0n I1850_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I131_XG_MN2 (XI1850_I131_XG_n1 I1850_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I131_XG_MN0 (I1850_G6_0 I1850_P6_3n XI1850_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I131_XG_MN1 (XI1850_I131_XG_n1 I1850_G2_0n I1850_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I133_XG_MN2 (XI1850_I133_XG_n1 I1850_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I133_XG_MN0 (I1850_G8_1 I1850_P8_5n XI1850_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I133_XG_MN1 (XI1850_I133_XG_n1 I1850_G4_1n I1850_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I135_XG_MN2 (XI1850_I135_XG_n1 I1850_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I135_XG_MN0 (I1850_G10_3 I1850_P10_7n XI1850_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I135_XG_MN1 (XI1850_I135_XG_n1 I1850_G6_3n I1850_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I137_XG_MN2 (XI1850_I137_XG_n1 I1850_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I137_XG_MN0 (I1850_G12_5 I1850_P12_9n XI1850_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I137_XG_MN1 (XI1850_I137_XG_n1 I1850_G8_5n I1850_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I141_XG_MN2 (XI1850_I141_XG_n1 I1850_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I141_XG_MN0 (I1850_G16_9 I1850_P16_13n XI1850_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I141_XG_MN1 (XI1850_I141_XG_n1 I1850_G12_9n I1850_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I139_XG_MN2 (XI1850_I139_XG_n1 I1850_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I139_XG_MN0 (I1850_G14_7 I1850_P14_11n XI1850_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I139_XG_MN1 (XI1850_I139_XG_n1 I1850_G10_7n I1850_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I143_XG_MN2 (XI1850_I143_XG_n1 I1850_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I143_XG_MN0 (I1850_G18_11 I1850_P18_15n XI1850_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I143_XG_MN1 (XI1850_I143_XG_n1 I1850_G14_11n I1850_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I199_XG_MN2 (XI1850_I199_XG_n1 I1850_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I199_XG_MN0 (I1850_G28_0 I1850_P28_13n XI1850_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I199_XG_MN1 (XI1850_I199_XG_n1 I1850_G12_0n I1850_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I201_XG_MN2 (XI1850_I201_XG_n1 I1850_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I201_XG_MN0 (c28_m I1850_P30_15n XI1850_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I201_XG_MN1 (XI1850_I201_XG_n1 I1850_G14_0n c28_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I141_XG_MN2 (XI700_I141_XG_n1 I700_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I141_XG_MN0 (I700_G16_9 I700_P16_13n XI700_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I141_XG_MN1 (XI700_I141_XG_n1 I700_G12_9n I700_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I137_XG_MN2 (XI700_I137_XG_n1 I700_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I137_XG_MN0 (I700_G12_5 I700_P12_9n XI700_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I137_XG_MN1 (XI700_I137_XG_n1 I700_G8_5n I700_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I135_XG_MN2 (XI700_I135_XG_n1 I700_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I135_XG_MN0 (I700_G10_3 I700_P10_7n XI700_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I135_XG_MN1 (XI700_I135_XG_n1 I700_G6_3n I700_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I133_XG_MN2 (XI700_I133_XG_n1 I700_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I133_XG_MN0 (I700_G8_1 I700_P8_5n XI700_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I133_XG_MN1 (XI700_I133_XG_n1 I700_G4_1n I700_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I131_XG_MN2 (XI700_I131_XG_n1 I700_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I131_XG_MN0 (I700_G6_0 I700_P6_3n XI700_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I131_XG_MN1 (XI700_I131_XG_n1 I700_G2_0n I700_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I70_XG_MN2 (XI700_I70_XG_n1 I700_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I70_XG_MN0 (I700_G4_3 I700_pn4 XI700_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I70_XG_MN1 (XI700_I70_XG_n1 I700_gn3 I700_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I69_XG_MN2 (XI700_I69_XG_n1 I700_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I69_XG_MN0 (I700_G3_2 I700_pn3 XI700_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I69_XG_MN1 (XI700_I69_XG_n1 I700_gn2 I700_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I68_XG_MN2 (XI700_I68_XG_n1 I700_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I68_XG_MN0 (I700_G2_1 I700_pn2 XI700_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I68_XG_MN1 (XI700_I68_XG_n1 I700_gn1 I700_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I65_XG_MN2 (XI562_I65_XG_n1 I562_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I65_XG_MN0 (I562_G0_0 I562_pn0 XI562_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I65_XG_MN1 (XI562_I65_XG_n1 I562_cinn I562_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I65_XG_MN2 (XI2066_I65_XG_n1 I2066_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I65_XG_MN0 (I2066_G0_0 I2066_pn0 XI2066_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I65_XG_MN1 (XI2066_I65_XG_n1 I2066_cinn I2066_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I65_XG_MN2 (XI1942_I65_XG_n1 I1942_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I65_XG_MN0 (I1942_G0_0 I1942_pn0 XI1942_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I65_XG_MN1 (XI1942_I65_XG_n1 I1942_cinn I1942_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I68_XG_MN2 (XI1850_I68_XG_n1 I1850_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I68_XG_MN0 (I1850_G2_1 I1850_pn2 XI1850_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I68_XG_MN1 (XI1850_I68_XG_n1 I1850_gn1 I1850_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I69_XG_MN2 (XI1850_I69_XG_n1 I1850_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I69_XG_MN0 (I1850_G3_2 I1850_pn3 XI1850_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I69_XG_MN1 (XI1850_I69_XG_n1 I1850_gn2 I1850_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I70_XG_MN2 (XI1850_I70_XG_n1 I1850_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I70_XG_MN0 (I1850_G4_3 I1850_pn4 XI1850_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I70_XG_MN1 (XI1850_I70_XG_n1 I1850_gn3 I1850_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I71_XG_MN2 (XI1850_I71_XG_n1 I1850_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I71_XG_MN0 (I1850_G5_4 I1850_pn5 XI1850_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I71_XG_MN1 (XI1850_I71_XG_n1 I1850_gn4 I1850_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I72_XG_MN2 (XI1850_I72_XG_n1 I1850_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I72_XG_MN0 (I1850_G6_5 I1850_pn6 XI1850_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I72_XG_MN1 (XI1850_I72_XG_n1 I1850_gn5 I1850_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I75_XG_MN2 (XI1850_I75_XG_n1 I1850_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I75_XG_MN0 (I1850_G9_8 I1850_pn9 XI1850_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I75_XG_MN1 (XI1850_I75_XG_n1 I1850_gn8 I1850_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I76_XG_MN2 (XI1850_I76_XG_n1 I1850_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I76_XG_MN0 (I1850_G10_9 I1850_pn10 XI1850_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I76_XG_MN1 (XI1850_I76_XG_n1 I1850_gn9 I1850_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I77_XG_MN2 (XI1850_I77_XG_n1 I1850_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I77_XG_MN0 (I1850_G11_10 I1850_pn11 XI1850_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I77_XG_MN1 (XI1850_I77_XG_n1 I1850_gn10 I1850_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I145_XG_MN2 (XI1850_I145_XG_n1 I1850_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I145_XG_MN0 (I1850_G20_13 I1850_P20_17n XI1850_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I145_XG_MN1 (XI1850_I145_XG_n1 I1850_G16_13n I1850_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I149_XG_MN2 (XI1850_I149_XG_n1 I1850_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I149_XG_MN0 (I1850_G24_17 I1850_P24_21n XI1850_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I149_XG_MN1 (XI1850_I149_XG_n1 I1850_G20_17n I1850_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I147_XG_MN2 (XI1850_I147_XG_n1 I1850_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I147_XG_MN0 (I1850_G22_15 I1850_P22_19n XI1850_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I147_XG_MN1 (XI1850_I147_XG_n1 I1850_G18_15n I1850_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I151_XG_MN2 (XI1850_I151_XG_n1 I1850_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I151_XG_MN0 (I1850_G26_19 I1850_P26_23n XI1850_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I151_XG_MN1 (XI1850_I151_XG_n1 I1850_G22_19n I1850_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I153_XG_MN2 (XI1850_I153_XG_n1 I1850_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I153_XG_MN0 (I1850_G28_21 I1850_P28_25n XI1850_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I153_XG_MN1 (XI1850_I153_XG_n1 I1850_G24_21n I1850_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I155_XG_MN2 (XI1850_I155_XG_n1 I1850_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I155_XG_MN0 (I1850_G30_23 I1850_P30_27n XI1850_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I155_XG_MN1 (XI1850_I155_XG_n1 I1850_G26_23n I1850_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I199_XG_MN2 (XI700_I199_XG_n1 I700_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I199_XG_MN0 (I700_G28_0 I700_P28_13n XI700_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I199_XG_MN1 (XI700_I199_XG_n1 I700_G12_0n I700_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I197_XG_MN2 (XI700_I197_XG_n1 I700_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I197_XG_MN0 (I700_G26_0 I700_P26_11n XI700_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I197_XG_MN1 (XI700_I197_XG_n1 I700_G10_0n I700_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I195_XG_MN2 (XI700_I195_XG_n1 I700_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I195_XG_MN0 (I700_G24_0 I700_P24_9n XI700_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I195_XG_MN1 (XI700_I195_XG_n1 I700_G8_0n I700_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I185_XG_MN2 (XI700_I185_XG_n1 I700_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I185_XG_MN0 (I700_G18_0 I700_P18_3n XI700_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I185_XG_MN1 (XI700_I185_XG_n1 I700_G2_0n I700_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I183_XG_MN2 (XI700_I183_XG_n1 I700_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I183_XG_MN0 (I700_G16_0 I700_P16_1n XI700_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I183_XG_MN1 (XI700_I183_XG_n1 I700_G0_0n I700_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I128_XG_MN2 (XI700_I128_XG_n1 I700_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I128_XG_MN0 (I700_G4_0 I700_P4_1n XI700_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I128_XG_MN1 (XI700_I128_XG_n1 I700_G0_0n I700_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I67_XG_MN2 (XI700_I67_XG_n1 I700_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I67_XG_MN0 (I700_G1_0 I700_pn1 XI700_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I67_XG_MN1 (XI700_I67_XG_n1 I700_G0_0n I700_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I65_XG_MN2 (XI700_I65_XG_n1 I700_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I65_XG_MN0 (I700_G0_0 I700_pn0 XI700_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I65_XG_MN1 (XI700_I65_XG_n1 I700_cinn I700_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I65_XG_MN2 (XI1988_I65_XG_n1 I1988_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I65_XG_MN0 (I1988_G0_0 I1988_pn0 XI1988_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I65_XG_MN1 (XI1988_I65_XG_n1 I1988_cinn I1988_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I65_XG_MN2 (XI1896_I65_XG_n1 I1896_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I65_XG_MN0 (I1896_G0_0 I1896_pn0 XI1896_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I65_XG_MN1 (XI1896_I65_XG_n1 I1896_cinn I1896_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I65_XG_MN2 (XI1850_I65_XG_n1 I1850_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I65_XG_MN0 (I1850_G0_0 I1850_pn0 XI1850_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I65_XG_MN1 (XI1850_I65_XG_n1 I1850_cinn I1850_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I73_XG_MN2 (XI1850_I73_XG_n1 I1850_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I73_XG_MN0 (I1850_G7_6 I1850_pn7 XI1850_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I73_XG_MN1 (XI1850_I73_XG_n1 I1850_gn6 I1850_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I74_XG_MN2 (XI1850_I74_XG_n1 I1850_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I74_XG_MN0 (I1850_G8_7 I1850_pn8 XI1850_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I74_XG_MN1 (XI1850_I74_XG_n1 I1850_gn7 I1850_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I78_XG_MN2 (XI1850_I78_XG_n1 I1850_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I78_XG_MN0 (I1850_G12_11 I1850_pn12 XI1850_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I78_XG_MN1 (XI1850_I78_XG_n1 I1850_gn11 I1850_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I79_XG_MN2 (XI1850_I79_XG_n1 I1850_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I79_XG_MN0 (I1850_G13_12 I1850_pn13 XI1850_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I79_XG_MN1 (XI1850_I79_XG_n1 I1850_gn12 I1850_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I80_XG_MN2 (XI1850_I80_XG_n1 I1850_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I80_XG_MN0 (I1850_G14_13 I1850_pn14 XI1850_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I80_XG_MN1 (XI1850_I80_XG_n1 I1850_gn13 I1850_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I83_XG_MN2 (XI1850_I83_XG_n1 I1850_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I83_XG_MN0 (I1850_G17_16 I1850_pn17 XI1850_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I83_XG_MN1 (XI1850_I83_XG_n1 I1850_gn16 I1850_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I81_XG_MN2 (XI1850_I81_XG_n1 I1850_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I81_XG_MN0 (I1850_G15_14 I1850_pn15 XI1850_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I81_XG_MN1 (XI1850_I81_XG_n1 I1850_gn14 I1850_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I82_XG_MN2 (XI1850_I82_XG_n1 I1850_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I82_XG_MN0 (I1850_G16_15 I1850_pn16 XI1850_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I82_XG_MN1 (XI1850_I82_XG_n1 I1850_gn15 I1850_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I84_XG_MN2 (XI1850_I84_XG_n1 I1850_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I84_XG_MN0 (I1850_G18_17 I1850_pn18 XI1850_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I84_XG_MN1 (XI1850_I84_XG_n1 I1850_gn17 I1850_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I86_XG_MN2 (XI1850_I86_XG_n1 I1850_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I86_XG_MN0 (I1850_G20_19 I1850_pn20 XI1850_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I86_XG_MN1 (XI1850_I86_XG_n1 I1850_gn19 I1850_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I87_XG_MN2 (XI1850_I87_XG_n1 I1850_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I87_XG_MN0 (I1850_G21_20 I1850_pn21 XI1850_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I87_XG_MN1 (XI1850_I87_XG_n1 I1850_gn20 I1850_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I89_XG_MN2 (XI1850_I89_XG_n1 I1850_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I89_XG_MN0 (I1850_G23_22 I1850_pn23 XI1850_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I89_XG_MN1 (XI1850_I89_XG_n1 I1850_gn22 I1850_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I188_XG_MN2 (XI700_I188_XG_n1 I700_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I188_XG_MN0 (I700_G20_0 I700_P20_5n XI700_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I188_XG_MN1 (XI700_I188_XG_n1 I700_G4_0n I700_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I65_XG_MN2 (XI746_I65_XG_n1 I746_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I65_XG_MN0 (I746_G0_0 I746_pn0 XI746_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I65_XG_MN1 (XI746_I65_XG_n1 I746_cinn I746_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I65_XG_MN2 (XI792_I65_XG_n1 I792_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I65_XG_MN0 (I792_G0_0 I792_pn0 XI792_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I65_XG_MN1 (XI792_I65_XG_n1 I792_cinn I792_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I65_XG_MN2 (XI838_I65_XG_n1 I838_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I65_XG_MN0 (I838_G0_0 I838_pn0 XI838_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I65_XG_MN1 (XI838_I65_XG_n1 I838_cinn I838_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I65_XG_MN2 (XI1804_I65_XG_n1 I1804_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I65_XG_MN0 (I1804_G0_0 I1804_pn0 XI1804_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I65_XG_MN1 (XI1804_I65_XG_n1 I1804_cinn I1804_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I85_XG_MN2 (XI1850_I85_XG_n1 I1850_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I85_XG_MN0 (I1850_G19_18 I1850_pn19 XI1850_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I85_XG_MN1 (XI1850_I85_XG_n1 I1850_gn18 I1850_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I88_XG_MN2 (XI1850_I88_XG_n1 I1850_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I88_XG_MN0 (I1850_G22_21 I1850_pn22 XI1850_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I88_XG_MN1 (XI1850_I88_XG_n1 I1850_gn21 I1850_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I91_XG_MN2 (XI1850_I91_XG_n1 I1850_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I91_XG_MN0 (I1850_G25_24 I1850_pn25 XI1850_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I91_XG_MN1 (XI1850_I91_XG_n1 I1850_gn24 I1850_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I90_XG_MN2 (XI1850_I90_XG_n1 I1850_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I90_XG_MN0 (I1850_G24_23 I1850_pn24 XI1850_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I90_XG_MN1 (XI1850_I90_XG_n1 I1850_gn23 I1850_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I93_XG_MN2 (XI1850_I93_XG_n1 I1850_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I93_XG_MN0 (I1850_G27_26 I1850_pn27 XI1850_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I93_XG_MN1 (XI1850_I93_XG_n1 I1850_gn26 I1850_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I92_XG_MN2 (XI1850_I92_XG_n1 I1850_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I92_XG_MN0 (I1850_G26_25 I1850_pn26 XI1850_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I92_XG_MN1 (XI1850_I92_XG_n1 I1850_gn25 I1850_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I94_XG_MN2 (XI1850_I94_XG_n1 I1850_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I94_XG_MN0 (I1850_G28_27 I1850_pn28 XI1850_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I94_XG_MN1 (XI1850_I94_XG_n1 I1850_gn27 I1850_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I95_XG_MN2 (XI1850_I95_XG_n1 I1850_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I95_XG_MN0 (I1850_G29_28 I1850_pn29 XI1850_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I95_XG_MN1 (XI1850_I95_XG_n1 I1850_gn28 I1850_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I70_XG_MN2 (XI746_I70_XG_n1 I746_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I70_XG_MN0 (I746_G4_3 I746_pn4 XI746_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I70_XG_MN1 (XI746_I70_XG_n1 I746_gn3 I746_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I69_XG_MN2 (XI746_I69_XG_n1 I746_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I69_XG_MN0 (I746_G3_2 I746_pn3 XI746_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I69_XG_MN1 (XI746_I69_XG_n1 I746_gn2 I746_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I69_XG_MN2 (XI792_I69_XG_n1 I792_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I69_XG_MN0 (I792_G3_2 I792_pn3 XI792_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I69_XG_MN1 (XI792_I69_XG_n1 I792_gn2 I792_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I68_XG_MN2 (XI792_I68_XG_n1 I792_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I68_XG_MN0 (I792_G2_1 I792_pn2 XI792_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I68_XG_MN1 (XI792_I68_XG_n1 I792_gn1 I792_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I67_XG_MN2 (XI792_I67_XG_n1 I792_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I67_XG_MN0 (I792_G1_0 I792_pn1 XI792_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I67_XG_MN1 (XI792_I67_XG_n1 I792_G0_0n I792_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I68_XG_MN2 (XI838_I68_XG_n1 I838_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I68_XG_MN0 (I838_G2_1 I838_pn2 XI838_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I68_XG_MN1 (XI838_I68_XG_n1 I838_gn1 I838_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I65_XG_MN2 (XI1712_I65_XG_n1 I1712_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I65_XG_MN0 (I1712_G0_0 I1712_pn0 XI1712_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I65_XG_MN1 (XI1712_I65_XG_n1 I1712_cinn I1712_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I65_XG_MN2 (XI1758_I65_XG_n1 I1758_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I65_XG_MN0 (I1758_G0_0 I1758_pn0 XI1758_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I65_XG_MN1 (XI1758_I65_XG_n1 I1758_cinn I1758_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I68_XG_MN2 (XI1804_I68_XG_n1 I1804_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I68_XG_MN0 (I1804_G2_1 I1804_pn2 XI1804_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I68_XG_MN1 (XI1804_I68_XG_n1 I1804_gn1 I1804_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I96_XG_MN2 (XI1850_I96_XG_n1 I1850_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I96_XG_MN0 (I1850_G30_29 I1850_pn30 XI1850_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I96_XG_MN1 (XI1850_I96_XG_n1 I1850_gn29 I1850_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I76_XG_MN2 (XI746_I76_XG_n1 I746_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I76_XG_MN0 (I746_G10_9 I746_pn10 XI746_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I76_XG_MN1 (XI746_I76_XG_n1 I746_gn9 I746_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I75_XG_MN2 (XI746_I75_XG_n1 I746_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I75_XG_MN0 (I746_G9_8 I746_pn9 XI746_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I75_XG_MN1 (XI746_I75_XG_n1 I746_gn8 I746_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I74_XG_MN2 (XI746_I74_XG_n1 I746_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I74_XG_MN0 (I746_G8_7 I746_pn8 XI746_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I74_XG_MN1 (XI746_I74_XG_n1 I746_gn7 I746_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I73_XG_MN2 (XI746_I73_XG_n1 I746_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I73_XG_MN0 (I746_G7_6 I746_pn7 XI746_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I73_XG_MN1 (XI746_I73_XG_n1 I746_gn6 I746_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I72_XG_MN2 (XI746_I72_XG_n1 I746_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I72_XG_MN0 (I746_G6_5 I746_pn6 XI746_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I72_XG_MN1 (XI746_I72_XG_n1 I746_gn5 I746_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I71_XG_MN2 (XI746_I71_XG_n1 I746_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I71_XG_MN0 (I746_G5_4 I746_pn5 XI746_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I71_XG_MN1 (XI746_I71_XG_n1 I746_gn4 I746_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I68_XG_MN2 (XI746_I68_XG_n1 I746_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I68_XG_MN0 (I746_G2_1 I746_pn2 XI746_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I68_XG_MN1 (XI746_I68_XG_n1 I746_gn1 I746_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I73_XG_MN2 (XI792_I73_XG_n1 I792_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I73_XG_MN0 (I792_G7_6 I792_pn7 XI792_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I73_XG_MN1 (XI792_I73_XG_n1 I792_gn6 I792_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I71_XG_MN2 (XI792_I71_XG_n1 I792_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I71_XG_MN0 (I792_G5_4 I792_pn5 XI792_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I71_XG_MN1 (XI792_I71_XG_n1 I792_gn4 I792_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I72_XG_MN2 (XI792_I72_XG_n1 I792_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I72_XG_MN0 (I792_G6_5 I792_pn6 XI792_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I72_XG_MN1 (XI792_I72_XG_n1 I792_gn5 I792_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I70_XG_MN2 (XI792_I70_XG_n1 I792_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I70_XG_MN0 (I792_G4_3 I792_pn4 XI792_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I70_XG_MN1 (XI792_I70_XG_n1 I792_gn3 I792_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I71_XG_MN2 (XI838_I71_XG_n1 I838_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I71_XG_MN0 (I838_G5_4 I838_pn5 XI838_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I71_XG_MN1 (XI838_I71_XG_n1 I838_gn4 I838_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I70_XG_MN2 (XI838_I70_XG_n1 I838_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I70_XG_MN0 (I838_G4_3 I838_pn4 XI838_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I70_XG_MN1 (XI838_I70_XG_n1 I838_gn3 I838_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I69_XG_MN2 (XI838_I69_XG_n1 I838_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I69_XG_MN0 (I838_G3_2 I838_pn3 XI838_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I69_XG_MN1 (XI838_I69_XG_n1 I838_gn2 I838_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I67_XG_MN2 (XI838_I67_XG_n1 I838_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I67_XG_MN0 (I838_G1_0 I838_pn1 XI838_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I67_XG_MN1 (XI838_I67_XG_n1 I838_G0_0n I838_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I71_XG_MN2 (XI884_I71_XG_n1 I884_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I71_XG_MN0 (I884_G5_4 I884_pn5 XI884_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I71_XG_MN1 (XI884_I71_XG_n1 I884_gn4 I884_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I70_XG_MN2 (XI884_I70_XG_n1 I884_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I70_XG_MN0 (I884_G4_3 I884_pn4 XI884_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I70_XG_MN1 (XI884_I70_XG_n1 I884_gn3 I884_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I69_XG_MN2 (XI884_I69_XG_n1 I884_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I69_XG_MN0 (I884_G3_2 I884_pn3 XI884_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I69_XG_MN1 (XI884_I69_XG_n1 I884_gn2 I884_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I68_XG_MN2 (XI884_I68_XG_n1 I884_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I68_XG_MN0 (I884_G2_1 I884_pn2 XI884_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I68_XG_MN1 (XI884_I68_XG_n1 I884_gn1 I884_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I67_XG_MN2 (XI884_I67_XG_n1 I884_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I67_XG_MN0 (I884_G1_0 I884_pn1 XI884_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I67_XG_MN1 (XI884_I67_XG_n1 I884_G0_0n I884_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I68_XG_MN2 (XI1712_I68_XG_n1 I1712_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I68_XG_MN0 (I1712_G2_1 I1712_pn2 XI1712_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I68_XG_MN1 (XI1712_I68_XG_n1 I1712_gn1 I1712_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I67_XG_MN2 (XI1712_I67_XG_n1 I1712_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I67_XG_MN0 (I1712_G1_0 I1712_pn1 XI1712_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I67_XG_MN1 (XI1712_I67_XG_n1 I1712_G0_0n I1712_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I69_XG_MN2 (XI1758_I69_XG_n1 I1758_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I69_XG_MN0 (I1758_G3_2 I1758_pn3 XI1758_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I69_XG_MN1 (XI1758_I69_XG_n1 I1758_gn2 I1758_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I68_XG_MN2 (XI1758_I68_XG_n1 I1758_gn2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I68_XG_MN0 (I1758_G2_1 I1758_pn2 XI1758_I68_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I68_XG_MN1 (XI1758_I68_XG_n1 I1758_gn1 I1758_G2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I67_XG_MN2 (XI1758_I67_XG_n1 I1758_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I67_XG_MN0 (I1758_G1_0 I1758_pn1 XI1758_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I67_XG_MN1 (XI1758_I67_XG_n1 I1758_G0_0n I1758_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I69_XG_MN2 (XI1804_I69_XG_n1 I1804_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I69_XG_MN0 (I1804_G3_2 I1804_pn3 XI1804_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I69_XG_MN1 (XI1804_I69_XG_n1 I1804_gn2 I1804_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I67_XG_MN2 (XI1804_I67_XG_n1 I1804_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I67_XG_MN0 (I1804_G1_0 I1804_pn1 XI1804_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I67_XG_MN1 (XI1804_I67_XG_n1 I1804_G0_0n I1804_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I88_XG_MN2 (XI746_I88_XG_n1 I746_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I88_XG_MN0 (I746_G22_21 I746_pn22 XI746_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I88_XG_MN1 (XI746_I88_XG_n1 I746_gn21 I746_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I87_XG_MN2 (XI746_I87_XG_n1 I746_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I87_XG_MN0 (I746_G21_20 I746_pn21 XI746_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I87_XG_MN1 (XI746_I87_XG_n1 I746_gn20 I746_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I86_XG_MN2 (XI746_I86_XG_n1 I746_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I86_XG_MN0 (I746_G20_19 I746_pn20 XI746_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I86_XG_MN1 (XI746_I86_XG_n1 I746_gn19 I746_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I85_XG_MN2 (XI746_I85_XG_n1 I746_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I85_XG_MN0 (I746_G19_18 I746_pn19 XI746_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I85_XG_MN1 (XI746_I85_XG_n1 I746_gn18 I746_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I84_XG_MN2 (XI746_I84_XG_n1 I746_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I84_XG_MN0 (I746_G18_17 I746_pn18 XI746_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I84_XG_MN1 (XI746_I84_XG_n1 I746_gn17 I746_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I81_XG_MN2 (XI746_I81_XG_n1 I746_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I81_XG_MN0 (I746_G15_14 I746_pn15 XI746_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I81_XG_MN1 (XI746_I81_XG_n1 I746_gn14 I746_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I80_XG_MN2 (XI746_I80_XG_n1 I746_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I80_XG_MN0 (I746_G14_13 I746_pn14 XI746_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I80_XG_MN1 (XI746_I80_XG_n1 I746_gn13 I746_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I79_XG_MN2 (XI746_I79_XG_n1 I746_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I79_XG_MN0 (I746_G13_12 I746_pn13 XI746_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I79_XG_MN1 (XI746_I79_XG_n1 I746_gn12 I746_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I78_XG_MN2 (XI746_I78_XG_n1 I746_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I78_XG_MN0 (I746_G12_11 I746_pn12 XI746_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I78_XG_MN1 (XI746_I78_XG_n1 I746_gn11 I746_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I77_XG_MN2 (XI746_I77_XG_n1 I746_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I77_XG_MN0 (I746_G11_10 I746_pn11 XI746_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I77_XG_MN1 (XI746_I77_XG_n1 I746_gn10 I746_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I67_XG_MN2 (XI746_I67_XG_n1 I746_gn1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I67_XG_MN0 (I746_G1_0 I746_pn1 XI746_I67_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I67_XG_MN1 (XI746_I67_XG_n1 I746_G0_0n I746_G1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I74_XG_MN2 (XI792_I74_XG_n1 I792_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I74_XG_MN0 (I792_G8_7 I792_pn8 XI792_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I74_XG_MN1 (XI792_I74_XG_n1 I792_gn7 I792_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I130_XG_MN2 (XI792_I130_XG_n1 I792_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I130_XG_MN0 (I792_G5_0 I792_P5_2n XI792_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I130_XG_MN1 (XI792_I130_XG_n1 I792_G1_0n I792_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I133_XG_MN2 (XI792_I133_XG_n1 I792_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I133_XG_MN0 (I792_G8_1 I792_P8_5n XI792_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I133_XG_MN1 (XI792_I133_XG_n1 I792_G4_1n I792_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I128_XG_MN2 (XI792_I128_XG_n1 I792_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I128_XG_MN0 (I792_G4_0 I792_P4_1n XI792_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I128_XG_MN1 (XI792_I128_XG_n1 I792_G0_0n I792_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I73_XG_MN2 (XI838_I73_XG_n1 I838_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I73_XG_MN0 (I838_G7_6 I838_pn7 XI838_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I73_XG_MN1 (XI838_I73_XG_n1 I838_gn6 I838_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I72_XG_MN2 (XI838_I72_XG_n1 I838_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I72_XG_MN0 (I838_G6_5 I838_pn6 XI838_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I72_XG_MN1 (XI838_I72_XG_n1 I838_gn5 I838_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I130_XG_MN2 (XI838_I130_XG_n1 I838_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I130_XG_MN0 (I838_G5_0 I838_P5_2n XI838_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I130_XG_MN1 (XI838_I130_XG_n1 I838_G1_0n I838_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I133_XG_MN2 (XI838_I133_XG_n1 I838_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I133_XG_MN0 (I838_G8_1 I838_P8_5n XI838_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I133_XG_MN1 (XI838_I133_XG_n1 I838_G4_1n I838_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I128_XG_MN2 (XI838_I128_XG_n1 I838_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I128_XG_MN0 (I838_G4_0 I838_P4_1n XI838_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I128_XG_MN1 (XI838_I128_XG_n1 I838_G0_0n I838_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I65_XG_MN2 (XI884_I65_XG_n1 I884_gn0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I65_XG_MN0 (I884_G0_0 I884_pn0 XI884_I65_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I65_XG_MN1 (XI884_I65_XG_n1 I884_cinn I884_G0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I72_XG_MN2 (XI884_I72_XG_n1 I884_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I72_XG_MN0 (I884_G6_5 I884_pn6 XI884_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I72_XG_MN1 (XI884_I72_XG_n1 I884_gn5 I884_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I133_XG_MN2 (XI1712_I133_XG_n1 I1712_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I133_XG_MN0 (I1712_G8_1 I1712_P8_5n XI1712_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I133_XG_MN1 (XI1712_I133_XG_n1 I1712_G4_1n I1712_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I183_XG_MN2 (XI1712_I183_XG_n1 I1712_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I183_XG_MN0 (I1712_G16_0 I1712_P16_1n XI1712_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I183_XG_MN1 (XI1712_I183_XG_n1 I1712_G0_0n I1712_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I128_XG_MN2 (XI1712_I128_XG_n1 I1712_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I128_XG_MN0 (I1712_G4_0 I1712_P4_1n XI1712_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I128_XG_MN1 (XI1712_I128_XG_n1 I1712_G0_0n I1712_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I70_XG_MN2 (XI1712_I70_XG_n1 I1712_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I70_XG_MN0 (I1712_G4_3 I1712_pn4 XI1712_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I70_XG_MN1 (XI1712_I70_XG_n1 I1712_gn3 I1712_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I69_XG_MN2 (XI1712_I69_XG_n1 I1712_gn3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I69_XG_MN0 (I1712_G3_2 I1712_pn3 XI1712_I69_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I69_XG_MN1 (XI1712_I69_XG_n1 I1712_gn2 I1712_G3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I71_XG_MN2 (XI1758_I71_XG_n1 I1758_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I71_XG_MN0 (I1758_G5_4 I1758_pn5 XI1758_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I71_XG_MN1 (XI1758_I71_XG_n1 I1758_gn4 I1758_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I70_XG_MN2 (XI1758_I70_XG_n1 I1758_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I70_XG_MN0 (I1758_G4_3 I1758_pn4 XI1758_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I70_XG_MN1 (XI1758_I70_XG_n1 I1758_gn3 I1758_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I128_XG_MN2 (XI1758_I128_XG_n1 I1758_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I128_XG_MN0 (I1758_G4_0 I1758_P4_1n XI1758_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I128_XG_MN1 (XI1758_I128_XG_n1 I1758_G0_0n I1758_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I70_XG_MN2 (XI1804_I70_XG_n1 I1804_gn4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I70_XG_MN0 (I1804_G4_3 I1804_pn4 XI1804_I70_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I70_XG_MN1 (XI1804_I70_XG_n1 I1804_gn3 I1804_G4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I71_XG_MN2 (XI1804_I71_XG_n1 I1804_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I71_XG_MN0 (I1804_G5_4 I1804_pn5 XI1804_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I71_XG_MN1 (XI1804_I71_XG_n1 I1804_gn4 I1804_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I72_XG_MN2 (XI1804_I72_XG_n1 I1804_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I72_XG_MN0 (I1804_G6_5 I1804_pn6 XI1804_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I72_XG_MN1 (XI1804_I72_XG_n1 I1804_gn5 I1804_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I128_XG_MN2 (XI1804_I128_XG_n1 I1804_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I128_XG_MN0 (I1804_G4_0 I1804_P4_1n XI1804_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I128_XG_MN1 (XI1804_I128_XG_n1 I1804_G0_0n I1804_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I133_XG_MN2 (XI1804_I133_XG_n1 I1804_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I133_XG_MN0 (I1804_G8_1 I1804_P8_5n XI1804_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I133_XG_MN1 (XI1804_I133_XG_n1 I1804_G4_1n I1804_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I131_XG_MN2 (XI1804_I131_XG_n1 I1804_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I131_XG_MN0 (I1804_G6_0 I1804_P6_3n XI1804_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I131_XG_MN1 (XI1804_I131_XG_n1 I1804_G2_0n I1804_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I183_XG_MN2 (XI1804_I183_XG_n1 I1804_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I183_XG_MN0 (I1804_G16_0 I1804_P16_1n XI1804_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I183_XG_MN1 (XI1804_I183_XG_n1 I1804_G0_0n I1804_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I185_XG_MN2 (XI1804_I185_XG_n1 I1804_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I185_XG_MN0 (I1804_G18_0 I1804_P18_3n XI1804_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I185_XG_MN1 (XI1804_I185_XG_n1 I1804_G2_0n I1804_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I97_XG_MN2 (XI1850_I97_XG_n1 I1850_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I97_XG_MN0 (I1850_G31_30 I1850_pn31 XI1850_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I97_XG_MN1 (XI1850_I97_XG_n1 I1850_gn30 I1850_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I194_XG_MN2 (XI746_I194_XG_n1 I746_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I194_XG_MN0 (I746_G23_0 I746_P23_8n XI746_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I194_XG_MN1 (XI746_I194_XG_n1 I746_G7_0n I746_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I89_XG_MN2 (XI746_I89_XG_n1 I746_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I89_XG_MN0 (I746_G23_22 I746_pn23 XI746_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I89_XG_MN1 (XI746_I89_XG_n1 I746_gn22 I746_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I140_XG_MN2 (XI746_I140_XG_n1 I746_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I140_XG_MN0 (I746_G15_8 I746_P15_12n XI746_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I140_XG_MN1 (XI746_I140_XG_n1 I746_G11_8n I746_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I136_XG_MN2 (XI746_I136_XG_n1 I746_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I136_XG_MN0 (I746_G11_4 I746_P11_8n XI746_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I136_XG_MN1 (XI746_I136_XG_n1 I746_G7_4n I746_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I132_XG_MN2 (XI746_I132_XG_n1 I746_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I132_XG_MN0 (I746_G7_0 I746_P7_4n XI746_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I132_XG_MN1 (XI746_I132_XG_n1 I746_G3_0n I746_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I83_XG_MN2 (XI746_I83_XG_n1 I746_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I83_XG_MN0 (I746_G17_16 I746_pn17 XI746_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I83_XG_MN1 (XI746_I83_XG_n1 I746_gn16 I746_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I82_XG_MN2 (XI746_I82_XG_n1 I746_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I82_XG_MN0 (I746_G16_15 I746_pn16 XI746_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I82_XG_MN1 (XI746_I82_XG_n1 I746_gn15 I746_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I134_XG_MN2 (XI746_I134_XG_n1 I746_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I134_XG_MN0 (I746_G9_2 I746_P9_6n XI746_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I134_XG_MN1 (XI746_I134_XG_n1 I746_G5_2n I746_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I130_XG_MN2 (XI746_I130_XG_n1 I746_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I130_XG_MN0 (I746_G5_0 I746_P5_2n XI746_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I130_XG_MN1 (XI746_I130_XG_n1 I746_G1_0n I746_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I76_XG_MN2 (XI792_I76_XG_n1 I792_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I76_XG_MN0 (I792_G10_9 I792_pn10 XI792_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I76_XG_MN1 (XI792_I76_XG_n1 I792_gn9 I792_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I75_XG_MN2 (XI792_I75_XG_n1 I792_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I75_XG_MN0 (I792_G9_8 I792_pn9 XI792_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I75_XG_MN1 (XI792_I75_XG_n1 I792_gn8 I792_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I134_XG_MN2 (XI792_I134_XG_n1 I792_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I134_XG_MN0 (I792_G9_2 I792_P9_6n XI792_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I134_XG_MN1 (XI792_I134_XG_n1 I792_G5_2n I792_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I131_XG_MN2 (XI792_I131_XG_n1 I792_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I131_XG_MN0 (I792_G6_0 I792_P6_3n XI792_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I131_XG_MN1 (XI792_I131_XG_n1 I792_G2_0n I792_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I75_XG_MN2 (XI838_I75_XG_n1 I838_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I75_XG_MN0 (I838_G9_8 I838_pn9 XI838_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I75_XG_MN1 (XI838_I75_XG_n1 I838_gn8 I838_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I74_XG_MN2 (XI838_I74_XG_n1 I838_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I74_XG_MN0 (I838_G8_7 I838_pn8 XI838_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I74_XG_MN1 (XI838_I74_XG_n1 I838_gn7 I838_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I134_XG_MN2 (XI838_I134_XG_n1 I838_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I134_XG_MN0 (I838_G9_2 I838_P9_6n XI838_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I134_XG_MN1 (XI838_I134_XG_n1 I838_G5_2n I838_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I183_XG_MN2 (XI838_I183_XG_n1 I838_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I183_XG_MN0 (I838_G16_0 I838_P16_1n XI838_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I183_XG_MN1 (XI838_I183_XG_n1 I838_G0_0n I838_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I131_XG_MN2 (XI838_I131_XG_n1 I838_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I131_XG_MN0 (I838_G6_0 I838_P6_3n XI838_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I131_XG_MN1 (XI838_I131_XG_n1 I838_G2_0n I838_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I75_XG_MN2 (XI884_I75_XG_n1 I884_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I75_XG_MN0 (I884_G9_8 I884_pn9 XI884_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I75_XG_MN1 (XI884_I75_XG_n1 I884_gn8 I884_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I74_XG_MN2 (XI884_I74_XG_n1 I884_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I74_XG_MN0 (I884_G8_7 I884_pn8 XI884_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I74_XG_MN1 (XI884_I74_XG_n1 I884_gn7 I884_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I73_XG_MN2 (XI884_I73_XG_n1 I884_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I73_XG_MN0 (I884_G7_6 I884_pn7 XI884_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I73_XG_MN1 (XI884_I73_XG_n1 I884_gn6 I884_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I133_XG_MN2 (XI884_I133_XG_n1 I884_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I133_XG_MN0 (I884_G8_1 I884_P8_5n XI884_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I133_XG_MN1 (XI884_I133_XG_n1 I884_G4_1n I884_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I128_XG_MN2 (XI884_I128_XG_n1 I884_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I128_XG_MN0 (I884_G4_0 I884_P4_1n XI884_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I128_XG_MN1 (XI884_I128_XG_n1 I884_G0_0n I884_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I130_XG_MN2 (XI884_I130_XG_n1 I884_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I130_XG_MN0 (I884_G5_0 I884_P5_2n XI884_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I130_XG_MN1 (XI884_I130_XG_n1 I884_G1_0n I884_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I72_XG_MN2 (XI1712_I72_XG_n1 I1712_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I72_XG_MN0 (I1712_G6_5 I1712_pn6 XI1712_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I72_XG_MN1 (XI1712_I72_XG_n1 I1712_gn5 I1712_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I71_XG_MN2 (XI1712_I71_XG_n1 I1712_gn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I71_XG_MN0 (I1712_G5_4 I1712_pn5 XI1712_I71_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I71_XG_MN1 (XI1712_I71_XG_n1 I1712_gn4 I1712_G5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I73_XG_MN2 (XI1758_I73_XG_n1 I1758_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I73_XG_MN0 (I1758_G7_6 I1758_pn7 XI1758_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I73_XG_MN1 (XI1758_I73_XG_n1 I1758_gn6 I1758_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I72_XG_MN2 (XI1758_I72_XG_n1 I1758_gn6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I72_XG_MN0 (I1758_G6_5 I1758_pn6 XI1758_I72_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I72_XG_MN1 (XI1758_I72_XG_n1 I1758_gn5 I1758_G6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I133_XG_MN2 (XI1758_I133_XG_n1 I1758_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I133_XG_MN0 (I1758_G8_1 I1758_P8_5n XI1758_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I133_XG_MN1 (XI1758_I133_XG_n1 I1758_G4_1n I1758_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I183_XG_MN2 (XI1758_I183_XG_n1 I1758_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I183_XG_MN0 (I1758_G16_0 I1758_P16_1n XI1758_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I183_XG_MN1 (XI1758_I183_XG_n1 I1758_G0_0n I1758_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I73_XG_MN2 (XI1804_I73_XG_n1 I1804_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I73_XG_MN0 (I1804_G7_6 I1804_pn7 XI1804_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I73_XG_MN1 (XI1804_I73_XG_n1 I1804_gn6 I1804_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I74_XG_MN2 (XI1804_I74_XG_n1 I1804_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I74_XG_MN0 (I1804_G8_7 I1804_pn8 XI1804_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I74_XG_MN1 (XI1804_I74_XG_n1 I1804_gn7 I1804_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I130_XG_MN2 (XI1804_I130_XG_n1 I1804_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I130_XG_MN0 (I1804_G5_0 I1804_P5_2n XI1804_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I130_XG_MN1 (XI1804_I130_XG_n1 I1804_G1_0n I1804_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I135_XG_MN2 (XI1804_I135_XG_n1 I1804_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I135_XG_MN0 (I1804_G10_3 I1804_P10_7n XI1804_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I135_XG_MN1 (XI1804_I135_XG_n1 I1804_G6_3n I1804_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I188_XG_MN2 (XI1804_I188_XG_n1 I1804_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I188_XG_MN0 (I1804_G20_0 I1804_P20_5n XI1804_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I188_XG_MN1 (XI1804_I188_XG_n1 I1804_G4_0n I1804_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I195_XG_MN2 (XI1804_I195_XG_n1 I1804_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I195_XG_MN0 (I1804_G24_0 I1804_P24_9n XI1804_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I195_XG_MN1 (XI1804_I195_XG_n1 I1804_G8_0n I1804_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I202_XG_MN2 (XI746_I202_XG_n1 I746_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I202_XG_MN0 (c4_o I746_P31_16n XI746_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I202_XG_MN1 (XI746_I202_XG_n1 I746_G15_0n c4_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I148_XG_MN2 (XI746_I148_XG_n1 I746_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I148_XG_MN0 (I746_G23_16 I746_P23_20n XI746_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I148_XG_MN1 (XI746_I148_XG_n1 I746_G19_16n I746_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I144_XG_MN2 (XI746_I144_XG_n1 I746_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I144_XG_MN0 (I746_G19_12 I746_P19_16n XI746_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I144_XG_MN1 (XI746_I144_XG_n1 I746_G15_12n I746_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I186_XG_MN2 (XI746_I186_XG_n1 I746_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I186_XG_MN0 (I746_G19_0 I746_P19_4n XI746_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I186_XG_MN1 (XI746_I186_XG_n1 I746_G3_0n I746_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I142_XG_MN2 (XI746_I142_XG_n1 I746_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I142_XG_MN0 (I746_G17_10 I746_P17_14n XI746_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I142_XG_MN1 (XI746_I142_XG_n1 I746_G13_10n I746_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I138_XG_MN2 (XI746_I138_XG_n1 I746_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I138_XG_MN0 (I746_G13_6 I746_P13_10n XI746_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I138_XG_MN1 (XI746_I138_XG_n1 I746_G9_6n I746_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I184_XG_MN2 (XI746_I184_XG_n1 I746_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I184_XG_MN0 (I746_G17_0 I746_P17_2n XI746_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I184_XG_MN1 (XI746_I184_XG_n1 I746_G1_0n I746_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I133_XG_MN2 (XI746_I133_XG_n1 I746_G8_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I133_XG_MN0 (I746_G8_1 I746_P8_5n XI746_I133_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I133_XG_MN1 (XI746_I133_XG_n1 I746_G4_1n I746_G8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I128_XG_MN2 (XI746_I128_XG_n1 I746_G4_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I128_XG_MN0 (I746_G4_0 I746_P4_1n XI746_I128_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I128_XG_MN1 (XI746_I128_XG_n1 I746_G0_0n I746_G4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I78_XG_MN2 (XI792_I78_XG_n1 I792_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I78_XG_MN0 (I792_G12_11 I792_pn12 XI792_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I78_XG_MN1 (XI792_I78_XG_n1 I792_gn11 I792_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I77_XG_MN2 (XI792_I77_XG_n1 I792_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I77_XG_MN0 (I792_G11_10 I792_pn11 XI792_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I77_XG_MN1 (XI792_I77_XG_n1 I792_gn10 I792_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I136_XG_MN2 (XI792_I136_XG_n1 I792_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I136_XG_MN0 (I792_G11_4 I792_P11_8n XI792_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I136_XG_MN1 (XI792_I136_XG_n1 I792_G7_4n I792_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I132_XG_MN2 (XI792_I132_XG_n1 I792_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I132_XG_MN0 (I792_G7_0 I792_P7_4n XI792_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I132_XG_MN1 (XI792_I132_XG_n1 I792_G3_0n I792_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I184_XG_MN2 (XI792_I184_XG_n1 I792_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I184_XG_MN0 (I792_G17_0 I792_P17_2n XI792_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I184_XG_MN1 (XI792_I184_XG_n1 I792_G1_0n I792_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I135_XG_MN2 (XI792_I135_XG_n1 I792_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I135_XG_MN0 (I792_G10_3 I792_P10_7n XI792_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I135_XG_MN1 (XI792_I135_XG_n1 I792_G6_3n I792_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I183_XG_MN2 (XI792_I183_XG_n1 I792_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I183_XG_MN0 (I792_G16_0 I792_P16_1n XI792_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I183_XG_MN1 (XI792_I183_XG_n1 I792_G0_0n I792_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I76_XG_MN2 (XI838_I76_XG_n1 I838_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I76_XG_MN0 (I838_G10_9 I838_pn10 XI838_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I76_XG_MN1 (XI838_I76_XG_n1 I838_gn9 I838_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I132_XG_MN2 (XI838_I132_XG_n1 I838_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I132_XG_MN0 (I838_G7_0 I838_P7_4n XI838_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I132_XG_MN1 (XI838_I132_XG_n1 I838_G3_0n I838_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I184_XG_MN2 (XI838_I184_XG_n1 I838_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I184_XG_MN0 (I838_G17_0 I838_P17_2n XI838_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I184_XG_MN1 (XI838_I184_XG_n1 I838_G1_0n I838_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I137_XG_MN2 (XI838_I137_XG_n1 I838_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I137_XG_MN0 (I838_G12_5 I838_P12_9n XI838_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I137_XG_MN1 (XI838_I137_XG_n1 I838_G8_5n I838_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I195_XG_MN2 (XI838_I195_XG_n1 I838_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I195_XG_MN0 (I838_G24_0 I838_P24_9n XI838_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I195_XG_MN1 (XI838_I195_XG_n1 I838_G8_0n I838_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I135_XG_MN2 (XI838_I135_XG_n1 I838_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I135_XG_MN0 (I838_G10_3 I838_P10_7n XI838_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I135_XG_MN1 (XI838_I135_XG_n1 I838_G6_3n I838_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I185_XG_MN2 (XI838_I185_XG_n1 I838_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I185_XG_MN0 (I838_G18_0 I838_P18_3n XI838_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I185_XG_MN1 (XI838_I185_XG_n1 I838_G2_0n I838_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I76_XG_MN2 (XI884_I76_XG_n1 I884_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I76_XG_MN0 (I884_G10_9 I884_pn10 XI884_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I76_XG_MN1 (XI884_I76_XG_n1 I884_gn9 I884_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I135_XG_MN2 (XI884_I135_XG_n1 I884_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I135_XG_MN0 (I884_G10_3 I884_P10_7n XI884_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I135_XG_MN1 (XI884_I135_XG_n1 I884_G6_3n I884_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I131_XG_MN2 (XI884_I131_XG_n1 I884_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I131_XG_MN0 (I884_G6_0 I884_P6_3n XI884_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I131_XG_MN1 (XI884_I131_XG_n1 I884_G2_0n I884_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I183_XG_MN2 (XI884_I183_XG_n1 I884_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I183_XG_MN0 (I884_G16_0 I884_P16_1n XI884_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I183_XG_MN1 (XI884_I183_XG_n1 I884_G0_0n I884_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I134_XG_MN2 (XI884_I134_XG_n1 I884_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I134_XG_MN0 (I884_G9_2 I884_P9_6n XI884_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I134_XG_MN1 (XI884_I134_XG_n1 I884_G5_2n I884_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I135_XG_MN2 (XI1712_I135_XG_n1 I1712_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I135_XG_MN0 (I1712_G10_3 I1712_P10_7n XI1712_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I135_XG_MN1 (XI1712_I135_XG_n1 I1712_G6_3n I1712_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I131_XG_MN2 (XI1712_I131_XG_n1 I1712_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I131_XG_MN0 (I1712_G6_0 I1712_P6_3n XI1712_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I131_XG_MN1 (XI1712_I131_XG_n1 I1712_G2_0n I1712_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I188_XG_MN2 (XI1712_I188_XG_n1 I1712_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I188_XG_MN0 (I1712_G20_0 I1712_P20_5n XI1712_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I188_XG_MN1 (XI1712_I188_XG_n1 I1712_G4_0n I1712_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I137_XG_MN2 (XI1712_I137_XG_n1 I1712_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I137_XG_MN0 (I1712_G12_5 I1712_P12_9n XI1712_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I137_XG_MN1 (XI1712_I137_XG_n1 I1712_G8_5n I1712_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I74_XG_MN2 (XI1712_I74_XG_n1 I1712_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I74_XG_MN0 (I1712_G8_7 I1712_pn8 XI1712_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I74_XG_MN1 (XI1712_I74_XG_n1 I1712_gn7 I1712_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I73_XG_MN2 (XI1712_I73_XG_n1 I1712_gn7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I73_XG_MN0 (I1712_G7_6 I1712_pn7 XI1712_I73_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I73_XG_MN1 (XI1712_I73_XG_n1 I1712_gn6 I1712_G7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I130_XG_MN2 (XI1712_I130_XG_n1 I1712_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I130_XG_MN0 (I1712_G5_0 I1712_P5_2n XI1712_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I130_XG_MN1 (XI1712_I130_XG_n1 I1712_G1_0n I1712_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I74_XG_MN2 (XI1758_I74_XG_n1 I1758_gn8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I74_XG_MN0 (I1758_G8_7 I1758_pn8 XI1758_I74_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I74_XG_MN1 (XI1758_I74_XG_n1 I1758_gn7 I1758_G8_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I75_XG_MN2 (XI1758_I75_XG_n1 I1758_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I75_XG_MN0 (I1758_G9_8 I1758_pn9 XI1758_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I75_XG_MN1 (XI1758_I75_XG_n1 I1758_gn8 I1758_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I135_XG_MN2 (XI1758_I135_XG_n1 I1758_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I135_XG_MN0 (I1758_G10_3 I1758_P10_7n XI1758_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I135_XG_MN1 (XI1758_I135_XG_n1 I1758_G6_3n I1758_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I131_XG_MN2 (XI1758_I131_XG_n1 I1758_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I131_XG_MN0 (I1758_G6_0 I1758_P6_3n XI1758_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I131_XG_MN1 (XI1758_I131_XG_n1 I1758_G2_0n I1758_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I134_XG_MN2 (XI1758_I134_XG_n1 I1758_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I134_XG_MN0 (I1758_G9_2 I1758_P9_6n XI1758_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I134_XG_MN1 (XI1758_I134_XG_n1 I1758_G5_2n I1758_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I130_XG_MN2 (XI1758_I130_XG_n1 I1758_G5_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I130_XG_MN0 (I1758_G5_0 I1758_P5_2n XI1758_I130_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I130_XG_MN1 (XI1758_I130_XG_n1 I1758_G1_0n I1758_G5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I75_XG_MN2 (XI1804_I75_XG_n1 I1804_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I75_XG_MN0 (I1804_G9_8 I1804_pn9 XI1804_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I75_XG_MN1 (XI1804_I75_XG_n1 I1804_gn8 I1804_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I76_XG_MN2 (XI1804_I76_XG_n1 I1804_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I76_XG_MN0 (I1804_G10_9 I1804_pn10 XI1804_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I76_XG_MN1 (XI1804_I76_XG_n1 I1804_gn9 I1804_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I134_XG_MN2 (XI1804_I134_XG_n1 I1804_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I134_XG_MN0 (I1804_G9_2 I1804_P9_6n XI1804_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I134_XG_MN1 (XI1804_I134_XG_n1 I1804_G5_2n I1804_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I184_XG_MN2 (XI1804_I184_XG_n1 I1804_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I184_XG_MN0 (I1804_G17_0 I1804_P17_2n XI1804_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I184_XG_MN1 (XI1804_I184_XG_n1 I1804_G1_0n I1804_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I137_XG_MN2 (XI1804_I137_XG_n1 I1804_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I137_XG_MN0 (I1804_G12_5 I1804_P12_9n XI1804_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I137_XG_MN1 (XI1804_I137_XG_n1 I1804_G8_5n I1804_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I141_XG_MN2 (XI1804_I141_XG_n1 I1804_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I141_XG_MN0 (I1804_G16_9 I1804_P16_13n XI1804_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I141_XG_MN1 (XI1804_I141_XG_n1 I1804_G12_9n I1804_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I199_XG_MN2 (XI1804_I199_XG_n1 I1804_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I199_XG_MN0 (I1804_G28_0 I1804_P28_13n XI1804_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I199_XG_MN1 (XI1804_I199_XG_n1 I1804_G12_0n I1804_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I197_XG_MN2 (XI1804_I197_XG_n1 I1804_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I197_XG_MN0 (I1804_G26_0 I1804_P26_11n XI1804_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I197_XG_MN1 (XI1804_I197_XG_n1 I1804_G10_0n I1804_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I152_XG_MN2 (XI746_I152_XG_n1 I746_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I152_XG_MN0 (I746_G27_20 I746_P27_24n XI746_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I152_XG_MN1 (XI746_I152_XG_n1 I746_G23_20n I746_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I198_XG_MN2 (XI746_I198_XG_n1 I746_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I198_XG_MN0 (I746_G27_0 I746_P27_12n XI746_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I198_XG_MN1 (XI746_I198_XG_n1 I746_G11_0n I746_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I150_XG_MN2 (XI746_I150_XG_n1 I746_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I150_XG_MN0 (I746_G25_18 I746_P25_22n XI746_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I150_XG_MN1 (XI746_I150_XG_n1 I746_G21_18n I746_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I146_XG_MN2 (XI746_I146_XG_n1 I746_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I146_XG_MN0 (I746_G21_14 I746_P21_18n XI746_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I146_XG_MN1 (XI746_I146_XG_n1 I746_G17_14n I746_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I190_XG_MN2 (XI746_I190_XG_n1 I746_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I190_XG_MN0 (I746_G21_0 I746_P21_6n XI746_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I190_XG_MN1 (XI746_I190_XG_n1 I746_G5_0n I746_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I137_XG_MN2 (XI746_I137_XG_n1 I746_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I137_XG_MN0 (I746_G12_5 I746_P12_9n XI746_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I137_XG_MN1 (XI746_I137_XG_n1 I746_G8_5n I746_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I131_XG_MN2 (XI746_I131_XG_n1 I746_G6_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I131_XG_MN0 (I746_G6_0 I746_P6_3n XI746_I131_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I131_XG_MN1 (XI746_I131_XG_n1 I746_G2_0n I746_G6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I135_XG_MN2 (XI746_I135_XG_n1 I746_G10_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I135_XG_MN0 (I746_G10_3 I746_P10_7n XI746_I135_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I135_XG_MN1 (XI746_I135_XG_n1 I746_G6_3n I746_G10_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I183_XG_MN2 (XI746_I183_XG_n1 I746_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I183_XG_MN0 (I746_G16_0 I746_P16_1n XI746_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I183_XG_MN1 (XI746_I183_XG_n1 I746_G0_0n I746_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I80_XG_MN2 (XI792_I80_XG_n1 I792_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I80_XG_MN0 (I792_G14_13 I792_pn14 XI792_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I80_XG_MN1 (XI792_I80_XG_n1 I792_gn13 I792_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I79_XG_MN2 (XI792_I79_XG_n1 I792_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I79_XG_MN0 (I792_G13_12 I792_pn13 XI792_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I79_XG_MN1 (XI792_I79_XG_n1 I792_gn12 I792_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I141_XG_MN2 (XI792_I141_XG_n1 I792_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I141_XG_MN0 (I792_G16_9 I792_P16_13n XI792_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I141_XG_MN1 (XI792_I141_XG_n1 I792_G12_9n I792_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I137_XG_MN2 (XI792_I137_XG_n1 I792_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I137_XG_MN0 (I792_G12_5 I792_P12_9n XI792_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I137_XG_MN1 (XI792_I137_XG_n1 I792_G8_5n I792_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I185_XG_MN2 (XI792_I185_XG_n1 I792_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I185_XG_MN0 (I792_G18_0 I792_P18_3n XI792_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I185_XG_MN1 (XI792_I185_XG_n1 I792_G2_0n I792_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I79_XG_MN2 (XI838_I79_XG_n1 I838_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I79_XG_MN0 (I838_G13_12 I838_pn13 XI838_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I79_XG_MN1 (XI838_I79_XG_n1 I838_gn12 I838_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I77_XG_MN2 (XI838_I77_XG_n1 I838_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I77_XG_MN0 (I838_G11_10 I838_pn11 XI838_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I77_XG_MN1 (XI838_I77_XG_n1 I838_gn10 I838_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I78_XG_MN2 (XI838_I78_XG_n1 I838_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I78_XG_MN0 (I838_G12_11 I838_pn12 XI838_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I78_XG_MN1 (XI838_I78_XG_n1 I838_gn11 I838_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I138_XG_MN2 (XI838_I138_XG_n1 I838_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I138_XG_MN0 (I838_G13_6 I838_P13_10n XI838_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I138_XG_MN1 (XI838_I138_XG_n1 I838_G9_6n I838_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I196_XG_MN2 (XI838_I196_XG_n1 I838_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I196_XG_MN0 (I838_G25_0 I838_P25_10n XI838_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I196_XG_MN1 (XI838_I196_XG_n1 I838_G9_0n I838_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I141_XG_MN2 (XI838_I141_XG_n1 I838_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I141_XG_MN0 (I838_G16_9 I838_P16_13n XI838_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I141_XG_MN1 (XI838_I141_XG_n1 I838_G12_9n I838_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I77_XG_MN2 (XI884_I77_XG_n1 I884_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I77_XG_MN0 (I884_G11_10 I884_pn11 XI884_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I77_XG_MN1 (XI884_I77_XG_n1 I884_gn10 I884_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I78_XG_MN2 (XI884_I78_XG_n1 I884_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I78_XG_MN0 (I884_G12_11 I884_pn12 XI884_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I78_XG_MN1 (XI884_I78_XG_n1 I884_gn11 I884_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I185_XG_MN2 (XI884_I185_XG_n1 I884_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I185_XG_MN0 (I884_G18_0 I884_P18_3n XI884_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I185_XG_MN1 (XI884_I185_XG_n1 I884_G2_0n I884_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I137_XG_MN2 (XI884_I137_XG_n1 I884_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I137_XG_MN0 (I884_G12_5 I884_P12_9n XI884_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I137_XG_MN1 (XI884_I137_XG_n1 I884_G8_5n I884_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I184_XG_MN2 (XI884_I184_XG_n1 I884_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I184_XG_MN0 (I884_G17_0 I884_P17_2n XI884_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I184_XG_MN1 (XI884_I184_XG_n1 I884_G1_0n I884_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I185_XG_MN2 (XI1712_I185_XG_n1 I1712_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I185_XG_MN0 (I1712_G18_0 I1712_P18_3n XI1712_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I185_XG_MN1 (XI1712_I185_XG_n1 I1712_G2_0n I1712_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I141_XG_MN2 (XI1712_I141_XG_n1 I1712_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I141_XG_MN0 (I1712_G16_9 I1712_P16_13n XI1712_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I141_XG_MN1 (XI1712_I141_XG_n1 I1712_G12_9n I1712_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I195_XG_MN2 (XI1712_I195_XG_n1 I1712_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I195_XG_MN0 (I1712_G24_0 I1712_P24_9n XI1712_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I195_XG_MN1 (XI1712_I195_XG_n1 I1712_G8_0n I1712_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I76_XG_MN2 (XI1712_I76_XG_n1 I1712_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I76_XG_MN0 (I1712_G10_9 I1712_pn10 XI1712_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I76_XG_MN1 (XI1712_I76_XG_n1 I1712_gn9 I1712_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I75_XG_MN2 (XI1712_I75_XG_n1 I1712_gn9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I75_XG_MN0 (I1712_G9_8 I1712_pn9 XI1712_I75_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I75_XG_MN1 (XI1712_I75_XG_n1 I1712_gn8 I1712_G9_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I134_XG_MN2 (XI1712_I134_XG_n1 I1712_G9_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I134_XG_MN0 (I1712_G9_2 I1712_P9_6n XI1712_I134_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I134_XG_MN1 (XI1712_I134_XG_n1 I1712_G5_2n I1712_G9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I77_XG_MN2 (XI1758_I77_XG_n1 I1758_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I77_XG_MN0 (I1758_G11_10 I1758_pn11 XI1758_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I77_XG_MN1 (XI1758_I77_XG_n1 I1758_gn10 I1758_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I76_XG_MN2 (XI1758_I76_XG_n1 I1758_gn10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I76_XG_MN0 (I1758_G10_9 I1758_pn10 XI1758_I76_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I76_XG_MN1 (XI1758_I76_XG_n1 I1758_gn9 I1758_G10_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I141_XG_MN2 (XI1758_I141_XG_n1 I1758_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I141_XG_MN0 (I1758_G16_9 I1758_P16_13n XI1758_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I141_XG_MN1 (XI1758_I141_XG_n1 I1758_G12_9n I1758_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I137_XG_MN2 (XI1758_I137_XG_n1 I1758_G12_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I137_XG_MN0 (I1758_G12_5 I1758_P12_9n XI1758_I137_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I137_XG_MN1 (XI1758_I137_XG_n1 I1758_G8_5n I1758_G12_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I185_XG_MN2 (XI1758_I185_XG_n1 I1758_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I185_XG_MN0 (I1758_G18_0 I1758_P18_3n XI1758_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I185_XG_MN1 (XI1758_I185_XG_n1 I1758_G2_0n I1758_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I195_XG_MN2 (XI1758_I195_XG_n1 I1758_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I195_XG_MN0 (I1758_G24_0 I1758_P24_9n XI1758_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I195_XG_MN1 (XI1758_I195_XG_n1 I1758_G8_0n I1758_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I184_XG_MN2 (XI1758_I184_XG_n1 I1758_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I184_XG_MN0 (I1758_G17_0 I1758_P17_2n XI1758_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I184_XG_MN1 (XI1758_I184_XG_n1 I1758_G1_0n I1758_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I132_XG_MN2 (XI1758_I132_XG_n1 I1758_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I132_XG_MN0 (I1758_G7_0 I1758_P7_4n XI1758_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I132_XG_MN1 (XI1758_I132_XG_n1 I1758_G3_0n I1758_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I78_XG_MN2 (XI1804_I78_XG_n1 I1804_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I78_XG_MN0 (I1804_G12_11 I1804_pn12 XI1804_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I78_XG_MN1 (XI1804_I78_XG_n1 I1804_gn11 I1804_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I77_XG_MN2 (XI1804_I77_XG_n1 I1804_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I77_XG_MN0 (I1804_G11_10 I1804_pn11 XI1804_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I77_XG_MN1 (XI1804_I77_XG_n1 I1804_gn10 I1804_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I132_XG_MN2 (XI1804_I132_XG_n1 I1804_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I132_XG_MN0 (I1804_G7_0 I1804_P7_4n XI1804_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I132_XG_MN1 (XI1804_I132_XG_n1 I1804_G3_0n I1804_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I136_XG_MN2 (XI1804_I136_XG_n1 I1804_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I136_XG_MN0 (I1804_G11_4 I1804_P11_8n XI1804_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I136_XG_MN1 (XI1804_I136_XG_n1 I1804_G7_4n I1804_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I186_XG_MN2 (XI1804_I186_XG_n1 I1804_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I186_XG_MN0 (I1804_G19_0 I1804_P19_4n XI1804_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I186_XG_MN1 (XI1804_I186_XG_n1 I1804_G3_0n I1804_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I139_XG_MN2 (XI1804_I139_XG_n1 I1804_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I139_XG_MN0 (I1804_G14_7 I1804_P14_11n XI1804_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I139_XG_MN1 (XI1804_I139_XG_n1 I1804_G10_7n I1804_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I143_XG_MN2 (XI1804_I143_XG_n1 I1804_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I143_XG_MN0 (I1804_G18_11 I1804_P18_15n XI1804_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I143_XG_MN1 (XI1804_I143_XG_n1 I1804_G14_11n I1804_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I192_XG_MN2 (XI1804_I192_XG_n1 I1804_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I192_XG_MN0 (I1804_G22_0 I1804_P22_7n XI1804_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I192_XG_MN1 (XI1804_I192_XG_n1 I1804_G6_0n I1804_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I156_XG_MN2 (XI746_I156_XG_n1 I746_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I156_XG_MN0 (I746_G31_24 I746_P31_28n XI746_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I156_XG_MN1 (XI746_I156_XG_n1 I746_G27_24n I746_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I154_XG_MN2 (XI746_I154_XG_n1 I746_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I154_XG_MN0 (I746_G29_22 I746_P29_26n XI746_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I154_XG_MN1 (XI746_I154_XG_n1 I746_G25_22n I746_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I200_XG_MN2 (XI746_I200_XG_n1 I746_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I200_XG_MN0 (I746_G29_0 I746_P29_14n XI746_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I200_XG_MN1 (XI746_I200_XG_n1 I746_G13_0n I746_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I196_XG_MN2 (XI746_I196_XG_n1 I746_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I196_XG_MN0 (I746_G25_0 I746_P25_10n XI746_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I196_XG_MN1 (XI746_I196_XG_n1 I746_G9_0n I746_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I141_XG_MN2 (XI746_I141_XG_n1 I746_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I141_XG_MN0 (I746_G16_9 I746_P16_13n XI746_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I141_XG_MN1 (XI746_I141_XG_n1 I746_G12_9n I746_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I82_XG_MN2 (XI792_I82_XG_n1 I792_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I82_XG_MN0 (I792_G16_15 I792_pn16 XI792_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I82_XG_MN1 (XI792_I82_XG_n1 I792_gn15 I792_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I83_XG_MN2 (XI792_I83_XG_n1 I792_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I83_XG_MN0 (I792_G17_16 I792_pn17 XI792_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I83_XG_MN1 (XI792_I83_XG_n1 I792_gn16 I792_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I81_XG_MN2 (XI792_I81_XG_n1 I792_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I81_XG_MN0 (I792_G15_14 I792_pn15 XI792_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I81_XG_MN1 (XI792_I81_XG_n1 I792_gn14 I792_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I138_XG_MN2 (XI792_I138_XG_n1 I792_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I138_XG_MN0 (I792_G13_6 I792_P13_10n XI792_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I138_XG_MN1 (XI792_I138_XG_n1 I792_G9_6n I792_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I186_XG_MN2 (XI792_I186_XG_n1 I792_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I186_XG_MN0 (I792_G19_0 I792_P19_4n XI792_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I186_XG_MN1 (XI792_I186_XG_n1 I792_G3_0n I792_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I139_XG_MN2 (XI792_I139_XG_n1 I792_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I139_XG_MN0 (I792_G14_7 I792_P14_11n XI792_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I139_XG_MN1 (XI792_I139_XG_n1 I792_G10_7n I792_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I80_XG_MN2 (XI838_I80_XG_n1 I838_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I80_XG_MN0 (I838_G14_13 I838_pn14 XI838_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I80_XG_MN1 (XI838_I80_XG_n1 I838_gn13 I838_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I140_XG_MN2 (XI838_I140_XG_n1 I838_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I140_XG_MN0 (I838_G15_8 I838_P15_12n XI838_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I140_XG_MN1 (XI838_I140_XG_n1 I838_G11_8n I838_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I136_XG_MN2 (XI838_I136_XG_n1 I838_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I136_XG_MN0 (I838_G11_4 I838_P11_8n XI838_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I136_XG_MN1 (XI838_I136_XG_n1 I838_G7_4n I838_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I186_XG_MN2 (XI838_I186_XG_n1 I838_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I186_XG_MN0 (I838_G19_0 I838_P19_4n XI838_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I186_XG_MN1 (XI838_I186_XG_n1 I838_G3_0n I838_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I142_XG_MN2 (XI838_I142_XG_n1 I838_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I142_XG_MN0 (I838_G17_10 I838_P17_14n XI838_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I142_XG_MN1 (XI838_I142_XG_n1 I838_G13_10n I838_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I190_XG_MN2 (XI838_I190_XG_n1 I838_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I190_XG_MN0 (I838_G21_0 I838_P21_6n XI838_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I190_XG_MN1 (XI838_I190_XG_n1 I838_G5_0n I838_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I188_XG_MN2 (XI838_I188_XG_n1 I838_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I188_XG_MN0 (I838_G20_0 I838_P20_5n XI838_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I188_XG_MN1 (XI838_I188_XG_n1 I838_G4_0n I838_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I139_XG_MN2 (XI838_I139_XG_n1 I838_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I139_XG_MN0 (I838_G14_7 I838_P14_11n XI838_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I139_XG_MN1 (XI838_I139_XG_n1 I838_G10_7n I838_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I197_XG_MN2 (XI838_I197_XG_n1 I838_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I197_XG_MN0 (I838_G26_0 I838_P26_11n XI838_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I197_XG_MN1 (XI838_I197_XG_n1 I838_G10_0n I838_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I80_XG_MN2 (XI884_I80_XG_n1 I884_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I80_XG_MN0 (I884_G14_13 I884_pn14 XI884_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I80_XG_MN1 (XI884_I80_XG_n1 I884_gn13 I884_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I79_XG_MN2 (XI884_I79_XG_n1 I884_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I79_XG_MN0 (I884_G13_12 I884_pn13 XI884_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I79_XG_MN1 (XI884_I79_XG_n1 I884_gn12 I884_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I139_XG_MN2 (XI884_I139_XG_n1 I884_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I139_XG_MN0 (I884_G14_7 I884_P14_11n XI884_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I139_XG_MN1 (XI884_I139_XG_n1 I884_G10_7n I884_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I141_XG_MN2 (XI884_I141_XG_n1 I884_G16_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I141_XG_MN0 (I884_G16_9 I884_P16_13n XI884_I141_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I141_XG_MN1 (XI884_I141_XG_n1 I884_G12_9n I884_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I195_XG_MN2 (XI884_I195_XG_n1 I884_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I195_XG_MN0 (I884_G24_0 I884_P24_9n XI884_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I195_XG_MN1 (XI884_I195_XG_n1 I884_G8_0n I884_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I142_XG_MN2 (XI884_I142_XG_n1 I884_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I142_XG_MN0 (I884_G17_10 I884_P17_14n XI884_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I142_XG_MN1 (XI884_I142_XG_n1 I884_G13_10n I884_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I138_XG_MN2 (XI884_I138_XG_n1 I884_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I138_XG_MN0 (I884_G13_6 I884_P13_10n XI884_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I138_XG_MN1 (XI884_I138_XG_n1 I884_G9_6n I884_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I196_XG_MN2 (XI884_I196_XG_n1 I884_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I196_XG_MN0 (I884_G25_0 I884_P25_10n XI884_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I196_XG_MN1 (XI884_I196_XG_n1 I884_G9_0n I884_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I139_XG_MN2 (XI1712_I139_XG_n1 I1712_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I139_XG_MN0 (I1712_G14_7 I1712_P14_11n XI1712_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I139_XG_MN1 (XI1712_I139_XG_n1 I1712_G10_7n I1712_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I78_XG_MN2 (XI1712_I78_XG_n1 I1712_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I78_XG_MN0 (I1712_G12_11 I1712_pn12 XI1712_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I78_XG_MN1 (XI1712_I78_XG_n1 I1712_gn11 I1712_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I77_XG_MN2 (XI1712_I77_XG_n1 I1712_gn11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I77_XG_MN0 (I1712_G11_10 I1712_pn11 XI1712_I77_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I77_XG_MN1 (XI1712_I77_XG_n1 I1712_gn10 I1712_G11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I184_XG_MN2 (XI1712_I184_XG_n1 I1712_G17_2n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I184_XG_MN0 (I1712_G17_0 I1712_P17_2n XI1712_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I184_XG_MN1 (XI1712_I184_XG_n1 I1712_G1_0n I1712_G17_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I132_XG_MN2 (XI1712_I132_XG_n1 I1712_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I132_XG_MN0 (I1712_G7_0 I1712_P7_4n XI1712_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I132_XG_MN1 (XI1712_I132_XG_n1 I1712_G3_0n I1712_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I136_XG_MN2 (XI1712_I136_XG_n1 I1712_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I136_XG_MN0 (I1712_G11_4 I1712_P11_8n XI1712_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I136_XG_MN1 (XI1712_I136_XG_n1 I1712_G7_4n I1712_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I79_XG_MN2 (XI1758_I79_XG_n1 I1758_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I79_XG_MN0 (I1758_G13_12 I1758_pn13 XI1758_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I79_XG_MN1 (XI1758_I79_XG_n1 I1758_gn12 I1758_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I78_XG_MN2 (XI1758_I78_XG_n1 I1758_gn12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I78_XG_MN0 (I1758_G12_11 I1758_pn12 XI1758_I78_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I78_XG_MN1 (XI1758_I78_XG_n1 I1758_gn11 I1758_G12_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I139_XG_MN2 (XI1758_I139_XG_n1 I1758_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I139_XG_MN0 (I1758_G14_7 I1758_P14_11n XI1758_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I139_XG_MN1 (XI1758_I139_XG_n1 I1758_G10_7n I1758_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I188_XG_MN2 (XI1758_I188_XG_n1 I1758_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I188_XG_MN0 (I1758_G20_0 I1758_P20_5n XI1758_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I188_XG_MN1 (XI1758_I188_XG_n1 I1758_G4_0n I1758_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I138_XG_MN2 (XI1758_I138_XG_n1 I1758_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I138_XG_MN0 (I1758_G13_6 I1758_P13_10n XI1758_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I138_XG_MN1 (XI1758_I138_XG_n1 I1758_G9_6n I1758_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I196_XG_MN2 (XI1758_I196_XG_n1 I1758_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I196_XG_MN0 (I1758_G25_0 I1758_P25_10n XI1758_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I196_XG_MN1 (XI1758_I196_XG_n1 I1758_G9_0n I1758_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I136_XG_MN2 (XI1758_I136_XG_n1 I1758_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I136_XG_MN0 (I1758_G11_4 I1758_P11_8n XI1758_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I136_XG_MN1 (XI1758_I136_XG_n1 I1758_G7_4n I1758_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I79_XG_MN2 (XI1804_I79_XG_n1 I1804_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I79_XG_MN0 (I1804_G13_12 I1804_pn13 XI1804_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I79_XG_MN1 (XI1804_I79_XG_n1 I1804_gn12 I1804_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I80_XG_MN2 (XI1804_I80_XG_n1 I1804_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I80_XG_MN0 (I1804_G14_13 I1804_pn14 XI1804_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I80_XG_MN1 (XI1804_I80_XG_n1 I1804_gn13 I1804_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I138_XG_MN2 (XI1804_I138_XG_n1 I1804_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I138_XG_MN0 (I1804_G13_6 I1804_P13_10n XI1804_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I138_XG_MN1 (XI1804_I138_XG_n1 I1804_G9_6n I1804_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I145_XG_MN2 (XI1804_I145_XG_n1 I1804_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I145_XG_MN0 (I1804_G20_13 I1804_P20_17n XI1804_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I145_XG_MN1 (XI1804_I145_XG_n1 I1804_G16_13n I1804_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I149_XG_MN2 (XI1804_I149_XG_n1 I1804_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I149_XG_MN0 (I1804_G24_17 I1804_P24_21n XI1804_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I149_XG_MN1 (XI1804_I149_XG_n1 I1804_G20_17n I1804_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I201_XG_MN2 (XI1804_I201_XG_n1 I1804_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I201_XG_MN0 (c27_m I1804_P30_15n XI1804_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I201_XG_MN1 (XI1804_I201_XG_n1 I1804_G14_0n c27_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I91_XG_MN2 (XI746_I91_XG_n1 I746_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I91_XG_MN0 (I746_G25_24 I746_pn25 XI746_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I91_XG_MN1 (XI746_I91_XG_n1 I746_gn24 I746_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I149_XG_MN2 (XI746_I149_XG_n1 I746_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I149_XG_MN0 (I746_G24_17 I746_P24_21n XI746_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I149_XG_MN1 (XI746_I149_XG_n1 I746_G20_17n I746_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I145_XG_MN2 (XI746_I145_XG_n1 I746_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I145_XG_MN0 (I746_G20_13 I746_P20_17n XI746_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I145_XG_MN1 (XI746_I145_XG_n1 I746_G16_13n I746_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I143_XG_MN2 (XI746_I143_XG_n1 I746_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I143_XG_MN0 (I746_G18_11 I746_P18_15n XI746_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I143_XG_MN1 (XI746_I143_XG_n1 I746_G14_11n I746_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I139_XG_MN2 (XI746_I139_XG_n1 I746_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I139_XG_MN0 (I746_G14_7 I746_P14_11n XI746_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I139_XG_MN1 (XI746_I139_XG_n1 I746_G10_7n I746_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I188_XG_MN2 (XI746_I188_XG_n1 I746_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I188_XG_MN0 (I746_G20_0 I746_P20_5n XI746_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I188_XG_MN1 (XI746_I188_XG_n1 I746_G4_0n I746_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I195_XG_MN2 (XI746_I195_XG_n1 I746_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I195_XG_MN0 (I746_G24_0 I746_P24_9n XI746_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I195_XG_MN1 (XI746_I195_XG_n1 I746_G8_0n I746_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I185_XG_MN2 (XI746_I185_XG_n1 I746_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I185_XG_MN0 (I746_G18_0 I746_P18_3n XI746_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I185_XG_MN1 (XI746_I185_XG_n1 I746_G2_0n I746_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I85_XG_MN2 (XI792_I85_XG_n1 I792_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I85_XG_MN0 (I792_G19_18 I792_pn19 XI792_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I85_XG_MN1 (XI792_I85_XG_n1 I792_gn18 I792_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I84_XG_MN2 (XI792_I84_XG_n1 I792_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I84_XG_MN0 (I792_G18_17 I792_pn18 XI792_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I84_XG_MN1 (XI792_I84_XG_n1 I792_gn17 I792_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I144_XG_MN2 (XI792_I144_XG_n1 I792_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I144_XG_MN0 (I792_G19_12 I792_P19_16n XI792_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I144_XG_MN1 (XI792_I144_XG_n1 I792_G15_12n I792_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I140_XG_MN2 (XI792_I140_XG_n1 I792_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I140_XG_MN0 (I792_G15_8 I792_P15_12n XI792_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I140_XG_MN1 (XI792_I140_XG_n1 I792_G11_8n I792_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I142_XG_MN2 (XI792_I142_XG_n1 I792_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I142_XG_MN0 (I792_G17_10 I792_P17_14n XI792_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I142_XG_MN1 (XI792_I142_XG_n1 I792_G13_10n I792_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I145_XG_MN2 (XI792_I145_XG_n1 I792_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I145_XG_MN0 (I792_G20_13 I792_P20_17n XI792_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I145_XG_MN1 (XI792_I145_XG_n1 I792_G16_13n I792_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I143_XG_MN2 (XI792_I143_XG_n1 I792_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I143_XG_MN0 (I792_G18_11 I792_P18_15n XI792_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I143_XG_MN1 (XI792_I143_XG_n1 I792_G14_11n I792_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I188_XG_MN2 (XI792_I188_XG_n1 I792_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I188_XG_MN0 (I792_G20_0 I792_P20_5n XI792_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I188_XG_MN1 (XI792_I188_XG_n1 I792_G4_0n I792_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I195_XG_MN2 (XI792_I195_XG_n1 I792_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I195_XG_MN0 (I792_G24_0 I792_P24_9n XI792_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I195_XG_MN1 (XI792_I195_XG_n1 I792_G8_0n I792_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I81_XG_MN2 (XI838_I81_XG_n1 I838_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I81_XG_MN0 (I838_G15_14 I838_pn15 XI838_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I81_XG_MN1 (XI838_I81_XG_n1 I838_gn14 I838_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I144_XG_MN2 (XI838_I144_XG_n1 I838_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I144_XG_MN0 (I838_G19_12 I838_P19_16n XI838_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I144_XG_MN1 (XI838_I144_XG_n1 I838_G15_12n I838_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I150_XG_MN2 (XI838_I150_XG_n1 I838_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I150_XG_MN0 (I838_G25_18 I838_P25_22n XI838_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I150_XG_MN1 (XI838_I150_XG_n1 I838_G21_18n I838_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I146_XG_MN2 (XI838_I146_XG_n1 I838_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I146_XG_MN0 (I838_G21_14 I838_P21_18n XI838_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I146_XG_MN1 (XI838_I146_XG_n1 I838_G17_14n I838_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I200_XG_MN2 (XI838_I200_XG_n1 I838_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I200_XG_MN0 (I838_G29_0 I838_P29_14n XI838_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I200_XG_MN1 (XI838_I200_XG_n1 I838_G13_0n I838_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I145_XG_MN2 (XI838_I145_XG_n1 I838_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I145_XG_MN0 (I838_G20_13 I838_P20_17n XI838_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I145_XG_MN1 (XI838_I145_XG_n1 I838_G16_13n I838_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I149_XG_MN2 (XI838_I149_XG_n1 I838_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I149_XG_MN0 (I838_G24_17 I838_P24_21n XI838_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I149_XG_MN1 (XI838_I149_XG_n1 I838_G20_17n I838_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I143_XG_MN2 (XI838_I143_XG_n1 I838_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I143_XG_MN0 (I838_G18_11 I838_P18_15n XI838_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I143_XG_MN1 (XI838_I143_XG_n1 I838_G14_11n I838_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I82_XG_MN2 (XI884_I82_XG_n1 I884_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I82_XG_MN0 (I884_G16_15 I884_pn16 XI884_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I82_XG_MN1 (XI884_I82_XG_n1 I884_gn15 I884_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I81_XG_MN2 (XI884_I81_XG_n1 I884_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I81_XG_MN0 (I884_G15_14 I884_pn15 XI884_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I81_XG_MN1 (XI884_I81_XG_n1 I884_gn14 I884_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I143_XG_MN2 (XI884_I143_XG_n1 I884_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I143_XG_MN0 (I884_G18_11 I884_P18_15n XI884_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I143_XG_MN1 (XI884_I143_XG_n1 I884_G14_11n I884_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I197_XG_MN2 (XI884_I197_XG_n1 I884_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I197_XG_MN0 (I884_G26_0 I884_P26_11n XI884_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I197_XG_MN1 (XI884_I197_XG_n1 I884_G10_0n I884_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I188_XG_MN2 (XI884_I188_XG_n1 I884_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I188_XG_MN0 (I884_G20_0 I884_P20_5n XI884_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I188_XG_MN1 (XI884_I188_XG_n1 I884_G4_0n I884_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I190_XG_MN2 (XI884_I190_XG_n1 I884_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I190_XG_MN0 (I884_G21_0 I884_P21_6n XI884_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I190_XG_MN1 (XI884_I190_XG_n1 I884_G5_0n I884_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I136_XG_MN2 (XI884_I136_XG_n1 I884_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I136_XG_MN0 (I884_G11_4 I884_P11_8n XI884_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I136_XG_MN1 (XI884_I136_XG_n1 I884_G7_4n I884_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I132_XG_MN2 (XI884_I132_XG_n1 I884_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I132_XG_MN0 (I884_G7_0 I884_P7_4n XI884_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I132_XG_MN1 (XI884_I132_XG_n1 I884_G3_0n I884_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I192_XG_MN2 (XI1712_I192_XG_n1 I1712_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I192_XG_MN0 (I1712_G22_0 I1712_P22_7n XI1712_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I192_XG_MN1 (XI1712_I192_XG_n1 I1712_G6_0n I1712_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I143_XG_MN2 (XI1712_I143_XG_n1 I1712_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I143_XG_MN0 (I1712_G18_11 I1712_P18_15n XI1712_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I143_XG_MN1 (XI1712_I143_XG_n1 I1712_G14_11n I1712_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I145_XG_MN2 (XI1712_I145_XG_n1 I1712_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I145_XG_MN0 (I1712_G20_13 I1712_P20_17n XI1712_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I145_XG_MN1 (XI1712_I145_XG_n1 I1712_G16_13n I1712_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I199_XG_MN2 (XI1712_I199_XG_n1 I1712_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I199_XG_MN0 (I1712_G28_0 I1712_P28_13n XI1712_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I199_XG_MN1 (XI1712_I199_XG_n1 I1712_G12_0n I1712_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I80_XG_MN2 (XI1712_I80_XG_n1 I1712_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I80_XG_MN0 (I1712_G14_13 I1712_pn14 XI1712_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I80_XG_MN1 (XI1712_I80_XG_n1 I1712_gn13 I1712_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I79_XG_MN2 (XI1712_I79_XG_n1 I1712_gn13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I79_XG_MN0 (I1712_G13_12 I1712_pn13 XI1712_I79_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I79_XG_MN1 (XI1712_I79_XG_n1 I1712_gn12 I1712_G13_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I142_XG_MN2 (XI1712_I142_XG_n1 I1712_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I142_XG_MN0 (I1712_G17_10 I1712_P17_14n XI1712_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I142_XG_MN1 (XI1712_I142_XG_n1 I1712_G13_10n I1712_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I138_XG_MN2 (XI1712_I138_XG_n1 I1712_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I138_XG_MN0 (I1712_G13_6 I1712_P13_10n XI1712_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I138_XG_MN1 (XI1712_I138_XG_n1 I1712_G9_6n I1712_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I196_XG_MN2 (XI1712_I196_XG_n1 I1712_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I196_XG_MN0 (I1712_G25_0 I1712_P25_10n XI1712_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I196_XG_MN1 (XI1712_I196_XG_n1 I1712_G9_0n I1712_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I186_XG_MN2 (XI1712_I186_XG_n1 I1712_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I186_XG_MN0 (I1712_G19_0 I1712_P19_4n XI1712_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I186_XG_MN1 (XI1712_I186_XG_n1 I1712_G3_0n I1712_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I80_XG_MN2 (XI1758_I80_XG_n1 I1758_gn14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I80_XG_MN0 (I1758_G14_13 I1758_pn14 XI1758_I80_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I80_XG_MN1 (XI1758_I80_XG_n1 I1758_gn13 I1758_G14_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I81_XG_MN2 (XI1758_I81_XG_n1 I1758_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I81_XG_MN0 (I1758_G15_14 I1758_pn15 XI1758_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I81_XG_MN1 (XI1758_I81_XG_n1 I1758_gn14 I1758_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I145_XG_MN2 (XI1758_I145_XG_n1 I1758_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
