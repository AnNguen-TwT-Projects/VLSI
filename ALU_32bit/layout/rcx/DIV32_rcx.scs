    I_MXI1257_MN1 (qu16_b1_0 qu16_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1257_MN1_1 (VSS qu16_b0 qu16_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1347_MN1 (qu14 p17_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1347_MN1_1 (VSS p17_32 qu14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1393_MN1 (qu13 p18_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1393_MN1_1 (VSS p18_32 qu13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1395_MN1 (qu13_b1_0 qu13_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1395_MN1_1 (VSS qu13_b0 qu13_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1443_MN1 (qu12_b2_1 qu12_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1443_MN1_1 (VSS qu12_b1_0 qu12_b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1442_MN1 (qu12_b2_0 qu12_b1_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1442_MN1_1 (VSS qu12_b1_0 qu12_b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1441_MN1 (qu12_b1_0 qu12_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1441_MN1_1 (VSS qu12_b0 qu12_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1449_MN1 (qu12_b3_5 qu12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1449_MN1_1 (VSS qu12_b2_1 qu12_b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1448_MN1 (qu12_b3_4 qu12_b2_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1448_MN1_1 (VSS qu12_b2_1 qu12_b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1485_MN1 (qu11 p20_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1485_MN1_1 (VSS p20_32 qu11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1255_MN1 (qu16 p15_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1255_MN1_1 (VSS p15_32 qu16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1301_MN1 (qu15 p16_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1301_MN1_1 (VSS p16_32 qu15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1303_MN1 (qu15_b1_0 qu15_b0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1303_MN1_1 (VSS qu15_b0 qu15_b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1439_MN1 (qu12 p19_32 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1439_MN1_1 (VSS p19_32 qu12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I127_XG_MN2 (I654_G31_28n I654_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I127_XG_MN0 (XI654_I127_XG_n1 I654_P31_30 I654_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I127_XG_MN1 (VSS I654_G29_28 XI654_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I126_XG_MN2 (I654_G30_27n I654_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I126_XG_MN0 (XI654_I126_XG_n1 I654_P30_29 I654_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I126_XG_MN1 (VSS I654_G28_27 XI654_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I127_XG_MN2 (I608_G31_28n I608_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I127_XG_MN0 (XI608_I127_XG_n1 I608_P31_30 I608_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I127_XG_MN1 (VSS I608_G29_28 XI608_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I127_XG_MN2 (I562_G31_28n I562_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I127_XG_MN0 (XI562_I127_XG_n1 I562_P31_30 I562_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I127_XG_MN1 (VSS I562_G29_28 XI562_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2233_MN2 (nrkn22 nrk21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2233_MN0 (XI2233_n1 A_31_b3_9 nrkn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2233_MN1 (VSS ru21 XI2233_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2236_MN2 (nrkn23 nrk22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2236_MN0 (XI2236_n1 A_31_b3_9 nrkn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2236_MN1 (VSS ru22 XI2236_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2239_MN2 (nrkn24 nrk23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2239_MN0 (XI2239_n1 A_31_b3_9 nrkn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2239_MN1 (VSS ru23 XI2239_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2242_MN2 (nrkn25 nrk24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2242_MN0 (XI2242_n1 A_31_b3_9 nrkn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2242_MN1 (VSS ru24 XI2242_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2251_MN2 (nrkn28 nrk27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2251_MN0 (XI2251_n1 A_31_b3_10 nrkn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2251_MN1 (VSS ru27 XI2251_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2248_MN2 (nrkn27 nrk26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2248_MN0 (XI2248_n1 A_31_b3_10 nrkn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2248_MN1 (VSS ru26 XI2248_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2254_MN2 (nrkn29 nrk28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2254_MN0 (XI2254_n1 A_31_b3_10 nrkn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2254_MN1 (VSS ru28 XI2254_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2257_MN2 (nrkn30 nrk29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2257_MN0 (XI2257_n1 A_31_b3_10 nrkn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2257_MN1 (VSS ru29 XI2257_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2260_MN2 (nrkn31 nrk30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2260_MN0 (XI2260_n1 A_31_b3_10 nrkn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2260_MN1 (VSS ru30 XI2260_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I126_XG_MN2 (I1942_G30_27n I1942_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I126_XG_MN0 (XI1942_I126_XG_n1 I1942_P30_29 I1942_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I126_XG_MN1 (VSS I1942_G28_27 XI1942_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I127_XG_MN2 (I1942_G31_28n I1942_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I127_XG_MN0 (XI1942_I127_XG_n1 I1942_P31_30 I1942_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I127_XG_MN1 (VSS I1942_G29_28 XI1942_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I181_XG_MN2 (I1896_G30_15n I1896_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I181_XG_MN0 (XI1896_I181_XG_n1 I1896_P30_23 I1896_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I181_XG_MN1 (VSS I1896_G22_15 XI1896_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I126_XG_MN2 (I1896_G30_27n I1896_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I126_XG_MN0 (XI1896_I126_XG_n1 I1896_P30_29 I1896_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I126_XG_MN1 (VSS I1896_G28_27 XI1896_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I182_XG_MN2 (I654_G31_16n I654_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I182_XG_MN0 (XI654_I182_XG_n1 I654_P31_24 I654_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I182_XG_MN1 (VSS I654_G23_16 XI654_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I125_XG_MN2 (I654_G29_26n I654_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I125_XG_MN0 (XI654_I125_XG_n1 I654_P29_28 I654_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I125_XG_MN1 (VSS I654_G27_26 XI654_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I123_XG_MN2 (I654_G27_24n I654_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I123_XG_MN0 (XI654_I123_XG_n1 I654_P27_26 I654_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I123_XG_MN1 (VSS I654_G25_24 XI654_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I124_XG_MN2 (I654_G28_25n I654_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I124_XG_MN0 (XI654_I124_XG_n1 I654_P28_27 I654_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I124_XG_MN1 (VSS I654_G26_25 XI654_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I182_XG_MN2 (I608_G31_16n I608_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I182_XG_MN0 (XI608_I182_XG_n1 I608_P31_24 I608_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I182_XG_MN1 (VSS I608_G23_16 XI608_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I123_XG_MN2 (I608_G27_24n I608_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I123_XG_MN0 (XI608_I123_XG_n1 I608_P27_26 I608_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I123_XG_MN1 (VSS I608_G25_24 XI608_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I125_XG_MN2 (I608_G29_26n I608_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I125_XG_MN0 (XI608_I125_XG_n1 I608_P29_28 I608_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I125_XG_MN1 (VSS I608_G27_26 XI608_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I126_XG_MN2 (I608_G30_27n I608_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I126_XG_MN0 (XI608_I126_XG_n1 I608_P30_29 I608_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I126_XG_MN1 (VSS I608_G28_27 XI608_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I124_XG_MN2 (I608_G28_25n I608_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I124_XG_MN0 (XI608_I124_XG_n1 I608_P28_27 I608_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I124_XG_MN1 (VSS I608_G26_25 XI608_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I126_XG_MN2 (I562_G30_27n I562_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I126_XG_MN0 (XI562_I126_XG_n1 I562_P30_29 I562_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I126_XG_MN1 (VSS I562_G28_27 XI562_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2230_MN2 (nrkn21 nrk20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2230_MN0 (XI2230_n1 A_31_b3_9 nrkn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2230_MN1 (VSS ru20 XI2230_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2245_MN2 (nrkn26 nrk25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2245_MN0 (XI2245_n1 A_31_b3_9 nrkn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2245_MN1 (VSS ru25 XI2245_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I125_XG_MN2 (I2066_G29_26n I2066_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I125_XG_MN0 (XI2066_I125_XG_n1 I2066_P29_28 I2066_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I125_XG_MN1 (VSS I2066_G27_26 XI2066_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I127_XG_MN2 (I2066_G31_28n I2066_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I127_XG_MN0 (XI2066_I127_XG_n1 I2066_P31_30 I2066_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I127_XG_MN1 (VSS I2066_G29_28 XI2066_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I126_XG_MN2 (I2066_G30_27n I2066_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I126_XG_MN0 (XI2066_I126_XG_n1 I2066_P30_29 I2066_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I126_XG_MN1 (VSS I2066_G28_27 XI2066_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I126_XG_MN2 (I1988_G30_27n I1988_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I126_XG_MN0 (XI1988_I126_XG_n1 I1988_P30_29 I1988_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I126_XG_MN1 (VSS I1988_G28_27 XI1988_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I124_XG_MN2 (I1988_G28_25n I1988_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I124_XG_MN0 (XI1988_I124_XG_n1 I1988_P28_27 I1988_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I124_XG_MN1 (VSS I1988_G26_25 XI1988_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I127_XG_MN2 (I1988_G31_28n I1988_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I127_XG_MN0 (XI1988_I127_XG_n1 I1988_P31_30 I1988_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I127_XG_MN1 (VSS I1988_G29_28 XI1988_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I125_XG_MN2 (I1988_G29_26n I1988_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I125_XG_MN0 (XI1988_I125_XG_n1 I1988_P29_28 I1988_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I125_XG_MN1 (VSS I1988_G27_26 XI1988_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I181_XG_MN2 (I1942_G30_15n I1942_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I181_XG_MN0 (XI1942_I181_XG_n1 I1942_P30_23 I1942_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I181_XG_MN1 (VSS I1942_G22_15 XI1942_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I124_XG_MN2 (I1942_G28_25n I1942_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I124_XG_MN0 (XI1942_I124_XG_n1 I1942_P28_27 I1942_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I124_XG_MN1 (VSS I1942_G26_25 XI1942_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I182_XG_MN2 (I1942_G31_16n I1942_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I182_XG_MN0 (XI1942_I182_XG_n1 I1942_P31_24 I1942_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I182_XG_MN1 (VSS I1942_G23_16 XI1942_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I125_XG_MN2 (I1942_G29_26n I1942_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I125_XG_MN0 (XI1942_I125_XG_n1 I1942_P29_28 I1942_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I125_XG_MN1 (VSS I1942_G27_26 XI1942_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I123_XG_MN2 (I1942_G27_24n I1942_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I123_XG_MN0 (XI1942_I123_XG_n1 I1942_P27_26 I1942_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I123_XG_MN1 (VSS I1942_G25_24 XI1942_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I177_XG_MN2 (I1896_G26_11n I1896_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I177_XG_MN0 (XI1896_I177_XG_n1 I1896_P26_19 I1896_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I177_XG_MN1 (VSS I1896_G18_11 XI1896_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I179_XG_MN2 (I1896_G28_13n I1896_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I179_XG_MN0 (XI1896_I179_XG_n1 I1896_P28_21 I1896_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I179_XG_MN1 (VSS I1896_G20_13 XI1896_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I122_XG_MN2 (I1896_G26_23n I1896_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I122_XG_MN0 (XI1896_I122_XG_n1 I1896_P26_25 I1896_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I122_XG_MN1 (VSS I1896_G24_23 XI1896_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I124_XG_MN2 (I1896_G28_25n I1896_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I124_XG_MN0 (XI1896_I124_XG_n1 I1896_P28_27 I1896_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I124_XG_MN1 (VSS I1896_G26_25 XI1896_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I178_XG_MN2 (I654_G27_12n I654_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I178_XG_MN0 (XI654_I178_XG_n1 I654_P27_20 I654_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I178_XG_MN1 (VSS I654_G19_12 XI654_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I121_XG_MN2 (I654_G25_22n I654_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I121_XG_MN0 (XI654_I121_XG_n1 I654_P25_24 I654_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I121_XG_MN1 (VSS I654_G23_22 XI654_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I181_XG_MN2 (I654_G30_15n I654_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I181_XG_MN0 (XI654_I181_XG_n1 I654_P30_23 I654_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I181_XG_MN1 (VSS I654_G22_15 XI654_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I122_XG_MN2 (I654_G26_23n I654_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I122_XG_MN0 (XI654_I122_XG_n1 I654_P26_25 I654_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I122_XG_MN1 (VSS I654_G24_23 XI654_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I174_XG_MN2 (I608_G23_8n I608_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I174_XG_MN0 (XI608_I174_XG_n1 I608_P23_16 I608_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I174_XG_MN1 (VSS I608_G15_8 XI608_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I178_XG_MN2 (I608_G27_12n I608_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I178_XG_MN0 (XI608_I178_XG_n1 I608_P27_20 I608_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I178_XG_MN1 (VSS I608_G19_12 XI608_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I121_XG_MN2 (I608_G25_22n I608_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I121_XG_MN0 (XI608_I121_XG_n1 I608_P25_24 I608_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I121_XG_MN1 (VSS I608_G23_22 XI608_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I119_XG_MN2 (I608_G23_20n I608_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I119_XG_MN0 (XI608_I119_XG_n1 I608_P23_22 I608_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I119_XG_MN1 (VSS I608_G21_20 XI608_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I122_XG_MN2 (I608_G26_23n I608_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I122_XG_MN0 (XI608_I122_XG_n1 I608_P26_25 I608_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I122_XG_MN1 (VSS I608_G24_23 XI608_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I124_XG_MN2 (I562_G28_25n I562_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I124_XG_MN0 (XI562_I124_XG_n1 I562_P28_27 I562_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I124_XG_MN1 (VSS I562_G26_25 XI562_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I125_XG_MN2 (I562_G29_26n I562_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I125_XG_MN0 (XI562_I125_XG_n1 I562_P29_28 I562_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I125_XG_MN1 (VSS I562_G27_26 XI562_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I123_XG_MN2 (I562_G27_24n I562_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I123_XG_MN0 (XI562_I123_XG_n1 I562_P27_26 I562_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I123_XG_MN1 (VSS I562_G25_24 XI562_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2224_MN2 (nrkn19 nrk18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2224_MN0 (XI2224_n1 A_31_b3_8 nrkn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2224_MN1 (VSS ru18 XI2224_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2227_MN2 (nrkn20 nrk19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2227_MN0 (XI2227_n1 A_31_b3_8 nrkn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2227_MN1 (VSS ru19 XI2227_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2221_MN2 (nrkn18 nrk17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2221_MN0 (XI2221_n1 A_31_b3_8 nrkn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2221_MN1 (VSS ru17 XI2221_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2218_MN2 (nrkn17 nrk16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2218_MN0 (XI2218_n1 A_31_b3_8 nrkn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2218_MN1 (VSS ru16 XI2218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I182_XG_MN2 (I2066_G31_16n I2066_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I182_XG_MN0 (XI2066_I182_XG_n1 I2066_P31_24 I2066_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I182_XG_MN1 (VSS I2066_G23_16 XI2066_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I180_XG_MN2 (I2066_G29_14n I2066_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I180_XG_MN0 (XI2066_I180_XG_n1 I2066_P29_22 I2066_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I180_XG_MN1 (VSS I2066_G21_14 XI2066_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I123_XG_MN2 (I2066_G27_24n I2066_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I123_XG_MN0 (XI2066_I123_XG_n1 I2066_P27_26 I2066_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I123_XG_MN1 (VSS I2066_G25_24 XI2066_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I121_XG_MN2 (I2066_G25_22n I2066_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I121_XG_MN0 (XI2066_I121_XG_n1 I2066_P25_24 I2066_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I121_XG_MN1 (VSS I2066_G23_22 XI2066_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I124_XG_MN2 (I2066_G28_25n I2066_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I124_XG_MN0 (XI2066_I124_XG_n1 I2066_P28_27 I2066_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I124_XG_MN1 (VSS I2066_G26_25 XI2066_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I182_XG_MN2 (I1988_G31_16n I1988_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I182_XG_MN0 (XI1988_I182_XG_n1 I1988_P31_24 I1988_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I182_XG_MN1 (VSS I1988_G23_16 XI1988_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I123_XG_MN2 (I1988_G27_24n I1988_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I123_XG_MN0 (XI1988_I123_XG_n1 I1988_P27_26 I1988_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I123_XG_MN1 (VSS I1988_G25_24 XI1988_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I179_XG_MN2 (I1942_G28_13n I1942_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I179_XG_MN0 (XI1942_I179_XG_n1 I1942_P28_21 I1942_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I179_XG_MN1 (VSS I1942_G20_13 XI1942_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I122_XG_MN2 (I1942_G26_23n I1942_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I122_XG_MN0 (XI1942_I122_XG_n1 I1942_P26_25 I1942_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I122_XG_MN1 (VSS I1942_G24_23 XI1942_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I120_XG_MN2 (I1942_G24_21n I1942_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I120_XG_MN0 (XI1942_I120_XG_n1 I1942_P24_23 I1942_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I120_XG_MN1 (VSS I1942_G22_21 XI1942_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I180_XG_MN2 (I1942_G29_14n I1942_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I180_XG_MN0 (XI1942_I180_XG_n1 I1942_P29_22 I1942_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I180_XG_MN1 (VSS I1942_G21_14 XI1942_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I121_XG_MN2 (I1942_G25_22n I1942_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I121_XG_MN0 (XI1942_I121_XG_n1 I1942_P25_24 I1942_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I121_XG_MN1 (VSS I1942_G23_22 XI1942_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I173_XG_MN2 (I1896_G22_7n I1896_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I173_XG_MN0 (XI1896_I173_XG_n1 I1896_P22_15 I1896_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I173_XG_MN1 (VSS I1896_G14_7 XI1896_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I175_XG_MN2 (I1896_G24_9n I1896_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I175_XG_MN0 (XI1896_I175_XG_n1 I1896_P24_17 I1896_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I175_XG_MN1 (VSS I1896_G16_9 XI1896_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I118_XG_MN2 (I1896_G22_19n I1896_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I118_XG_MN0 (XI1896_I118_XG_n1 I1896_P22_21 I1896_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I118_XG_MN1 (VSS I1896_G20_19 XI1896_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I120_XG_MN2 (I1896_G24_21n I1896_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I120_XG_MN0 (XI1896_I120_XG_n1 I1896_P24_23 I1896_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I120_XG_MN1 (VSS I1896_G22_21 XI1896_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I180_XG_MN2 (I1896_G29_14n I1896_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I180_XG_MN0 (XI1896_I180_XG_n1 I1896_P29_22 I1896_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I180_XG_MN1 (VSS I1896_G21_14 XI1896_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I125_XG_MN2 (I1896_G29_26n I1896_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I125_XG_MN0 (XI1896_I125_XG_n1 I1896_P29_28 I1896_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I125_XG_MN1 (VSS I1896_G27_26 XI1896_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I174_XG_MN2 (I654_G23_8n I654_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I174_XG_MN0 (XI654_I174_XG_n1 I654_P23_16 I654_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I174_XG_MN1 (VSS I654_G15_8 XI654_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I180_XG_MN2 (I654_G29_14n I654_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I180_XG_MN0 (XI654_I180_XG_n1 I654_P29_22 I654_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I180_XG_MN1 (VSS I654_G21_14 XI654_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I119_XG_MN2 (I654_G23_20n I654_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I119_XG_MN0 (XI654_I119_XG_n1 I654_P23_22 I654_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I119_XG_MN1 (VSS I654_G21_20 XI654_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I179_XG_MN2 (I654_G28_13n I654_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I179_XG_MN0 (XI654_I179_XG_n1 I654_P28_21 I654_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I179_XG_MN1 (VSS I654_G20_13 XI654_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I120_XG_MN2 (I654_G24_21n I654_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I120_XG_MN0 (XI654_I120_XG_n1 I654_P24_23 I654_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I120_XG_MN1 (VSS I654_G22_21 XI654_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I118_XG_MN2 (I654_G22_19n I654_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I118_XG_MN0 (XI654_I118_XG_n1 I654_P22_21 I654_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I118_XG_MN1 (VSS I654_G20_19 XI654_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I180_XG_MN2 (I608_G29_14n I608_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I180_XG_MN0 (XI608_I180_XG_n1 I608_P29_22 I608_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I180_XG_MN1 (VSS I608_G21_14 XI608_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I181_XG_MN2 (I608_G30_15n I608_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I181_XG_MN0 (XI608_I181_XG_n1 I608_P30_23 I608_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I181_XG_MN1 (VSS I608_G22_15 XI608_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I120_XG_MN2 (I608_G24_21n I608_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I120_XG_MN0 (XI608_I120_XG_n1 I608_P24_23 I608_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I120_XG_MN1 (VSS I608_G22_21 XI608_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I122_XG_MN2 (I562_G26_23n I562_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I122_XG_MN0 (XI562_I122_XG_n1 I562_P26_25 I562_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I122_XG_MN1 (VSS I562_G24_23 XI562_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I121_XG_MN2 (I562_G25_22n I562_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I121_XG_MN0 (XI562_I121_XG_n1 I562_P25_24 I562_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I121_XG_MN1 (VSS I562_G23_22 XI562_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I182_XG_MN2 (I562_G31_16n I562_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I182_XG_MN0 (XI562_I182_XG_n1 I562_P31_24 I562_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I182_XG_MN1 (VSS I562_G23_16 XI562_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2215_MN2 (nrkn16 nrk15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2215_MN0 (XI2215_n1 A_31_b3_8 nrkn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2215_MN1 (VSS ru15 XI2215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I174_XG_MN2 (I2066_G23_8n I2066_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I174_XG_MN0 (XI2066_I174_XG_n1 I2066_P23_16 I2066_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I174_XG_MN1 (VSS I2066_G15_8 XI2066_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I119_XG_MN2 (I2066_G23_20n I2066_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I119_XG_MN0 (XI2066_I119_XG_n1 I2066_P23_22 I2066_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I119_XG_MN1 (VSS I2066_G21_20 XI2066_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I181_XG_MN2 (I2066_G30_15n I2066_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I181_XG_MN0 (XI2066_I181_XG_n1 I2066_P30_23 I2066_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I181_XG_MN1 (VSS I2066_G22_15 XI2066_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I122_XG_MN2 (I2066_G26_23n I2066_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I122_XG_MN0 (XI2066_I122_XG_n1 I2066_P26_25 I2066_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I122_XG_MN1 (VSS I2066_G24_23 XI2066_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I181_XG_MN2 (I1988_G30_15n I1988_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I181_XG_MN0 (XI1988_I181_XG_n1 I1988_P30_23 I1988_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I181_XG_MN1 (VSS I1988_G22_15 XI1988_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I122_XG_MN2 (I1988_G26_23n I1988_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I122_XG_MN0 (XI1988_I122_XG_n1 I1988_P26_25 I1988_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I122_XG_MN1 (VSS I1988_G24_23 XI1988_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I120_XG_MN2 (I1988_G24_21n I1988_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I120_XG_MN0 (XI1988_I120_XG_n1 I1988_P24_23 I1988_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I120_XG_MN1 (VSS I1988_G22_21 XI1988_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I180_XG_MN2 (I1988_G29_14n I1988_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I180_XG_MN0 (XI1988_I180_XG_n1 I1988_P29_22 I1988_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I180_XG_MN1 (VSS I1988_G21_14 XI1988_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I121_XG_MN2 (I1988_G25_22n I1988_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I121_XG_MN0 (XI1988_I121_XG_n1 I1988_P25_24 I1988_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I121_XG_MN1 (VSS I1988_G23_22 XI1988_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I177_XG_MN2 (I1942_G26_11n I1942_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I177_XG_MN0 (XI1942_I177_XG_n1 I1942_P26_19 I1942_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I177_XG_MN1 (VSS I1942_G18_11 XI1942_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I173_XG_MN2 (I1942_G22_7n I1942_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I173_XG_MN0 (XI1942_I173_XG_n1 I1942_P22_15 I1942_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I173_XG_MN1 (VSS I1942_G14_7 XI1942_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I118_XG_MN2 (I1942_G22_19n I1942_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I118_XG_MN0 (XI1942_I118_XG_n1 I1942_P22_21 I1942_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I118_XG_MN1 (VSS I1942_G20_19 XI1942_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I178_XG_MN2 (I1942_G27_12n I1942_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I178_XG_MN0 (XI1942_I178_XG_n1 I1942_P27_20 I1942_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I178_XG_MN1 (VSS I1942_G19_12 XI1942_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I174_XG_MN2 (I1942_G23_8n I1942_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I174_XG_MN0 (XI1942_I174_XG_n1 I1942_P23_16 I1942_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I174_XG_MN1 (VSS I1942_G15_8 XI1942_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I119_XG_MN2 (I1942_G23_20n I1942_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I119_XG_MN0 (XI1942_I119_XG_n1 I1942_P23_22 I1942_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I119_XG_MN1 (VSS I1942_G21_20 XI1942_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I171_XG_MN2 (I1896_G20_5n I1896_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I171_XG_MN0 (XI1896_I171_XG_n1 I1896_P20_13 I1896_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I171_XG_MN1 (VSS I1896_G12_5 XI1896_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I165_XG_MN2 (I1896_G14_0n I1896_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I165_XG_MN0 (XI1896_I165_XG_n1 I1896_P14_7 I1896_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I165_XG_MN1 (VSS I1896_G6_0 XI1896_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I116_XG_MN2 (I1896_G20_17n I1896_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I116_XG_MN0 (XI1896_I116_XG_n1 I1896_P20_19 I1896_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I116_XG_MN1 (VSS I1896_G18_17 XI1896_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I176_XG_MN2 (I1896_G25_10n I1896_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I176_XG_MN0 (XI1896_I176_XG_n1 I1896_P25_18 I1896_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I176_XG_MN1 (VSS I1896_G17_10 XI1896_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I121_XG_MN2 (I1896_G25_22n I1896_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I121_XG_MN0 (XI1896_I121_XG_n1 I1896_P25_24 I1896_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I121_XG_MN1 (VSS I1896_G23_22 XI1896_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I123_XG_MN2 (I1896_G27_24n I1896_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I123_XG_MN0 (XI1896_I123_XG_n1 I1896_P27_26 I1896_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I123_XG_MN1 (VSS I1896_G25_24 XI1896_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I127_XG_MN2 (I1896_G31_28n I1896_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I127_XG_MN0 (XI1896_I127_XG_n1 I1896_P31_30 I1896_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I127_XG_MN1 (VSS I1896_G29_28 XI1896_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I127_XG_MN2 (I700_G31_28n I700_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I127_XG_MN0 (XI700_I127_XG_n1 I700_P31_30 I700_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I127_XG_MN1 (VSS I700_G29_28 XI700_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I172_XG_MN2 (I654_G21_6n I654_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I172_XG_MN0 (XI654_I172_XG_n1 I654_P21_14 I654_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I172_XG_MN1 (VSS I654_G13_6 XI654_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I117_XG_MN2 (I654_G21_18n I654_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I117_XG_MN0 (XI654_I117_XG_n1 I654_P21_20 I654_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I117_XG_MN1 (VSS I654_G19_18 XI654_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I173_XG_MN2 (I654_G22_7n I654_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I173_XG_MN0 (XI654_I173_XG_n1 I654_P22_15 I654_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I173_XG_MN1 (VSS I654_G14_7 XI654_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I172_XG_MN2 (I608_G21_6n I608_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I172_XG_MN0 (XI608_I172_XG_n1 I608_P21_14 I608_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I172_XG_MN1 (VSS I608_G13_6 XI608_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I117_XG_MN2 (I608_G21_18n I608_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I117_XG_MN0 (XI608_I117_XG_n1 I608_P21_20 I608_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I117_XG_MN1 (VSS I608_G19_18 XI608_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I173_XG_MN2 (I608_G22_7n I608_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I173_XG_MN0 (XI608_I173_XG_n1 I608_P22_15 I608_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I173_XG_MN1 (VSS I608_G14_7 XI608_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I179_XG_MN2 (I608_G28_13n I608_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I179_XG_MN0 (XI608_I179_XG_n1 I608_P28_21 I608_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I179_XG_MN1 (VSS I608_G20_13 XI608_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I118_XG_MN2 (I608_G22_19n I608_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I118_XG_MN0 (XI608_I118_XG_n1 I608_P22_21 I608_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I118_XG_MN1 (VSS I608_G20_19 XI608_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I120_XG_MN2 (I562_G24_21n I562_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I120_XG_MN0 (XI562_I120_XG_n1 I562_P24_23 I562_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I120_XG_MN1 (VSS I562_G22_21 XI562_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I118_XG_MN2 (I562_G22_19n I562_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I118_XG_MN0 (XI562_I118_XG_n1 I562_P22_21 I562_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I118_XG_MN1 (VSS I562_G20_19 XI562_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I181_XG_MN2 (I562_G30_15n I562_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I181_XG_MN0 (XI562_I181_XG_n1 I562_P30_23 I562_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I181_XG_MN1 (VSS I562_G22_15 XI562_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I119_XG_MN2 (I562_G23_20n I562_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I119_XG_MN0 (XI562_I119_XG_n1 I562_P23_22 I562_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I119_XG_MN1 (VSS I562_G21_20 XI562_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I180_XG_MN2 (I562_G29_14n I562_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I180_XG_MN0 (XI562_I180_XG_n1 I562_P29_22 I562_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I180_XG_MN1 (VSS I562_G21_14 XI562_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I174_XG_MN2 (I562_G23_8n I562_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I174_XG_MN0 (XI562_I174_XG_n1 I562_P23_16 I562_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I174_XG_MN1 (VSS I562_G15_8 XI562_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2212_MN2 (nrkn15 nrk14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2212_MN0 (XI2212_n1 A_31_b3_8 nrkn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2212_MN1 (VSS ru14 XI2212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I166_XG_MN2 (I2066_G15_0n I2066_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I166_XG_MN0 (XI2066_I166_XG_n1 I2066_P15_8 I2066_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I166_XG_MN1 (VSS I2066_G7_0 XI2066_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I178_XG_MN2 (I2066_G27_12n I2066_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I178_XG_MN0 (XI2066_I178_XG_n1 I2066_P27_20 I2066_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I178_XG_MN1 (VSS I2066_G19_12 XI2066_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I173_XG_MN2 (I2066_G22_7n I2066_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I173_XG_MN0 (XI2066_I173_XG_n1 I2066_P22_15 I2066_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I173_XG_MN1 (VSS I2066_G14_7 XI2066_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I165_XG_MN2 (I2066_G14_0n I2066_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I165_XG_MN0 (XI2066_I165_XG_n1 I2066_P14_7 I2066_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I165_XG_MN1 (VSS I2066_G6_0 XI2066_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I120_XG_MN2 (I2066_G24_21n I2066_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I120_XG_MN0 (XI2066_I120_XG_n1 I2066_P24_23 I2066_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I120_XG_MN1 (VSS I2066_G22_21 XI2066_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I179_XG_MN2 (I1988_G28_13n I1988_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I179_XG_MN0 (XI1988_I179_XG_n1 I1988_P28_21 I1988_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I179_XG_MN1 (VSS I1988_G20_13 XI1988_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I118_XG_MN2 (I1988_G22_19n I1988_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I118_XG_MN0 (XI1988_I118_XG_n1 I1988_P22_21 I1988_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I118_XG_MN1 (VSS I1988_G20_19 XI1988_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I174_XG_MN2 (I1988_G23_8n I1988_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I174_XG_MN0 (XI1988_I174_XG_n1 I1988_P23_16 I1988_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I174_XG_MN1 (VSS I1988_G15_8 XI1988_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I119_XG_MN2 (I1988_G23_20n I1988_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I119_XG_MN0 (XI1988_I119_XG_n1 I1988_P23_22 I1988_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I119_XG_MN1 (VSS I1988_G21_20 XI1988_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I165_XG_MN2 (I1942_G14_0n I1942_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I165_XG_MN0 (XI1942_I165_XG_n1 I1942_P14_7 I1942_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I165_XG_MN1 (VSS I1942_G6_0 XI1942_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I166_XG_MN2 (I1942_G15_0n I1942_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I166_XG_MN0 (XI1942_I166_XG_n1 I1942_P15_8 I1942_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I166_XG_MN1 (VSS I1942_G7_0 XI1942_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I176_XG_MN2 (I1942_G25_10n I1942_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I176_XG_MN0 (XI1942_I176_XG_n1 I1942_P25_18 I1942_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I176_XG_MN1 (VSS I1942_G17_10 XI1942_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I117_XG_MN2 (I1942_G21_18n I1942_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I117_XG_MN0 (XI1942_I117_XG_n1 I1942_P21_20 I1942_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I117_XG_MN1 (VSS I1942_G19_18 XI1942_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I160_XG_MN2 (I1896_G10_0n I1896_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I160_XG_MN0 (XI1896_I160_XG_n1 I1896_P10_3 I1896_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I160_XG_MN1 (VSS I1896_G2_0np XI1896_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I163_XG_MN2 (I1896_G12_0n I1896_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I163_XG_MN0 (XI1896_I163_XG_n1 I1896_P12_5 I1896_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I163_XG_MN1 (VSS I1896_G4_0 XI1896_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I169_XG_MN2 (I1896_G18_3n I1896_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I169_XG_MN0 (XI1896_I169_XG_n1 I1896_P18_11 I1896_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I169_XG_MN1 (VSS I1896_G10_3 XI1896_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I114_XG_MN2 (I1896_G18_15n I1896_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I114_XG_MN0 (XI1896_I114_XG_n1 I1896_P18_17 I1896_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I114_XG_MN1 (VSS I1896_G16_15 XI1896_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I172_XG_MN2 (I1896_G21_6n I1896_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I172_XG_MN0 (XI1896_I172_XG_n1 I1896_P21_14 I1896_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I172_XG_MN1 (VSS I1896_G13_6 XI1896_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I117_XG_MN2 (I1896_G21_18n I1896_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I117_XG_MN0 (XI1896_I117_XG_n1 I1896_P21_20 I1896_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I117_XG_MN1 (VSS I1896_G19_18 XI1896_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I119_XG_MN2 (I1896_G23_20n I1896_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I119_XG_MN0 (XI1896_I119_XG_n1 I1896_P23_22 I1896_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I119_XG_MN1 (VSS I1896_G21_20 XI1896_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I125_XG_MN2 (I700_G29_26n I700_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I125_XG_MN0 (XI700_I125_XG_n1 I700_P29_28 I700_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I125_XG_MN1 (VSS I700_G27_26 XI700_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I123_XG_MN2 (I700_G27_24n I700_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I123_XG_MN0 (XI700_I123_XG_n1 I700_P27_26 I700_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I123_XG_MN1 (VSS I700_G25_24 XI700_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I121_XG_MN2 (I700_G25_22n I700_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I121_XG_MN0 (XI700_I121_XG_n1 I700_P25_24 I700_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I121_XG_MN1 (VSS I700_G23_22 XI700_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I166_XG_MN2 (I654_G15_0n I654_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I166_XG_MN0 (XI654_I166_XG_n1 I654_P15_8 I654_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I166_XG_MN1 (VSS I654_G7_0 XI654_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I170_XG_MN2 (I654_G19_4n I654_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I170_XG_MN0 (XI654_I170_XG_n1 I654_P19_12 I654_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I170_XG_MN1 (VSS I654_G11_4 XI654_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I176_XG_MN2 (I654_G25_10n I654_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I176_XG_MN0 (XI654_I176_XG_n1 I654_P25_18 I654_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I176_XG_MN1 (VSS I654_G17_10 XI654_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I115_XG_MN2 (I654_G19_16n I654_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I115_XG_MN0 (XI654_I115_XG_n1 I654_P19_18 I654_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I115_XG_MN1 (VSS I654_G17_16 XI654_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I165_XG_MN2 (I654_G14_0n I654_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I165_XG_MN0 (XI654_I165_XG_n1 I654_P14_7 I654_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I165_XG_MN1 (VSS I654_G6_0 XI654_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I175_XG_MN2 (I654_G24_9n I654_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I175_XG_MN0 (XI654_I175_XG_n1 I654_P24_17 I654_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I175_XG_MN1 (VSS I654_G16_9 XI654_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I177_XG_MN2 (I654_G26_11n I654_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I177_XG_MN0 (XI654_I177_XG_n1 I654_P26_19 I654_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I177_XG_MN1 (VSS I654_G18_11 XI654_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I114_XG_MN2 (I654_G18_15n I654_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I114_XG_MN0 (XI654_I114_XG_n1 I654_P18_17 I654_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I114_XG_MN1 (VSS I654_G16_15 XI654_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I116_XG_MN2 (I654_G20_17n I654_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I116_XG_MN0 (XI654_I116_XG_n1 I654_P20_19 I654_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I116_XG_MN1 (VSS I654_G18_17 XI654_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I166_XG_MN2 (I608_G15_0n I608_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I166_XG_MN0 (XI608_I166_XG_n1 I608_P15_8 I608_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I166_XG_MN1 (VSS I608_G7_0 XI608_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I176_XG_MN2 (I608_G25_10n I608_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I176_XG_MN0 (XI608_I176_XG_n1 I608_P25_18 I608_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I176_XG_MN1 (VSS I608_G17_10 XI608_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I115_XG_MN2 (I608_G19_16n I608_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I115_XG_MN0 (XI608_I115_XG_n1 I608_P19_18 I608_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I115_XG_MN1 (VSS I608_G17_16 XI608_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I177_XG_MN2 (I608_G26_11n I608_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I177_XG_MN0 (XI608_I177_XG_n1 I608_P26_19 I608_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I177_XG_MN1 (VSS I608_G18_11 XI608_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I116_XG_MN2 (I608_G20_17n I608_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I116_XG_MN0 (XI608_I116_XG_n1 I608_P20_19 I608_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I116_XG_MN1 (VSS I608_G18_17 XI608_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I173_XG_MN2 (I562_G22_7n I562_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I173_XG_MN0 (XI562_I173_XG_n1 I562_P22_15 I562_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I173_XG_MN1 (VSS I562_G14_7 XI562_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I117_XG_MN2 (I562_G21_18n I562_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I117_XG_MN0 (XI562_I117_XG_n1 I562_P21_20 I562_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I117_XG_MN1 (VSS I562_G19_18 XI562_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I172_XG_MN2 (I562_G21_6n I562_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I172_XG_MN0 (XI562_I172_XG_n1 I562_P21_14 I562_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I172_XG_MN1 (VSS I562_G13_6 XI562_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I178_XG_MN2 (I562_G27_12n I562_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I178_XG_MN0 (XI562_I178_XG_n1 I562_P27_20 I562_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I178_XG_MN1 (VSS I562_G19_12 XI562_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2209_MN2 (nrkn14 nrk13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2209_MN0 (XI2209_n1 A_31_b3_7 nrkn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2209_MN1 (VSS ru13 XI2209_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2206_MN2 (nrkn13 nrk12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2206_MN0 (XI2206_n1 A_31_b3_7 nrkn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2206_MN1 (VSS ru12 XI2206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I172_XG_MN2 (I2066_G21_6n I2066_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I172_XG_MN0 (XI2066_I172_XG_n1 I2066_P21_14 I2066_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I172_XG_MN1 (VSS I2066_G13_6 XI2066_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I117_XG_MN2 (I2066_G21_18n I2066_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I117_XG_MN0 (XI2066_I117_XG_n1 I2066_P21_20 I2066_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I117_XG_MN1 (VSS I2066_G19_18 XI2066_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I177_XG_MN2 (I2066_G26_11n I2066_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I177_XG_MN0 (XI2066_I177_XG_n1 I2066_P26_19 I2066_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I177_XG_MN1 (VSS I2066_G18_11 XI2066_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I118_XG_MN2 (I2066_G22_19n I2066_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I118_XG_MN0 (XI2066_I118_XG_n1 I2066_P22_21 I2066_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I118_XG_MN1 (VSS I2066_G20_19 XI2066_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I177_XG_MN2 (I1988_G26_11n I1988_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I177_XG_MN0 (XI1988_I177_XG_n1 I1988_P26_19 I1988_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I177_XG_MN1 (VSS I1988_G18_11 XI1988_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I166_XG_MN2 (I1988_G15_0n I1988_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I166_XG_MN0 (XI1988_I166_XG_n1 I1988_P15_8 I1988_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I166_XG_MN1 (VSS I1988_G7_0 XI1988_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I178_XG_MN2 (I1988_G27_12n I1988_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I178_XG_MN0 (XI1988_I178_XG_n1 I1988_P27_20 I1988_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I178_XG_MN1 (VSS I1988_G19_12 XI1988_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I117_XG_MN2 (I1988_G21_18n I1988_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I117_XG_MN0 (XI1988_I117_XG_n1 I1988_P21_20 I1988_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I117_XG_MN1 (VSS I1988_G19_18 XI1988_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I175_XG_MN2 (I1942_G24_9n I1942_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I175_XG_MN0 (XI1942_I175_XG_n1 I1942_P24_17 I1942_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I175_XG_MN1 (VSS I1942_G16_9 XI1942_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I116_XG_MN2 (I1942_G20_17n I1942_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I116_XG_MN0 (XI1942_I116_XG_n1 I1942_P20_19 I1942_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I116_XG_MN1 (VSS I1942_G18_17 XI1942_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I164_XG_MN2 (I1942_G13_0n I1942_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I164_XG_MN0 (XI1942_I164_XG_n1 I1942_P13_6 I1942_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I164_XG_MN1 (VSS I1942_G5_0 XI1942_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I172_XG_MN2 (I1942_G21_6n I1942_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I172_XG_MN0 (XI1942_I172_XG_n1 I1942_P21_14 I1942_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I172_XG_MN1 (VSS I1942_G13_6 XI1942_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I115_XG_MN2 (I1942_G19_16n I1942_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I115_XG_MN0 (XI1942_I115_XG_n1 I1942_P19_18 I1942_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I115_XG_MN1 (VSS I1942_G17_16 XI1942_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I110_XG_MN2 (I1896_G14_11n I1896_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I110_XG_MN0 (XI1896_I110_XG_n1 I1896_P14_13 I1896_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I110_XG_MN1 (VSS I1896_G12_11 XI1896_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I112_XG_MN2 (I1896_G16_13n I1896_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I112_XG_MN0 (XI1896_I112_XG_n1 I1896_P16_15 I1896_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I112_XG_MN1 (VSS I1896_G14_13 XI1896_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I164_XG_MN2 (I1896_G13_0n I1896_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I164_XG_MN0 (XI1896_I164_XG_n1 I1896_P13_6 I1896_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I164_XG_MN1 (VSS I1896_G5_0 XI1896_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I115_XG_MN2 (I1896_G19_16n I1896_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I115_XG_MN0 (XI1896_I115_XG_n1 I1896_P19_18 I1896_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I115_XG_MN1 (VSS I1896_G17_16 XI1896_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I178_XG_MN2 (I1896_G27_12n I1896_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I178_XG_MN0 (XI1896_I178_XG_n1 I1896_P27_20 I1896_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I178_XG_MN1 (VSS I1896_G19_12 XI1896_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I119_XG_MN2 (I700_G23_20n I700_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I119_XG_MN0 (XI700_I119_XG_n1 I700_P23_22 I700_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I119_XG_MN1 (VSS I700_G21_20 XI700_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I182_XG_MN2 (I700_G31_16n I700_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I182_XG_MN0 (XI700_I182_XG_n1 I700_P31_24 I700_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I182_XG_MN1 (VSS I700_G23_16 XI700_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I162_XG_MN2 (I654_G11_0n I654_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I162_XG_MN0 (XI654_I162_XG_n1 I654_P11_4 I654_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I162_XG_MN1 (VSS I654_G3_0np XI654_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I113_XG_MN2 (I654_G17_14n I654_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I113_XG_MN0 (XI654_I113_XG_n1 I654_P17_16 I654_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I113_XG_MN1 (VSS I654_G15_14 XI654_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I171_XG_MN2 (I654_G20_5n I654_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I171_XG_MN0 (XI654_I171_XG_n1 I654_P20_13 I654_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I171_XG_MN1 (VSS I654_G12_5 XI654_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I112_XG_MN2 (I654_G16_13n I654_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I112_XG_MN0 (XI654_I112_XG_n1 I654_P16_15 I654_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I112_XG_MN1 (VSS I654_G14_13 XI654_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I164_XG_MN2 (I608_G13_0n I608_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I164_XG_MN0 (XI608_I164_XG_n1 I608_P13_6 I608_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I164_XG_MN1 (VSS I608_G5_0 XI608_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I113_XG_MN2 (I608_G17_14n I608_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I113_XG_MN0 (XI608_I113_XG_n1 I608_P17_16 I608_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I113_XG_MN1 (VSS I608_G15_14 XI608_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I165_XG_MN2 (I608_G14_0n I608_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I165_XG_MN0 (XI608_I165_XG_n1 I608_P14_7 I608_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I165_XG_MN1 (VSS I608_G6_0 XI608_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I114_XG_MN2 (I608_G18_15n I608_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I114_XG_MN0 (XI608_I114_XG_n1 I608_P18_17 I608_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I114_XG_MN1 (VSS I608_G16_15 XI608_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I179_XG_MN2 (I562_G28_13n I562_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I179_XG_MN0 (XI562_I179_XG_n1 I562_P28_21 I562_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I179_XG_MN1 (VSS I562_G20_13 XI562_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I177_XG_MN2 (I562_G26_11n I562_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I177_XG_MN0 (XI562_I177_XG_n1 I562_P26_19 I562_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I177_XG_MN1 (VSS I562_G18_11 XI562_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I165_XG_MN2 (I562_G14_0n I562_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I165_XG_MN0 (XI562_I165_XG_n1 I562_P14_7 I562_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I165_XG_MN1 (VSS I562_G6_0 XI562_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I164_XG_MN2 (I562_G13_0n I562_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I164_XG_MN0 (XI562_I164_XG_n1 I562_P13_6 I562_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I164_XG_MN1 (VSS I562_G5_0 XI562_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I115_XG_MN2 (I562_G19_16n I562_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I115_XG_MN0 (XI562_I115_XG_n1 I562_P19_18 I562_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I115_XG_MN1 (VSS I562_G17_16 XI562_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I176_XG_MN2 (I562_G25_10n I562_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I176_XG_MN0 (XI562_I176_XG_n1 I562_P25_18 I562_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I176_XG_MN1 (VSS I562_G17_10 XI562_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I166_XG_MN2 (I562_G15_0n I562_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I166_XG_MN0 (XI562_I166_XG_n1 I562_P15_8 I562_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I166_XG_MN1 (VSS I562_G7_0 XI562_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2203_MN2 (nrkn12 nrk11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2203_MN0 (XI2203_n1 A_31_b3_7 nrkn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2203_MN1 (VSS ru11 XI2203_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I170_XG_MN2 (I2066_G19_4n I2066_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I170_XG_MN0 (XI2066_I170_XG_n1 I2066_P19_12 I2066_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I170_XG_MN1 (VSS I2066_G11_4 XI2066_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I164_XG_MN2 (I2066_G13_0n I2066_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I164_XG_MN0 (XI2066_I164_XG_n1 I2066_P13_6 I2066_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I164_XG_MN1 (VSS I2066_G5_0 XI2066_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I176_XG_MN2 (I2066_G25_10n I2066_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I176_XG_MN0 (XI2066_I176_XG_n1 I2066_P25_18 I2066_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I176_XG_MN1 (VSS I2066_G17_10 XI2066_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I113_XG_MN2 (I2066_G17_14n I2066_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I113_XG_MN0 (XI2066_I113_XG_n1 I2066_P17_16 I2066_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I113_XG_MN1 (VSS I2066_G15_14 XI2066_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I115_XG_MN2 (I2066_G19_16n I2066_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I115_XG_MN0 (XI2066_I115_XG_n1 I2066_P19_18 I2066_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I115_XG_MN1 (VSS I2066_G17_16 XI2066_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I171_XG_MN2 (I2066_G20_5n I2066_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I171_XG_MN0 (XI2066_I171_XG_n1 I2066_P20_13 I2066_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I171_XG_MN1 (VSS I2066_G12_5 XI2066_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I179_XG_MN2 (I2066_G28_13n I2066_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I179_XG_MN0 (XI2066_I179_XG_n1 I2066_P28_21 I2066_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I179_XG_MN1 (VSS I2066_G20_13 XI2066_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I116_XG_MN2 (I2066_G20_17n I2066_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I116_XG_MN0 (XI2066_I116_XG_n1 I2066_P20_19 I2066_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I116_XG_MN1 (VSS I2066_G18_17 XI2066_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I173_XG_MN2 (I1988_G22_7n I1988_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I173_XG_MN0 (XI1988_I173_XG_n1 I1988_P22_15 I1988_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I173_XG_MN1 (VSS I1988_G14_7 XI1988_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I114_XG_MN2 (I1988_G18_15n I1988_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I114_XG_MN0 (XI1988_I114_XG_n1 I1988_P18_17 I1988_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I114_XG_MN1 (VSS I1988_G16_15 XI1988_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I116_XG_MN2 (I1988_G20_17n I1988_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I116_XG_MN0 (XI1988_I116_XG_n1 I1988_P20_19 I1988_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I116_XG_MN1 (VSS I1988_G18_17 XI1988_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I172_XG_MN2 (I1988_G21_6n I1988_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I172_XG_MN0 (XI1988_I172_XG_n1 I1988_P21_14 I1988_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I172_XG_MN1 (VSS I1988_G13_6 XI1988_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I115_XG_MN2 (I1988_G19_16n I1988_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I115_XG_MN0 (XI1988_I115_XG_n1 I1988_P19_18 I1988_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I115_XG_MN1 (VSS I1988_G17_16 XI1988_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I171_XG_MN2 (I1942_G20_5n I1942_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I171_XG_MN0 (XI1942_I171_XG_n1 I1942_P20_13 I1942_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I171_XG_MN1 (VSS I1942_G12_5 XI1942_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I114_XG_MN2 (I1942_G18_15n I1942_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I114_XG_MN0 (XI1942_I114_XG_n1 I1942_P18_17 I1942_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I114_XG_MN1 (VSS I1942_G16_15 XI1942_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I112_XG_MN2 (I1942_G16_13n I1942_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I112_XG_MN0 (XI1942_I112_XG_n1 I1942_P16_15 I1942_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I112_XG_MN1 (VSS I1942_G14_13 XI1942_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I111_XG_MN2 (I1942_G15_12n I1942_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I111_XG_MN0 (XI1942_I111_XG_n1 I1942_P15_14 I1942_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I111_XG_MN1 (VSS I1942_G13_12 XI1942_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I113_XG_MN2 (I1942_G17_14n I1942_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I113_XG_MN0 (XI1942_I113_XG_n1 I1942_P17_16 I1942_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I113_XG_MN1 (VSS I1942_G15_14 XI1942_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I167_XG_MN2 (I1896_G16_1n I1896_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I167_XG_MN0 (XI1896_I167_XG_n1 I1896_P16_9 I1896_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I167_XG_MN1 (VSS I1896_G8_1 XI1896_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I168_XG_MN2 (I1896_G17_2n I1896_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I168_XG_MN0 (XI1896_I168_XG_n1 I1896_P17_10 I1896_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I168_XG_MN1 (VSS I1896_G9_2 XI1896_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I108_XG_MN2 (I1896_G12_9n I1896_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I108_XG_MN0 (XI1896_I108_XG_n1 I1896_P12_11 I1896_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I108_XG_MN1 (VSS I1896_G10_9 XI1896_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I113_XG_MN2 (I1896_G17_14n I1896_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I113_XG_MN0 (XI1896_I113_XG_n1 I1896_P17_16 I1896_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I113_XG_MN1 (VSS I1896_G15_14 XI1896_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I170_XG_MN2 (I1896_G19_4n I1896_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I170_XG_MN0 (XI1896_I170_XG_n1 I1896_P19_12 I1896_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I170_XG_MN1 (VSS I1896_G11_4 XI1896_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I174_XG_MN2 (I1896_G23_8n I1896_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I174_XG_MN0 (XI1896_I174_XG_n1 I1896_P23_16 I1896_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I174_XG_MN1 (VSS I1896_G15_8 XI1896_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I182_XG_MN2 (I1896_G31_16n I1896_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I182_XG_MN0 (XI1896_I182_XG_n1 I1896_P31_24 I1896_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I182_XG_MN1 (VSS I1896_G23_16 XI1896_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I117_XG_MN2 (I700_G21_18n I700_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I117_XG_MN0 (XI700_I117_XG_n1 I700_P21_20 I700_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I117_XG_MN1 (VSS I700_G19_18 XI700_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I115_XG_MN2 (I700_G19_16n I700_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I115_XG_MN0 (XI700_I115_XG_n1 I700_P19_18 I700_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I115_XG_MN1 (VSS I700_G17_16 XI700_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I164_XG_MN2 (I654_G13_0n I654_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I164_XG_MN0 (XI654_I164_XG_n1 I654_P13_6 I654_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I164_XG_MN1 (VSS I654_G5_0 XI654_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I111_XG_MN2 (I654_G15_12n I654_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I111_XG_MN0 (XI654_I111_XG_n1 I654_P15_14 I654_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I111_XG_MN1 (VSS I654_G13_12 XI654_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I109_XG_MN2 (I654_G13_10n I654_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I109_XG_MN0 (XI654_I109_XG_n1 I654_P13_12 I654_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I109_XG_MN1 (VSS I654_G11_10 XI654_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I110_XG_MN2 (I654_G14_11n I654_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I110_XG_MN0 (XI654_I110_XG_n1 I654_P14_13 I654_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I110_XG_MN1 (VSS I654_G12_11 XI654_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I170_XG_MN2 (I608_G19_4n I608_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I170_XG_MN0 (XI608_I170_XG_n1 I608_P19_12 I608_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I170_XG_MN1 (VSS I608_G11_4 XI608_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I111_XG_MN2 (I608_G15_12n I608_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I111_XG_MN0 (XI608_I111_XG_n1 I608_P15_14 I608_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I111_XG_MN1 (VSS I608_G13_12 XI608_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I171_XG_MN2 (I608_G20_5n I608_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I171_XG_MN0 (XI608_I171_XG_n1 I608_P20_13 I608_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I171_XG_MN1 (VSS I608_G12_5 XI608_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I112_XG_MN2 (I608_G16_13n I608_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I112_XG_MN0 (XI608_I112_XG_n1 I608_P16_15 I608_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I112_XG_MN1 (VSS I608_G14_13 XI608_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I116_XG_MN2 (I562_G20_17n I562_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I116_XG_MN0 (XI562_I116_XG_n1 I562_P20_19 I562_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I116_XG_MN1 (VSS I562_G18_17 XI562_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I114_XG_MN2 (I562_G18_15n I562_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I114_XG_MN0 (XI562_I114_XG_n1 I562_P18_17 I562_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I114_XG_MN1 (VSS I562_G16_15 XI562_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I113_XG_MN2 (I562_G17_14n I562_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I113_XG_MN0 (XI562_I113_XG_n1 I562_P17_16 I562_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I113_XG_MN1 (VSS I562_G15_14 XI562_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I111_XG_MN2 (I562_G15_12n I562_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I111_XG_MN0 (XI562_I111_XG_n1 I562_P15_14 I562_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I111_XG_MN1 (VSS I562_G13_12 XI562_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I170_XG_MN2 (I562_G19_4n I562_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I170_XG_MN0 (XI562_I170_XG_n1 I562_P19_12 I562_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I170_XG_MN1 (VSS I562_G11_4 XI562_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2200_MN2 (nrkn11 nrk10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2200_MN0 (XI2200_n1 A_31_b3_7 nrkn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2200_MN1 (VSS ru10 XI2200_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I162_XG_MN2 (I2066_G11_0n I2066_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I162_XG_MN0 (XI2066_I162_XG_n1 I2066_P11_4 I2066_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I162_XG_MN1 (VSS I2066_G3_0np XI2066_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I111_XG_MN2 (I2066_G15_12n I2066_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I111_XG_MN0 (XI2066_I111_XG_n1 I2066_P15_14 I2066_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I111_XG_MN1 (VSS I2066_G13_12 XI2066_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I163_XG_MN2 (I2066_G12_0n I2066_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I163_XG_MN0 (XI2066_I163_XG_n1 I2066_P12_5 I2066_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I163_XG_MN1 (VSS I2066_G4_0 XI2066_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I114_XG_MN2 (I2066_G18_15n I2066_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I114_XG_MN0 (XI2066_I114_XG_n1 I2066_P18_17 I2066_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I114_XG_MN1 (VSS I2066_G16_15 XI2066_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I112_XG_MN2 (I2066_G16_13n I2066_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I112_XG_MN0 (XI2066_I112_XG_n1 I2066_P16_15 I2066_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I112_XG_MN1 (VSS I2066_G14_13 XI2066_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I171_XG_MN2 (I1988_G20_5n I1988_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I171_XG_MN0 (XI1988_I171_XG_n1 I1988_P20_13 I1988_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I171_XG_MN1 (VSS I1988_G12_5 XI1988_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I165_XG_MN2 (I1988_G14_0n I1988_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I165_XG_MN0 (XI1988_I165_XG_n1 I1988_P14_7 I1988_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I165_XG_MN1 (VSS I1988_G6_0 XI1988_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I112_XG_MN2 (I1988_G16_13n I1988_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I112_XG_MN0 (XI1988_I112_XG_n1 I1988_P16_15 I1988_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I112_XG_MN1 (VSS I1988_G14_13 XI1988_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I111_XG_MN2 (I1988_G15_12n I1988_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I111_XG_MN0 (XI1988_I111_XG_n1 I1988_P15_14 I1988_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I111_XG_MN1 (VSS I1988_G13_12 XI1988_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I113_XG_MN2 (I1988_G17_14n I1988_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I113_XG_MN0 (XI1988_I113_XG_n1 I1988_P17_16 I1988_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I113_XG_MN1 (VSS I1988_G15_14 XI1988_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I163_XG_MN2 (I1942_G12_0n I1942_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I163_XG_MN0 (XI1942_I163_XG_n1 I1942_P12_5 I1942_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I163_XG_MN1 (VSS I1942_G4_0 XI1942_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I110_XG_MN2 (I1942_G14_11n I1942_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I110_XG_MN0 (XI1942_I110_XG_n1 I1942_P14_13 I1942_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I110_XG_MN1 (VSS I1942_G12_11 XI1942_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I170_XG_MN2 (I1942_G19_4n I1942_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I170_XG_MN0 (XI1942_I170_XG_n1 I1942_P19_12 I1942_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I170_XG_MN1 (VSS I1942_G11_4 XI1942_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I109_XG_MN2 (I1942_G13_10n I1942_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I109_XG_MN0 (XI1942_I109_XG_n1 I1942_P13_12 I1942_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I109_XG_MN1 (VSS I1942_G11_10 XI1942_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I157_XG_MN2 (I1896_G8_0n I1896_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I157_XG_MN0 (XI1896_I157_XG_n1 I1896_P8_1 I1896_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I157_XG_MN1 (VSS I1896_G0_0 XI1896_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I158_XG_MN2 (I1896_G9_0n I1896_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I158_XG_MN0 (XI1896_I158_XG_n1 I1896_P9_2 I1896_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I158_XG_MN1 (VSS I1896_G1_0 XI1896_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I106_XG_MN2 (I1896_G10_7n I1896_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I106_XG_MN0 (XI1896_I106_XG_n1 I1896_P10_9 I1896_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I106_XG_MN1 (VSS I1896_G8_7 XI1896_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I109_XG_MN2 (I1896_G13_10n I1896_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I109_XG_MN0 (XI1896_I109_XG_n1 I1896_P13_12 I1896_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I109_XG_MN1 (VSS I1896_G11_10 XI1896_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I111_XG_MN2 (I1896_G15_12n I1896_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I111_XG_MN0 (XI1896_I111_XG_n1 I1896_P15_14 I1896_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I111_XG_MN1 (VSS I1896_G13_12 XI1896_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I162_XG_MN2 (I1896_G11_0n I1896_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I162_XG_MN0 (XI1896_I162_XG_n1 I1896_P11_4 I1896_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I162_XG_MN1 (VSS I1896_G3_0np XI1896_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I166_XG_MN2 (I1896_G15_0n I1896_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I166_XG_MN0 (XI1896_I166_XG_n1 I1896_P15_8 I1896_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I166_XG_MN1 (VSS I1896_G7_0 XI1896_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I180_XG_MN2 (I700_G29_14n I700_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I180_XG_MN0 (XI700_I180_XG_n1 I700_P29_22 I700_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I180_XG_MN1 (VSS I700_G21_14 XI700_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I178_XG_MN2 (I700_G27_12n I700_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I178_XG_MN0 (XI700_I178_XG_n1 I700_P27_20 I700_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I178_XG_MN1 (VSS I700_G19_12 XI700_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I113_XG_MN2 (I700_G17_14n I700_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I113_XG_MN0 (XI700_I113_XG_n1 I700_P17_16 I700_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I113_XG_MN1 (VSS I700_G15_14 XI700_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I168_XG_MN2 (I654_G17_2n I654_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I168_XG_MN0 (XI654_I168_XG_n1 I654_P17_10 I654_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I168_XG_MN1 (VSS I654_G9_2 XI654_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I107_XG_MN2 (I654_G11_8n I654_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I107_XG_MN0 (XI654_I107_XG_n1 I654_P11_10 I654_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I107_XG_MN1 (VSS I654_G9_8 XI654_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I169_XG_MN2 (I654_G18_3n I654_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I169_XG_MN0 (XI654_I169_XG_n1 I654_P18_11 I654_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I169_XG_MN1 (VSS I654_G10_3 XI654_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I163_XG_MN2 (I654_G12_0n I654_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I163_XG_MN0 (XI654_I163_XG_n1 I654_P12_5 I654_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I163_XG_MN1 (VSS I654_G4_0 XI654_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I108_XG_MN2 (I654_G12_9n I654_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I108_XG_MN0 (XI654_I108_XG_n1 I654_P12_11 I654_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I108_XG_MN1 (VSS I654_G10_9 XI654_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I162_XG_MN2 (I608_G11_0n I608_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I162_XG_MN0 (XI608_I162_XG_n1 I608_P11_4 I608_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I162_XG_MN1 (VSS I608_G3_0np XI608_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I109_XG_MN2 (I608_G13_10n I608_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I109_XG_MN0 (XI608_I109_XG_n1 I608_P13_12 I608_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I109_XG_MN1 (VSS I608_G11_10 XI608_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I163_XG_MN2 (I608_G12_0n I608_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I163_XG_MN0 (XI608_I163_XG_n1 I608_P12_5 I608_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I163_XG_MN1 (VSS I608_G4_0 XI608_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I175_XG_MN2 (I608_G24_9n I608_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I175_XG_MN0 (XI608_I175_XG_n1 I608_P24_17 I608_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I175_XG_MN1 (VSS I608_G16_9 XI608_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I169_XG_MN2 (I608_G18_3n I608_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I169_XG_MN0 (XI608_I169_XG_n1 I608_P18_11 I608_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I169_XG_MN1 (VSS I608_G10_3 XI608_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I110_XG_MN2 (I608_G14_11n I608_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I110_XG_MN0 (XI608_I110_XG_n1 I608_P14_13 I608_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I110_XG_MN1 (VSS I608_G12_11 XI608_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I112_XG_MN2 (I562_G16_13n I562_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I112_XG_MN0 (XI562_I112_XG_n1 I562_P16_15 I562_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I112_XG_MN1 (VSS I562_G14_13 XI562_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I109_XG_MN2 (I562_G13_10n I562_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I109_XG_MN0 (XI562_I109_XG_n1 I562_P13_12 I562_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I109_XG_MN1 (VSS I562_G11_10 XI562_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I162_XG_MN2 (I562_G11_0n I562_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I162_XG_MN0 (XI562_I162_XG_n1 I562_P11_4 I562_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I162_XG_MN1 (VSS I562_G3_0np XI562_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2197_MN2 (nrkn10 nrk9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2197_MN0 (XI2197_n1 A_31_b3_7 nrkn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2197_MN1 (VSS ru9 XI2197_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I168_XG_MN2 (I2066_G17_2n I2066_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I168_XG_MN0 (XI2066_I168_XG_n1 I2066_P17_10 I2066_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I168_XG_MN1 (VSS I2066_G9_2 XI2066_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I109_XG_MN2 (I2066_G13_10n I2066_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I109_XG_MN0 (XI2066_I109_XG_n1 I2066_P13_12 I2066_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I109_XG_MN1 (VSS I2066_G11_10 XI2066_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I160_XG_MN2 (I2066_G10_0n I2066_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I160_XG_MN0 (XI2066_I160_XG_n1 I2066_P10_3 I2066_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I160_XG_MN1 (VSS I2066_G2_0np XI2066_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I169_XG_MN2 (I2066_G18_3n I2066_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I169_XG_MN0 (XI2066_I169_XG_n1 I2066_P18_11 I2066_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I169_XG_MN1 (VSS I2066_G10_3 XI2066_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I175_XG_MN2 (I2066_G24_9n I2066_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I175_XG_MN0 (XI2066_I175_XG_n1 I2066_P24_17 I2066_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I175_XG_MN1 (VSS I2066_G16_9 XI2066_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I110_XG_MN2 (I2066_G14_11n I2066_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I110_XG_MN0 (XI2066_I110_XG_n1 I2066_P14_13 I2066_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I110_XG_MN1 (VSS I2066_G12_11 XI2066_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I163_XG_MN2 (I1988_G12_0n I1988_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I163_XG_MN0 (XI1988_I163_XG_n1 I1988_P12_5 I1988_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I163_XG_MN1 (VSS I1988_G4_0 XI1988_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I110_XG_MN2 (I1988_G14_11n I1988_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I110_XG_MN0 (XI1988_I110_XG_n1 I1988_P14_13 I1988_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I110_XG_MN1 (VSS I1988_G12_11 XI1988_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I164_XG_MN2 (I1988_G13_0n I1988_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I164_XG_MN0 (XI1988_I164_XG_n1 I1988_P13_6 I1988_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I164_XG_MN1 (VSS I1988_G5_0 XI1988_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I176_XG_MN2 (I1988_G25_10n I1988_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I176_XG_MN0 (XI1988_I176_XG_n1 I1988_P25_18 I1988_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I176_XG_MN1 (VSS I1988_G17_10 XI1988_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I169_XG_MN2 (I1942_G18_3n I1942_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I169_XG_MN0 (XI1942_I169_XG_n1 I1942_P18_11 I1942_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I169_XG_MN1 (VSS I1942_G10_3 XI1942_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I108_XG_MN2 (I1942_G12_9n I1942_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I108_XG_MN0 (XI1942_I108_XG_n1 I1942_P12_11 I1942_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I108_XG_MN1 (VSS I1942_G10_9 XI1942_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I162_XG_MN2 (I1942_G11_0n I1942_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I162_XG_MN0 (XI1942_I162_XG_n1 I1942_P11_4 I1942_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I162_XG_MN1 (VSS I1942_G3_0np XI1942_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I107_XG_MN2 (I1942_G11_8n I1942_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I107_XG_MN0 (XI1942_I107_XG_n1 I1942_P11_10 I1942_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I107_XG_MN1 (VSS I1942_G9_8 XI1942_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I104_XG_MN2 (I1896_G8_5n I1896_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I104_XG_MN0 (XI1896_I104_XG_n1 I1896_P8_7 I1896_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I104_XG_MN1 (VSS I1896_G6_5 XI1896_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I103_XG_MN2 (I1896_G7_4n I1896_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I103_XG_MN0 (XI1896_I103_XG_n1 I1896_P7_6 I1896_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I103_XG_MN1 (VSS I1896_G5_4 XI1896_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I105_XG_MN2 (I1896_G9_6n I1896_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I105_XG_MN0 (XI1896_I105_XG_n1 I1896_P9_8 I1896_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I105_XG_MN1 (VSS I1896_G7_6 XI1896_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I107_XG_MN2 (I1896_G11_8n I1896_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I107_XG_MN0 (XI1896_I107_XG_n1 I1896_P11_10 I1896_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I107_XG_MN1 (VSS I1896_G9_8 XI1896_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I174_XG_MN2 (I700_G23_8n I700_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I174_XG_MN0 (XI700_I174_XG_n1 I700_P23_16 I700_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I174_XG_MN1 (VSS I700_G15_8 XI700_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I166_XG_MN2 (I700_G15_0n I700_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I166_XG_MN0 (XI700_I166_XG_n1 I700_P15_8 I700_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I166_XG_MN1 (VSS I700_G7_0 XI700_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I111_XG_MN2 (I700_G15_12n I700_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I111_XG_MN0 (XI700_I111_XG_n1 I700_P15_14 I700_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I111_XG_MN1 (VSS I700_G13_12 XI700_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I158_XG_MN2 (I654_G9_0n I654_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I158_XG_MN0 (XI654_I158_XG_n1 I654_P9_2 I654_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I158_XG_MN1 (VSS I654_G1_0 XI654_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I160_XG_MN2 (I654_G10_0n I654_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I160_XG_MN0 (XI654_I160_XG_n1 I654_P10_3 I654_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I160_XG_MN1 (VSS I654_G2_0np XI654_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I167_XG_MN2 (I654_G16_1n I654_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I167_XG_MN0 (XI654_I167_XG_n1 I654_P16_9 I654_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I167_XG_MN1 (VSS I654_G8_1 XI654_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I106_XG_MN2 (I654_G10_7n I654_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I106_XG_MN0 (XI654_I106_XG_n1 I654_P10_9 I654_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I106_XG_MN1 (VSS I654_G8_7 XI654_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I168_XG_MN2 (I608_G17_2n I608_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I168_XG_MN0 (XI608_I168_XG_n1 I608_P17_10 I608_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I168_XG_MN1 (VSS I608_G9_2 XI608_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I107_XG_MN2 (I608_G11_8n I608_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I107_XG_MN0 (XI608_I107_XG_n1 I608_P11_10 I608_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I107_XG_MN1 (VSS I608_G9_8 XI608_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I160_XG_MN2 (I608_G10_0n I608_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I160_XG_MN0 (XI608_I160_XG_n1 I608_P10_3 I608_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I160_XG_MN1 (VSS I608_G2_0np XI608_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I108_XG_MN2 (I608_G12_9n I608_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I108_XG_MN0 (XI608_I108_XG_n1 I608_P12_11 I608_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I108_XG_MN1 (VSS I608_G10_9 XI608_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I171_XG_MN2 (I562_G20_5n I562_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I171_XG_MN0 (XI562_I171_XG_n1 I562_P20_13 I562_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I171_XG_MN1 (VSS I562_G12_5 XI562_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I169_XG_MN2 (I562_G18_3n I562_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I169_XG_MN0 (XI562_I169_XG_n1 I562_P18_11 I562_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I169_XG_MN1 (VSS I562_G10_3 XI562_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I110_XG_MN2 (I562_G14_11n I562_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I110_XG_MN0 (XI562_I110_XG_n1 I562_P14_13 I562_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I110_XG_MN1 (VSS I562_G12_11 XI562_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I168_XG_MN2 (I562_G17_2n I562_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I168_XG_MN0 (XI562_I168_XG_n1 I562_P17_10 I562_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I168_XG_MN1 (VSS I562_G9_2 XI562_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I107_XG_MN2 (I562_G11_8n I562_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I107_XG_MN0 (XI562_I107_XG_n1 I562_P11_10 I562_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I107_XG_MN1 (VSS I562_G9_8 XI562_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2194_MN2 (nrkn9 nrk8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2194_MN0 (XI2194_n1 A_31_b3_7 nrkn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2194_MN1 (VSS ru8 XI2194_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I158_XG_MN2 (I2066_G9_0n I2066_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I158_XG_MN0 (XI2066_I158_XG_n1 I2066_P9_2 I2066_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I158_XG_MN1 (VSS I2066_G1_0 XI2066_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I107_XG_MN2 (I2066_G11_8n I2066_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I107_XG_MN0 (XI2066_I107_XG_n1 I2066_P11_10 I2066_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I107_XG_MN1 (VSS I2066_G9_8 XI2066_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I108_XG_MN2 (I2066_G12_9n I2066_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I108_XG_MN0 (XI2066_I108_XG_n1 I2066_P12_11 I2066_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I108_XG_MN1 (VSS I2066_G10_9 XI2066_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I169_XG_MN2 (I1988_G18_3n I1988_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I169_XG_MN0 (XI1988_I169_XG_n1 I1988_P18_11 I1988_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I169_XG_MN1 (VSS I1988_G10_3 XI1988_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I175_XG_MN2 (I1988_G24_9n I1988_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I175_XG_MN0 (XI1988_I175_XG_n1 I1988_P24_17 I1988_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I175_XG_MN1 (VSS I1988_G16_9 XI1988_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I162_XG_MN2 (I1988_G11_0n I1988_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I162_XG_MN0 (XI1988_I162_XG_n1 I1988_P11_4 I1988_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I162_XG_MN1 (VSS I1988_G3_0np XI1988_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I170_XG_MN2 (I1988_G19_4n I1988_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I170_XG_MN0 (XI1988_I170_XG_n1 I1988_P19_12 I1988_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I170_XG_MN1 (VSS I1988_G11_4 XI1988_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I109_XG_MN2 (I1988_G13_10n I1988_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I109_XG_MN0 (XI1988_I109_XG_n1 I1988_P13_12 I1988_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I109_XG_MN1 (VSS I1988_G11_10 XI1988_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I160_XG_MN2 (I1942_G10_0n I1942_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I160_XG_MN0 (XI1942_I160_XG_n1 I1942_P10_3 I1942_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I160_XG_MN1 (VSS I1942_G2_0np XI1942_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I106_XG_MN2 (I1942_G10_7n I1942_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I106_XG_MN0 (XI1942_I106_XG_n1 I1942_P10_9 I1942_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I106_XG_MN1 (VSS I1942_G8_7 XI1942_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I168_XG_MN2 (I1942_G17_2n I1942_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I168_XG_MN0 (XI1942_I168_XG_n1 I1942_P17_10 I1942_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I168_XG_MN1 (VSS I1942_G9_2 XI1942_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I105_XG_MN2 (I1942_G9_6n I1942_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I105_XG_MN0 (XI1942_I105_XG_n1 I1942_P9_8 I1942_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I105_XG_MN1 (VSS I1942_G7_6 XI1942_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I101_XG_MN2 (I1896_G5_2n I1896_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I101_XG_MN0 (XI1896_I101_XG_n1 I1896_P5_4 I1896_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I101_XG_MN1 (VSS I1896_G3_2 XI1896_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I102_XG_MN2 (I1896_G6_3n I1896_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I102_XG_MN0 (XI1896_I102_XG_n1 I1896_P6_5 I1896_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I102_XG_MN1 (VSS I1896_G4_3 XI1896_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I162_XG_MN2 (I1850_G11_0n I1850_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I162_XG_MN0 (XI1850_I162_XG_n1 I1850_P11_4 I1850_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I162_XG_MN1 (VSS I1850_G3_0np XI1850_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I170_XG_MN2 (I1850_G19_4n I1850_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I170_XG_MN0 (XI1850_I170_XG_n1 I1850_P19_12 I1850_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I170_XG_MN1 (VSS I1850_G11_4 XI1850_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I166_XG_MN2 (I1850_G15_0n I1850_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I166_XG_MN0 (XI1850_I166_XG_n1 I1850_P15_8 I1850_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I166_XG_MN1 (VSS I1850_G7_0 XI1850_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I174_XG_MN2 (I1850_G23_8n I1850_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I174_XG_MN0 (XI1850_I174_XG_n1 I1850_P23_16 I1850_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I174_XG_MN1 (VSS I1850_G15_8 XI1850_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I178_XG_MN2 (I1850_G27_12n I1850_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I178_XG_MN0 (XI1850_I178_XG_n1 I1850_P27_20 I1850_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I178_XG_MN1 (VSS I1850_G19_12 XI1850_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I182_XG_MN2 (I1850_G31_16n I1850_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I182_XG_MN0 (XI1850_I182_XG_n1 I1850_P31_24 I1850_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I182_XG_MN1 (VSS I1850_G23_16 XI1850_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I126_XG_MN2 (I700_G30_27n I700_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I126_XG_MN0 (XI700_I126_XG_n1 I700_P30_29 I700_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I126_XG_MN1 (VSS I700_G28_27 XI700_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I172_XG_MN2 (I700_G21_6n I700_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I172_XG_MN0 (XI700_I172_XG_n1 I700_P21_14 I700_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I172_XG_MN1 (VSS I700_G13_6 XI700_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I176_XG_MN2 (I700_G25_10n I700_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I176_XG_MN0 (XI700_I176_XG_n1 I700_P25_18 I700_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I176_XG_MN1 (VSS I700_G17_10 XI700_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I109_XG_MN2 (I700_G13_10n I700_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I109_XG_MN0 (XI700_I109_XG_n1 I700_P13_12 I700_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I109_XG_MN1 (VSS I700_G11_10 XI700_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I103_XG_MN2 (I654_G7_4n I654_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I103_XG_MN0 (XI654_I103_XG_n1 I654_P7_6 I654_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I103_XG_MN1 (VSS I654_G5_4 XI654_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I105_XG_MN2 (I654_G9_6n I654_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I105_XG_MN0 (XI654_I105_XG_n1 I654_P9_8 I654_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I105_XG_MN1 (VSS I654_G7_6 XI654_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I157_XG_MN2 (I654_G8_0n I654_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I157_XG_MN0 (XI654_I157_XG_n1 I654_P8_1 I654_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I157_XG_MN1 (VSS I654_G0_0 XI654_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I104_XG_MN2 (I654_G8_5n I654_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I104_XG_MN0 (XI654_I104_XG_n1 I654_P8_7 I654_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I104_XG_MN1 (VSS I654_G6_5 XI654_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I158_XG_MN2 (I608_G9_0n I608_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I158_XG_MN0 (XI608_I158_XG_n1 I608_P9_2 I608_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I158_XG_MN1 (VSS I608_G1_0 XI608_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I105_XG_MN2 (I608_G9_6n I608_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I105_XG_MN0 (XI608_I105_XG_n1 I608_P9_8 I608_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I105_XG_MN1 (VSS I608_G7_6 XI608_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I157_XG_MN2 (I608_G8_0n I608_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I157_XG_MN0 (XI608_I157_XG_n1 I608_P8_1 I608_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I157_XG_MN1 (VSS I608_G0_0 XI608_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I167_XG_MN2 (I608_G16_1n I608_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I167_XG_MN0 (XI608_I167_XG_n1 I608_P16_9 I608_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I167_XG_MN1 (VSS I608_G8_1 XI608_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I106_XG_MN2 (I608_G10_7n I608_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I106_XG_MN0 (XI608_I106_XG_n1 I608_P10_9 I608_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I106_XG_MN1 (VSS I608_G8_7 XI608_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I175_XG_MN2 (I562_G24_9n I562_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I175_XG_MN0 (XI562_I175_XG_n1 I562_P24_17 I562_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I175_XG_MN1 (VSS I562_G16_9 XI562_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I163_XG_MN2 (I562_G12_0n I562_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I163_XG_MN0 (XI562_I163_XG_n1 I562_P12_5 I562_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I163_XG_MN1 (VSS I562_G4_0 XI562_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I160_XG_MN2 (I562_G10_0n I562_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I160_XG_MN0 (XI562_I160_XG_n1 I562_P10_3 I562_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I160_XG_MN1 (VSS I562_G2_0np XI562_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I108_XG_MN2 (I562_G12_9n I562_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I108_XG_MN0 (XI562_I108_XG_n1 I562_P12_11 I562_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I108_XG_MN1 (VSS I562_G10_9 XI562_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I158_XG_MN2 (I562_G9_0n I562_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I158_XG_MN0 (XI562_I158_XG_n1 I562_P9_2 I562_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I158_XG_MN1 (VSS I562_G1_0 XI562_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2191_MN2 (nrkn8 nrk7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2191_MN0 (XI2191_n1 A_31_b3_6 nrkn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2191_MN1 (VSS ru7 XI2191_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2188_MN2 (nrkn7 nrk6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2188_MN0 (XI2188_n1 A_31_b3_6 nrkn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2188_MN1 (VSS ru6 XI2188_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I103_XG_MN2 (I2066_G7_4n I2066_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I103_XG_MN0 (XI2066_I103_XG_n1 I2066_P7_6 I2066_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I103_XG_MN1 (VSS I2066_G5_4 XI2066_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I105_XG_MN2 (I2066_G9_6n I2066_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I105_XG_MN0 (XI2066_I105_XG_n1 I2066_P9_8 I2066_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I105_XG_MN1 (VSS I2066_G7_6 XI2066_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I167_XG_MN2 (I2066_G16_1n I2066_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I167_XG_MN0 (XI2066_I167_XG_n1 I2066_P16_9 I2066_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I167_XG_MN1 (VSS I2066_G8_1 XI2066_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I106_XG_MN2 (I2066_G10_7n I2066_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I106_XG_MN0 (XI2066_I106_XG_n1 I2066_P10_9 I2066_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I106_XG_MN1 (VSS I2066_G8_7 XI2066_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I160_XG_MN2 (I1988_G10_0n I1988_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I160_XG_MN0 (XI1988_I160_XG_n1 I1988_P10_3 I1988_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I160_XG_MN1 (VSS I1988_G2_0np XI1988_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I108_XG_MN2 (I1988_G12_9n I1988_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I108_XG_MN0 (XI1988_I108_XG_n1 I1988_P12_11 I1988_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I108_XG_MN1 (VSS I1988_G10_9 XI1988_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I106_XG_MN2 (I1988_G10_7n I1988_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I106_XG_MN0 (XI1988_I106_XG_n1 I1988_P10_9 I1988_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I106_XG_MN1 (VSS I1988_G8_7 XI1988_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I168_XG_MN2 (I1988_G17_2n I1988_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I168_XG_MN0 (XI1988_I168_XG_n1 I1988_P17_10 I1988_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I168_XG_MN1 (VSS I1988_G9_2 XI1988_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I107_XG_MN2 (I1988_G11_8n I1988_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I107_XG_MN0 (XI1988_I107_XG_n1 I1988_P11_10 I1988_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I107_XG_MN1 (VSS I1988_G9_8 XI1988_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I167_XG_MN2 (I1942_G16_1n I1942_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I167_XG_MN0 (XI1942_I167_XG_n1 I1942_P16_9 I1942_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I167_XG_MN1 (VSS I1942_G8_1 XI1942_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I104_XG_MN2 (I1942_G8_5n I1942_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I104_XG_MN0 (XI1942_I104_XG_n1 I1942_P8_7 I1942_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I104_XG_MN1 (VSS I1942_G6_5 XI1942_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I158_XG_MN2 (I1942_G9_0n I1942_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I158_XG_MN0 (XI1942_I158_XG_n1 I1942_P9_2 I1942_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I158_XG_MN1 (VSS I1942_G1_0 XI1942_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I99_XG_MN2 (I1896_G3_0n I1896_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I99_XG_MN0 (XI1896_I99_XG_n1 I1896_P3_2 I1896_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I99_XG_MN1 (VSS I1896_G1_0 XI1896_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I100_XG_MN2 (I1896_G4_1n I1896_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I100_XG_MN0 (XI1896_I100_XG_n1 I1896_P4_3 I1896_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I100_XG_MN1 (VSS I1896_G2_1 XI1896_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I124_XG_MN2 (I700_G28_25n I700_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I124_XG_MN0 (XI700_I124_XG_n1 I700_P28_27 I700_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I124_XG_MN1 (VSS I700_G26_25 XI700_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I170_XG_MN2 (I700_G19_4n I700_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I170_XG_MN0 (XI700_I170_XG_n1 I700_P19_12 I700_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I170_XG_MN1 (VSS I700_G11_4 XI700_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I164_XG_MN2 (I700_G13_0n I700_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I164_XG_MN0 (XI700_I164_XG_n1 I700_P13_6 I700_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I164_XG_MN1 (VSS I700_G5_0 XI700_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I162_XG_MN2 (I700_G11_0n I700_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I162_XG_MN0 (XI700_I162_XG_n1 I700_P11_4 I700_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I162_XG_MN1 (VSS I700_G3_0np XI700_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I107_XG_MN2 (I700_G11_8n I700_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I107_XG_MN0 (XI700_I107_XG_n1 I700_P11_10 I700_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I107_XG_MN1 (VSS I700_G9_8 XI700_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I101_XG_MN2 (I654_G5_2n I654_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I101_XG_MN0 (XI654_I101_XG_n1 I654_P5_4 I654_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I101_XG_MN1 (VSS I654_G3_2 XI654_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I102_XG_MN2 (I654_G6_3n I654_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I102_XG_MN0 (XI654_I102_XG_n1 I654_P6_5 I654_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I102_XG_MN1 (VSS I654_G4_3 XI654_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I103_XG_MN2 (I608_G7_4n I608_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I103_XG_MN0 (XI608_I103_XG_n1 I608_P7_6 I608_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I103_XG_MN1 (VSS I608_G5_4 XI608_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I102_XG_MN2 (I608_G6_3n I608_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I102_XG_MN0 (XI608_I102_XG_n1 I608_P6_5 I608_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I102_XG_MN1 (VSS I608_G4_3 XI608_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I104_XG_MN2 (I608_G8_5n I608_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I104_XG_MN0 (XI608_I104_XG_n1 I608_P8_7 I608_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I104_XG_MN1 (VSS I608_G6_5 XI608_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I157_XG_MN2 (I562_G8_0n I562_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I157_XG_MN0 (XI562_I157_XG_n1 I562_P8_1 I562_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I157_XG_MN1 (VSS I562_G0_0 XI562_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I167_XG_MN2 (I562_G16_1n I562_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I167_XG_MN0 (XI562_I167_XG_n1 I562_P16_9 I562_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I167_XG_MN1 (VSS I562_G8_1 XI562_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I104_XG_MN2 (I562_G8_5n I562_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I104_XG_MN0 (XI562_I104_XG_n1 I562_P8_7 I562_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I104_XG_MN1 (VSS I562_G6_5 XI562_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I106_XG_MN2 (I562_G10_7n I562_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I106_XG_MN0 (XI562_I106_XG_n1 I562_P10_9 I562_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I106_XG_MN1 (VSS I562_G8_7 XI562_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I105_XG_MN2 (I562_G9_6n I562_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I105_XG_MN0 (XI562_I105_XG_n1 I562_P9_8 I562_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I105_XG_MN1 (VSS I562_G7_6 XI562_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2185_MN2 (nrkn6 nrk5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2185_MN0 (XI2185_n1 A_31_b3_6 nrkn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2185_MN1 (VSS ru5 XI2185_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2182_MN2 (nrkn5 nrk4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2182_MN0 (XI2182_n1 A_31_b3_6 nrkn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2182_MN1 (VSS ru4 XI2182_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I99_XG_MN2 (I2066_G3_0n I2066_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I99_XG_MN0 (XI2066_I99_XG_n1 I2066_P3_2 I2066_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I99_XG_MN1 (VSS I2066_G1_0 XI2066_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I101_XG_MN2 (I2066_G5_2n I2066_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I101_XG_MN0 (XI2066_I101_XG_n1 I2066_P5_4 I2066_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I101_XG_MN1 (VSS I2066_G3_2 XI2066_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I157_XG_MN2 (I2066_G8_0n I2066_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I157_XG_MN0 (XI2066_I157_XG_n1 I2066_P8_1 I2066_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I157_XG_MN1 (VSS I2066_G0_0 XI2066_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I104_XG_MN2 (I2066_G8_5n I2066_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I104_XG_MN0 (XI2066_I104_XG_n1 I2066_P8_7 I2066_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I104_XG_MN1 (VSS I2066_G6_5 XI2066_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I167_XG_MN2 (I1988_G16_1n I1988_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I167_XG_MN0 (XI1988_I167_XG_n1 I1988_P16_9 I1988_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I167_XG_MN1 (VSS I1988_G8_1 XI1988_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I158_XG_MN2 (I1988_G9_0n I1988_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I158_XG_MN0 (XI1988_I158_XG_n1 I1988_P9_2 I1988_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I158_XG_MN1 (VSS I1988_G1_0 XI1988_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I105_XG_MN2 (I1988_G9_6n I1988_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I105_XG_MN0 (XI1988_I105_XG_n1 I1988_P9_8 I1988_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I105_XG_MN1 (VSS I1988_G7_6 XI1988_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I157_XG_MN2 (I1942_G8_0n I1942_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I157_XG_MN0 (XI1942_I157_XG_n1 I1942_P8_1 I1942_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I157_XG_MN1 (VSS I1942_G0_0 XI1942_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I102_XG_MN2 (I1942_G6_3n I1942_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I102_XG_MN0 (XI1942_I102_XG_n1 I1942_P6_5 I1942_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I102_XG_MN1 (VSS I1942_G4_3 XI1942_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I103_XG_MN2 (I1942_G7_4n I1942_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I103_XG_MN0 (XI1942_I103_XG_n1 I1942_P7_6 I1942_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I103_XG_MN1 (VSS I1942_G5_4 XI1942_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1896_I98_XG_MN2 (I1896_G2_0n I1896_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1896_I98_XG_MN0 (XI1896_I98_XG_n1 I1896_P2_1 I1896_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1896_I98_XG_MN1 (VSS I1896_G0_0 XI1896_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I158_XG_MN2 (I1850_G9_0n I1850_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I158_XG_MN0 (XI1850_I158_XG_n1 I1850_P9_2 I1850_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I158_XG_MN1 (VSS I1850_G1_0 XI1850_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I168_XG_MN2 (I1850_G17_2n I1850_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I168_XG_MN0 (XI1850_I168_XG_n1 I1850_P17_10 I1850_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I168_XG_MN1 (VSS I1850_G9_2 XI1850_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I164_XG_MN2 (I1850_G13_0n I1850_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I164_XG_MN0 (XI1850_I164_XG_n1 I1850_P13_6 I1850_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I164_XG_MN1 (VSS I1850_G5_0 XI1850_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I172_XG_MN2 (I1850_G21_6n I1850_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I172_XG_MN0 (XI1850_I172_XG_n1 I1850_P21_14 I1850_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I172_XG_MN1 (VSS I1850_G13_6 XI1850_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I176_XG_MN2 (I1850_G25_10n I1850_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I176_XG_MN0 (XI1850_I176_XG_n1 I1850_P25_18 I1850_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I176_XG_MN1 (VSS I1850_G17_10 XI1850_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I180_XG_MN2 (I1850_G29_14n I1850_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I180_XG_MN0 (XI1850_I180_XG_n1 I1850_P29_22 I1850_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I180_XG_MN1 (VSS I1850_G21_14 XI1850_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I122_XG_MN2 (I700_G26_23n I700_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I122_XG_MN0 (XI700_I122_XG_n1 I700_P26_25 I700_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I122_XG_MN1 (VSS I700_G24_23 XI700_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I120_XG_MN2 (I700_G24_21n I700_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I120_XG_MN0 (XI700_I120_XG_n1 I700_P24_23 I700_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I120_XG_MN1 (VSS I700_G22_21 XI700_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I118_XG_MN2 (I700_G22_19n I700_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I118_XG_MN0 (XI700_I118_XG_n1 I700_P22_21 I700_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I118_XG_MN1 (VSS I700_G20_19 XI700_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I168_XG_MN2 (I700_G17_2n I700_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I168_XG_MN0 (XI700_I168_XG_n1 I700_P17_10 I700_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I168_XG_MN1 (VSS I700_G9_2 XI700_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I105_XG_MN2 (I700_G9_6n I700_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I105_XG_MN0 (XI700_I105_XG_n1 I700_P9_8 I700_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I105_XG_MN1 (VSS I700_G7_6 XI700_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I99_XG_MN2 (I654_G3_0n I654_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I99_XG_MN0 (XI654_I99_XG_n1 I654_P3_2 I654_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I99_XG_MN1 (VSS I654_G1_0 XI654_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I100_XG_MN2 (I654_G4_1n I654_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I100_XG_MN0 (XI654_I100_XG_n1 I654_P4_3 I654_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I100_XG_MN1 (VSS I654_G2_1 XI654_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I99_XG_MN2 (I608_G3_0n I608_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I99_XG_MN0 (XI608_I99_XG_n1 I608_P3_2 I608_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I99_XG_MN1 (VSS I608_G1_0 XI608_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I101_XG_MN2 (I608_G5_2n I608_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I101_XG_MN0 (XI608_I101_XG_n1 I608_P5_4 I608_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I101_XG_MN1 (VSS I608_G3_2 XI608_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I98_XG_MN2 (I608_G2_0n I608_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I98_XG_MN0 (XI608_I98_XG_n1 I608_P2_1 I608_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I98_XG_MN1 (VSS I608_G0_0 XI608_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI608_I100_XG_MN2 (I608_G4_1n I608_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI608_I100_XG_MN0 (XI608_I100_XG_n1 I608_P4_3 I608_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI608_I100_XG_MN1 (VSS I608_G2_1 XI608_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I98_XG_MN2 (I562_G2_0n I562_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I98_XG_MN0 (XI562_I98_XG_n1 I562_P2_1 I562_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I98_XG_MN1 (VSS I562_G0_0 XI562_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I100_XG_MN2 (I562_G4_1n I562_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I100_XG_MN0 (XI562_I100_XG_n1 I562_P4_3 I562_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I100_XG_MN1 (VSS I562_G2_1 XI562_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I102_XG_MN2 (I562_G6_3n I562_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I102_XG_MN0 (XI562_I102_XG_n1 I562_P6_5 I562_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I102_XG_MN1 (VSS I562_G4_3 XI562_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I99_XG_MN2 (I562_G3_0n I562_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I99_XG_MN0 (XI562_I99_XG_n1 I562_P3_2 I562_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I99_XG_MN1 (VSS I562_G1_0 XI562_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I101_XG_MN2 (I562_G5_2n I562_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I101_XG_MN0 (XI562_I101_XG_n1 I562_P5_4 I562_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I101_XG_MN1 (VSS I562_G3_2 XI562_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI562_I103_XG_MN2 (I562_G7_4n I562_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI562_I103_XG_MN0 (XI562_I103_XG_n1 I562_P7_6 I562_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI562_I103_XG_MN1 (VSS I562_G5_4 XI562_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2179_MN2 (nrkn4 nrk3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2179_MN0 (XI2179_n1 A_31_b3_6 nrkn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2179_MN1 (VSS ru3 XI2179_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2176_MN2 (nrkn3 nrk2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2176_MN0 (XI2176_n1 A_31_b3_6 nrkn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2176_MN1 (VSS ru2 XI2176_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I98_XG_MN2 (I2066_G2_0n I2066_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I98_XG_MN0 (XI2066_I98_XG_n1 I2066_P2_1 I2066_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I98_XG_MN1 (VSS I2066_G0_0 XI2066_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I100_XG_MN2 (I2066_G4_1n I2066_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I100_XG_MN0 (XI2066_I100_XG_n1 I2066_P4_3 I2066_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I100_XG_MN1 (VSS I2066_G2_1 XI2066_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2066_I102_XG_MN2 (I2066_G6_3n I2066_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2066_I102_XG_MN0 (XI2066_I102_XG_n1 I2066_P6_5 I2066_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2066_I102_XG_MN1 (VSS I2066_G4_3 XI2066_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I157_XG_MN2 (I1988_G8_0n I1988_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I157_XG_MN0 (XI1988_I157_XG_n1 I1988_P8_1 I1988_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I157_XG_MN1 (VSS I1988_G0_0 XI1988_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I104_XG_MN2 (I1988_G8_5n I1988_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I104_XG_MN0 (XI1988_I104_XG_n1 I1988_P8_7 I1988_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I104_XG_MN1 (VSS I1988_G6_5 XI1988_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I103_XG_MN2 (I1988_G7_4n I1988_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I103_XG_MN0 (XI1988_I103_XG_n1 I1988_P7_6 I1988_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I103_XG_MN1 (VSS I1988_G5_4 XI1988_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I100_XG_MN2 (I1942_G4_1n I1942_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I100_XG_MN0 (XI1942_I100_XG_n1 I1942_P4_3 I1942_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I100_XG_MN1 (VSS I1942_G2_1 XI1942_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I99_XG_MN2 (I1942_G3_0n I1942_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I99_XG_MN0 (XI1942_I99_XG_n1 I1942_P3_2 I1942_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I99_XG_MN1 (VSS I1942_G1_0 XI1942_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I101_XG_MN2 (I1942_G5_2n I1942_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I101_XG_MN0 (XI1942_I101_XG_n1 I1942_P5_4 I1942_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I101_XG_MN1 (VSS I1942_G3_2 XI1942_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I101_XG_MN2 (I1850_G5_2n I1850_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I101_XG_MN0 (XI1850_I101_XG_n1 I1850_P5_4 I1850_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I101_XG_MN1 (VSS I1850_G3_2 XI1850_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I103_XG_MN2 (I1850_G7_4n I1850_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I103_XG_MN0 (XI1850_I103_XG_n1 I1850_P7_6 I1850_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I103_XG_MN1 (VSS I1850_G5_4 XI1850_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I105_XG_MN2 (I1850_G9_6n I1850_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I105_XG_MN0 (XI1850_I105_XG_n1 I1850_P9_8 I1850_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I105_XG_MN1 (VSS I1850_G7_6 XI1850_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I107_XG_MN2 (I1850_G11_8n I1850_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I107_XG_MN0 (XI1850_I107_XG_n1 I1850_P11_10 I1850_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I107_XG_MN1 (VSS I1850_G9_8 XI1850_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I109_XG_MN2 (I1850_G13_10n I1850_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I109_XG_MN0 (XI1850_I109_XG_n1 I1850_P13_12 I1850_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I109_XG_MN1 (VSS I1850_G11_10 XI1850_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I111_XG_MN2 (I1850_G15_12n I1850_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I111_XG_MN0 (XI1850_I111_XG_n1 I1850_P15_14 I1850_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I111_XG_MN1 (VSS I1850_G13_12 XI1850_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I113_XG_MN2 (I1850_G17_14n I1850_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I113_XG_MN0 (XI1850_I113_XG_n1 I1850_P17_16 I1850_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I113_XG_MN1 (VSS I1850_G15_14 XI1850_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I115_XG_MN2 (I1850_G19_16n I1850_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I115_XG_MN0 (XI1850_I115_XG_n1 I1850_P19_18 I1850_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I115_XG_MN1 (VSS I1850_G17_16 XI1850_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I117_XG_MN2 (I1850_G21_18n I1850_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I117_XG_MN0 (XI1850_I117_XG_n1 I1850_P21_20 I1850_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I117_XG_MN1 (VSS I1850_G19_18 XI1850_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I119_XG_MN2 (I1850_G23_20n I1850_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I119_XG_MN0 (XI1850_I119_XG_n1 I1850_P23_22 I1850_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I119_XG_MN1 (VSS I1850_G21_20 XI1850_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I121_XG_MN2 (I1850_G25_22n I1850_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I121_XG_MN0 (XI1850_I121_XG_n1 I1850_P25_24 I1850_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I121_XG_MN1 (VSS I1850_G23_22 XI1850_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I123_XG_MN2 (I1850_G27_24n I1850_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I123_XG_MN0 (XI1850_I123_XG_n1 I1850_P27_26 I1850_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I123_XG_MN1 (VSS I1850_G25_24 XI1850_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I125_XG_MN2 (I1850_G29_26n I1850_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I125_XG_MN0 (XI1850_I125_XG_n1 I1850_P29_28 I1850_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I125_XG_MN1 (VSS I1850_G27_26 XI1850_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I127_XG_MN2 (I1850_G31_28n I1850_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I127_XG_MN0 (XI1850_I127_XG_n1 I1850_P31_30 I1850_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I127_XG_MN1 (VSS I1850_G29_28 XI1850_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I181_XG_MN2 (I700_G30_15n I700_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I181_XG_MN0 (XI700_I181_XG_n1 I700_P30_23 I700_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I181_XG_MN1 (VSS I700_G22_15 XI700_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I116_XG_MN2 (I700_G20_17n I700_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I116_XG_MN0 (XI700_I116_XG_n1 I700_P20_19 I700_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I116_XG_MN1 (VSS I700_G18_17 XI700_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I114_XG_MN2 (I700_G18_15n I700_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I114_XG_MN0 (XI700_I114_XG_n1 I700_P18_17 I700_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I114_XG_MN1 (VSS I700_G16_15 XI700_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I112_XG_MN2 (I700_G16_13n I700_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I112_XG_MN0 (XI700_I112_XG_n1 I700_P16_15 I700_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I112_XG_MN1 (VSS I700_G14_13 XI700_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I158_XG_MN2 (I700_G9_0n I700_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I158_XG_MN0 (XI700_I158_XG_n1 I700_P9_2 I700_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I158_XG_MN1 (VSS I700_G1_0 XI700_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I103_XG_MN2 (I700_G7_4n I700_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I103_XG_MN0 (XI700_I103_XG_n1 I700_P7_6 I700_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I103_XG_MN1 (VSS I700_G5_4 XI700_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I101_XG_MN2 (I700_G5_2n I700_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I101_XG_MN0 (XI700_I101_XG_n1 I700_P5_4 I700_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I101_XG_MN1 (VSS I700_G3_2 XI700_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI654_I98_XG_MN2 (I654_G2_0n I654_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI654_I98_XG_MN0 (XI654_I98_XG_n1 I654_P2_1 I654_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI654_I98_XG_MN1 (VSS I654_G0_0 XI654_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI180_MN2 (nbkn5 nbk4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI180_MN0 (XI180_n1 B_31_b3_0 nbkn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI180_MN1 (VSS B_4 XI180_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI193_MN2 (nbkn6 nbk5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI193_MN0 (XI193_n1 B_31_b3_0 nbkn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI193_MN1 (VSS B_5 XI193_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI206_MN2 (nbkn7 nbk6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI206_MN0 (XI206_n1 B_31_b3_1 nbkn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI206_MN1 (VSS B_6 XI206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI219_MN2 (nbkn8 nbk7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI219_MN0 (XI219_n1 B_31_b3_1 nbkn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI219_MN1 (VSS B_7 XI219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI232_MN2 (nbkn9 nbk8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI232_MN0 (XI232_n1 B_31_b3_1 nbkn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI232_MN1 (VSS B_8 XI232_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2173_MN2 (nrkn2 nrk1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2173_MN0 (XI2173_n1 A_31_b3_5 nrkn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2173_MN1 (VSS ru1 XI2173_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I98_XG_MN2 (I1988_G2_0n I1988_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I98_XG_MN0 (XI1988_I98_XG_n1 I1988_P2_1 I1988_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I98_XG_MN1 (VSS I1988_G0_0 XI1988_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I100_XG_MN2 (I1988_G4_1n I1988_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I100_XG_MN0 (XI1988_I100_XG_n1 I1988_P4_3 I1988_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I100_XG_MN1 (VSS I1988_G2_1 XI1988_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I102_XG_MN2 (I1988_G6_3n I1988_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I102_XG_MN0 (XI1988_I102_XG_n1 I1988_P6_5 I1988_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I102_XG_MN1 (VSS I1988_G4_3 XI1988_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I99_XG_MN2 (I1988_G3_0n I1988_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I99_XG_MN0 (XI1988_I99_XG_n1 I1988_P3_2 I1988_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I99_XG_MN1 (VSS I1988_G1_0 XI1988_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1988_I101_XG_MN2 (I1988_G5_2n I1988_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1988_I101_XG_MN0 (XI1988_I101_XG_n1 I1988_P5_4 I1988_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1988_I101_XG_MN1 (VSS I1988_G3_2 XI1988_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1942_I98_XG_MN2 (I1942_G2_0n I1942_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1942_I98_XG_MN0 (XI1942_I98_XG_n1 I1942_P2_1 I1942_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1942_I98_XG_MN1 (VSS I1942_G0_0 XI1942_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I99_XG_MN2 (I1850_G3_0n I1850_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I99_XG_MN0 (XI1850_I99_XG_n1 I1850_P3_2 I1850_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I99_XG_MN1 (VSS I1850_G1_0 XI1850_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I157_XG_MN2 (I1850_G8_0n I1850_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I157_XG_MN0 (XI1850_I157_XG_n1 I1850_P8_1 I1850_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I157_XG_MN1 (VSS I1850_G0_0 XI1850_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I167_XG_MN2 (I1850_G16_1n I1850_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I167_XG_MN0 (XI1850_I167_XG_n1 I1850_P16_9 I1850_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I167_XG_MN1 (VSS I1850_G8_1 XI1850_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I160_XG_MN2 (I1850_G10_0n I1850_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I160_XG_MN0 (XI1850_I160_XG_n1 I1850_P10_3 I1850_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I160_XG_MN1 (VSS I1850_G2_0np XI1850_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I169_XG_MN2 (I1850_G18_3n I1850_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I169_XG_MN0 (XI1850_I169_XG_n1 I1850_P18_11 I1850_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I169_XG_MN1 (VSS I1850_G10_3 XI1850_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I175_XG_MN2 (I1850_G24_9n I1850_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I175_XG_MN0 (XI1850_I175_XG_n1 I1850_P24_17 I1850_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I175_XG_MN1 (VSS I1850_G16_9 XI1850_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I173_XG_MN2 (I700_G22_7n I700_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I173_XG_MN0 (XI700_I173_XG_n1 I700_P22_15 I700_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I173_XG_MN1 (VSS I700_G14_7 XI700_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I165_XG_MN2 (I700_G14_0n I700_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I165_XG_MN0 (XI700_I165_XG_n1 I700_P14_7 I700_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I165_XG_MN1 (VSS I700_G6_0 XI700_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I110_XG_MN2 (I700_G14_11n I700_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I110_XG_MN0 (XI700_I110_XG_n1 I700_P14_13 I700_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I110_XG_MN1 (VSS I700_G12_11 XI700_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I108_XG_MN2 (I700_G12_9n I700_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I108_XG_MN0 (XI700_I108_XG_n1 I700_P12_11 I700_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I108_XG_MN1 (VSS I700_G10_9 XI700_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I106_XG_MN2 (I700_G10_7n I700_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I106_XG_MN0 (XI700_I106_XG_n1 I700_P10_9 I700_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I106_XG_MN1 (VSS I700_G8_7 XI700_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I99_XG_MN2 (I700_G3_0n I700_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I99_XG_MN0 (XI700_I99_XG_n1 I700_P3_2 I700_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I99_XG_MN1 (VSS I700_G1_0 XI700_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2165_MN2 (nqkn30 nqk29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2165_MN0 (XI2165_n1 sq_b3_5 nqkn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2165_MN1 (VSS qu29_b3_5 XI2165_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2168_MN2 (nqkn31 nqk30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2168_MN0 (XI2168_n1 sq_b3_5 nqkn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2168_MN1 (VSS qu30_b3_5 XI2168_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI123_MN2 (nakn30 nak29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI123_MN0 (XI123_n1 A_31_b3_4 nakn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI123_MN1 (VSS A_29 XI123_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI126_MN2 (nakn31 nak30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI126_MN0 (XI126_n1 A_31_b3_5 nakn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI126_MN1 (VSS A_30 XI126_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI167_MN2 (nbkn4 nbk3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI167_MN0 (XI167_n1 B_31_b3_0 nbkn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI167_MN1 (VSS B_3 XI167_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI245_MN2 (nbkn10 nbk9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI245_MN0 (XI245_n1 B_31_b3_1 nbkn10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI245_MN1 (VSS B_9 XI245_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI310_MN2 (nbkn15 nbk14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI310_MN0 (XI310_n1 B_31_b3_2 nbkn15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI310_MN1 (VSS B_14 XI310_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI323_MN2 (nbkn16 nbk15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI323_MN0 (XI323_n1 B_31_b3_2 nbkn16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI323_MN1 (VSS B_15 XI323_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2081_MN2 (nqkn2 nqk1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2081_MN0 (XI2081_n1 sq_b3_0 nqkn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2081_MN1 (VSS qu1_b3_5 XI2081_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2084_MN2 (nqkn3 nqk2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2084_MN0 (XI2084_n1 sq_b3_0 nqkn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2084_MN1 (VSS qu2_b3_5 XI2084_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I98_XG_MN2 (I1850_G2_0n I1850_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I98_XG_MN0 (XI1850_I98_XG_n1 I1850_P2_1 I1850_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I98_XG_MN1 (VSS I1850_G0_0 XI1850_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I100_XG_MN2 (I1850_G4_1n I1850_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I100_XG_MN0 (XI1850_I100_XG_n1 I1850_P4_3 I1850_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I100_XG_MN1 (VSS I1850_G2_1 XI1850_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I163_XG_MN2 (I1850_G12_0n I1850_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I163_XG_MN0 (XI1850_I163_XG_n1 I1850_P12_5 I1850_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I163_XG_MN1 (VSS I1850_G4_0 XI1850_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I171_XG_MN2 (I1850_G20_5n I1850_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I171_XG_MN0 (XI1850_I171_XG_n1 I1850_P20_13 I1850_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I171_XG_MN1 (VSS I1850_G12_5 XI1850_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I165_XG_MN2 (I1850_G14_0n I1850_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I165_XG_MN0 (XI1850_I165_XG_n1 I1850_P14_7 I1850_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I165_XG_MN1 (VSS I1850_G6_0 XI1850_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I173_XG_MN2 (I1850_G22_7n I1850_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I173_XG_MN0 (XI1850_I173_XG_n1 I1850_P22_15 I1850_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I173_XG_MN1 (VSS I1850_G14_7 XI1850_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I177_XG_MN2 (I1850_G26_11n I1850_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I177_XG_MN0 (XI1850_I177_XG_n1 I1850_P26_19 I1850_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I177_XG_MN1 (VSS I1850_G18_11 XI1850_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I179_XG_MN2 (I1850_G28_13n I1850_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I179_XG_MN0 (XI1850_I179_XG_n1 I1850_P28_21 I1850_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I179_XG_MN1 (VSS I1850_G20_13 XI1850_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I179_XG_MN2 (I700_G28_13n I700_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I179_XG_MN0 (XI700_I179_XG_n1 I700_P28_21 I700_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I179_XG_MN1 (VSS I700_G20_13 XI700_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I177_XG_MN2 (I700_G26_11n I700_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I177_XG_MN0 (XI700_I177_XG_n1 I700_P26_19 I700_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I177_XG_MN1 (VSS I700_G18_11 XI700_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I175_XG_MN2 (I700_G24_9n I700_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I175_XG_MN0 (XI700_I175_XG_n1 I700_P24_17 I700_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I175_XG_MN1 (VSS I700_G16_9 XI700_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I169_XG_MN2 (I700_G18_3n I700_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I169_XG_MN0 (XI700_I169_XG_n1 I700_P18_11 I700_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I169_XG_MN1 (VSS I700_G10_3 XI700_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I160_XG_MN2 (I700_G10_0n I700_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I160_XG_MN0 (XI700_I160_XG_n1 I700_P10_3 I700_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I160_XG_MN1 (VSS I700_G2_0np XI700_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I167_XG_MN2 (I700_G16_1n I700_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I167_XG_MN0 (XI700_I167_XG_n1 I700_P16_9 I700_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I167_XG_MN1 (VSS I700_G8_1 XI700_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I104_XG_MN2 (I700_G8_5n I700_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I104_XG_MN0 (XI700_I104_XG_n1 I700_P8_7 I700_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I104_XG_MN1 (VSS I700_G6_5 XI700_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I102_XG_MN2 (I700_G6_3n I700_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I102_XG_MN0 (XI700_I102_XG_n1 I700_P6_5 I700_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I102_XG_MN1 (VSS I700_G4_3 XI700_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I100_XG_MN2 (I700_G4_1n I700_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I100_XG_MN0 (XI700_I100_XG_n1 I700_P4_3 I700_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I100_XG_MN1 (VSS I700_G2_1 XI700_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI120_MN2 (nakn29 nak28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI120_MN0 (XI120_n1 A_31_b3_4 nakn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI120_MN1 (VSS A_28 XI120_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI141_MN2 (nbkn2 nbk1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI141_MN0 (XI141_n1 B_31_b3_0 nbkn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI141_MN1 (VSS B_1 XI141_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI154_MN2 (nbkn3 nbk2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI154_MN0 (XI154_n1 B_31_b3_0 nbkn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI154_MN1 (VSS B_2 XI154_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI258_MN2 (nbkn11 nbk10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI258_MN0 (XI258_n1 B_31_b3_1 nbkn11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI258_MN1 (VSS B_10 XI258_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI271_MN2 (nbkn12 nbk11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI271_MN0 (XI271_n1 B_31_b3_1 nbkn12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI271_MN1 (VSS B_11 XI271_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI284_MN2 (nbkn13 nbk12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI284_MN0 (XI284_n1 B_31_b3_2 nbkn13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI284_MN1 (VSS B_12 XI284_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI297_MN2 (nbkn14 nbk13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI297_MN0 (XI297_n1 B_31_b3_2 nbkn14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI297_MN1 (VSS B_13 XI297_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI336_MN2 (nbkn17 nbk16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI336_MN0 (XI336_n1 B_31_b3_2 nbkn17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI336_MN1 (VSS B_16 XI336_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI349_MN2 (nbkn18 nbk17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI349_MN0 (XI349_n1 B_31_b3_3 nbkn18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI349_MN1 (VSS B_17 XI349_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI362_MN2 (nbkn19 nbk18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI362_MN0 (XI362_n1 B_31_b3_3 nbkn19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI362_MN1 (VSS B_18 XI362_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI375_MN2 (nbkn20 nbk19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI375_MN0 (XI375_n1 B_31_b3_3 nbkn20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI375_MN1 (VSS B_19 XI375_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI388_MN2 (nbkn21 nbk20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI388_MN0 (XI388_n1 B_31_b3_3 nbkn21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI388_MN1 (VSS B_20 XI388_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I102_XG_MN2 (I1850_G6_3n I1850_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I102_XG_MN0 (XI1850_I102_XG_n1 I1850_P6_5 I1850_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I102_XG_MN1 (VSS I1850_G4_3 XI1850_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I104_XG_MN2 (I1850_G8_5n I1850_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I104_XG_MN0 (XI1850_I104_XG_n1 I1850_P8_7 I1850_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I104_XG_MN1 (VSS I1850_G6_5 XI1850_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I106_XG_MN2 (I1850_G10_7n I1850_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I106_XG_MN0 (XI1850_I106_XG_n1 I1850_P10_9 I1850_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I106_XG_MN1 (VSS I1850_G8_7 XI1850_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I108_XG_MN2 (I1850_G12_9n I1850_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I108_XG_MN0 (XI1850_I108_XG_n1 I1850_P12_11 I1850_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I108_XG_MN1 (VSS I1850_G10_9 XI1850_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I110_XG_MN2 (I1850_G14_11n I1850_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I110_XG_MN0 (XI1850_I110_XG_n1 I1850_P14_13 I1850_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I110_XG_MN1 (VSS I1850_G12_11 XI1850_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I112_XG_MN2 (I1850_G16_13n I1850_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I112_XG_MN0 (XI1850_I112_XG_n1 I1850_P16_15 I1850_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I112_XG_MN1 (VSS I1850_G14_13 XI1850_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I181_XG_MN2 (I1850_G30_15n I1850_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I181_XG_MN0 (XI1850_I181_XG_n1 I1850_P30_23 I1850_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I181_XG_MN1 (VSS I1850_G22_15 XI1850_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I171_XG_MN2 (I700_G20_5n I700_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I171_XG_MN0 (XI700_I171_XG_n1 I700_P20_13 I700_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I171_XG_MN1 (VSS I700_G12_5 XI700_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I163_XG_MN2 (I700_G12_0n I700_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I163_XG_MN0 (XI700_I163_XG_n1 I700_P12_5 I700_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I163_XG_MN1 (VSS I700_G4_0 XI700_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I157_XG_MN2 (I700_G8_0n I700_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I157_XG_MN0 (XI700_I157_XG_n1 I700_P8_1 I700_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I157_XG_MN1 (VSS I700_G0_0 XI700_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI700_I98_XG_MN2 (I700_G2_0n I700_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI700_I98_XG_MN0 (XI700_I98_XG_n1 I700_P2_1 I700_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI700_I98_XG_MN1 (VSS I700_G0_0 XI700_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI117_MN2 (nakn28 nak27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI117_MN0 (XI117_n1 A_31_b3_4 nakn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI117_MN1 (VSS A_27 XI117_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI114_MN2 (nakn27 nak26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI114_MN0 (XI114_n1 A_31_b3_4 nakn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI114_MN1 (VSS A_26 XI114_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI111_MN2 (nakn26 nak25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI111_MN0 (XI111_n1 A_31_b3_4 nakn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI111_MN1 (VSS A_25 XI111_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI108_MN2 (nakn25 nak24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI108_MN0 (XI108_n1 A_31_b3_4 nakn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI108_MN1 (VSS A_24 XI108_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI414_MN2 (nbkn23 nbk22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI414_MN0 (XI414_n1 B_31_b3_3 nbkn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI414_MN1 (VSS B_22 XI414_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI401_MN2 (nbkn22 nbk21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI401_MN0 (XI401_n1 B_31_b3_3 nbkn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI401_MN1 (VSS B_21 XI401_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI39_MN2 (nakn2 nak1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI39_MN0 (XI39_n1 A_31_b3_0 nakn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI39_MN1 (VSS A_1 XI39_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2087_MN2 (nqkn4 nqk3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2087_MN0 (XI2087_n1 sq_b3_0 nqkn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2087_MN1 (VSS qu3_b3_5 XI2087_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I114_XG_MN2 (I1850_G18_15n I1850_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I114_XG_MN0 (XI1850_I114_XG_n1 I1850_P18_17 I1850_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I114_XG_MN1 (VSS I1850_G16_15 XI1850_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I116_XG_MN2 (I1850_G20_17n I1850_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I116_XG_MN0 (XI1850_I116_XG_n1 I1850_P20_19 I1850_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I116_XG_MN1 (VSS I1850_G18_17 XI1850_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I118_XG_MN2 (I1850_G22_19n I1850_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I118_XG_MN0 (XI1850_I118_XG_n1 I1850_P22_21 I1850_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I118_XG_MN1 (VSS I1850_G20_19 XI1850_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I120_XG_MN2 (I1850_G24_21n I1850_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I120_XG_MN0 (XI1850_I120_XG_n1 I1850_P24_23 I1850_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I120_XG_MN1 (VSS I1850_G22_21 XI1850_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I122_XG_MN2 (I1850_G26_23n I1850_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I122_XG_MN0 (XI1850_I122_XG_n1 I1850_P26_25 I1850_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I122_XG_MN1 (VSS I1850_G24_23 XI1850_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I124_XG_MN2 (I1850_G28_25n I1850_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I124_XG_MN0 (XI1850_I124_XG_n1 I1850_P28_27 I1850_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I124_XG_MN1 (VSS I1850_G26_25 XI1850_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1850_I126_XG_MN2 (I1850_G30_27n I1850_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1850_I126_XG_MN0 (XI1850_I126_XG_n1 I1850_P30_29 I1850_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1850_I126_XG_MN1 (VSS I1850_G28_27 XI1850_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2162_MN2 (nqkn29 nqk28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2162_MN0 (XI2162_n1 sq_b3_5 nqkn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2162_MN1 (VSS qu28_b3_5 XI2162_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI518_MN2 (nbkn31 nbk30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI518_MN0 (XI518_n1 B_31_b3_5 nbkn31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI518_MN1 (VSS B_30 XI518_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI505_MN2 (nbkn30 nbk29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI505_MN0 (XI505_n1 B_31_b3_5 nbkn30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI505_MN1 (VSS B_29 XI505_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI427_MN2 (nbkn24 nbk23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI427_MN0 (XI427_n1 B_31_b3_4 nbkn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI427_MN1 (VSS B_23 XI427_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI42_MN2 (nakn3 nak2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI42_MN0 (XI42_n1 A_31_b3_0 nakn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI42_MN1 (VSS A_2 XI42_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI45_MN2 (nakn4 nak3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI45_MN0 (XI45_n1 A_31_b3_0 nakn4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI45_MN1 (VSS A_3 XI45_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI48_MN2 (nakn5 nak4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI48_MN0 (XI48_n1 A_31_b3_0 nakn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI48_MN1 (VSS A_4 XI48_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI51_MN2 (nakn6 nak5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI51_MN0 (XI51_n1 A_31_b3_0 nakn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI51_MN1 (VSS A_5 XI51_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2090_MN2 (nqkn5 nqk4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2090_MN0 (XI2090_n1 sq_b3_0 nqkn5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2090_MN1 (VSS qu4_b3_5 XI2090_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2159_MN2 (nqkn28 nqk27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2159_MN0 (XI2159_n1 sq_b3_5 nqkn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2159_MN1 (VSS qu27_b3_5 XI2159_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI492_MN2 (nbkn29 nbk28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI492_MN0 (XI492_n1 B_31_b3_4 nbkn29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI492_MN1 (VSS B_28 XI492_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI440_MN2 (nbkn25 nbk24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI440_MN0 (XI440_n1 B_31_b3_4 nbkn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI440_MN1 (VSS B_24 XI440_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2093_MN2 (nqkn6 nqk5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI2093_MN0 (XI2093_n1 sq_b3_0 nqkn6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI2093_MN1 (VSS qu5_b3_5 XI2093_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI792_I99_XG_MN2 (I792_G3_0n I792_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI792_I99_XG_MN0 (XI792_I99_XG_n1 I792_P3_2 I792_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI792_I99_XG_MN1 (VSS I792_G1_0 XI792_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI792_I100_XG_MN2 (I792_G4_1n I792_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI792_I100_XG_MN0 (XI792_I100_XG_n1 I792_P4_3 I792_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI792_I100_XG_MN1 (VSS I792_G2_1 XI792_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI792_I98_XG_MN2 (I792_G2_0n I792_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI792_I98_XG_MN0 (XI792_I98_XG_n1 I792_P2_1 I792_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI792_I98_XG_MN1 (VSS I792_G0_0 XI792_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI838_I100_XG_MN2 (I838_G4_1n I838_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI838_I100_XG_MN0 (XI838_I100_XG_n1 I838_P4_3 I838_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI838_I100_XG_MN1 (VSS I838_G2_1 XI838_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI838_I98_XG_MN2 (I838_G2_0n I838_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI838_I98_XG_MN0 (XI838_I98_XG_n1 I838_P2_1 I838_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI838_I98_XG_MN1 (VSS I838_G0_0 XI838_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI479_MN2 (nbkn28 nbk27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI479_MN0 (XI479_n1 B_31_b3_4 nbkn28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI479_MN1 (VSS B_27 XI479_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI466_MN2 (nbkn27 nbk26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI466_MN0 (XI466_n1 B_31_b3_4 nbkn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI466_MN1 (VSS B_26 XI466_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI453_MN2 (nbkn26 nbk25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI453_MN0 (XI453_n1 B_31_b3_4 nbkn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI453_MN1 (VSS B_25 XI453_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1712_I98_XG_MN2 (I1712_G2_0n I1712_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1712_I98_XG_MN0 (XI1712_I98_XG_n1 I1712_P2_1 I1712_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1712_I98_XG_MN1 (VSS I1712_G0_0 XI1712_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1804_I99_XG_MN2 (I1804_G3_0n I1804_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1804_I99_XG_MN0 (XI1804_I99_XG_n1 I1804_P3_2 I1804_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1804_I99_XG_MN1 (VSS I1804_G1_0 XI1804_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1804_I98_XG_MN2 (I1804_G2_0n I1804_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1804_I98_XG_MN0 (XI1804_I98_XG_n1 I1804_P2_1 I1804_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1804_I98_XG_MN1 (VSS I1804_G0_0 XI1804_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1804_I100_XG_MN2 (I1804_G4_1n I1804_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1804_I100_XG_MN0 (XI1804_I100_XG_n1 I1804_P4_3 I1804_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1804_I100_XG_MN1 (VSS I1804_G2_1 XI1804_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I107_XG_MN2 (I746_G11_8n I746_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I107_XG_MN0 (XI746_I107_XG_n1 I746_P11_10 I746_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I107_XG_MN1 (VSS I746_G9_8 XI746_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I105_XG_MN2 (I746_G9_6n I746_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I105_XG_MN0 (XI746_I105_XG_n1 I746_P9_8 I746_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I105_XG_MN1 (VSS I746_G7_6 XI746_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I103_XG_MN2 (I746_G7_4n I746_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I103_XG_MN0 (XI746_I103_XG_n1 I746_P7_6 I746_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I103_XG_MN1 (VSS I746_G5_4 XI746_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I101_XG_MN2 (I746_G5_2n I746_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I101_XG_MN0 (XI746_I101_XG_n1 I746_P5_4 I746_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I101_XG_MN1 (VSS I746_G3_2 XI746_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I99_XG_MN2 (I746_G3_0n I746_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I99_XG_MN0 (XI746_I99_XG_n1 I746_P3_2 I746_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I99_XG_MN1 (VSS I746_G1_0 XI746_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI792_I103_XG_MN2 (I792_G7_4n I792_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI792_I103_XG_MN0 (XI792_I103_XG_n1 I792_P7_6 I792_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI792_I103_XG_MN1 (VSS I792_G5_4 XI792_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI792_I101_XG_MN2 (I792_G5_2n I792_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI792_I101_XG_MN0 (XI792_I101_XG_n1 I792_P5_4 I792_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI792_I101_XG_MN1 (VSS I792_G3_2 XI792_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI792_I104_XG_MN2 (I792_G8_5n I792_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI792_I104_XG_MN0 (XI792_I104_XG_n1 I792_P8_7 I792_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI792_I104_XG_MN1 (VSS I792_G6_5 XI792_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI792_I102_XG_MN2 (I792_G6_3n I792_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI792_I102_XG_MN0 (XI792_I102_XG_n1 I792_P6_5 I792_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI792_I102_XG_MN1 (VSS I792_G4_3 XI792_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI838_I103_XG_MN2 (I838_G7_4n I838_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI838_I103_XG_MN0 (XI838_I103_XG_n1 I838_P7_6 I838_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI838_I103_XG_MN1 (VSS I838_G5_4 XI838_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI838_I101_XG_MN2 (I838_G5_2n I838_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI838_I101_XG_MN0 (XI838_I101_XG_n1 I838_P5_4 I838_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI838_I101_XG_MN1 (VSS I838_G3_2 XI838_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI838_I99_XG_MN2 (I838_G3_0n I838_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI838_I99_XG_MN0 (XI838_I99_XG_n1 I838_P3_2 I838_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI838_I99_XG_MN1 (VSS I838_G1_0 XI838_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI838_I102_XG_MN2 (I838_G6_3n I838_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI838_I102_XG_MN0 (XI838_I102_XG_n1 I838_P6_5 I838_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI838_I102_XG_MN1 (VSS I838_G4_3 XI838_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI838_I104_XG_MN2 (I838_G8_5n I838_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI838_I104_XG_MN0 (XI838_I104_XG_n1 I838_P8_7 I838_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI838_I104_XG_MN1 (VSS I838_G6_5 XI838_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI838_I157_XG_MN2 (I838_G8_0n I838_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI838_I157_XG_MN0 (XI838_I157_XG_n1 I838_P8_1 I838_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI838_I157_XG_MN1 (VSS I838_G0_0 XI838_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI884_I98_XG_MN2 (I884_G2_0n I884_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI884_I98_XG_MN0 (XI884_I98_XG_n1 I884_P2_1 I884_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI884_I98_XG_MN1 (VSS I884_G0_0 XI884_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI884_I99_XG_MN2 (I884_G3_0n I884_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI884_I99_XG_MN0 (XI884_I99_XG_n1 I884_P3_2 I884_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI884_I99_XG_MN1 (VSS I884_G1_0 XI884_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI884_I101_XG_MN2 (I884_G5_2n I884_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI884_I101_XG_MN0 (XI884_I101_XG_n1 I884_P5_4 I884_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI884_I101_XG_MN1 (VSS I884_G3_2 XI884_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1712_I100_XG_MN2 (I1712_G4_1n I1712_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1712_I100_XG_MN0 (XI1712_I100_XG_n1 I1712_P4_3 I1712_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1712_I100_XG_MN1 (VSS I1712_G2_1 XI1712_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1712_I99_XG_MN2 (I1712_G3_0n I1712_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1712_I99_XG_MN0 (XI1712_I99_XG_n1 I1712_P3_2 I1712_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1712_I99_XG_MN1 (VSS I1712_G1_0 XI1712_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1758_I100_XG_MN2 (I1758_G4_1n I1758_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1758_I100_XG_MN0 (XI1758_I100_XG_n1 I1758_P4_3 I1758_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1758_I100_XG_MN1 (VSS I1758_G2_1 XI1758_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1758_I98_XG_MN2 (I1758_G2_0n I1758_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1758_I98_XG_MN0 (XI1758_I98_XG_n1 I1758_P2_1 I1758_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1758_I98_XG_MN1 (VSS I1758_G0_0 XI1758_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1758_I99_XG_MN2 (I1758_G3_0n I1758_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1758_I99_XG_MN0 (XI1758_I99_XG_n1 I1758_P3_2 I1758_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1758_I99_XG_MN1 (VSS I1758_G1_0 XI1758_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1804_I101_XG_MN2 (I1804_G5_2n I1804_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1804_I101_XG_MN0 (XI1804_I101_XG_n1 I1804_P5_4 I1804_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1804_I101_XG_MN1 (VSS I1804_G3_2 XI1804_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1804_I102_XG_MN2 (I1804_G6_3n I1804_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1804_I102_XG_MN0 (XI1804_I102_XG_n1 I1804_P6_5 I1804_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1804_I102_XG_MN1 (VSS I1804_G4_3 XI1804_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1804_I157_XG_MN2 (I1804_G8_0n I1804_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1804_I157_XG_MN0 (XI1804_I157_XG_n1 I1804_P8_1 I1804_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1804_I157_XG_MN1 (VSS I1804_G0_0 XI1804_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1804_I167_XG_MN2 (I1804_G16_1n I1804_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1804_I167_XG_MN0 (XI1804_I167_XG_n1 I1804_P16_9 I1804_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1804_I167_XG_MN1 (VSS I1804_G8_1 XI1804_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I174_XG_MN2 (I746_G23_8n I746_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I174_XG_MN0 (XI746_I174_XG_n1 I746_P23_16 I746_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I174_XG_MN1 (VSS I746_G15_8 XI746_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I166_XG_MN2 (I746_G15_0n I746_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I166_XG_MN0 (XI746_I166_XG_n1 I746_P15_8 I746_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I166_XG_MN1 (VSS I746_G7_0 XI746_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I162_XG_MN2 (I746_G11_0n I746_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I162_XG_MN0 (XI746_I162_XG_n1 I746_P11_4 I746_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I162_XG_MN1 (VSS I746_G3_0np XI746_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I113_XG_MN2 (I746_G17_14n I746_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I113_XG_MN0 (XI746_I113_XG_n1 I746_P17_16 I746_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I113_XG_MN1 (VSS I746_G15_14 XI746_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I111_XG_MN2 (I746_G15_12n I746_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I111_XG_MN0 (XI746_I111_XG_n1 I746_P15_14 I746_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I111_XG_MN1 (VSS I746_G13_12 XI746_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I109_XG_MN2 (I746_G13_10n I746_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I109_XG_MN0 (XI746_I109_XG_n1 I746_P13_12 I746_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I109_XG_MN1 (VSS I746_G11_10 XI746_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I158_XG_MN2 (I746_G9_0n I746_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I158_XG_MN0 (XI746_I158_XG_n1 I746_P9_2 I746_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I158_XG_MN1 (VSS I746_G1_0 XI746_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I102_XG_MN2 (I746_G6_3n I746_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I102_XG_MN0 (XI746_I102_XG_n1 I746_P6_5 I746_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I102_XG_MN1 (VSS I746_G4_3 XI746_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I100_XG_MN2 (I746_G4_1n I746_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I100_XG_MN0 (XI746_I100_XG_n1 I746_P4_3 I746_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I100_XG_MN1 (VSS I746_G2_1 XI746_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I98_XG_MN2 (I746_G2_0n I746_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I98_XG_MN0 (XI746_I98_XG_n1 I746_P2_1 I746_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I98_XG_MN1 (VSS I746_G0_0 XI746_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI792_I105_XG_MN2 (I792_G9_6n I792_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI792_I105_XG_MN0 (XI792_I105_XG_n1 I792_P9_8 I792_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI792_I105_XG_MN1 (VSS I792_G7_6 XI792_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI792_I158_XG_MN2 (I792_G9_0n I792_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI792_I158_XG_MN0 (XI792_I158_XG_n1 I792_P9_2 I792_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI792_I158_XG_MN1 (VSS I792_G1_0 XI792_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI792_I157_XG_MN2 (I792_G8_0n I792_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI792_I157_XG_MN0 (XI792_I157_XG_n1 I792_P8_1 I792_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI792_I157_XG_MN1 (VSS I792_G0_0 XI792_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI838_I105_XG_MN2 (I838_G9_6n I838_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI838_I105_XG_MN0 (XI838_I105_XG_n1 I838_P9_8 I838_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI838_I105_XG_MN1 (VSS I838_G7_6 XI838_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI838_I158_XG_MN2 (I838_G9_0n I838_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI838_I158_XG_MN0 (XI838_I158_XG_n1 I838_P9_2 I838_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI838_I158_XG_MN1 (VSS I838_G1_0 XI838_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI838_I106_XG_MN2 (I838_G10_7n I838_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI838_I106_XG_MN0 (XI838_I106_XG_n1 I838_P10_9 I838_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI838_I106_XG_MN1 (VSS I838_G8_7 XI838_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI838_I167_XG_MN2 (I838_G16_1n I838_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI838_I167_XG_MN0 (XI838_I167_XG_n1 I838_P16_9 I838_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI838_I167_XG_MN1 (VSS I838_G8_1 XI838_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI884_I104_XG_MN2 (I884_G8_5n I884_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI884_I104_XG_MN0 (XI884_I104_XG_n1 I884_P8_7 I884_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI884_I104_XG_MN1 (VSS I884_G6_5 XI884_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI884_I102_XG_MN2 (I884_G6_3n I884_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI884_I102_XG_MN0 (XI884_I102_XG_n1 I884_P6_5 I884_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI884_I102_XG_MN1 (VSS I884_G4_3 XI884_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI884_I100_XG_MN2 (I884_G4_1n I884_G4_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI884_I100_XG_MN0 (XI884_I100_XG_n1 I884_P4_3 I884_G4_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI884_I100_XG_MN1 (VSS I884_G2_1 XI884_I100_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI884_I157_XG_MN2 (I884_G8_0n I884_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI884_I157_XG_MN0 (XI884_I157_XG_n1 I884_P8_1 I884_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI884_I157_XG_MN1 (VSS I884_G0_0 XI884_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI884_I103_XG_MN2 (I884_G7_4n I884_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI884_I103_XG_MN0 (XI884_I103_XG_n1 I884_P7_6 I884_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI884_I103_XG_MN1 (VSS I884_G5_4 XI884_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1712_I167_XG_MN2 (I1712_G16_1n I1712_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1712_I167_XG_MN0 (XI1712_I167_XG_n1 I1712_P16_9 I1712_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1712_I167_XG_MN1 (VSS I1712_G8_1 XI1712_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1712_I157_XG_MN2 (I1712_G8_0n I1712_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1712_I157_XG_MN0 (XI1712_I157_XG_n1 I1712_P8_1 I1712_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1712_I157_XG_MN1 (VSS I1712_G0_0 XI1712_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1712_I104_XG_MN2 (I1712_G8_5n I1712_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1712_I104_XG_MN0 (XI1712_I104_XG_n1 I1712_P8_7 I1712_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1712_I104_XG_MN1 (VSS I1712_G6_5 XI1712_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1712_I102_XG_MN2 (I1712_G6_3n I1712_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1712_I102_XG_MN0 (XI1712_I102_XG_n1 I1712_P6_5 I1712_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1712_I102_XG_MN1 (VSS I1712_G4_3 XI1712_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1712_I101_XG_MN2 (I1712_G5_2n I1712_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1712_I101_XG_MN0 (XI1712_I101_XG_n1 I1712_P5_4 I1712_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1712_I101_XG_MN1 (VSS I1712_G3_2 XI1712_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1758_I104_XG_MN2 (I1758_G8_5n I1758_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1758_I104_XG_MN0 (XI1758_I104_XG_n1 I1758_P8_7 I1758_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1758_I104_XG_MN1 (VSS I1758_G6_5 XI1758_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1758_I102_XG_MN2 (I1758_G6_3n I1758_G6_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1758_I102_XG_MN0 (XI1758_I102_XG_n1 I1758_P6_5 I1758_G6_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1758_I102_XG_MN1 (VSS I1758_G4_3 XI1758_I102_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1758_I167_XG_MN2 (I1758_G16_1n I1758_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1758_I167_XG_MN0 (XI1758_I167_XG_n1 I1758_P16_9 I1758_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1758_I167_XG_MN1 (VSS I1758_G8_1 XI1758_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1758_I157_XG_MN2 (I1758_G8_0n I1758_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1758_I157_XG_MN0 (XI1758_I157_XG_n1 I1758_P8_1 I1758_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1758_I157_XG_MN1 (VSS I1758_G0_0 XI1758_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1758_I101_XG_MN2 (I1758_G5_2n I1758_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1758_I101_XG_MN0 (XI1758_I101_XG_n1 I1758_P5_4 I1758_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1758_I101_XG_MN1 (VSS I1758_G3_2 XI1758_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI54_MN2 (nakn7 nak6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI54_MN0 (XI54_n1 A_31_b3_1 nakn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI54_MN1 (VSS A_6 XI54_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1804_I103_XG_MN2 (I1804_G7_4n I1804_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1804_I103_XG_MN0 (XI1804_I103_XG_n1 I1804_P7_6 I1804_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1804_I103_XG_MN1 (VSS I1804_G5_4 XI1804_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1804_I104_XG_MN2 (I1804_G8_5n I1804_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1804_I104_XG_MN0 (XI1804_I104_XG_n1 I1804_P8_7 I1804_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1804_I104_XG_MN1 (VSS I1804_G6_5 XI1804_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1804_I106_XG_MN2 (I1804_G10_7n I1804_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1804_I106_XG_MN0 (XI1804_I106_XG_n1 I1804_P10_9 I1804_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1804_I106_XG_MN1 (VSS I1804_G8_7 XI1804_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1804_I160_XG_MN2 (I1804_G10_0n I1804_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1804_I160_XG_MN0 (XI1804_I160_XG_n1 I1804_P10_3 I1804_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1804_I160_XG_MN1 (VSS I1804_G2_0np XI1804_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1804_I169_XG_MN2 (I1804_G18_3n I1804_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1804_I169_XG_MN0 (XI1804_I169_XG_n1 I1804_P18_11 I1804_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1804_I169_XG_MN1 (VSS I1804_G10_3 XI1804_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I170_XG_MN2 (I746_G19_4n I746_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I170_XG_MN0 (XI746_I170_XG_n1 I746_P19_12 I746_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I170_XG_MN1 (VSS I746_G11_4 XI746_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I115_XG_MN2 (I746_G19_16n I746_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I115_XG_MN0 (XI746_I115_XG_n1 I746_P19_18 I746_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I115_XG_MN1 (VSS I746_G17_16 XI746_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I168_XG_MN2 (I746_G17_2n I746_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I168_XG_MN0 (XI746_I168_XG_n1 I746_P17_10 I746_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I168_XG_MN1 (VSS I746_G9_2 XI746_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I106_XG_MN2 (I746_G10_7n I746_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I106_XG_MN0 (XI746_I106_XG_n1 I746_P10_9 I746_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I106_XG_MN1 (VSS I746_G8_7 XI746_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI746_I104_XG_MN2 (I746_G8_5n I746_G8_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI746_I104_XG_MN0 (XI746_I104_XG_n1 I746_P8_7 I746_G8_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI746_I104_XG_MN1 (VSS I746_G6_5 XI746_I104_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI792_I107_XG_MN2 (I792_G11_8n I792_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI792_I107_XG_MN0 (XI792_I107_XG_n1 I792_P11_10 I792_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI792_I107_XG_MN1 (VSS I792_G9_8 XI792_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI792_I168_XG_MN2 (I792_G17_2n I792_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI792_I168_XG_MN0 (XI792_I168_XG_n1 I792_P17_10 I792_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI792_I168_XG_MN1 (VSS I792_G9_2 XI792_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI792_I106_XG_MN2 (I792_G10_7n I792_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI792_I106_XG_MN0 (XI792_I106_XG_n1 I792_P10_9 I792_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI792_I106_XG_MN1 (VSS I792_G8_7 XI792_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI792_I167_XG_MN2 (I792_G16_1n I792_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI792_I167_XG_MN0 (XI792_I167_XG_n1 I792_P16_9 I792_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI792_I167_XG_MN1 (VSS I792_G8_1 XI792_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI838_I107_XG_MN2 (I838_G11_8n I838_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI838_I107_XG_MN0 (XI838_I107_XG_n1 I838_P11_10 I838_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI838_I107_XG_MN1 (VSS I838_G9_8 XI838_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI838_I168_XG_MN2 (I838_G17_2n I838_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI838_I168_XG_MN0 (XI838_I168_XG_n1 I838_P17_10 I838_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI838_I168_XG_MN1 (VSS I838_G9_2 XI838_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI838_I108_XG_MN2 (I838_G12_9n I838_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI838_I108_XG_MN0 (XI838_I108_XG_n1 I838_P12_11 I838_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI838_I108_XG_MN1 (VSS I838_G10_9 XI838_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI838_I160_XG_MN2 (I838_G10_0n I838_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI838_I160_XG_MN0 (XI838_I160_XG_n1 I838_P10_3 I838_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI838_I160_XG_MN1 (VSS I838_G2_0np XI838_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI838_I169_XG_MN2 (I838_G18_3n I838_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI838_I169_XG_MN0 (XI838_I169_XG_n1 I838_P18_11 I838_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI838_I169_XG_MN1 (VSS I838_G10_3 XI838_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI884_I106_XG_MN2 (I884_G10_7n I884_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI884_I106_XG_MN0 (XI884_I106_XG_n1 I884_P10_9 I884_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI884_I106_XG_MN1 (VSS I884_G8_7 XI884_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI884_I167_XG_MN2 (I884_G16_1n I884_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI884_I167_XG_MN0 (XI884_I167_XG_n1 I884_P16_9 I884_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI884_I167_XG_MN1 (VSS I884_G8_1 XI884_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI884_I105_XG_MN2 (I884_G9_6n I884_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI884_I105_XG_MN0 (XI884_I105_XG_n1 I884_P9_8 I884_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI884_I105_XG_MN1 (VSS I884_G7_6 XI884_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI884_I158_XG_MN2 (I884_G9_0n I884_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI884_I158_XG_MN0 (XI884_I158_XG_n1 I884_P9_2 I884_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI884_I158_XG_MN1 (VSS I884_G1_0 XI884_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1712_I171_XG_MN2 (I1712_G20_5n I1712_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1712_I171_XG_MN0 (XI1712_I171_XG_n1 I1712_P20_13 I1712_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1712_I171_XG_MN1 (VSS I1712_G12_5 XI1712_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1712_I163_XG_MN2 (I1712_G12_0n I1712_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1712_I163_XG_MN0 (XI1712_I163_XG_n1 I1712_P12_5 I1712_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1712_I163_XG_MN1 (VSS I1712_G4_0 XI1712_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1712_I106_XG_MN2 (I1712_G10_7n I1712_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1712_I106_XG_MN0 (XI1712_I106_XG_n1 I1712_P10_9 I1712_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1712_I106_XG_MN1 (VSS I1712_G8_7 XI1712_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1712_I103_XG_MN2 (I1712_G7_4n I1712_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1712_I103_XG_MN0 (XI1712_I103_XG_n1 I1712_P7_6 I1712_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1712_I103_XG_MN1 (VSS I1712_G5_4 XI1712_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1758_I106_XG_MN2 (I1758_G10_7n I1758_G10_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1758_I106_XG_MN0 (XI1758_I106_XG_n1 I1758_P10_9 I1758_G10_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1758_I106_XG_MN1 (VSS I1758_G8_7 XI1758_I106_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1758_I105_XG_MN2 (I1758_G9_6n I1758_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1758_I105_XG_MN0 (XI1758_I105_XG_n1 I1758_P9_8 I1758_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1758_I105_XG_MN1 (VSS I1758_G7_6 XI1758_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1758_I103_XG_MN2 (I1758_G7_4n I1758_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1758_I103_XG_MN0 (XI1758_I103_XG_n1 I1758_P7_6 I1758_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1758_I103_XG_MN1 (VSS I1758_G5_4 XI1758_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1804_I105_XG_MN2 (I1804_G9_6n I1804_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1804_I105_XG_MN0 (XI1804_I105_XG_n1 I1804_P9_8 I1804_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1804_I105_XG_MN1 (VSS I1804_G7_6 XI1804_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1804_I158_XG_MN2 (I1804_G9_0n I1804_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1804_I158_XG_MN0 (XI1804_I158_XG_n1 I1804_P9_2 I1804_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1804_I158_XG_MN1 (VSS I1804_G1_0 XI1804_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1804_I108_XG_MN2 (I1804_G12_9n I1804_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1804_I108_XG_MN0 (XI1804_I108_XG_n1 I1804_P12_11 I1804_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1804_I108_XG_MN1 (VSS I1804_G10_9 XI1804_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1804_I163_XG_MN2 (I1804_G12_0n I1804_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1804_I163_XG_MN0 (XI1804_I163_XG_n1 I1804_P12_5 I1804_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1804_I163_XG_MN1 (VSS I1804_G4_0 XI1804_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1804_I171_XG_MN2 (I1804_G20_5n I1804_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1804_I171_XG_MN0 (XI1804_I171_XG_n1 I1804_P20_13 I1804_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.0468p pd=0.68u ps=0.68u
    I_MXI1804_I171_XG_MN1 (VSS I1804_G12_5 XI1804_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1804_I175_XG_MN2 (I1804_G24_9n I1804_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.0468p as=0.0696p pd=0.68u ps=1.16u
    I_MXI1804_I175_XG_MN0 (XI1804_I175_XG_n1 I1804_P24_17 I1804_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.0528p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I175_XG_MN1 (VSS I1804_G16_9 XI1804_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I182_XG_MN2 (I746_G31_16n I746_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I182_XG_MN0 (XI746_I182_XG_n1 I746_P31_24 I746_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I182_XG_MN1 (VSS I746_G23_16 XI746_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I178_XG_MN2 (I746_G27_12n I746_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I178_XG_MN0 (XI746_I178_XG_n1 I746_P27_20 I746_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I178_XG_MN1 (VSS I746_G19_12 XI746_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I119_XG_MN2 (I746_G23_20n I746_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I119_XG_MN0 (XI746_I119_XG_n1 I746_P23_22 I746_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I119_XG_MN1 (VSS I746_G21_20 XI746_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I117_XG_MN2 (I746_G21_18n I746_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I117_XG_MN0 (XI746_I117_XG_n1 I746_P21_20 I746_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I117_XG_MN1 (VSS I746_G19_18 XI746_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I172_XG_MN2 (I746_G21_6n I746_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I172_XG_MN0 (XI746_I172_XG_n1 I746_P21_14 I746_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I172_XG_MN1 (VSS I746_G13_6 XI746_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I176_XG_MN2 (I746_G25_10n I746_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I176_XG_MN0 (XI746_I176_XG_n1 I746_P25_18 I746_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I176_XG_MN1 (VSS I746_G17_10 XI746_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I164_XG_MN2 (I746_G13_0n I746_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I164_XG_MN0 (XI746_I164_XG_n1 I746_P13_6 I746_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I164_XG_MN1 (VSS I746_G5_0 XI746_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I110_XG_MN2 (I746_G14_11n I746_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I110_XG_MN0 (XI746_I110_XG_n1 I746_P14_13 I746_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I110_XG_MN1 (VSS I746_G12_11 XI746_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I108_XG_MN2 (I746_G12_9n I746_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I108_XG_MN0 (XI746_I108_XG_n1 I746_P12_11 I746_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I108_XG_MN1 (VSS I746_G10_9 XI746_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I167_XG_MN2 (I746_G16_1n I746_G16_9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I167_XG_MN0 (XI746_I167_XG_n1 I746_P16_9 I746_G16_1n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I167_XG_MN1 (VSS I746_G8_1 XI746_I167_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I157_XG_MN2 (I746_G8_0n I746_G8_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I157_XG_MN0 (XI746_I157_XG_n1 I746_P8_1 I746_G8_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I157_XG_MN1 (VSS I746_G0_0 XI746_I157_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I109_XG_MN2 (I792_G13_10n I792_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I109_XG_MN0 (XI792_I109_XG_n1 I792_P13_12 I792_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I109_XG_MN1 (VSS I792_G11_10 XI792_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I110_XG_MN2 (I792_G14_11n I792_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I110_XG_MN0 (XI792_I110_XG_n1 I792_P14_13 I792_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I110_XG_MN1 (VSS I792_G12_11 XI792_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I108_XG_MN2 (I792_G12_9n I792_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I108_XG_MN0 (XI792_I108_XG_n1 I792_P12_11 I792_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I108_XG_MN1 (VSS I792_G10_9 XI792_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I160_XG_MN2 (I792_G10_0n I792_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I160_XG_MN0 (XI792_I160_XG_n1 I792_P10_3 I792_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I160_XG_MN1 (VSS I792_G2_0np XI792_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I109_XG_MN2 (I838_G13_10n I838_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I109_XG_MN0 (XI838_I109_XG_n1 I838_P13_12 I838_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I109_XG_MN1 (VSS I838_G11_10 XI838_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I176_XG_MN2 (I838_G25_10n I838_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I176_XG_MN0 (XI838_I176_XG_n1 I838_P25_18 I838_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I176_XG_MN1 (VSS I838_G17_10 XI838_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I175_XG_MN2 (I838_G24_9n I838_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I175_XG_MN0 (XI838_I175_XG_n1 I838_P24_17 I838_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I175_XG_MN1 (VSS I838_G16_9 XI838_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I163_XG_MN2 (I838_G12_0n I838_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I163_XG_MN0 (XI838_I163_XG_n1 I838_P12_5 I838_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I163_XG_MN1 (VSS I838_G4_0 XI838_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I108_XG_MN2 (I884_G12_9n I884_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I108_XG_MN0 (XI884_I108_XG_n1 I884_P12_11 I884_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I108_XG_MN1 (VSS I884_G10_9 XI884_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I160_XG_MN2 (I884_G10_0n I884_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I160_XG_MN0 (XI884_I160_XG_n1 I884_P10_3 I884_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I160_XG_MN1 (VSS I884_G2_0np XI884_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I107_XG_MN2 (I884_G11_8n I884_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I107_XG_MN0 (XI884_I107_XG_n1 I884_P11_10 I884_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I107_XG_MN1 (VSS I884_G9_8 XI884_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I168_XG_MN2 (I884_G17_2n I884_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I168_XG_MN0 (XI884_I168_XG_n1 I884_P17_10 I884_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I168_XG_MN1 (VSS I884_G9_2 XI884_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I169_XG_MN2 (I1712_G18_3n I1712_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I169_XG_MN0 (XI1712_I169_XG_n1 I1712_P18_11 I1712_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I169_XG_MN1 (VSS I1712_G10_3 XI1712_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I160_XG_MN2 (I1712_G10_0n I1712_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I160_XG_MN0 (XI1712_I160_XG_n1 I1712_P10_3 I1712_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I160_XG_MN1 (VSS I1712_G2_0np XI1712_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I108_XG_MN2 (I1712_G12_9n I1712_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I108_XG_MN0 (XI1712_I108_XG_n1 I1712_P12_11 I1712_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I108_XG_MN1 (VSS I1712_G10_9 XI1712_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I105_XG_MN2 (I1712_G9_6n I1712_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I105_XG_MN0 (XI1712_I105_XG_n1 I1712_P9_8 I1712_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I105_XG_MN1 (VSS I1712_G7_6 XI1712_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I158_XG_MN2 (I1712_G9_0n I1712_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I158_XG_MN0 (XI1712_I158_XG_n1 I1712_P9_2 I1712_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I158_XG_MN1 (VSS I1712_G1_0 XI1712_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I108_XG_MN2 (I1758_G12_9n I1758_G12_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I108_XG_MN0 (XI1758_I108_XG_n1 I1758_P12_11 I1758_G12_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I108_XG_MN1 (VSS I1758_G10_9 XI1758_I108_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I169_XG_MN2 (I1758_G18_3n I1758_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I169_XG_MN0 (XI1758_I169_XG_n1 I1758_P18_11 I1758_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I169_XG_MN1 (VSS I1758_G10_3 XI1758_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I160_XG_MN2 (I1758_G10_0n I1758_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I160_XG_MN0 (XI1758_I160_XG_n1 I1758_P10_3 I1758_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I160_XG_MN1 (VSS I1758_G2_0np XI1758_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I168_XG_MN2 (I1758_G17_2n I1758_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I168_XG_MN0 (XI1758_I168_XG_n1 I1758_P17_10 I1758_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I168_XG_MN1 (VSS I1758_G9_2 XI1758_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I158_XG_MN2 (I1758_G9_0n I1758_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I158_XG_MN0 (XI1758_I158_XG_n1 I1758_P9_2 I1758_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I158_XG_MN1 (VSS I1758_G1_0 XI1758_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I107_XG_MN2 (I1804_G11_8n I1804_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I107_XG_MN0 (XI1804_I107_XG_n1 I1804_P11_10 I1804_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I107_XG_MN1 (VSS I1804_G9_8 XI1804_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I162_XG_MN2 (I1804_G11_0n I1804_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I162_XG_MN0 (XI1804_I162_XG_n1 I1804_P11_4 I1804_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I162_XG_MN1 (VSS I1804_G3_0np XI1804_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I168_XG_MN2 (I1804_G17_2n I1804_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I168_XG_MN0 (XI1804_I168_XG_n1 I1804_P17_10 I1804_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I168_XG_MN1 (VSS I1804_G9_2 XI1804_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I110_XG_MN2 (I1804_G14_11n I1804_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I110_XG_MN0 (XI1804_I110_XG_n1 I1804_P14_13 I1804_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I110_XG_MN1 (VSS I1804_G12_11 XI1804_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I165_XG_MN2 (I1804_G14_0n I1804_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I165_XG_MN0 (XI1804_I165_XG_n1 I1804_P14_7 I1804_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I165_XG_MN1 (VSS I1804_G6_0 XI1804_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I177_XG_MN2 (I1804_G26_11n I1804_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I177_XG_MN0 (XI1804_I177_XG_n1 I1804_P26_19 I1804_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I177_XG_MN1 (VSS I1804_G18_11 XI1804_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I173_XG_MN2 (I1804_G22_7n I1804_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I173_XG_MN0 (XI1804_I173_XG_n1 I1804_P22_15 I1804_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I173_XG_MN1 (VSS I1804_G14_7 XI1804_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I121_XG_MN2 (I746_G25_22n I746_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I121_XG_MN0 (XI746_I121_XG_n1 I746_P25_24 I746_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I121_XG_MN1 (VSS I746_G23_22 XI746_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I180_XG_MN2 (I746_G29_14n I746_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I180_XG_MN0 (XI746_I180_XG_n1 I746_P29_22 I746_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I180_XG_MN1 (VSS I746_G21_14 XI746_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I114_XG_MN2 (I746_G18_15n I746_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I114_XG_MN0 (XI746_I114_XG_n1 I746_P18_17 I746_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I114_XG_MN1 (VSS I746_G16_15 XI746_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I112_XG_MN2 (I746_G16_13n I746_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I112_XG_MN0 (XI746_I112_XG_n1 I746_P16_15 I746_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I112_XG_MN1 (VSS I746_G14_13 XI746_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I163_XG_MN2 (I746_G12_0n I746_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I163_XG_MN0 (XI746_I163_XG_n1 I746_P12_5 I746_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I163_XG_MN1 (VSS I746_G4_0 XI746_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I160_XG_MN2 (I746_G10_0n I746_G10_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I160_XG_MN0 (XI746_I160_XG_n1 I746_P10_3 I746_G10_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I160_XG_MN1 (VSS I746_G2_0np XI746_I160_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I111_XG_MN2 (I792_G15_12n I792_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I111_XG_MN0 (XI792_I111_XG_n1 I792_P15_14 I792_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I111_XG_MN1 (VSS I792_G13_12 XI792_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I162_XG_MN2 (I792_G11_0n I792_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I162_XG_MN0 (XI792_I162_XG_n1 I792_P11_4 I792_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I162_XG_MN1 (VSS I792_G3_0np XI792_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I112_XG_MN2 (I792_G16_13n I792_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I112_XG_MN0 (XI792_I112_XG_n1 I792_P16_15 I792_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I112_XG_MN1 (VSS I792_G14_13 XI792_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I163_XG_MN2 (I792_G12_0n I792_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I163_XG_MN0 (XI792_I163_XG_n1 I792_P12_5 I792_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I163_XG_MN1 (VSS I792_G4_0 XI792_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I169_XG_MN2 (I792_G18_3n I792_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I169_XG_MN0 (XI792_I169_XG_n1 I792_P18_11 I792_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I169_XG_MN1 (VSS I792_G10_3 XI792_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I111_XG_MN2 (I838_G15_12n I838_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I111_XG_MN0 (XI838_I111_XG_n1 I838_P15_14 I838_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I111_XG_MN1 (VSS I838_G13_12 XI838_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I162_XG_MN2 (I838_G11_0n I838_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I162_XG_MN0 (XI838_I162_XG_n1 I838_P11_4 I838_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I162_XG_MN1 (VSS I838_G3_0np XI838_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I172_XG_MN2 (I838_G21_6n I838_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I172_XG_MN0 (XI838_I172_XG_n1 I838_P21_14 I838_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I172_XG_MN1 (VSS I838_G13_6 XI838_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I164_XG_MN2 (I838_G13_0n I838_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I164_XG_MN0 (XI838_I164_XG_n1 I838_P13_6 I838_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I164_XG_MN1 (VSS I838_G5_0 XI838_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I110_XG_MN2 (I838_G14_11n I838_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I110_XG_MN0 (XI838_I110_XG_n1 I838_P14_13 I838_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I110_XG_MN1 (VSS I838_G12_11 XI838_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I171_XG_MN2 (I838_G20_5n I838_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I171_XG_MN0 (XI838_I171_XG_n1 I838_P20_13 I838_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I171_XG_MN1 (VSS I838_G12_5 XI838_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I110_XG_MN2 (I884_G14_11n I884_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I110_XG_MN0 (XI884_I110_XG_n1 I884_P14_13 I884_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I110_XG_MN1 (VSS I884_G12_11 XI884_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I169_XG_MN2 (I884_G18_3n I884_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I169_XG_MN0 (XI884_I169_XG_n1 I884_P18_11 I884_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I169_XG_MN1 (VSS I884_G10_3 XI884_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I175_XG_MN2 (I884_G24_9n I884_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I175_XG_MN0 (XI884_I175_XG_n1 I884_P24_17 I884_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I175_XG_MN1 (VSS I884_G16_9 XI884_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I163_XG_MN2 (I884_G12_0n I884_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I163_XG_MN0 (XI884_I163_XG_n1 I884_P12_5 I884_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I163_XG_MN1 (VSS I884_G4_0 XI884_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I109_XG_MN2 (I884_G13_10n I884_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I109_XG_MN0 (XI884_I109_XG_n1 I884_P13_12 I884_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I109_XG_MN1 (VSS I884_G11_10 XI884_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I164_XG_MN2 (I884_G13_0n I884_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I164_XG_MN0 (XI884_I164_XG_n1 I884_P13_6 I884_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I164_XG_MN1 (VSS I884_G5_0 XI884_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I176_XG_MN2 (I884_G25_10n I884_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I176_XG_MN0 (XI884_I176_XG_n1 I884_P25_18 I884_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I176_XG_MN1 (VSS I884_G17_10 XI884_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I165_XG_MN2 (I1712_G14_0n I1712_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I165_XG_MN0 (XI1712_I165_XG_n1 I1712_P14_7 I1712_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I165_XG_MN1 (VSS I1712_G6_0 XI1712_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I175_XG_MN2 (I1712_G24_9n I1712_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I175_XG_MN0 (XI1712_I175_XG_n1 I1712_P24_17 I1712_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I175_XG_MN1 (VSS I1712_G16_9 XI1712_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I110_XG_MN2 (I1712_G14_11n I1712_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I110_XG_MN0 (XI1712_I110_XG_n1 I1712_P14_13 I1712_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I110_XG_MN1 (VSS I1712_G12_11 XI1712_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I107_XG_MN2 (I1712_G11_8n I1712_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I107_XG_MN0 (XI1712_I107_XG_n1 I1712_P11_10 I1712_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I107_XG_MN1 (VSS I1712_G9_8 XI1712_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I168_XG_MN2 (I1712_G17_2n I1712_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I168_XG_MN0 (XI1712_I168_XG_n1 I1712_P17_10 I1712_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I168_XG_MN1 (VSS I1712_G9_2 XI1712_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I162_XG_MN2 (I1712_G11_0n I1712_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I162_XG_MN0 (XI1712_I162_XG_n1 I1712_P11_4 I1712_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I162_XG_MN1 (VSS I1712_G3_0np XI1712_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I110_XG_MN2 (I1758_G14_11n I1758_G14_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I110_XG_MN0 (XI1758_I110_XG_n1 I1758_P14_13 I1758_G14_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I110_XG_MN1 (VSS I1758_G12_11 XI1758_I110_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I175_XG_MN2 (I1758_G24_9n I1758_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I175_XG_MN0 (XI1758_I175_XG_n1 I1758_P24_17 I1758_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I175_XG_MN1 (VSS I1758_G16_9 XI1758_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I163_XG_MN2 (I1758_G12_0n I1758_G12_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I163_XG_MN0 (XI1758_I163_XG_n1 I1758_P12_5 I1758_G12_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I163_XG_MN1 (VSS I1758_G4_0 XI1758_I163_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I107_XG_MN2 (I1758_G11_8n I1758_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I107_XG_MN0 (XI1758_I107_XG_n1 I1758_P11_10 I1758_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I107_XG_MN1 (VSS I1758_G9_8 XI1758_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I109_XG_MN2 (I1758_G13_10n I1758_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I109_XG_MN0 (XI1758_I109_XG_n1 I1758_P13_12 I1758_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I109_XG_MN1 (VSS I1758_G11_10 XI1758_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I176_XG_MN2 (I1758_G25_10n I1758_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I176_XG_MN0 (XI1758_I176_XG_n1 I1758_P25_18 I1758_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I176_XG_MN1 (VSS I1758_G17_10 XI1758_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I162_XG_MN2 (I1758_G11_0n I1758_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I162_XG_MN0 (XI1758_I162_XG_n1 I1758_P11_4 I1758_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I162_XG_MN1 (VSS I1758_G3_0np XI1758_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I109_XG_MN2 (I1804_G13_10n I1804_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I109_XG_MN0 (XI1804_I109_XG_n1 I1804_P13_12 I1804_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I109_XG_MN1 (VSS I1804_G11_10 XI1804_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I170_XG_MN2 (I1804_G19_4n I1804_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I170_XG_MN0 (XI1804_I170_XG_n1 I1804_P19_12 I1804_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I170_XG_MN1 (VSS I1804_G11_4 XI1804_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I112_XG_MN2 (I1804_G16_13n I1804_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I112_XG_MN0 (XI1804_I112_XG_n1 I1804_P16_15 I1804_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I112_XG_MN1 (VSS I1804_G14_13 XI1804_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I114_XG_MN2 (I1804_G18_15n I1804_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I114_XG_MN0 (XI1804_I114_XG_n1 I1804_P18_17 I1804_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I114_XG_MN1 (VSS I1804_G16_15 XI1804_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I179_XG_MN2 (I1804_G28_13n I1804_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I179_XG_MN0 (XI1804_I179_XG_n1 I1804_P28_21 I1804_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I179_XG_MN1 (VSS I1804_G20_13 XI1804_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I123_XG_MN2 (I746_G27_24n I746_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I123_XG_MN0 (XI746_I123_XG_n1 I746_P27_26 I746_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I123_XG_MN1 (VSS I746_G25_24 XI746_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I118_XG_MN2 (I746_G22_19n I746_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I118_XG_MN0 (XI746_I118_XG_n1 I746_P22_21 I746_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I118_XG_MN1 (VSS I746_G20_19 XI746_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I116_XG_MN2 (I746_G20_17n I746_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I116_XG_MN0 (XI746_I116_XG_n1 I746_P20_19 I746_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I116_XG_MN1 (VSS I746_G18_17 XI746_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I171_XG_MN2 (I746_G20_5n I746_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I171_XG_MN0 (XI746_I171_XG_n1 I746_P20_13 I746_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I171_XG_MN1 (VSS I746_G12_5 XI746_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I175_XG_MN2 (I746_G24_9n I746_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I175_XG_MN0 (XI746_I175_XG_n1 I746_P24_17 I746_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I175_XG_MN1 (VSS I746_G16_9 XI746_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I169_XG_MN2 (I746_G18_3n I746_G18_11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I169_XG_MN0 (XI746_I169_XG_n1 I746_P18_11 I746_G18_3n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I169_XG_MN1 (VSS I746_G10_3 XI746_I169_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I115_XG_MN2 (I792_G19_16n I792_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I115_XG_MN0 (XI792_I115_XG_n1 I792_P19_18 I792_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I115_XG_MN1 (VSS I792_G17_16 XI792_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I113_XG_MN2 (I792_G17_14n I792_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I113_XG_MN0 (XI792_I113_XG_n1 I792_P17_16 I792_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I113_XG_MN1 (VSS I792_G15_14 XI792_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I170_XG_MN2 (I792_G19_4n I792_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I170_XG_MN0 (XI792_I170_XG_n1 I792_P19_12 I792_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I170_XG_MN1 (VSS I792_G11_4 XI792_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I164_XG_MN2 (I792_G13_0n I792_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I164_XG_MN0 (XI792_I164_XG_n1 I792_P13_6 I792_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I164_XG_MN1 (VSS I792_G5_0 XI792_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I116_XG_MN2 (I792_G20_17n I792_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I116_XG_MN0 (XI792_I116_XG_n1 I792_P20_19 I792_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I116_XG_MN1 (VSS I792_G18_17 XI792_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I114_XG_MN2 (I792_G18_15n I792_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I114_XG_MN0 (XI792_I114_XG_n1 I792_P18_17 I792_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I114_XG_MN1 (VSS I792_G16_15 XI792_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I171_XG_MN2 (I792_G20_5n I792_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I171_XG_MN0 (XI792_I171_XG_n1 I792_P20_13 I792_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I171_XG_MN1 (VSS I792_G12_5 XI792_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I175_XG_MN2 (I792_G24_9n I792_G24_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I175_XG_MN0 (XI792_I175_XG_n1 I792_P24_17 I792_G24_9n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I175_XG_MN1 (VSS I792_G16_9 XI792_I175_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I113_XG_MN2 (I838_G17_14n I838_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I113_XG_MN0 (XI838_I113_XG_n1 I838_P17_16 I838_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I113_XG_MN1 (VSS I838_G15_14 XI838_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I170_XG_MN2 (I838_G19_4n I838_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I170_XG_MN0 (XI838_I170_XG_n1 I838_P19_12 I838_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I170_XG_MN1 (VSS I838_G11_4 XI838_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I180_XG_MN2 (I838_G29_14n I838_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I180_XG_MN0 (XI838_I180_XG_n1 I838_P29_22 I838_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I180_XG_MN1 (VSS I838_G21_14 XI838_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I112_XG_MN2 (I838_G16_13n I838_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I112_XG_MN0 (XI838_I112_XG_n1 I838_P16_15 I838_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I112_XG_MN1 (VSS I838_G14_13 XI838_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I177_XG_MN2 (I838_G26_11n I838_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I177_XG_MN0 (XI838_I177_XG_n1 I838_P26_19 I838_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I177_XG_MN1 (VSS I838_G18_11 XI838_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I112_XG_MN2 (I884_G16_13n I884_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I112_XG_MN0 (XI884_I112_XG_n1 I884_P16_15 I884_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I112_XG_MN1 (VSS I884_G14_13 XI884_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I165_XG_MN2 (I884_G14_0n I884_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I165_XG_MN0 (XI884_I165_XG_n1 I884_P14_7 I884_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I165_XG_MN1 (VSS I884_G6_0 XI884_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I177_XG_MN2 (I884_G26_11n I884_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I177_XG_MN0 (XI884_I177_XG_n1 I884_P26_19 I884_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I177_XG_MN1 (VSS I884_G18_11 XI884_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I171_XG_MN2 (I884_G20_5n I884_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I171_XG_MN0 (XI884_I171_XG_n1 I884_P20_13 I884_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I171_XG_MN1 (VSS I884_G12_5 XI884_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I111_XG_MN2 (I884_G15_12n I884_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I111_XG_MN0 (XI884_I111_XG_n1 I884_P15_14 I884_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I111_XG_MN1 (VSS I884_G13_12 XI884_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I173_XG_MN2 (I1712_G22_7n I1712_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I173_XG_MN0 (XI1712_I173_XG_n1 I1712_P22_15 I1712_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I173_XG_MN1 (VSS I1712_G14_7 XI1712_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I112_XG_MN2 (I1712_G16_13n I1712_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I112_XG_MN0 (XI1712_I112_XG_n1 I1712_P16_15 I1712_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I112_XG_MN1 (VSS I1712_G14_13 XI1712_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I109_XG_MN2 (I1712_G13_10n I1712_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I109_XG_MN0 (XI1712_I109_XG_n1 I1712_P13_12 I1712_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I109_XG_MN1 (VSS I1712_G11_10 XI1712_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I176_XG_MN2 (I1712_G25_10n I1712_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I176_XG_MN0 (XI1712_I176_XG_n1 I1712_P25_18 I1712_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I176_XG_MN1 (VSS I1712_G17_10 XI1712_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I170_XG_MN2 (I1712_G19_4n I1712_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I170_XG_MN0 (XI1712_I170_XG_n1 I1712_P19_12 I1712_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I170_XG_MN1 (VSS I1712_G11_4 XI1712_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I112_XG_MN2 (I1758_G16_13n I1758_G16_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I112_XG_MN0 (XI1758_I112_XG_n1 I1758_P16_15 I1758_G16_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I112_XG_MN1 (VSS I1758_G14_13 XI1758_I112_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I171_XG_MN2 (I1758_G20_5n I1758_G20_13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I171_XG_MN0 (XI1758_I171_XG_n1 I1758_P20_13 I1758_G20_5n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I171_XG_MN1 (VSS I1758_G12_5 XI1758_I171_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I177_XG_MN2 (I1758_G26_11n I1758_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I177_XG_MN0 (XI1758_I177_XG_n1 I1758_P26_19 I1758_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I177_XG_MN1 (VSS I1758_G18_11 XI1758_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I111_XG_MN2 (I1758_G15_12n I1758_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I111_XG_MN0 (XI1758_I111_XG_n1 I1758_P15_14 I1758_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I111_XG_MN1 (VSS I1758_G13_12 XI1758_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I164_XG_MN2 (I1758_G13_0n I1758_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I164_XG_MN0 (XI1758_I164_XG_n1 I1758_P13_6 I1758_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I164_XG_MN1 (VSS I1758_G5_0 XI1758_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I170_XG_MN2 (I1758_G19_4n I1758_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I170_XG_MN0 (XI1758_I170_XG_n1 I1758_P19_12 I1758_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I170_XG_MN1 (VSS I1758_G11_4 XI1758_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I111_XG_MN2 (I1804_G15_12n I1804_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I111_XG_MN0 (XI1804_I111_XG_n1 I1804_P15_14 I1804_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I111_XG_MN1 (VSS I1804_G13_12 XI1804_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I164_XG_MN2 (I1804_G13_0n I1804_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I164_XG_MN0 (XI1804_I164_XG_n1 I1804_P13_6 I1804_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I164_XG_MN1 (VSS I1804_G5_0 XI1804_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I116_XG_MN2 (I1804_G20_17n I1804_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I116_XG_MN0 (XI1804_I116_XG_n1 I1804_P20_19 I1804_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I116_XG_MN1 (VSS I1804_G18_17 XI1804_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I181_XG_MN2 (I1804_G30_15n I1804_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I181_XG_MN0 (XI1804_I181_XG_n1 I1804_P30_23 I1804_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I181_XG_MN1 (VSS I1804_G22_15 XI1804_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I127_XG_MN2 (I746_G31_28n I746_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I127_XG_MN0 (XI746_I127_XG_n1 I746_P31_30 I746_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I127_XG_MN1 (VSS I746_G29_28 XI746_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I125_XG_MN2 (I746_G29_26n I746_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I125_XG_MN0 (XI746_I125_XG_n1 I746_P29_28 I746_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I125_XG_MN1 (VSS I746_G27_26 XI746_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I120_XG_MN2 (I746_G24_21n I746_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I120_XG_MN0 (XI746_I120_XG_n1 I746_P24_23 I746_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I120_XG_MN1 (VSS I746_G22_21 XI746_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I179_XG_MN2 (I746_G28_13n I746_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I179_XG_MN0 (XI746_I179_XG_n1 I746_P28_21 I746_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I179_XG_MN1 (VSS I746_G20_13 XI746_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I173_XG_MN2 (I746_G22_7n I746_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I173_XG_MN0 (XI746_I173_XG_n1 I746_P22_15 I746_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I173_XG_MN1 (VSS I746_G14_7 XI746_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I165_XG_MN2 (I746_G14_0n I746_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I165_XG_MN0 (XI746_I165_XG_n1 I746_P14_7 I746_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I165_XG_MN1 (VSS I746_G6_0 XI746_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I117_XG_MN2 (I792_G21_18n I792_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I117_XG_MN0 (XI792_I117_XG_n1 I792_P21_20 I792_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I117_XG_MN1 (VSS I792_G19_18 XI792_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I176_XG_MN2 (I792_G25_10n I792_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I176_XG_MN0 (XI792_I176_XG_n1 I792_P25_18 I792_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I176_XG_MN1 (VSS I792_G17_10 XI792_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I172_XG_MN2 (I792_G21_6n I792_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I172_XG_MN0 (XI792_I172_XG_n1 I792_P21_14 I792_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I172_XG_MN1 (VSS I792_G13_6 XI792_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I179_XG_MN2 (I792_G28_13n I792_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I179_XG_MN0 (XI792_I179_XG_n1 I792_P28_21 I792_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I179_XG_MN1 (VSS I792_G20_13 XI792_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I165_XG_MN2 (I792_G14_0n I792_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I165_XG_MN0 (XI792_I165_XG_n1 I792_P14_7 I792_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I165_XG_MN1 (VSS I792_G6_0 XI792_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I115_XG_MN2 (I838_G19_16n I838_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I115_XG_MN0 (XI838_I115_XG_n1 I838_P19_18 I838_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I115_XG_MN1 (VSS I838_G17_16 XI838_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I178_XG_MN2 (I838_G27_12n I838_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I178_XG_MN0 (XI838_I178_XG_n1 I838_P27_20 I838_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I178_XG_MN1 (VSS I838_G19_12 XI838_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I166_XG_MN2 (I838_G15_0n I838_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I166_XG_MN0 (XI838_I166_XG_n1 I838_P15_8 I838_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I166_XG_MN1 (VSS I838_G7_0 XI838_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I117_XG_MN2 (I838_G21_18n I838_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I117_XG_MN0 (XI838_I117_XG_n1 I838_P21_20 I838_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I117_XG_MN1 (VSS I838_G19_18 XI838_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I114_XG_MN2 (I838_G18_15n I838_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I114_XG_MN0 (XI838_I114_XG_n1 I838_P18_17 I838_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I114_XG_MN1 (VSS I838_G16_15 XI838_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I116_XG_MN2 (I838_G20_17n I838_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I116_XG_MN0 (XI838_I116_XG_n1 I838_P20_19 I838_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I116_XG_MN1 (VSS I838_G18_17 XI838_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I179_XG_MN2 (I838_G28_13n I838_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I179_XG_MN0 (XI838_I179_XG_n1 I838_P28_21 I838_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I179_XG_MN1 (VSS I838_G20_13 XI838_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I165_XG_MN2 (I838_G14_0n I838_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I165_XG_MN0 (XI838_I165_XG_n1 I838_P14_7 I838_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I165_XG_MN1 (VSS I838_G6_0 XI838_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I114_XG_MN2 (I884_G18_15n I884_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I114_XG_MN0 (XI884_I114_XG_n1 I884_P18_17 I884_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I114_XG_MN1 (VSS I884_G16_15 XI884_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I116_XG_MN2 (I884_G20_17n I884_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I116_XG_MN0 (XI884_I116_XG_n1 I884_P20_19 I884_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I116_XG_MN1 (VSS I884_G18_17 XI884_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I173_XG_MN2 (I884_G22_7n I884_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I173_XG_MN0 (XI884_I173_XG_n1 I884_P22_15 I884_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I173_XG_MN1 (VSS I884_G14_7 XI884_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I113_XG_MN2 (I884_G17_14n I884_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I113_XG_MN0 (XI884_I113_XG_n1 I884_P17_16 I884_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I113_XG_MN1 (VSS I884_G15_14 XI884_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I172_XG_MN2 (I884_G21_6n I884_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I172_XG_MN0 (XI884_I172_XG_n1 I884_P21_14 I884_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I172_XG_MN1 (VSS I884_G13_6 XI884_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I177_XG_MN2 (I1712_G26_11n I1712_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I177_XG_MN0 (XI1712_I177_XG_n1 I1712_P26_19 I1712_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I177_XG_MN1 (VSS I1712_G18_11 XI1712_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I179_XG_MN2 (I1712_G28_13n I1712_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I179_XG_MN0 (XI1712_I179_XG_n1 I1712_P28_21 I1712_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I179_XG_MN1 (VSS I1712_G20_13 XI1712_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I111_XG_MN2 (I1712_G15_12n I1712_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I111_XG_MN0 (XI1712_I111_XG_n1 I1712_P15_14 I1712_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I111_XG_MN1 (VSS I1712_G13_12 XI1712_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I164_XG_MN2 (I1712_G13_0n I1712_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I164_XG_MN0 (XI1712_I164_XG_n1 I1712_P13_6 I1712_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I164_XG_MN1 (VSS I1712_G5_0 XI1712_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I114_XG_MN2 (I1758_G18_15n I1758_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I114_XG_MN0 (XI1758_I114_XG_n1 I1758_P18_17 I1758_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I114_XG_MN1 (VSS I1758_G16_15 XI1758_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I179_XG_MN2 (I1758_G28_13n I1758_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I179_XG_MN0 (XI1758_I179_XG_n1 I1758_P28_21 I1758_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I179_XG_MN1 (VSS I1758_G20_13 XI1758_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I165_XG_MN2 (I1758_G14_0n I1758_G14_7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I165_XG_MN0 (XI1758_I165_XG_n1 I1758_P14_7 I1758_G14_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I165_XG_MN1 (VSS I1758_G6_0 XI1758_I165_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I113_XG_MN2 (I1758_G17_14n I1758_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I113_XG_MN0 (XI1758_I113_XG_n1 I1758_P17_16 I1758_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I113_XG_MN1 (VSS I1758_G15_14 XI1758_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I172_XG_MN2 (I1758_G21_6n I1758_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I172_XG_MN0 (XI1758_I172_XG_n1 I1758_P21_14 I1758_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I172_XG_MN1 (VSS I1758_G13_6 XI1758_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I166_XG_MN2 (I1804_G15_0n I1804_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I166_XG_MN0 (XI1804_I166_XG_n1 I1804_P15_8 I1804_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I166_XG_MN1 (VSS I1804_G7_0 XI1804_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I113_XG_MN2 (I1804_G17_14n I1804_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I113_XG_MN0 (XI1804_I113_XG_n1 I1804_P17_16 I1804_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I113_XG_MN1 (VSS I1804_G15_14 XI1804_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I178_XG_MN2 (I1804_G27_12n I1804_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I178_XG_MN0 (XI1804_I178_XG_n1 I1804_P27_20 I1804_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I178_XG_MN1 (VSS I1804_G19_12 XI1804_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I176_XG_MN2 (I1804_G25_10n I1804_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I176_XG_MN0 (XI1804_I176_XG_n1 I1804_P25_18 I1804_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I176_XG_MN1 (VSS I1804_G17_10 XI1804_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I172_XG_MN2 (I1804_G21_6n I1804_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I172_XG_MN0 (XI1804_I172_XG_n1 I1804_P21_14 I1804_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I172_XG_MN1 (VSS I1804_G13_6 XI1804_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I180_XG_MN2 (I1804_G29_14n I1804_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I180_XG_MN0 (XI1804_I180_XG_n1 I1804_P29_22 I1804_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I180_XG_MN1 (VSS I1804_G21_14 XI1804_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I118_XG_MN2 (I1804_G22_19n I1804_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I118_XG_MN0 (XI1804_I118_XG_n1 I1804_P22_21 I1804_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I118_XG_MN1 (VSS I1804_G20_19 XI1804_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I122_XG_MN2 (I746_G26_23n I746_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I122_XG_MN0 (XI746_I122_XG_n1 I746_P26_25 I746_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I122_XG_MN1 (VSS I746_G24_23 XI746_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I124_XG_MN2 (I746_G28_25n I746_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I124_XG_MN0 (XI746_I124_XG_n1 I746_P28_27 I746_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I124_XG_MN1 (VSS I746_G26_25 XI746_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I177_XG_MN2 (I746_G26_11n I746_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I177_XG_MN0 (XI746_I177_XG_n1 I746_P26_19 I746_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I177_XG_MN1 (VSS I746_G18_11 XI746_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I119_XG_MN2 (I792_G23_20n I792_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I119_XG_MN0 (XI792_I119_XG_n1 I792_P23_22 I792_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I119_XG_MN1 (VSS I792_G21_20 XI792_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I180_XG_MN2 (I792_G29_14n I792_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I180_XG_MN0 (XI792_I180_XG_n1 I792_P29_22 I792_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I180_XG_MN1 (VSS I792_G21_14 XI792_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I118_XG_MN2 (I792_G22_19n I792_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I118_XG_MN0 (XI792_I118_XG_n1 I792_P22_21 I792_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I118_XG_MN1 (VSS I792_G20_19 XI792_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I120_XG_MN2 (I792_G24_21n I792_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I120_XG_MN0 (XI792_I120_XG_n1 I792_P24_23 I792_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I120_XG_MN1 (VSS I792_G22_21 XI792_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I173_XG_MN2 (I792_G22_7n I792_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I173_XG_MN0 (XI792_I173_XG_n1 I792_P22_15 I792_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I173_XG_MN1 (VSS I792_G14_7 XI792_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I174_XG_MN2 (I838_G23_8n I838_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I174_XG_MN0 (XI838_I174_XG_n1 I838_P23_16 I838_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I174_XG_MN1 (VSS I838_G15_8 XI838_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I118_XG_MN2 (I838_G22_19n I838_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I118_XG_MN0 (XI838_I118_XG_n1 I838_P22_21 I838_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I118_XG_MN1 (VSS I838_G20_19 XI838_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I173_XG_MN2 (I838_G22_7n I838_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I173_XG_MN0 (XI838_I173_XG_n1 I838_P22_15 I838_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I173_XG_MN1 (VSS I838_G14_7 XI838_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I179_XG_MN2 (I884_G28_13n I884_G28_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I179_XG_MN0 (XI884_I179_XG_n1 I884_P28_21 I884_G28_13n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I179_XG_MN1 (VSS I884_G20_13 XI884_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I115_XG_MN2 (I884_G19_16n I884_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I115_XG_MN0 (XI884_I115_XG_n1 I884_P19_18 I884_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I115_XG_MN1 (VSS I884_G17_16 XI884_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I117_XG_MN2 (I884_G21_18n I884_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I117_XG_MN0 (XI884_I117_XG_n1 I884_P21_20 I884_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I117_XG_MN1 (VSS I884_G19_18 XI884_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I162_XG_MN2 (I884_G11_0n I884_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I162_XG_MN0 (XI884_I162_XG_n1 I884_P11_4 I884_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I162_XG_MN1 (VSS I884_G3_0np XI884_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I170_XG_MN2 (I884_G19_4n I884_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I170_XG_MN0 (XI884_I170_XG_n1 I884_P19_12 I884_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I170_XG_MN1 (VSS I884_G11_4 XI884_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I114_XG_MN2 (I1712_G18_15n I1712_G18_17 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I114_XG_MN0 (XI1712_I114_XG_n1 I1712_P18_17 I1712_G18_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I114_XG_MN1 (VSS I1712_G16_15 XI1712_I114_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I113_XG_MN2 (I1712_G17_14n I1712_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I113_XG_MN0 (XI1712_I113_XG_n1 I1712_P17_16 I1712_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I113_XG_MN1 (VSS I1712_G15_14 XI1712_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I172_XG_MN2 (I1712_G21_6n I1712_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I172_XG_MN0 (XI1712_I172_XG_n1 I1712_P21_14 I1712_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I172_XG_MN1 (VSS I1712_G13_6 XI1712_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I178_XG_MN2 (I1712_G27_12n I1712_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I178_XG_MN0 (XI1712_I178_XG_n1 I1712_P27_20 I1712_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I178_XG_MN1 (VSS I1712_G19_12 XI1712_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I166_XG_MN2 (I1712_G15_0n I1712_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I166_XG_MN0 (XI1712_I166_XG_n1 I1712_P15_8 I1712_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I166_XG_MN1 (VSS I1712_G7_0 XI1712_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I116_XG_MN2 (I1758_G20_17n I1758_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I116_XG_MN0 (XI1758_I116_XG_n1 I1758_P20_19 I1758_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I116_XG_MN1 (VSS I1758_G18_17 XI1758_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I173_XG_MN2 (I1758_G22_7n I1758_G22_15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I173_XG_MN0 (XI1758_I173_XG_n1 I1758_P22_15 I1758_G22_7n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I173_XG_MN1 (VSS I1758_G14_7 XI1758_I173_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I115_XG_MN2 (I1758_G19_16n I1758_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I115_XG_MN0 (XI1758_I115_XG_n1 I1758_P19_18 I1758_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I115_XG_MN1 (VSS I1758_G17_16 XI1758_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I117_XG_MN2 (I1758_G21_18n I1758_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I117_XG_MN0 (XI1758_I117_XG_n1 I1758_P21_20 I1758_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I117_XG_MN1 (VSS I1758_G19_18 XI1758_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I178_XG_MN2 (I1758_G27_12n I1758_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I178_XG_MN0 (XI1758_I178_XG_n1 I1758_P27_20 I1758_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I178_XG_MN1 (VSS I1758_G19_12 XI1758_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I166_XG_MN2 (I1758_G15_0n I1758_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I166_XG_MN0 (XI1758_I166_XG_n1 I1758_P15_8 I1758_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I166_XG_MN1 (VSS I1758_G7_0 XI1758_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I174_XG_MN2 (I1804_G23_8n I1804_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I174_XG_MN0 (XI1804_I174_XG_n1 I1804_P23_16 I1804_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I174_XG_MN1 (VSS I1804_G15_8 XI1804_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I115_XG_MN2 (I1804_G19_16n I1804_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I115_XG_MN0 (XI1804_I115_XG_n1 I1804_P19_18 I1804_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I115_XG_MN1 (VSS I1804_G17_16 XI1804_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I117_XG_MN2 (I1804_G21_18n I1804_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I117_XG_MN0 (XI1804_I117_XG_n1 I1804_P21_20 I1804_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I117_XG_MN1 (VSS I1804_G19_18 XI1804_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I120_XG_MN2 (I1804_G24_21n I1804_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I120_XG_MN0 (XI1804_I120_XG_n1 I1804_P24_23 I1804_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I120_XG_MN1 (VSS I1804_G22_21 XI1804_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I124_XG_MN2 (I1804_G28_25n I1804_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I124_XG_MN0 (XI1804_I124_XG_n1 I1804_P28_27 I1804_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I124_XG_MN1 (VSS I1804_G26_25 XI1804_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I122_XG_MN2 (I1804_G26_23n I1804_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I122_XG_MN0 (XI1804_I122_XG_n1 I1804_P26_25 I1804_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I122_XG_MN1 (VSS I1804_G24_23 XI1804_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I126_XG_MN2 (I746_G30_27n I746_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I126_XG_MN0 (XI746_I126_XG_n1 I746_P30_29 I746_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I126_XG_MN1 (VSS I746_G28_27 XI746_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I181_XG_MN2 (I746_G30_15n I746_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI746_I181_XG_MN0 (XI746_I181_XG_n1 I746_P30_23 I746_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI746_I181_XG_MN1 (VSS I746_G22_15 XI746_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I121_XG_MN2 (I792_G25_22n I792_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I121_XG_MN0 (XI792_I121_XG_n1 I792_P25_24 I792_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I121_XG_MN1 (VSS I792_G23_22 XI792_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I123_XG_MN2 (I792_G27_24n I792_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I123_XG_MN0 (XI792_I123_XG_n1 I792_P27_26 I792_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I123_XG_MN1 (VSS I792_G25_24 XI792_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I178_XG_MN2 (I792_G27_12n I792_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I178_XG_MN0 (XI792_I178_XG_n1 I792_P27_20 I792_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I178_XG_MN1 (VSS I792_G19_12 XI792_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I166_XG_MN2 (I792_G15_0n I792_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I166_XG_MN0 (XI792_I166_XG_n1 I792_P15_8 I792_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I166_XG_MN1 (VSS I792_G7_0 XI792_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I124_XG_MN2 (I792_G28_25n I792_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I124_XG_MN0 (XI792_I124_XG_n1 I792_P28_27 I792_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I124_XG_MN1 (VSS I792_G26_25 XI792_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I122_XG_MN2 (I792_G26_23n I792_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I122_XG_MN0 (XI792_I122_XG_n1 I792_P26_25 I792_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I122_XG_MN1 (VSS I792_G24_23 XI792_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I177_XG_MN2 (I792_G26_11n I792_G26_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I177_XG_MN0 (XI792_I177_XG_n1 I792_P26_19 I792_G26_11n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I177_XG_MN1 (VSS I792_G18_11 XI792_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I182_XG_MN2 (I838_G31_16n I838_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I182_XG_MN0 (XI838_I182_XG_n1 I838_P31_24 I838_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I182_XG_MN1 (VSS I838_G23_16 XI838_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I119_XG_MN2 (I838_G23_20n I838_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I119_XG_MN0 (XI838_I119_XG_n1 I838_P23_22 I838_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I119_XG_MN1 (VSS I838_G21_20 XI838_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I181_XG_MN2 (I838_G30_15n I838_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I181_XG_MN0 (XI838_I181_XG_n1 I838_P30_23 I838_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I181_XG_MN1 (VSS I838_G22_15 XI838_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I118_XG_MN2 (I884_G22_19n I884_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I118_XG_MN0 (XI884_I118_XG_n1 I884_P22_21 I884_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I118_XG_MN1 (VSS I884_G20_19 XI884_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I181_XG_MN2 (I884_G30_15n I884_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I181_XG_MN0 (XI884_I181_XG_n1 I884_P30_23 I884_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I181_XG_MN1 (VSS I884_G22_15 XI884_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I120_XG_MN2 (I884_G24_21n I884_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I120_XG_MN0 (XI884_I120_XG_n1 I884_P24_23 I884_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I120_XG_MN1 (VSS I884_G22_21 XI884_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I180_XG_MN2 (I884_G29_14n I884_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I180_XG_MN0 (XI884_I180_XG_n1 I884_P29_22 I884_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I180_XG_MN1 (VSS I884_G21_14 XI884_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I178_XG_MN2 (I884_G27_12n I884_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I178_XG_MN0 (XI884_I178_XG_n1 I884_P27_20 I884_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I178_XG_MN1 (VSS I884_G19_12 XI884_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I181_XG_MN2 (I1712_G30_15n I1712_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I181_XG_MN0 (XI1712_I181_XG_n1 I1712_P30_23 I1712_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I181_XG_MN1 (VSS I1712_G22_15 XI1712_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I118_XG_MN2 (I1712_G22_19n I1712_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I118_XG_MN0 (XI1712_I118_XG_n1 I1712_P22_21 I1712_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I118_XG_MN1 (VSS I1712_G20_19 XI1712_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I116_XG_MN2 (I1712_G20_17n I1712_G20_19 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I116_XG_MN0 (XI1712_I116_XG_n1 I1712_P20_19 I1712_G20_17n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I116_XG_MN1 (VSS I1712_G18_17 XI1712_I116_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I115_XG_MN2 (I1712_G19_16n I1712_G19_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I115_XG_MN0 (XI1712_I115_XG_n1 I1712_P19_18 I1712_G19_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I115_XG_MN1 (VSS I1712_G17_16 XI1712_I115_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I117_XG_MN2 (I1712_G21_18n I1712_G21_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I117_XG_MN0 (XI1712_I117_XG_n1 I1712_P21_20 I1712_G21_18n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I117_XG_MN1 (VSS I1712_G19_18 XI1712_I117_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I180_XG_MN2 (I1712_G29_14n I1712_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I180_XG_MN0 (XI1712_I180_XG_n1 I1712_P29_22 I1712_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I180_XG_MN1 (VSS I1712_G21_14 XI1712_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I118_XG_MN2 (I1758_G22_19n I1758_G22_21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I118_XG_MN0 (XI1758_I118_XG_n1 I1758_P22_21 I1758_G22_19n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I118_XG_MN1 (VSS I1758_G20_19 XI1758_I118_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I120_XG_MN2 (I1758_G24_21n I1758_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I120_XG_MN0 (XI1758_I120_XG_n1 I1758_P24_23 I1758_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I120_XG_MN1 (VSS I1758_G22_21 XI1758_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I181_XG_MN2 (I1758_G30_15n I1758_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I181_XG_MN0 (XI1758_I181_XG_n1 I1758_P30_23 I1758_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I181_XG_MN1 (VSS I1758_G22_15 XI1758_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I119_XG_MN2 (I1758_G23_20n I1758_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I119_XG_MN0 (XI1758_I119_XG_n1 I1758_P23_22 I1758_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I119_XG_MN1 (VSS I1758_G21_20 XI1758_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I180_XG_MN2 (I1758_G29_14n I1758_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I180_XG_MN0 (XI1758_I180_XG_n1 I1758_P29_22 I1758_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I180_XG_MN1 (VSS I1758_G21_14 XI1758_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I174_XG_MN2 (I1758_G23_8n I1758_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I174_XG_MN0 (XI1758_I174_XG_n1 I1758_P23_16 I1758_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I174_XG_MN1 (VSS I1758_G15_8 XI1758_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I119_XG_MN2 (I1804_G23_20n I1804_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I119_XG_MN0 (XI1804_I119_XG_n1 I1804_P23_22 I1804_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I119_XG_MN1 (VSS I1804_G21_20 XI1804_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I126_XG_MN2 (I1804_G30_27n I1804_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I126_XG_MN0 (XI1804_I126_XG_n1 I1804_P30_29 I1804_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I126_XG_MN1 (VSS I1804_G28_27 XI1804_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I127_XG_MN2 (I792_G31_28n I792_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I127_XG_MN0 (XI792_I127_XG_n1 I792_P31_30 I792_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I127_XG_MN1 (VSS I792_G29_28 XI792_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I125_XG_MN2 (I792_G29_26n I792_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I125_XG_MN0 (XI792_I125_XG_n1 I792_P29_28 I792_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I125_XG_MN1 (VSS I792_G27_26 XI792_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I182_XG_MN2 (I792_G31_16n I792_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I182_XG_MN0 (XI792_I182_XG_n1 I792_P31_24 I792_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I182_XG_MN1 (VSS I792_G23_16 XI792_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I174_XG_MN2 (I792_G23_8n I792_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I174_XG_MN0 (XI792_I174_XG_n1 I792_P23_16 I792_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I174_XG_MN1 (VSS I792_G15_8 XI792_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I126_XG_MN2 (I792_G30_27n I792_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I126_XG_MN0 (XI792_I126_XG_n1 I792_P30_29 I792_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I126_XG_MN1 (VSS I792_G28_27 XI792_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I181_XG_MN2 (I792_G30_15n I792_G30_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI792_I181_XG_MN0 (XI792_I181_XG_n1 I792_P30_23 I792_G30_15n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI792_I181_XG_MN1 (VSS I792_G22_15 XI792_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I127_XG_MN2 (I838_G31_28n I838_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I127_XG_MN0 (XI838_I127_XG_n1 I838_P31_30 I838_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I127_XG_MN1 (VSS I838_G29_28 XI838_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I125_XG_MN2 (I838_G29_26n I838_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I125_XG_MN0 (XI838_I125_XG_n1 I838_P29_28 I838_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I125_XG_MN1 (VSS I838_G27_26 XI838_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I123_XG_MN2 (I838_G27_24n I838_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I123_XG_MN0 (XI838_I123_XG_n1 I838_P27_26 I838_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I123_XG_MN1 (VSS I838_G25_24 XI838_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I121_XG_MN2 (I838_G25_22n I838_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I121_XG_MN0 (XI838_I121_XG_n1 I838_P25_24 I838_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I121_XG_MN1 (VSS I838_G23_22 XI838_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I120_XG_MN2 (I838_G24_21n I838_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I120_XG_MN0 (XI838_I120_XG_n1 I838_P24_23 I838_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I120_XG_MN1 (VSS I838_G22_21 XI838_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I122_XG_MN2 (I838_G26_23n I838_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I122_XG_MN0 (XI838_I122_XG_n1 I838_P26_25 I838_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I122_XG_MN1 (VSS I838_G24_23 XI838_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I122_XG_MN2 (I884_G26_23n I884_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I122_XG_MN0 (XI884_I122_XG_n1 I884_P26_25 I884_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I122_XG_MN1 (VSS I884_G24_23 XI884_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I119_XG_MN2 (I884_G23_20n I884_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I119_XG_MN0 (XI884_I119_XG_n1 I884_P23_22 I884_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I119_XG_MN1 (VSS I884_G21_20 XI884_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I121_XG_MN2 (I884_G25_22n I884_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I121_XG_MN0 (XI884_I121_XG_n1 I884_P25_24 I884_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I121_XG_MN1 (VSS I884_G23_22 XI884_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I122_XG_MN2 (I1712_G26_23n I1712_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I122_XG_MN0 (XI1712_I122_XG_n1 I1712_P26_25 I1712_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I122_XG_MN1 (VSS I1712_G24_23 XI1712_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I120_XG_MN2 (I1712_G24_21n I1712_G24_23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I120_XG_MN0 (XI1712_I120_XG_n1 I1712_P24_23 I1712_G24_21n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I120_XG_MN1 (VSS I1712_G22_21 XI1712_I120_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I119_XG_MN2 (I1712_G23_20n I1712_G23_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I119_XG_MN0 (XI1712_I119_XG_n1 I1712_P23_22 I1712_G23_20n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I119_XG_MN1 (VSS I1712_G21_20 XI1712_I119_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I182_XG_MN2 (I1712_G31_16n I1712_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I182_XG_MN0 (XI1712_I182_XG_n1 I1712_P31_24 I1712_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I182_XG_MN1 (VSS I1712_G23_16 XI1712_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I174_XG_MN2 (I1712_G23_8n I1712_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I174_XG_MN0 (XI1712_I174_XG_n1 I1712_P23_16 I1712_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I174_XG_MN1 (VSS I1712_G15_8 XI1712_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I122_XG_MN2 (I1758_G26_23n I1758_G26_25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I122_XG_MN0 (XI1758_I122_XG_n1 I1758_P26_25 I1758_G26_23n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I122_XG_MN1 (VSS I1758_G24_23 XI1758_I122_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I121_XG_MN2 (I1758_G25_22n I1758_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I121_XG_MN0 (XI1758_I121_XG_n1 I1758_P25_24 I1758_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I121_XG_MN1 (VSS I1758_G23_22 XI1758_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I123_XG_MN2 (I1758_G27_24n I1758_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I123_XG_MN0 (XI1758_I123_XG_n1 I1758_P27_26 I1758_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I123_XG_MN1 (VSS I1758_G25_24 XI1758_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I125_XG_MN2 (I1758_G29_26n I1758_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I125_XG_MN0 (XI1758_I125_XG_n1 I1758_P29_28 I1758_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I125_XG_MN1 (VSS I1758_G27_26 XI1758_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I182_XG_MN2 (I1758_G31_16n I1758_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I182_XG_MN0 (XI1758_I182_XG_n1 I1758_P31_24 I1758_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I182_XG_MN1 (VSS I1758_G23_16 XI1758_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I182_XG_MN2 (I1804_G31_16n I1804_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I182_XG_MN0 (XI1804_I182_XG_n1 I1804_P31_24 I1804_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I182_XG_MN1 (VSS I1804_G23_16 XI1804_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I121_XG_MN2 (I1804_G25_22n I1804_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I121_XG_MN0 (XI1804_I121_XG_n1 I1804_P25_24 I1804_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I121_XG_MN1 (VSS I1804_G23_22 XI1804_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I125_XG_MN2 (I1804_G29_26n I1804_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I125_XG_MN0 (XI1804_I125_XG_n1 I1804_P29_28 I1804_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I125_XG_MN1 (VSS I1804_G27_26 XI1804_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I123_XG_MN2 (I1804_G27_24n I1804_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I123_XG_MN0 (XI1804_I123_XG_n1 I1804_P27_26 I1804_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I123_XG_MN1 (VSS I1804_G25_24 XI1804_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2153_MN2 (nqkn26 nqk25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2153_MN0 (XI2153_n1 sq_b3_4 nqkn26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2153_MN1 (VSS qu25_b3_5 XI2153_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2156_MN2 (nqkn27 nqk26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2156_MN0 (XI2156_n1 sq_b3_4 nqkn27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2156_MN1 (VSS qu26_b3_5 XI2156_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I124_XG_MN2 (I838_G28_25n I838_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I124_XG_MN0 (XI838_I124_XG_n1 I838_P28_27 I838_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I124_XG_MN1 (VSS I838_G26_25 XI838_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I126_XG_MN2 (I838_G30_27n I838_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI838_I126_XG_MN0 (XI838_I126_XG_n1 I838_P30_29 I838_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI838_I126_XG_MN1 (VSS I838_G28_27 XI838_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I124_XG_MN2 (I884_G28_25n I884_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I124_XG_MN0 (XI884_I124_XG_n1 I884_P28_27 I884_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I124_XG_MN1 (VSS I884_G26_25 XI884_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I123_XG_MN2 (I884_G27_24n I884_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I123_XG_MN0 (XI884_I123_XG_n1 I884_P27_26 I884_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I123_XG_MN1 (VSS I884_G25_24 XI884_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I182_XG_MN2 (I884_G31_16n I884_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I182_XG_MN0 (XI884_I182_XG_n1 I884_P31_24 I884_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I182_XG_MN1 (VSS I884_G23_16 XI884_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I174_XG_MN2 (I884_G23_8n I884_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I174_XG_MN0 (XI884_I174_XG_n1 I884_P23_16 I884_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I174_XG_MN1 (VSS I884_G15_8 XI884_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I166_XG_MN2 (I884_G15_0n I884_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I166_XG_MN0 (XI884_I166_XG_n1 I884_P15_8 I884_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I166_XG_MN1 (VSS I884_G7_0 XI884_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I124_XG_MN2 (I1712_G28_25n I1712_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I124_XG_MN0 (XI1712_I124_XG_n1 I1712_P28_27 I1712_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I124_XG_MN1 (VSS I1712_G26_25 XI1712_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I126_XG_MN2 (I1712_G30_27n I1712_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I126_XG_MN0 (XI1712_I126_XG_n1 I1712_P30_29 I1712_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I126_XG_MN1 (VSS I1712_G28_27 XI1712_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I121_XG_MN2 (I1712_G25_22n I1712_G25_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I121_XG_MN0 (XI1712_I121_XG_n1 I1712_P25_24 I1712_G25_22n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I121_XG_MN1 (VSS I1712_G23_22 XI1712_I121_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I123_XG_MN2 (I1712_G27_24n I1712_G27_26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I123_XG_MN0 (XI1712_I123_XG_n1 I1712_P27_26 I1712_G27_24n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I123_XG_MN1 (VSS I1712_G25_24 XI1712_I123_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I125_XG_MN2 (I1712_G29_26n I1712_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I125_XG_MN0 (XI1712_I125_XG_n1 I1712_P29_28 I1712_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I125_XG_MN1 (VSS I1712_G27_26 XI1712_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I127_XG_MN2 (I1712_G31_28n I1712_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1712_I127_XG_MN0 (XI1712_I127_XG_n1 I1712_P31_30 I1712_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1712_I127_XG_MN1 (VSS I1712_G29_28 XI1712_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I124_XG_MN2 (I1758_G28_25n I1758_G28_27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I124_XG_MN0 (XI1758_I124_XG_n1 I1758_P28_27 I1758_G28_25n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I124_XG_MN1 (VSS I1758_G26_25 XI1758_I124_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I126_XG_MN2 (I1758_G30_27n I1758_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I126_XG_MN0 (XI1758_I126_XG_n1 I1758_P30_29 I1758_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I126_XG_MN1 (VSS I1758_G28_27 XI1758_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I127_XG_MN2 (I1758_G31_28n I1758_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1758_I127_XG_MN0 (XI1758_I127_XG_n1 I1758_P31_30 I1758_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1758_I127_XG_MN1 (VSS I1758_G29_28 XI1758_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I127_XG_MN2 (I1804_G31_28n I1804_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1804_I127_XG_MN0 (XI1804_I127_XG_n1 I1804_P31_30 I1804_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1804_I127_XG_MN1 (VSS I1804_G29_28 XI1804_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I180_XG_MN2 (I1068_G29_14n I1068_G29_22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I180_XG_MN0 (XI1068_I180_XG_n1 I1068_P29_22 I1068_G29_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I180_XG_MN1 (VSS I1068_G21_14 XI1068_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I176_XG_MN2 (I1068_G25_10n I1068_G25_18 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I176_XG_MN0 (XI1068_I176_XG_n1 I1068_P25_18 I1068_G25_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I176_XG_MN1 (VSS I1068_G17_10 XI1068_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I172_XG_MN2 (I1068_G21_6n I1068_G21_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I172_XG_MN0 (XI1068_I172_XG_n1 I1068_P21_14 I1068_G21_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I172_XG_MN1 (VSS I1068_G13_6 XI1068_I172_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I164_XG_MN2 (I1068_G13_0n I1068_G13_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I164_XG_MN0 (XI1068_I164_XG_n1 I1068_P13_6 I1068_G13_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I164_XG_MN1 (VSS I1068_G5_0 XI1068_I164_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I168_XG_MN2 (I1068_G17_2n I1068_G17_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I168_XG_MN0 (XI1068_I168_XG_n1 I1068_P17_10 I1068_G17_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I168_XG_MN1 (VSS I1068_G9_2 XI1068_I168_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I158_XG_MN2 (I1068_G9_0n I1068_G9_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I158_XG_MN0 (XI1068_I158_XG_n1 I1068_P9_2 I1068_G9_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I158_XG_MN1 (VSS I1068_G1_0 XI1068_I158_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I101_XG_MN2 (I1068_G5_2n I1068_G5_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I101_XG_MN0 (XI1068_I101_XG_n1 I1068_P5_4 I1068_G5_2n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I101_XG_MN1 (VSS I1068_G3_2 XI1068_I101_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I99_XG_MN2 (I1068_G3_0n I1068_G3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I99_XG_MN0 (XI1068_I99_XG_n1 I1068_P3_2 I1068_G3_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I99_XG_MN1 (VSS I1068_G1_0 XI1068_I99_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2150_MN2 (nqkn25 nqk24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2150_MN0 (XI2150_n1 sq_b3_4 nqkn25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2150_MN1 (VSS qu24_b3_5 XI2150_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI99_MN2 (nakn22 nak21 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI99_MN0 (XI99_n1 A_31_b3_3 nakn22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI99_MN1 (VSS A_21 XI99_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI102_MN2 (nakn23 nak22 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI102_MN0 (XI102_n1 A_31_b3_3 nakn23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI102_MN1 (VSS A_22 XI102_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I126_XG_MN2 (I884_G30_27n I884_G30_29 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I126_XG_MN0 (XI884_I126_XG_n1 I884_P30_29 I884_G30_27n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I126_XG_MN1 (VSS I884_G28_27 XI884_I126_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I125_XG_MN2 (I884_G29_26n I884_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I125_XG_MN0 (XI884_I125_XG_n1 I884_P29_28 I884_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I125_XG_MN1 (VSS I884_G27_26 XI884_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I127_XG_MN2 (I884_G31_28n I884_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI884_I127_XG_MN0 (XI884_I127_XG_n1 I884_P31_30 I884_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI884_I127_XG_MN1 (VSS I884_G29_28 XI884_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2096_MN2 (nqkn7 nqk6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2096_MN0 (XI2096_n1 sq_b3_1 nqkn7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2096_MN1 (VSS qu6_b3_5 XI2096_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2099_MN2 (nqkn8 nqk7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2099_MN0 (XI2099_n1 sq_b3_1 nqkn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2099_MN1 (VSS qu7_b3_5 XI2099_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I170_XG_MN2 (I1068_G19_4n I1068_G19_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I170_XG_MN0 (XI1068_I170_XG_n1 I1068_P19_12 I1068_G19_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I170_XG_MN1 (VSS I1068_G11_4 XI1068_I170_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I162_XG_MN2 (I1068_G11_0n I1068_G11_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I162_XG_MN0 (XI1068_I162_XG_n1 I1068_P11_4 I1068_G11_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I162_XG_MN1 (VSS I1068_G3_0np XI1068_I162_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I105_XG_MN2 (I1068_G9_6n I1068_G9_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I105_XG_MN0 (XI1068_I105_XG_n1 I1068_P9_8 I1068_G9_6n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I105_XG_MN1 (VSS I1068_G7_6 XI1068_I105_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I103_XG_MN2 (I1068_G7_4n I1068_G7_6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I103_XG_MN0 (XI1068_I103_XG_n1 I1068_P7_6 I1068_G7_4n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I103_XG_MN1 (VSS I1068_G5_4 XI1068_I103_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2147_MN2 (nqkn24 nqk23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2147_MN0 (XI2147_n1 sq_b3_4 nqkn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2147_MN1 (VSS qu23_b3_5 XI2147_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI105_MN2 (nakn24 nak23 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI105_MN0 (XI105_n1 A_31_b3_3 nakn24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI105_MN1 (VSS A_23 XI105_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI57_MN2 (nakn8 nak7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI57_MN0 (XI57_n1 A_31_b3_1 nakn8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI57_MN1 (VSS A_7 XI57_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI60_MN2 (nakn9 nak8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI60_MN0 (XI60_n1 A_31_b3_1 nakn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI60_MN1 (VSS A_8 XI60_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I127_XG_MN2 (I1068_G31_28n I1068_G31_30 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I127_XG_MN0 (XI1068_I127_XG_n1 I1068_P31_30 I1068_G31_28n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I127_XG_MN1 (VSS I1068_G29_28 XI1068_I127_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I125_XG_MN2 (I1068_G29_26n I1068_G29_28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I125_XG_MN0 (XI1068_I125_XG_n1 I1068_P29_28 I1068_G29_26n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I125_XG_MN1 (VSS I1068_G27_26 XI1068_I125_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I178_XG_MN2 (I1068_G27_12n I1068_G27_20 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I178_XG_MN0 (XI1068_I178_XG_n1 I1068_P27_20 I1068_G27_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I178_XG_MN1 (VSS I1068_G19_12 XI1068_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I182_XG_MN2 (I1068_G31_16n I1068_G31_24 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I182_XG_MN0 (XI1068_I182_XG_n1 I1068_P31_24 I1068_G31_16n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I182_XG_MN1 (VSS I1068_G23_16 XI1068_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I174_XG_MN2 (I1068_G23_8n I1068_G23_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I174_XG_MN0 (XI1068_I174_XG_n1 I1068_P23_16 I1068_G23_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I174_XG_MN1 (VSS I1068_G15_8 XI1068_I174_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I166_XG_MN2 (I1068_G15_0n I1068_G15_8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I166_XG_MN0 (XI1068_I166_XG_n1 I1068_P15_8 I1068_G15_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I166_XG_MN1 (VSS I1068_G7_0 XI1068_I166_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I113_XG_MN2 (I1068_G17_14n I1068_G17_16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I113_XG_MN0 (XI1068_I113_XG_n1 I1068_P17_16 I1068_G17_14n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I113_XG_MN1 (VSS I1068_G15_14 XI1068_I113_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I111_XG_MN2 (I1068_G15_12n I1068_G15_14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I111_XG_MN0 (XI1068_I111_XG_n1 I1068_P15_14 I1068_G15_12n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I111_XG_MN1 (VSS I1068_G13_12 XI1068_I111_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I109_XG_MN2 (I1068_G13_10n I1068_G13_12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I109_XG_MN0 (XI1068_I109_XG_n1 I1068_P13_12 I1068_G13_10n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I109_XG_MN1 (VSS I1068_G11_10 XI1068_I109_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I107_XG_MN2 (I1068_G11_8n I1068_G11_10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1068_I107_XG_MN0 (XI1068_I107_XG_n1 I1068_P11_10 I1068_G11_8n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1068_I107_XG_MN1 (VSS I1068_G9_8 XI1068_I107_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I98_XG_MN2 (I1666_G2_0n I1666_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1666_I98_XG_MN0 (XI1666_I98_XG_n1 I1666_P2_1 I1666_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI1666_I98_XG_MN1 (VSS I1666_G0_0 XI1666_I98_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2102_MN2 (nqkn9 nqk8 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI2102_MN0 (XI2102_n1 sq_b3_1 nqkn9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
    I_MXI2102_MN1 (VSS qu8_b3_5 XI2102_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I98_XG_MN2 (I1574_G2_0n I1574_G2_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04679p as=0.06959p pd=0.68u ps=1.16u
    I_MXI1574_I98_XG_MN0 (XI1574_I98_XG_n1 I1574_P2_1 I1574_G2_0n VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.04679p pd=0.68u ps=0.68u
