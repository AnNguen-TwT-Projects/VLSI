    I_MXI754_MP2_1 (VDD qu27_b2_0 qu27_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI134_MP2 (dd1_b3_0 dd1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI134_MP2_1 (VDD dd1_b2_0 dd1_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI316_MP2 (dd15_b3_0 dd15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI316_MP2_1 (VDD dd15_b2_0 dd15_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI277_MP2 (dd12_b3_0 dd12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI277_MP2_1 (VDD dd12_b2_0 dd12_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI186_MP2 (dd5_b3_0 dd5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI186_MP2_1 (VDD dd5_b2_0 dd5_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI342_MP2 (dd17_b3_0 dd17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI342_MP2_1 (VDD dd17_b2_0 dd17_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI329_MP2 (dd16_b3_0 dd16_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI329_MP2_1 (VDD dd16_b2_0 dd16_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI161_MP2 (dd3_b3_1 dd3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI161_MP2_1 (VDD dd3_b2_0 dd3_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI173_MP2 (dd4_b3_0 dd4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI173_MP2_1 (VDD dd4_b2_0 dd4_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI212_MP2 (dd7_b3_0 dd7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI212_MP2_1 (VDD dd7_b2_0 dd7_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI238_MP2 (dd9_b3_0 dd9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI238_MP2_1 (VDD dd9_b2_0 dd9_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI251_MP2 (dd10_b3_0 dd10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI251_MP2_1 (VDD dd10_b2_0 dd10_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI264_MP2 (dd11_b3_0 dd11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI264_MP2_1 (VDD dd11_b2_0 dd11_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI132_MP2 (dd1_b2_0 dd1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI132_MP2_1 (VDD dd1_b1_0 dd1_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI340_MP2 (dd17_b2_0 dd17_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI340_MP2_1 (VDD dd17_b1_0 dd17_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI314_MP2 (dd15_b2_0 dd15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI314_MP2_1 (VDD dd15_b1_0 dd15_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI184_MP2 (dd5_b2_0 dd5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI184_MP2_1 (VDD dd5_b1_0 dd5_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI327_MP2 (dd16_b2_0 dd16_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI327_MP2_1 (VDD dd16_b1_0 dd16_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI210_MP2 (dd7_b2_0 dd7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI210_MP2_1 (VDD dd7_b1_0 dd7_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI301_MP2 (dd14_b2_0 dd14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI301_MP2_1 (VDD dd14_b1_0 dd14_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI249_MP2 (dd10_b2_0 dd10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI249_MP2_1 (VDD dd10_b1_0 dd10_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI236_MP2 (dd9_b2_0 dd9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI236_MP2_1 (VDD dd9_b1_0 dd9_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI275_MP2 (dd12_b2_0 dd12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI275_MP2_1 (VDD dd12_b1_0 dd12_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_MP2 (A_31_b2_0 A_31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_MP2_1 (VDD A_31_b1_0 A_31_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI262_MP2 (dd11_b2_0 dd11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI262_MP2_1 (VDD dd11_b1_0 dd11_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI209_MP2 (dd7_b1_0 dd7_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI209_MP2_1 (VDD dd7_b0 dd7_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI248_MP2 (dd10_b1_0 dd10_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI248_MP2_1 (VDD dd10_b0 dd10_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI222_MP2 (dd8_b1_0 dd8_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI222_MP2_1 (VDD dd8_b0 dd8_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI261_MP2 (dd11_b1_0 dd11_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI261_MP2_1 (VDD dd11_b0 dd11_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI235_MP2 (dd9_b1_0 dd9_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI235_MP2_1 (VDD dd9_b0 dd9_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI274_MP2 (dd12_b1_0 dd12_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI274_MP2_1 (VDD dd12_b0 dd12_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI313_MP2 (dd15_b1_0 dd15_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI313_MP2_1 (VDD dd15_b0 dd15_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI300_MP2 (dd14_b1_0 dd14_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI300_MP2_1 (VDD dd14_b0 dd14_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2069_MP2 (sq_b1_0 sq_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2069_MP2_1 (VDD sq_b0 sq_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI326_MP2 (dd16_b1_0 dd16_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI326_MP2_1 (VDD dd16_b0 dd16_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI25_MP2 (B_31_b3_5 B_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI25_MP2_1 (VDD B_31_b2_1 B_31_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI339_MP2 (dd17_b1_0 dd17_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI339_MP2_1 (VDD dd17_b0 dd17_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI24_MP2 (B_31_b3_4 B_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI24_MP2_1 (VDD B_31_b2_1 B_31_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI352_MP2 (dd18_b1_0 dd18_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI352_MP2_1 (VDD dd18_b0 dd18_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI315_MP2 (dd15_b2_1 dd15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI315_MP2_1 (VDD dd15_b1_0 dd15_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI302_MP2 (dd14_b2_1 dd14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI302_MP2_1 (VDD dd14_b1_0 dd14_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI276_MP2 (dd12_b2_1 dd12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI276_MP2_1 (VDD dd12_b1_0 dd12_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI250_MP2 (dd10_b2_1 dd10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI250_MP2_1 (VDD dd10_b1_0 dd10_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI328_MP2 (dd16_b2_1 dd16_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI328_MP2_1 (VDD dd16_b1_0 dd16_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI263_MP2 (dd11_b2_1 dd11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI263_MP2_1 (VDD dd11_b1_0 dd11_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI341_MP2 (dd17_b2_1 dd17_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI341_MP2_1 (VDD dd17_b1_0 dd17_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI282_MP2 (dd12_b3_5 dd12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI282_MP2_1 (VDD dd12_b2_1 dd12_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI308_MP2 (dd14_b3_5 dd14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI308_MP2_1 (VDD dd14_b2_1 dd14_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI334_MP2 (dd16_b3_5 dd16_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI334_MP2_1 (VDD dd16_b2_1 dd16_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI321_MP2 (dd15_b3_5 dd15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI321_MP2_1 (VDD dd15_b2_1 dd15_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI185_MP2 (dd5_b2_1 dd5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI185_MP2_1 (VDD dd5_b1_0 dd5_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI347_MP2 (dd17_b3_5 dd17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI347_MP2_1 (VDD dd17_b2_1 dd17_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI133_MP2 (dd1_b2_1 dd1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI133_MP2_1 (VDD dd1_b1_0 dd1_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI211_MP2 (dd7_b2_1 dd7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI211_MP2_1 (VDD dd7_b1_0 dd7_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI217_MP2 (dd7_b3_5 dd7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI217_MP2_1 (VDD dd7_b2_1 dd7_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI237_MP2 (dd9_b2_1 dd9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI237_MP2_1 (VDD dd9_b1_0 dd9_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI243_MP2 (dd9_b3_5 dd9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI243_MP2_1 (VDD dd9_b2_1 dd9_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI34_MP2 (B_0_b3_4 B_0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI34_MP2_1 (VDD B_0_b2_1 B_0_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI5_MP2 (A_31_b3_0 A_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI5_MP2_1 (VDD A_31_b2_0 A_31_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI713_MP2 (qu28_b3_5 qu28_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI713_MP2_1 (VDD qu28_b2_1 qu28_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI707_MP2 (qu28_b2_1 qu28_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI707_MP2_1 (VDD qu28_b1_0 qu28_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI752_MP2 (qu27_b2_0 qu27_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI752_MP2_1 (VDD qu27_b1_0 qu27_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI755_MP2 (qu27_b3_1 qu27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI755_MP2_1 (VDD qu27_b2_0 qu27_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2077_MP2 (sq_b3_5 sq_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2077_MP2_1 (VDD sq_b2_1 sq_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2071_MP2 (sq_b2_1 sq_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2071_MP2_1 (VDD sq_b1_0 sq_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI368_MP2 (dd19_b3_0 dd19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI368_MP2_1 (VDD dd19_b2_0 dd19_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI303_MP2 (dd14_b3_0 dd14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI303_MP2_1 (VDD dd14_b2_0 dd14_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI290_MP2 (dd13_b3_0 dd13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI290_MP2_1 (VDD dd13_b2_0 dd13_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI148_MP2 (dd2_b3_1 dd2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI148_MP2_1 (VDD dd2_b2_0 dd2_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI225_MP2 (dd8_b3_0 dd8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI225_MP2_1 (VDD dd8_b2_0 dd8_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI366_MP2 (dd19_b2_0 dd19_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI366_MP2_1 (VDD dd19_b1_0 dd19_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI135_MP2 (dd1_b3_1 dd1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI135_MP2_1 (VDD dd1_b2_0 dd1_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI288_MP2 (dd13_b2_0 dd13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI288_MP2_1 (VDD dd13_b1_0 dd13_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI223_MP2 (dd8_b2_0 dd8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI223_MP2_1 (VDD dd8_b1_0 dd8_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI287_MP2 (dd13_b1_0 dd13_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI287_MP2_1 (VDD dd13_b0 dd13_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI365_MP2 (dd19_b1_0 dd19_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI365_MP2_1 (VDD dd19_b0 dd19_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI378_MP2 (dd20_b1_0 dd20_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI378_MP2_1 (VDD dd20_b0 dd20_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI404_MP2 (dd22_b1_0 dd22_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI404_MP2_1 (VDD dd22_b0 dd22_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI367_MP2 (dd19_b2_1 dd19_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI367_MP2_1 (VDD dd19_b1_0 dd19_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI391_MP2 (dd21_b1_0 dd21_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI391_MP2_1 (VDD dd21_b0 dd21_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI289_MP2 (dd13_b2_1 dd13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI289_MP2_1 (VDD dd13_b1_0 dd13_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI393_MP2 (dd21_b2_1 dd21_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI393_MP2_1 (VDD dd21_b1_0 dd21_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI295_MP2 (dd13_b3_5 dd13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI295_MP2_1 (VDD dd13_b2_1 dd13_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI412_MP2 (dd22_b3_5 dd22_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI412_MP2_1 (VDD dd22_b2_1 dd22_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI425_MP2 (dd23_b3_5 dd23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI425_MP2_1 (VDD dd23_b2_1 dd23_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI490_MP2 (dd28_b3_5 dd28_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI490_MP2_1 (VDD dd28_b2_1 dd28_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI224_MP2 (dd8_b2_1 dd8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI224_MP2_1 (VDD dd8_b1_0 dd8_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI373_MP2 (dd19_b3_5 dd19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI373_MP2_1 (VDD dd19_b2_1 dd19_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI399_MP2 (dd21_b3_5 dd21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI399_MP2_1 (VDD dd21_b2_1 dd21_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI230_MP2 (dd8_b3_5 dd8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI230_MP2_1 (VDD dd8_b2_1 dd8_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI164_MP2 (dd3_b3_4 dd3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI164_MP2_1 (VDD dd3_b2_1 dd3_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2070_MP2 (sq_b2_0 sq_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2070_MP2_1 (VDD sq_b1_0 sq_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2072_MP2 (sq_b3_0 sq_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2072_MP2_1 (VDD sq_b2_0 sq_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1812_MP2 (qu4_b3_0 qu4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1812_MP2_1 (VDD qu4_b2_0 qu4_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1813_MP2 (qu4_b3_1 qu4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1813_MP2_1 (VDD qu4_b2_0 qu4_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1810_MP2 (qu4_b2_0 qu4_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1810_MP2_1 (VDD qu4_b1_0 qu4_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1814_MP2 (qu4_b3_2 qu4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1814_MP2_1 (VDD qu4_b2_0 qu4_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI749_MP2 (qu27 p4_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI749_MP2_1 (VDD p4_32 qu27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI751_MP2 (qu27_b1_0 qu27_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI751_MP2_1 (VDD qu27_b0 qu27_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI711_MP2 (qu28_b3_3 qu28_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI711_MP2_1 (VDD qu28_b2_1 qu28_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI394_MP2 (dd21_b3_0 dd21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI394_MP2_1 (VDD dd21_b2_0 dd21_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI381_MP2 (dd20_b3_0 dd20_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI381_MP2_1 (VDD dd20_b2_0 dd20_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI355_MP2 (dd18_b3_0 dd18_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI355_MP2_1 (VDD dd18_b2_0 dd18_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI174_MP2 (dd4_b3_1 dd4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI174_MP2_1 (VDD dd4_b2_0 dd4_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI496_MP2 (dd29_b2_0 dd29_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI496_MP2_1 (VDD dd29_b1_0 dd29_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI405_MP2 (dd22_b2_0 dd22_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI405_MP2_1 (VDD dd22_b1_0 dd22_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI187_MP2 (dd5_b3_1 dd5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI187_MP2_1 (VDD dd5_b2_0 dd5_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI353_MP2 (dd18_b2_0 dd18_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI353_MP2_1 (VDD dd18_b1_0 dd18_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI379_MP2 (dd20_b2_0 dd20_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI379_MP2_1 (VDD dd20_b1_0 dd20_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI392_MP2 (dd21_b2_0 dd21_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI392_MP2_1 (VDD dd21_b1_0 dd21_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI521_MP2 (dd31_b1_0 dd31_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI521_MP2_1 (VDD dd31_b0 dd31_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI508_MP2 (dd30_b1_0 dd30_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI508_MP2_1 (VDD dd30_b0 dd30_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI495_MP2 (dd29_b1_0 dd29_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI495_MP2_1 (VDD dd29_b0 dd29_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI482_MP2 (dd28_b1_0 dd28_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI482_MP2_1 (VDD dd28_b0 dd28_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI417_MP2 (dd23_b1_0 dd23_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI417_MP2_1 (VDD dd23_b0 dd23_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI380_MP2 (dd20_b2_1 dd20_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI380_MP2_1 (VDD dd20_b1_0 dd20_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI484_MP2 (dd28_b2_1 dd28_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI484_MP2_1 (VDD dd28_b1_0 dd28_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI406_MP2 (dd22_b2_1 dd22_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI406_MP2_1 (VDD dd22_b1_0 dd22_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI354_MP2 (dd18_b2_1 dd18_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI354_MP2_1 (VDD dd18_b1_0 dd18_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI451_MP2 (dd25_b3_5 dd25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI451_MP2_1 (VDD dd25_b2_1 dd25_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI419_MP2 (dd23_b2_1 dd23_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI419_MP2_1 (VDD dd23_b1_0 dd23_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI497_MP2 (dd29_b2_1 dd29_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI497_MP2_1 (VDD dd29_b1_0 dd29_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI386_MP2 (dd20_b3_5 dd20_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI386_MP2_1 (VDD dd20_b2_1 dd20_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI477_MP2 (dd27_b3_5 dd27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI477_MP2_1 (VDD dd27_b2_1 dd27_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI360_MP2 (dd18_b3_5 dd18_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI360_MP2_1 (VDD dd18_b2_1 dd18_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI503_MP2 (dd29_b3_5 dd29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI503_MP2_1 (VDD dd29_b2_1 dd29_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI151_MP2 (dd2_b3_4 dd2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI151_MP2_1 (VDD dd2_b2_1 dd2_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI138_MP2 (dd1_b3_4 dd1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI138_MP2_1 (VDD dd1_b2_1 dd1_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1809_MP2 (qu4_b1_0 qu4_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1809_MP2_1 (VDD qu4_b0 qu4_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1811_MP2 (qu4_b2_1 qu4_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1811_MP2_1 (VDD qu4_b1_0 qu4_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1817_MP2 (qu4_b3_5 qu4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1817_MP2_1 (VDD qu4_b2_1 qu4_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1815_MP2 (qu4_b3_3 qu4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1815_MP2_1 (VDD qu4_b2_1 qu4_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI800_MP2 (qu26_b3_0 qu26_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI800_MP2_1 (VDD qu26_b2_0 qu26_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI420_MP2 (dd23_b3_0 dd23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI420_MP2_1 (VDD dd23_b2_0 dd23_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI200_MP2 (dd6_b3_1 dd6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI200_MP2_1 (VDD dd6_b2_0 dd6_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI485_MP2 (dd28_b3_0 dd28_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI485_MP2_1 (VDD dd28_b2_0 dd28_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI509_MP2 (dd30_b2_0 dd30_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI509_MP2_1 (VDD dd30_b1_0 dd30_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI846_MP2 (qu25_b3_0 qu25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI846_MP2_1 (VDD qu25_b2_0 qu25_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI418_MP2 (dd23_b2_0 dd23_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI418_MP2_1 (VDD dd23_b1_0 dd23_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI483_MP2 (dd28_b2_0 dd28_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI483_MP2_1 (VDD dd28_b1_0 dd28_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI443_MP2 (dd25_b1_0 dd25_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI443_MP2_1 (VDD dd25_b0 dd25_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI510_MP2 (dd30_b2_1 dd30_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI510_MP2_1 (VDD dd30_b1_0 dd30_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI438_MP2 (dd24_b3_5 dd24_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI438_MP2_1 (VDD dd24_b2_1 dd24_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI177_MP2 (dd4_b3_4 dd4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI177_MP2_1 (VDD dd4_b2_1 dd4_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI190_MP2 (dd5_b3_4 dd5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI190_MP2_1 (VDD dd5_b2_1 dd5_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI516_MP2 (dd30_b3_5 dd30_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI516_MP2_1 (VDD dd30_b2_1 dd30_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1766_MP2 (qu5_b3_0 qu5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1766_MP2_1 (VDD qu5_b2_0 qu5_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1816_MP2 (qu4_b3_4 qu4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1816_MP2_1 (VDD qu4_b2_1 qu4_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI753_MP2 (qu27_b2_1 qu27_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI753_MP2_1 (VDD qu27_b1_0 qu27_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI757_MP2 (qu27_b3_3 qu27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI757_MP2_1 (VDD qu27_b2_1 qu27_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI407_MP2 (dd22_b3_0 dd22_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI407_MP2_1 (VDD dd22_b2_0 dd22_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI459_MP2 (dd26_b3_0 dd26_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI459_MP2_1 (VDD dd26_b2_0 dd26_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI498_MP2 (dd29_b3_0 dd29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI498_MP2_1 (VDD dd29_b2_0 dd29_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI524_MP2 (dd31_b3_0 dd31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI524_MP2_1 (VDD dd31_b2_0 dd31_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI213_MP2 (dd7_b3_1 dd7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI213_MP2_1 (VDD dd7_b2_0 dd7_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI457_MP2 (dd26_b2_0 dd26_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI457_MP2_1 (VDD dd26_b1_0 dd26_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI444_MP2 (dd25_b2_0 dd25_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI444_MP2_1 (VDD dd25_b1_0 dd25_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI522_MP2 (dd31_b2_0 dd31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI522_MP2_1 (VDD dd31_b1_0 dd31_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI469_MP2 (dd27_b1_0 dd27_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI469_MP2_1 (VDD dd27_b0 dd27_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI430_MP2 (dd24_b1_0 dd24_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI430_MP2_1 (VDD dd24_b0 dd24_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI456_MP2 (dd26_b1_0 dd26_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI456_MP2_1 (VDD dd26_b0 dd26_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI471_MP2 (dd27_b2_1 dd27_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI471_MP2_1 (VDD dd27_b1_0 dd27_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI458_MP2 (dd26_b2_1 dd26_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI458_MP2_1 (VDD dd26_b1_0 dd26_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI445_MP2 (dd25_b2_1 dd25_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI445_MP2_1 (VDD dd25_b1_0 dd25_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI523_MP2 (dd31_b2_1 dd31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI523_MP2_1 (VDD dd31_b1_0 dd31_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI464_MP2 (dd26_b3_5 dd26_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI464_MP2_1 (VDD dd26_b2_1 dd26_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1674_MP2 (qu7_b3_0 qu7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1674_MP2_1 (VDD qu7_b2_0 qu7_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI529_MP2 (dd31_b3_5 dd31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI529_MP2_1 (VDD dd31_b2_1 dd31_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1721_MP2 (qu6_b3_1 qu6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1721_MP2_1 (VDD qu6_b2_0 qu6_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1720_MP2 (qu6_b3_0 qu6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1720_MP2_1 (VDD qu6_b2_0 qu6_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI801_MP2 (qu26_b3_1 qu26_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI801_MP2_1 (VDD qu26_b2_0 qu26_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI433_MP2 (dd24_b3_0 dd24_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI433_MP2_1 (VDD dd24_b2_0 dd24_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI511_MP2 (dd30_b3_0 dd30_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI511_MP2_1 (VDD dd30_b2_0 dd30_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI239_MP2 (dd9_b3_1 dd9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI239_MP2_1 (VDD dd9_b2_0 dd9_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI470_MP2 (dd27_b2_0 dd27_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI470_MP2_1 (VDD dd27_b1_0 dd27_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI431_MP2 (dd24_b2_0 dd24_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI431_MP2_1 (VDD dd24_b1_0 dd24_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI847_MP2 (qu25_b3_1 qu25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI847_MP2_1 (VDD qu25_b2_0 qu25_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI432_MP2 (dd24_b2_1 dd24_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI432_MP2_1 (VDD dd24_b1_0 dd24_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1675_MP2 (qu7_b3_1 qu7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1675_MP2_1 (VDD qu7_b2_0 qu7_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI6_MP2 (A_31_b3_1 A_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI6_MP2_1 (VDD A_31_b2_0 A_31_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI472_MP2 (dd27_b3_0 dd27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI472_MP2_1 (VDD dd27_b2_0 dd27_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI446_MP2 (dd25_b3_0 dd25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI446_MP2_1 (VDD dd25_b2_0 dd25_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI252_MP2 (dd10_b3_1 dd10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI252_MP2_1 (VDD dd10_b2_0 dd10_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI226_MP2 (dd8_b3_1 dd8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI226_MP2_1 (VDD dd8_b2_0 dd8_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI265_MP2 (dd11_b3_1 dd11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI265_MP2_1 (VDD dd11_b2_0 dd11_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1767_MP2 (qu5_b3_1 qu5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1767_MP2_1 (VDD qu5_b2_0 qu5_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI712_MP2 (qu28_b3_4 qu28_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI712_MP2_1 (VDD qu28_b2_1 qu28_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI759_MP2 (qu27_b3_5 qu27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI759_MP2_1 (VDD qu27_b2_1 qu27_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI291_MP2 (dd13_b3_1 dd13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI291_MP2_1 (VDD dd13_b2_0 dd13_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI844_MP2 (qu25_b2_0 qu25_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI844_MP2_1 (VDD qu25_b1_0 qu25_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI848_MP2 (qu25_b3_2 qu25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI848_MP2_1 (VDD qu25_b2_0 qu25_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI758_MP2 (qu27_b3_4 qu27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI758_MP2_1 (VDD qu27_b2_1 qu27_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI278_MP2 (dd12_b3_1 dd12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI278_MP2_1 (VDD dd12_b2_0 dd12_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1676_MP2 (qu7_b3_2 qu7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1676_MP2_1 (VDD qu7_b2_0 qu7_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI317_MP2 (dd15_b3_1 dd15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI317_MP2_1 (VDD dd15_b2_0 dd15_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1722_MP2 (qu6_b3_2 qu6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1722_MP2_1 (VDD qu6_b2_0 qu6_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1768_MP2 (qu5_b3_2 qu5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1768_MP2_1 (VDD qu5_b2_0 qu5_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI802_MP2 (qu26_b3_2 qu26_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI802_MP2_1 (VDD qu26_b2_0 qu26_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI343_MP2 (dd17_b3_1 dd17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI343_MP2_1 (VDD dd17_b2_0 dd17_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI330_MP2 (dd16_b3_1 dd16_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI330_MP2_1 (VDD dd16_b2_0 dd16_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI798_MP2 (qu26_b2_0 qu26_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI798_MP2_1 (VDD qu26_b1_0 qu26_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI304_MP2 (dd14_b3_1 dd14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI304_MP2_1 (VDD dd14_b2_0 dd14_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI841_MP2 (qu25 p6_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI841_MP2_1 (VDD p6_32 qu25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI843_MP2 (qu25_b1_0 qu25_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI843_MP2_1 (VDD qu25_b0 qu25_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1764_MP2 (qu5_b2_0 qu5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1764_MP2_1 (VDD qu5_b1_0 qu5_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1807_MP2 (qu4 p27_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1807_MP2_1 (VDD p27_32 qu4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI851_MP2 (qu25_b3_5 qu25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI851_MP2_1 (VDD qu25_b2_1 qu25_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI849_MP2 (qu25_b3_3 qu25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI849_MP2_1 (VDD qu25_b2_1 qu25_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI845_MP2 (qu25_b2_1 qu25_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI845_MP2_1 (VDD qu25_b1_0 qu25_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI795_MP2 (qu26 p5_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI795_MP2_1 (VDD p5_32 qu26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI797_MP2 (qu26_b1_0 qu26_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI797_MP2_1 (VDD qu26_b0 qu26_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI799_MP2 (qu26_b2_1 qu26_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI799_MP2_1 (VDD qu26_b1_0 qu26_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI805_MP2 (qu26_b3_5 qu26_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI805_MP2_1 (VDD qu26_b2_1 qu26_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI369_MP2 (dd19_b3_1 dd19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI369_MP2_1 (VDD dd19_b2_0 dd19_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI356_MP2 (dd18_b3_1 dd18_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI356_MP2_1 (VDD dd18_b2_0 dd18_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1718_MP2 (qu6_b2_0 qu6_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1718_MP2_1 (VDD qu6_b1_0 qu6_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1761_MP2 (qu5 p26_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1761_MP2_1 (VDD p26_32 qu5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1763_MP2 (qu5_b1_0 qu5_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1763_MP2_1 (VDD qu5_b0 qu5_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2076_MP2 (sq_b3_4 sq_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2076_MP2_1 (VDD sq_b2_1 sq_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2075_MP2 (sq_b3_3 sq_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2075_MP2_1 (VDD sq_b2_1 sq_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI804_MP2 (qu26_b3_4 qu26_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI804_MP2_1 (VDD qu26_b2_1 qu26_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI803_MP2 (qu26_b3_3 qu26_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI803_MP2_1 (VDD qu26_b2_1 qu26_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI188_MP2 (dd5_b3_2 dd5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI188_MP2_1 (VDD dd5_b2_0 dd5_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI175_MP2 (dd4_b3_2 dd4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI175_MP2_1 (VDD dd4_b2_0 dd4_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI201_MP2 (dd6_b3_2 dd6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI201_MP2_1 (VDD dd6_b2_0 dd6_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI214_MP2 (dd7_b3_2 dd7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI214_MP2_1 (VDD dd7_b2_0 dd7_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI31_MP2 (B_0_b3_1 B_0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI31_MP2_1 (VDD B_0_b2_0 B_0_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI408_MP2 (dd22_b3_1 dd22_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI408_MP2_1 (VDD dd22_b2_0 dd22_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI525_MP2 (dd31_b3_1 dd31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI525_MP2_1 (VDD dd31_b2_0 dd31_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI395_MP2 (dd21_b3_1 dd21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI395_MP2_1 (VDD dd21_b2_0 dd21_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI421_MP2 (dd23_b3_1 dd23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI421_MP2_1 (VDD dd23_b2_0 dd23_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI382_MP2 (dd20_b3_1 dd20_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI382_MP2_1 (VDD dd20_b2_0 dd20_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI850_MP2 (qu25_b3_4 qu25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI850_MP2_1 (VDD qu25_b2_1 qu25_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1672_MP2 (qu7_b2_0 qu7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1672_MP2_1 (VDD qu7_b1_0 qu7_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1715_MP2 (qu6 p25_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1715_MP2_1 (VDD p25_32 qu6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1717_MP2 (qu6_b1_0 qu6_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1717_MP2_1 (VDD qu6_b0 qu6_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1719_MP2 (qu6_b2_1 qu6_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1719_MP2_1 (VDD qu6_b1_0 qu6_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1723_MP2 (qu6_b3_3 qu6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1723_MP2_1 (VDD qu6_b2_1 qu6_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1724_MP2 (qu6_b3_4 qu6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1724_MP2_1 (VDD qu6_b2_1 qu6_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1725_MP2 (qu6_b3_5 qu6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1725_MP2_1 (VDD qu6_b2_1 qu6_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1765_MP2 (qu5_b2_1 qu5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1765_MP2_1 (VDD qu5_b1_0 qu5_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1769_MP2 (qu5_b3_3 qu5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1769_MP2_1 (VDD qu5_b2_1 qu5_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1771_MP2 (qu5_b3_5 qu5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1771_MP2_1 (VDD qu5_b2_1 qu5_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1770_MP2 (qu5_b3_4 qu5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1770_MP2_1 (VDD qu5_b2_1 qu5_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI461_MP2 (dd26_b3_2 dd26_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI461_MP2_1 (VDD dd26_b2_0 dd26_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI136_MP2 (dd1_b3_2 dd1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI136_MP2_1 (VDD dd1_b2_0 dd1_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI149_MP2 (dd2_b3_2 dd2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI149_MP2_1 (VDD dd2_b2_0 dd2_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI162_MP2 (dd3_b3_2 dd3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI162_MP2_1 (VDD dd3_b2_0 dd3_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI434_MP2 (dd24_b3_1 dd24_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI434_MP2_1 (VDD dd24_b2_0 dd24_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI499_MP2 (dd29_b3_1 dd29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI499_MP2_1 (VDD dd29_b2_0 dd29_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI447_MP2 (dd25_b3_1 dd25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI447_MP2_1 (VDD dd25_b2_0 dd25_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI473_MP2 (dd27_b3_1 dd27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI473_MP2_1 (VDD dd27_b2_0 dd27_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI227_MP2 (dd8_b3_2 dd8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI227_MP2_1 (VDD dd8_b2_0 dd8_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI460_MP2 (dd26_b3_1 dd26_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI460_MP2_1 (VDD dd26_b2_0 dd26_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI512_MP2 (dd30_b3_1 dd30_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI512_MP2_1 (VDD dd30_b2_0 dd30_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI8_MP2 (A_31_b3_3 A_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI8_MP2_1 (VDD A_31_b2_0 A_31_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI255_MP2 (dd10_b3_4 dd10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI255_MP2_1 (VDD dd10_b2_1 dd10_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1677_MP2 (qu7_b3_3 qu7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1677_MP2_1 (VDD qu7_b2_1 qu7_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1678_MP2 (qu7_b3_4 qu7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1678_MP2_1 (VDD qu7_b2_1 qu7_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI242_MP2 (dd9_b3_4 dd9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI242_MP2_1 (VDD dd9_b2_1 dd9_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI216_MP2 (dd7_b3_4 dd7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI216_MP2_1 (VDD dd7_b2_1 dd7_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1671_MP2 (qu7_b1_0 qu7_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1671_MP2_1 (VDD qu7_b0 qu7_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1679_MP2 (qu7_b3_5 qu7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1679_MP2_1 (VDD qu7_b2_1 qu7_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1673_MP2 (qu7_b2_1 qu7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1673_MP2_1 (VDD qu7_b1_0 qu7_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI515_MP2 (dd30_b3_4 dd30_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI515_MP2_1 (VDD dd30_b2_1 dd30_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI528_MP2 (dd31_b3_4 dd31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI528_MP2_1 (VDD dd31_b2_1 dd31_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI357_MP2 (dd18_b3_2 dd18_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI357_MP2_1 (VDD dd18_b2_0 dd18_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI486_MP2 (dd28_b3_1 dd28_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI486_MP2_1 (VDD dd28_b2_0 dd28_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI887_MP2 (qu24 p7_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI887_MP2_1 (VDD p7_32 qu24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI7_MP2 (A_31_b3_2 A_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI7_MP2_1 (VDD A_31_b2_0 A_31_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI385_MP2 (dd20_b3_4 dd20_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI385_MP2_1 (VDD dd20_b2_1 dd20_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI307_MP2 (dd14_b3_4 dd14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI307_MP2_1 (VDD dd14_b2_1 dd14_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI424_MP2 (dd23_b3_4 dd23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI424_MP2_1 (VDD dd23_b2_1 dd23_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI333_MP2 (dd16_b3_4 dd16_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI333_MP2_1 (VDD dd16_b2_1 dd16_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI359_MP2 (dd18_b3_4 dd18_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI359_MP2_1 (VDD dd18_b2_1 dd18_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI320_MP2 (dd15_b3_4 dd15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI320_MP2_1 (VDD dd15_b2_1 dd15_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI398_MP2 (dd21_b3_4 dd21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI398_MP2_1 (VDD dd21_b2_1 dd21_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI372_MP2 (dd19_b3_4 dd19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI372_MP2_1 (VDD dd19_b2_1 dd19_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI346_MP2 (dd17_b3_4 dd17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI346_MP2_1 (VDD dd17_b2_1 dd17_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI33_MP2 (B_0_b3_3 B_0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI33_MP2_1 (VDD B_0_b2_1 B_0_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI229_MP2 (dd8_b3_4 dd8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI229_MP2_1 (VDD dd8_b2_1 dd8_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI203_MP2 (dd6_b3_4 dd6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI203_MP2_1 (VDD dd6_b2_1 dd6_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI268_MP2 (dd11_b3_4 dd11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI268_MP2_1 (VDD dd11_b2_1 dd11_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2073_MP2 (sq_b3_1 sq_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2073_MP2_1 (VDD sq_b2_0 sq_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1582_MP2 (qu9_b3_0 qu9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1582_MP2_1 (VDD qu9_b2_0 qu9_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI984_MP2 (qu22_b3_0 qu22_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI984_MP2_1 (VDD qu22_b2_0 qu22_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI985_MP2 (qu22_b3_1 qu22_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI985_MP2_1 (VDD qu22_b2_0 qu22_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI474_MP2 (dd27_b3_2 dd27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI474_MP2_1 (VDD dd27_b2_0 dd27_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI266_MP2 (dd11_b3_2 dd11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI266_MP2_1 (VDD dd11_b2_0 dd11_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI487_MP2 (dd28_b3_2 dd28_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI487_MP2_1 (VDD dd28_b2_0 dd28_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI938_MP2 (qu23_b3_0 qu23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI938_MP2_1 (VDD qu23_b2_0 qu23_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI892_MP2 (qu24_b3_0 qu24_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI892_MP2_1 (VDD qu24_b2_0 qu24_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI463_MP2 (dd26_b3_4 dd26_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI463_MP2_1 (VDD dd26_b2_1 dd26_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI437_MP2 (dd24_b3_4 dd24_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI437_MP2_1 (VDD dd24_b2_1 dd24_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI450_MP2 (dd25_b3_4 dd25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI450_MP2_1 (VDD dd25_b2_1 dd25_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI411_MP2 (dd22_b3_4 dd22_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI411_MP2_1 (VDD dd22_b2_1 dd22_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI294_MP2 (dd13_b3_4 dd13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI294_MP2_1 (VDD dd13_b2_1 dd13_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1628_MP2 (qu8_b3_0 qu8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1628_MP2_1 (VDD qu8_b2_0 qu8_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI292_MP2 (dd13_b3_2 dd13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI292_MP2_1 (VDD dd13_b2_0 dd13_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI240_MP2 (dd9_b3_2 dd9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI240_MP2_1 (VDD dd9_b2_0 dd9_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI939_MP2 (qu23_b3_1 qu23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI939_MP2_1 (VDD qu23_b2_0 qu23_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI893_MP2 (qu24_b3_1 qu24_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI893_MP2_1 (VDD qu24_b2_0 qu24_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI889_MP2 (qu24_b1_0 qu24_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI889_MP2_1 (VDD qu24_b0 qu24_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI281_MP2 (dd12_b3_4 dd12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI281_MP2_1 (VDD dd12_b2_1 dd12_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1629_MP2 (qu8_b3_1 qu8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1629_MP2_1 (VDD qu8_b2_0 qu8_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1583_MP2 (qu9_b3_1 qu9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1583_MP2_1 (VDD qu9_b2_0 qu9_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1537_MP2 (qu10_b3_1 qu10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1537_MP2_1 (VDD qu10_b2_0 qu10_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1536_MP2 (qu10_b3_0 qu10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1536_MP2_1 (VDD qu10_b2_0 qu10_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI253_MP2 (dd10_b3_2 dd10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI253_MP2_1 (VDD dd10_b2_0 dd10_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI894_MP2 (qu24_b3_2 qu24_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI894_MP2_1 (VDD qu24_b2_0 qu24_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI891_MP2 (qu24_b2_1 qu24_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI891_MP2_1 (VDD qu24_b1_0 qu24_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI890_MP2 (qu24_b2_0 qu24_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI890_MP2_1 (VDD qu24_b1_0 qu24_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI370_MP2 (dd19_b3_2 dd19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI370_MP2_1 (VDD dd19_b2_0 dd19_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI409_MP2 (dd22_b3_2 dd22_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI409_MP2_1 (VDD dd22_b2_0 dd22_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI448_MP2 (dd25_b3_2 dd25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI448_MP2_1 (VDD dd25_b2_0 dd25_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI940_MP2 (qu23_b3_2 qu23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI940_MP2_1 (VDD qu23_b2_0 qu23_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI936_MP2 (qu23_b2_0 qu23_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI936_MP2_1 (VDD qu23_b1_0 qu23_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI935_MP2 (qu23_b1_0 qu23_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI935_MP2_1 (VDD qu23_b0 qu23_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI933_MP2 (qu23 p8_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI933_MP2_1 (VDD p8_32 qu23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI897_MP2 (qu24_b3_5 qu24_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI897_MP2_1 (VDD qu24_b2_1 qu24_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1031_MP2 (qu21_b3_1 qu21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1031_MP2_1 (VDD qu21_b2_0 qu21_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI986_MP2 (qu22_b3_2 qu22_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI986_MP2_1 (VDD qu22_b2_0 qu22_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI396_MP2 (dd21_b3_2 dd21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI396_MP2_1 (VDD dd21_b2_0 dd21_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI279_MP2 (dd12_b3_2 dd12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI279_MP2_1 (VDD dd12_b2_0 dd12_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI344_MP2 (dd17_b3_2 dd17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI344_MP2_1 (VDD dd17_b2_0 dd17_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI500_MP2 (dd29_b3_2 dd29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI500_MP2_1 (VDD dd29_b2_0 dd29_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI513_MP2 (dd30_b3_2 dd30_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI513_MP2_1 (VDD dd30_b2_0 dd30_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1630_MP2 (qu8_b3_2 qu8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1630_MP2_1 (VDD qu8_b2_0 qu8_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1584_MP2 (qu9_b3_2 qu9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1584_MP2_1 (VDD qu9_b2_0 qu9_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1538_MP2 (qu10_b3_2 qu10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1538_MP2_1 (VDD qu10_b2_0 qu10_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1034_MP2 (qu21_b3_4 qu21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1034_MP2_1 (VDD qu21_b2_1 qu21_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1033_MP2 (qu21_b3_3 qu21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1033_MP2_1 (VDD qu21_b2_1 qu21_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1035_MP2 (qu21_b3_5 qu21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1035_MP2_1 (VDD qu21_b2_1 qu21_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1032_MP2 (qu21_b3_2 qu21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1032_MP2_1 (VDD qu21_b2_0 qu21_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1028_MP2 (qu21_b2_0 qu21_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1028_MP2_1 (VDD qu21_b1_0 qu21_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1030_MP2 (qu21_b3_0 qu21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1030_MP2_1 (VDD qu21_b2_0 qu21_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI383_MP2 (dd20_b3_2 dd20_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI383_MP2_1 (VDD dd20_b2_0 dd20_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI305_MP2 (dd14_b3_2 dd14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI305_MP2_1 (VDD dd14_b2_0 dd14_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI318_MP2 (dd15_b3_2 dd15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI318_MP2_1 (VDD dd15_b2_0 dd15_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI331_MP2 (dd16_b3_2 dd16_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI331_MP2_1 (VDD dd16_b2_0 dd16_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI435_MP2 (dd24_b3_2 dd24_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI435_MP2_1 (VDD dd24_b2_0 dd24_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI526_MP2 (dd31_b3_2 dd31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI526_MP2_1 (VDD dd31_b2_0 dd31_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1029_MP2 (qu21_b2_1 qu21_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1029_MP2_1 (VDD qu21_b1_0 qu21_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1027_MP2 (qu21_b1_0 qu21_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1027_MP2_1 (VDD qu21_b0 qu21_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI422_MP2 (dd23_b3_2 dd23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI422_MP2_1 (VDD dd23_b2_0 dd23_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1080_MP2 (qu20_b3_4 qu20_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1080_MP2_1 (VDD qu20_b2_1 qu20_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1079_MP2 (qu20_b3_3 qu20_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1079_MP2_1 (VDD qu20_b2_1 qu20_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1071_MP2 (qu20 p11_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1071_MP2_1 (VDD p11_32 qu20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1075_MP2 (qu20_b2_1 qu20_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1075_MP2_1 (VDD qu20_b1_0 qu20_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1078_MP2 (qu20_b3_2 qu20_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1078_MP2_1 (VDD qu20_b2_0 qu20_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1073_MP2 (qu20_b1_0 qu20_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1073_MP2_1 (VDD qu20_b0 qu20_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1074_MP2 (qu20_b2_0 qu20_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1074_MP2_1 (VDD qu20_b1_0 qu20_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1077_MP2 (qu20_b3_1 qu20_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1077_MP2_1 (VDD qu20_b2_0 qu20_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1580_MP2 (qu9_b2_0 qu9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1580_MP2_1 (VDD qu9_b1_0 qu9_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1081_MP2 (qu20_b3_5 qu20_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1081_MP2_1 (VDD qu20_b2_1 qu20_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1025_MP2 (qu21 p10_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1025_MP2_1 (VDD p10_32 qu21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI937_MP2 (qu23_b2_1 qu23_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI937_MP2_1 (VDD qu23_b1_0 qu23_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI895_MP2 (qu24_b3_3 qu24_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI895_MP2_1 (VDD qu24_b2_1 qu24_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1669_MP2 (qu7 p24_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1669_MP2_1 (VDD p24_32 qu7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1631_MP2 (qu8_b3_3 qu8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1631_MP2_1 (VDD qu8_b2_1 qu8_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1626_MP2 (qu8_b2_0 qu8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1626_MP2_1 (VDD qu8_b1_0 qu8_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1581_MP2 (qu9_b2_1 qu9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1581_MP2_1 (VDD qu9_b1_0 qu9_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1585_MP2 (qu9_b3_3 qu9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1585_MP2_1 (VDD qu9_b2_1 qu9_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1076_MP2 (qu20_b3_0 qu20_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1076_MP2_1 (VDD qu20_b2_0 qu20_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI32_MP2 (B_0_b3_2 B_0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI32_MP2_1 (VDD B_0_b2_0 B_0_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI941_MP2 (qu23_b3_3 qu23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI941_MP2_1 (VDD qu23_b2_1 qu23_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI943_MP2 (qu23_b3_5 qu23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI943_MP2_1 (VDD qu23_b2_1 qu23_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI942_MP2 (qu23_b3_4 qu23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI942_MP2_1 (VDD qu23_b2_1 qu23_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI896_MP2 (qu24_b3_4 qu24_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI896_MP2_1 (VDD qu24_b2_1 qu24_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI319_MP2 (dd15_b3_3 dd15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI319_MP2_1 (VDD dd15_b2_1 dd15_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI489_MP2 (dd28_b3_4 dd28_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI489_MP2_1 (VDD dd28_b2_1 dd28_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1632_MP2 (qu8_b3_4 qu8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1632_MP2_1 (VDD qu8_b2_1 qu8_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1633_MP2 (qu8_b3_5 qu8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1633_MP2_1 (VDD qu8_b2_1 qu8_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1627_MP2 (qu8_b2_1 qu8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1627_MP2_1 (VDD qu8_b1_0 qu8_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1625_MP2 (qu8_b1_0 qu8_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1625_MP2_1 (VDD qu8_b0 qu8_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1623_MP2 (qu8 p23_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1623_MP2_1 (VDD p23_32 qu8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1586_MP2 (qu9_b3_4 qu9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1586_MP2_1 (VDD qu9_b2_1 qu9_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1587_MP2 (qu9_b3_5 qu9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1587_MP2_1 (VDD qu9_b2_1 qu9_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1579_MP2 (qu9_b1_0 qu9_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1579_MP2_1 (VDD qu9_b0 qu9_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1535_MP2 (qu10_b2_1 qu10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1535_MP2_1 (VDD qu10_b1_0 qu10_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1534_MP2 (qu10_b2_0 qu10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1534_MP2_1 (VDD qu10_b1_0 qu10_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1577_MP2 (qu9 p22_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1577_MP2_1 (VDD p22_32 qu9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1541_MP2 (qu10_b3_5 qu10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1541_MP2_1 (VDD qu10_b2_1 qu10_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1539_MP2 (qu10_b3_3 qu10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1539_MP2_1 (VDD qu10_b2_1 qu10_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1540_MP2 (qu10_b3_4 qu10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1540_MP2_1 (VDD qu10_b2_1 qu10_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI462_MP2 (dd26_b3_3 dd26_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI462_MP2_1 (VDD dd26_b2_1 dd26_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI449_MP2 (dd25_b3_3 dd25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI449_MP2_1 (VDD dd25_b2_1 dd25_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI371_MP2 (dd19_b3_3 dd19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI371_MP2_1 (VDD dd19_b2_1 dd19_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI384_MP2 (dd20_b3_3 dd20_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI384_MP2_1 (VDD dd20_b2_1 dd20_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI332_MP2 (dd16_b3_3 dd16_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI332_MP2_1 (VDD dd16_b2_1 dd16_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI358_MP2 (dd18_b3_3 dd18_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI358_MP2_1 (VDD dd18_b2_1 dd18_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI476_MP2 (dd27_b3_4 dd27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI476_MP2_1 (VDD dd27_b2_1 dd27_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI345_MP2 (dd17_b3_3 dd17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI345_MP2_1 (VDD dd17_b2_1 dd17_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI267_MP2 (dd11_b3_3 dd11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI267_MP2_1 (VDD dd11_b2_1 dd11_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2074_MP2 (sq_b3_2 sq_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2074_MP2_1 (VDD sq_b2_0 sq_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1533_MP2 (qu10_b1_0 qu10_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1533_MP2_1 (VDD qu10_b0 qu10_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI987_MP2 (qu22_b3_3 qu22_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI987_MP2_1 (VDD qu22_b2_1 qu22_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI982_MP2 (qu22_b2_0 qu22_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI982_MP2_1 (VDD qu22_b1_0 qu22_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI436_MP2 (dd24_b3_3 dd24_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI436_MP2_1 (VDD dd24_b2_1 dd24_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI475_MP2 (dd27_b3_3 dd27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI475_MP2_1 (VDD dd27_b2_1 dd27_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI306_MP2 (dd14_b3_3 dd14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI306_MP2_1 (VDD dd14_b2_1 dd14_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI488_MP2 (dd28_b3_3 dd28_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI488_MP2_1 (VDD dd28_b2_1 dd28_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI280_MP2 (dd12_b3_3 dd12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI280_MP2_1 (VDD dd12_b2_1 dd12_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI410_MP2 (dd22_b3_3 dd22_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI410_MP2_1 (VDD dd22_b2_1 dd22_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI423_MP2 (dd23_b3_3 dd23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI423_MP2_1 (VDD dd23_b2_1 dd23_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI501_MP2 (dd29_b3_3 dd29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI501_MP2_1 (VDD dd29_b2_1 dd29_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI163_MP2 (dd3_b3_3 dd3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI163_MP2_1 (VDD dd3_b2_1 dd3_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI254_MP2 (dd10_b3_3 dd10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI254_MP2_1 (VDD dd10_b2_1 dd10_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI150_MP2 (dd2_b3_3 dd2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI150_MP2_1 (VDD dd2_b2_1 dd2_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI228_MP2 (dd8_b3_3 dd8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI228_MP2_1 (VDD dd8_b2_1 dd8_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI502_MP2 (dd29_b3_4 dd29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI502_MP2_1 (VDD dd29_b2_1 dd29_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI241_MP2 (dd9_b3_3 dd9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI241_MP2_1 (VDD dd9_b2_1 dd9_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI215_MP2 (dd7_b3_3 dd7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI215_MP2_1 (VDD dd7_b2_1 dd7_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI137_MP2 (dd1_b3_3 dd1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI137_MP2_1 (VDD dd1_b2_1 dd1_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI527_MP2 (dd31_b3_3 dd31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI527_MP2_1 (VDD dd31_b2_1 dd31_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI514_MP2 (dd30_b3_3 dd30_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI514_MP2_1 (VDD dd30_b2_1 dd30_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1531_MP2 (qu10 p21_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1531_MP2_1 (VDD p21_32 qu10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI989_MP2 (qu22_b3_5 qu22_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI989_MP2_1 (VDD qu22_b2_1 qu22_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI988_MP2 (qu22_b3_4 qu22_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI988_MP2_1 (VDD qu22_b2_1 qu22_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI983_MP2 (qu22_b2_1 qu22_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI983_MP2_1 (VDD qu22_b1_0 qu22_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI981_MP2 (qu22_b1_0 qu22_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI981_MP2_1 (VDD qu22_b0 qu22_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI397_MP2 (dd21_b3_3 dd21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI397_MP2_1 (VDD dd21_b2_1 dd21_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI176_MP2 (dd4_b3_3 dd4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI176_MP2_1 (VDD dd4_b2_1 dd4_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI189_MP2 (dd5_b3_3 dd5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI189_MP2_1 (VDD dd5_b2_1 dd5_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI202_MP2 (dd6_b3_3 dd6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI202_MP2_1 (VDD dd6_b2_1 dd6_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI979_MP2 (qu22 p9_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI979_MP2_1 (VDD p9_32 qu22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI293_MP2 (dd13_b3_3 dd13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI293_MP2_1 (VDD dd13_b2_1 dd13_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1398_MP2 (qu13_b3_0 qu13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1398_MP2_1 (VDD qu13_b2_0 qu13_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1306_MP2 (qu15_b3_0 qu15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1306_MP2_1 (VDD qu15_b2_0 qu15_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1352_MP2 (qu14_b3_0 qu14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1352_MP2_1 (VDD qu14_b2_0 qu14_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1353_MP2 (qu14_b3_1 qu14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1353_MP2_1 (VDD qu14_b2_0 qu14_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1444_MP2 (qu12_b3_0 qu12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1444_MP2_1 (VDD qu12_b2_0 qu12_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1491_MP2 (qu11_b3_1 qu11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1491_MP2_1 (VDD qu11_b2_0 qu11_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1490_MP2 (qu11_b3_0 qu11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1490_MP2_1 (VDD qu11_b2_0 qu11_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1117_MP2 (qu19 p12_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1117_MP2_1 (VDD p12_32 qu19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1119_MP2 (qu19_b1_0 qu19_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1119_MP2_1 (VDD qu19_b0 qu19_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1121_MP2 (qu19_b2_1 qu19_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1121_MP2_1 (VDD qu19_b1_0 qu19_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1120_MP2 (qu19_b2_0 qu19_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1120_MP2_1 (VDD qu19_b1_0 qu19_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1124_MP2 (qu19_b3_2 qu19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1124_MP2_1 (VDD qu19_b2_0 qu19_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1123_MP2 (qu19_b3_1 qu19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1123_MP2_1 (VDD qu19_b2_0 qu19_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1122_MP2 (qu19_b3_0 qu19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1122_MP2_1 (VDD qu19_b2_0 qu19_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1214_MP2 (qu17_b3_0 qu17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1214_MP2_1 (VDD qu17_b2_0 qu17_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1307_MP2 (qu15_b3_1 qu15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1307_MP2_1 (VDD qu15_b2_0 qu15_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1399_MP2 (qu13_b3_1 qu13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1399_MP2_1 (VDD qu13_b2_0 qu13_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1127_MP2 (qu19_b3_5 qu19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1127_MP2_1 (VDD qu19_b2_1 qu19_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1125_MP2 (qu19_b3_3 qu19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1125_MP2_1 (VDD qu19_b2_1 qu19_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1168_MP2 (qu18_b3_0 qu18_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1168_MP2_1 (VDD qu18_b2_0 qu18_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1260_MP2 (qu16_b3_0 qu16_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1260_MP2_1 (VDD qu16_b2_0 qu16_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1445_MP2 (qu12_b3_1 qu12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1445_MP2_1 (VDD qu12_b2_0 qu12_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1169_MP2 (qu18_b3_1 qu18_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1169_MP2_1 (VDD qu18_b2_0 qu18_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1215_MP2 (qu17_b3_1 qu17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1215_MP2_1 (VDD qu17_b2_0 qu17_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1261_MP2 (qu16_b3_1 qu16_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1261_MP2_1 (VDD qu16_b2_0 qu16_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1126_MP2 (qu19_b3_4 qu19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1126_MP2_1 (VDD qu19_b2_1 qu19_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1350_MP2 (qu14_b2_0 qu14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1350_MP2_1 (VDD qu14_b1_0 qu14_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1354_MP2 (qu14_b3_2 qu14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1354_MP2_1 (VDD qu14_b2_0 qu14_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1492_MP2 (qu11_b3_2 qu11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1492_MP2_1 (VDD qu11_b2_0 qu11_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1488_MP2 (qu11_b2_0 qu11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1488_MP2_1 (VDD qu11_b1_0 qu11_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1163_MP2 (qu18 p13_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1163_MP2_1 (VDD p13_32 qu18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1258_MP2 (qu16_b2_0 qu16_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1258_MP2_1 (VDD qu16_b1_0 qu16_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1262_MP2 (qu16_b3_2 qu16_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1262_MP2_1 (VDD qu16_b2_0 qu16_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1308_MP2 (qu15_b3_2 qu15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1308_MP2_1 (VDD qu15_b2_0 qu15_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1304_MP2 (qu15_b2_0 qu15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1304_MP2_1 (VDD qu15_b1_0 qu15_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1400_MP2 (qu13_b3_2 qu13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1400_MP2_1 (VDD qu13_b2_0 qu13_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1165_MP2 (qu18_b1_0 qu18_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1165_MP2_1 (VDD qu18_b0 qu18_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1166_MP2 (qu18_b2_0 qu18_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1166_MP2_1 (VDD qu18_b1_0 qu18_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1170_MP2 (qu18_b3_2 qu18_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1170_MP2_1 (VDD qu18_b2_0 qu18_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1216_MP2 (qu17_b3_2 qu17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1216_MP2_1 (VDD qu17_b2_0 qu17_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1446_MP2 (qu12_b3_2 qu12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1446_MP2_1 (VDD qu12_b2_0 qu12_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1171_MP2 (qu18_b3_3 qu18_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1171_MP2_1 (VDD qu18_b2_1 qu18_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1167_MP2 (qu18_b2_1 qu18_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1167_MP2_1 (VDD qu18_b1_0 qu18_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1212_MP2 (qu17_b2_0 qu17_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1212_MP2_1 (VDD qu17_b1_0 qu17_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1309_MP2 (qu15_b3_3 qu15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1309_MP2_1 (VDD qu15_b2_1 qu15_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1351_MP2 (qu14_b2_1 qu14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1351_MP2_1 (VDD qu14_b1_0 qu14_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1355_MP2 (qu14_b3_3 qu14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1355_MP2_1 (VDD qu14_b2_1 qu14_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1357_MP2 (qu14_b3_5 qu14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1357_MP2_1 (VDD qu14_b2_1 qu14_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1396_MP2 (qu13_b2_0 qu13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1396_MP2_1 (VDD qu13_b1_0 qu13_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1401_MP2 (qu13_b3_3 qu13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1401_MP2_1 (VDD qu13_b2_1 qu13_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1489_MP2 (qu11_b2_1 qu11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1489_MP2_1 (VDD qu11_b1_0 qu11_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1493_MP2 (qu11_b3_3 qu11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1493_MP2_1 (VDD qu11_b2_1 qu11_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1494_MP2 (qu11_b3_4 qu11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1494_MP2_1 (VDD qu11_b2_1 qu11_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1495_MP2 (qu11_b3_5 qu11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1495_MP2_1 (VDD qu11_b2_1 qu11_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1172_MP2 (qu18_b3_4 qu18_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1172_MP2_1 (VDD qu18_b2_1 qu18_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1173_MP2 (qu18_b3_5 qu18_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1173_MP2_1 (VDD qu18_b2_1 qu18_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1209_MP2 (qu17 p14_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1209_MP2_1 (VDD p14_32 qu17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1211_MP2 (qu17_b1_0 qu17_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1211_MP2_1 (VDD qu17_b0 qu17_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1213_MP2 (qu17_b2_1 qu17_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1213_MP2_1 (VDD qu17_b1_0 qu17_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1218_MP2 (qu17_b3_4 qu17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1218_MP2_1 (VDD qu17_b2_1 qu17_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1219_MP2 (qu17_b3_5 qu17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1219_MP2_1 (VDD qu17_b2_1 qu17_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1217_MP2 (qu17_b3_3 qu17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1217_MP2_1 (VDD qu17_b2_1 qu17_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1265_MP2 (qu16_b3_5 qu16_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1265_MP2_1 (VDD qu16_b2_1 qu16_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1259_MP2 (qu16_b2_1 qu16_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1259_MP2_1 (VDD qu16_b1_0 qu16_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1263_MP2 (qu16_b3_3 qu16_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1263_MP2_1 (VDD qu16_b2_1 qu16_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1264_MP2 (qu16_b3_4 qu16_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1264_MP2_1 (VDD qu16_b2_1 qu16_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1310_MP2 (qu15_b3_4 qu15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1310_MP2_1 (VDD qu15_b2_1 qu15_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1311_MP2 (qu15_b3_5 qu15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1311_MP2_1 (VDD qu15_b2_1 qu15_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1305_MP2 (qu15_b2_1 qu15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1305_MP2_1 (VDD qu15_b1_0 qu15_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1349_MP2 (qu14_b1_0 qu14_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1349_MP2_1 (VDD qu14_b0 qu14_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1356_MP2 (qu14_b3_4 qu14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1356_MP2_1 (VDD qu14_b2_1 qu14_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1397_MP2 (qu13_b2_1 qu13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1397_MP2_1 (VDD qu13_b1_0 qu13_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1402_MP2 (qu13_b3_4 qu13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1402_MP2_1 (VDD qu13_b2_1 qu13_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1403_MP2 (qu13_b3_5 qu13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1403_MP2_1 (VDD qu13_b2_1 qu13_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1447_MP2 (qu12_b3_3 qu12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1447_MP2_1 (VDD qu12_b2_1 qu12_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1487_MP2 (qu11_b1_0 qu11_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1487_MP2_1 (VDD qu11_b0 qu11_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1257_MP2 (qu16_b1_0 qu16_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1257_MP2_1 (VDD qu16_b0 qu16_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1347_MP2 (qu14 p17_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1347_MP2_1 (VDD p17_32 qu14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1393_MP2 (qu13 p18_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1393_MP2_1 (VDD p18_32 qu13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1395_MP2 (qu13_b1_0 qu13_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1395_MP2_1 (VDD qu13_b0 qu13_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1443_MP2 (qu12_b2_1 qu12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1443_MP2_1 (VDD qu12_b1_0 qu12_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1442_MP2 (qu12_b2_0 qu12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1442_MP2_1 (VDD qu12_b1_0 qu12_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1441_MP2 (qu12_b1_0 qu12_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1441_MP2_1 (VDD qu12_b0 qu12_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1449_MP2 (qu12_b3_5 qu12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1449_MP2_1 (VDD qu12_b2_1 qu12_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1448_MP2 (qu12_b3_4 qu12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1448_MP2_1 (VDD qu12_b2_1 qu12_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1485_MP2 (qu11 p20_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1485_MP2_1 (VDD p20_32 qu11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1255_MP2 (qu16 p15_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1255_MP2_1 (VDD p15_32 qu16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1301_MP2 (qu15 p16_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1301_MP2_1 (VDD p16_32 qu15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1303_MP2 (qu15_b1_0 qu15_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1303_MP2_1 (VDD qu15_b0 qu15_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1439_MP2 (qu12 p19_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1439_MP2_1 (VDD p19_32 qu12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I127_XG_MP2 (XI654_I127_XG_p1 I654_G31_30 I654_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I127_XG_MP0 (VDD I654_P31_30 XI654_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I127_XG_MP1 (XI654_I127_XG_p1 I654_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I126_XG_MP2 (XI654_I126_XG_p1 I654_G30_29 I654_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I126_XG_MP0 (VDD I654_P30_29 XI654_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I126_XG_MP1 (XI654_I126_XG_p1 I654_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I127_XG_MP2 (XI608_I127_XG_p1 I608_G31_30 I608_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I127_XG_MP0 (VDD I608_P31_30 XI608_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I127_XG_MP1 (XI608_I127_XG_p1 I608_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I127_XG_MP2 (XI562_I127_XG_p1 I562_G31_30 I562_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I127_XG_MP0 (VDD I562_P31_30 XI562_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I127_XG_MP1 (XI562_I127_XG_p1 I562_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2233_MP2 (XI2233_p1 nrk21 nrkn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2233_MP0 (VDD A_31_b3_9 XI2233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2233_MP1 (XI2233_p1 ru21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2236_MP2 (XI2236_p1 nrk22 nrkn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2236_MP0 (VDD A_31_b3_9 XI2236_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2236_MP1 (XI2236_p1 ru22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2239_MP2 (XI2239_p1 nrk23 nrkn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2239_MP0 (VDD A_31_b3_9 XI2239_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2239_MP1 (XI2239_p1 ru23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2242_MP2 (XI2242_p1 nrk24 nrkn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2242_MP0 (VDD A_31_b3_9 XI2242_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2242_MP1 (XI2242_p1 ru24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2251_MP2 (XI2251_p1 nrk27 nrkn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2251_MP0 (VDD A_31_b3_10 XI2251_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2251_MP1 (XI2251_p1 ru27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2248_MP2 (XI2248_p1 nrk26 nrkn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2248_MP0 (VDD A_31_b3_10 XI2248_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2248_MP1 (XI2248_p1 ru26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2254_MP2 (XI2254_p1 nrk28 nrkn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2254_MP0 (VDD A_31_b3_10 XI2254_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2254_MP1 (XI2254_p1 ru28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2257_MP2 (XI2257_p1 nrk29 nrkn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2257_MP0 (VDD A_31_b3_10 XI2257_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2257_MP1 (XI2257_p1 ru29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2260_MP2 (XI2260_p1 nrk30 nrkn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2260_MP0 (VDD A_31_b3_10 XI2260_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2260_MP1 (XI2260_p1 ru30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I126_XG_MP2 (XI1942_I126_XG_p1 I1942_G30_29 I1942_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I126_XG_MP0 (VDD I1942_P30_29 XI1942_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I126_XG_MP1 (XI1942_I126_XG_p1 I1942_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I127_XG_MP2 (XI1942_I127_XG_p1 I1942_G31_30 I1942_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I127_XG_MP0 (VDD I1942_P31_30 XI1942_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I127_XG_MP1 (XI1942_I127_XG_p1 I1942_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I181_XG_MP2 (XI1896_I181_XG_p1 I1896_G30_23 I1896_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I181_XG_MP0 (VDD I1896_P30_23 XI1896_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I181_XG_MP1 (XI1896_I181_XG_p1 I1896_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I126_XG_MP2 (XI1896_I126_XG_p1 I1896_G30_29 I1896_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I126_XG_MP0 (VDD I1896_P30_29 XI1896_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I126_XG_MP1 (XI1896_I126_XG_p1 I1896_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I182_XG_MP2 (XI654_I182_XG_p1 I654_G31_24 I654_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I182_XG_MP0 (VDD I654_P31_24 XI654_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I182_XG_MP1 (XI654_I182_XG_p1 I654_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I125_XG_MP2 (XI654_I125_XG_p1 I654_G29_28 I654_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I125_XG_MP0 (VDD I654_P29_28 XI654_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I125_XG_MP1 (XI654_I125_XG_p1 I654_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I123_XG_MP2 (XI654_I123_XG_p1 I654_G27_26 I654_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I123_XG_MP0 (VDD I654_P27_26 XI654_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I123_XG_MP1 (XI654_I123_XG_p1 I654_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I124_XG_MP2 (XI654_I124_XG_p1 I654_G28_27 I654_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I124_XG_MP0 (VDD I654_P28_27 XI654_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I124_XG_MP1 (XI654_I124_XG_p1 I654_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I182_XG_MP2 (XI608_I182_XG_p1 I608_G31_24 I608_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I182_XG_MP0 (VDD I608_P31_24 XI608_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I182_XG_MP1 (XI608_I182_XG_p1 I608_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I123_XG_MP2 (XI608_I123_XG_p1 I608_G27_26 I608_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I123_XG_MP0 (VDD I608_P27_26 XI608_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I123_XG_MP1 (XI608_I123_XG_p1 I608_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I125_XG_MP2 (XI608_I125_XG_p1 I608_G29_28 I608_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I125_XG_MP0 (VDD I608_P29_28 XI608_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I125_XG_MP1 (XI608_I125_XG_p1 I608_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I126_XG_MP2 (XI608_I126_XG_p1 I608_G30_29 I608_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I126_XG_MP0 (VDD I608_P30_29 XI608_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I126_XG_MP1 (XI608_I126_XG_p1 I608_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I124_XG_MP2 (XI608_I124_XG_p1 I608_G28_27 I608_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I124_XG_MP0 (VDD I608_P28_27 XI608_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I124_XG_MP1 (XI608_I124_XG_p1 I608_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I126_XG_MP2 (XI562_I126_XG_p1 I562_G30_29 I562_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I126_XG_MP0 (VDD I562_P30_29 XI562_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I126_XG_MP1 (XI562_I126_XG_p1 I562_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2230_MP2 (XI2230_p1 nrk20 nrkn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2230_MP0 (VDD A_31_b3_9 XI2230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2230_MP1 (XI2230_p1 ru20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2245_MP2 (XI2245_p1 nrk25 nrkn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2245_MP0 (VDD A_31_b3_9 XI2245_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2245_MP1 (XI2245_p1 ru25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I125_XG_MP2 (XI2066_I125_XG_p1 I2066_G29_28 I2066_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I125_XG_MP0 (VDD I2066_P29_28 XI2066_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I125_XG_MP1 (XI2066_I125_XG_p1 I2066_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I127_XG_MP2 (XI2066_I127_XG_p1 I2066_G31_30 I2066_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I127_XG_MP0 (VDD I2066_P31_30 XI2066_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I127_XG_MP1 (XI2066_I127_XG_p1 I2066_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I126_XG_MP2 (XI2066_I126_XG_p1 I2066_G30_29 I2066_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I126_XG_MP0 (VDD I2066_P30_29 XI2066_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I126_XG_MP1 (XI2066_I126_XG_p1 I2066_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I126_XG_MP2 (XI1988_I126_XG_p1 I1988_G30_29 I1988_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I126_XG_MP0 (VDD I1988_P30_29 XI1988_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I126_XG_MP1 (XI1988_I126_XG_p1 I1988_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I124_XG_MP2 (XI1988_I124_XG_p1 I1988_G28_27 I1988_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I124_XG_MP0 (VDD I1988_P28_27 XI1988_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I124_XG_MP1 (XI1988_I124_XG_p1 I1988_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I127_XG_MP2 (XI1988_I127_XG_p1 I1988_G31_30 I1988_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I127_XG_MP0 (VDD I1988_P31_30 XI1988_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I127_XG_MP1 (XI1988_I127_XG_p1 I1988_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I125_XG_MP2 (XI1988_I125_XG_p1 I1988_G29_28 I1988_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I125_XG_MP0 (VDD I1988_P29_28 XI1988_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I125_XG_MP1 (XI1988_I125_XG_p1 I1988_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I181_XG_MP2 (XI1942_I181_XG_p1 I1942_G30_23 I1942_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I181_XG_MP0 (VDD I1942_P30_23 XI1942_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I181_XG_MP1 (XI1942_I181_XG_p1 I1942_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I124_XG_MP2 (XI1942_I124_XG_p1 I1942_G28_27 I1942_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I124_XG_MP0 (VDD I1942_P28_27 XI1942_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I124_XG_MP1 (XI1942_I124_XG_p1 I1942_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I182_XG_MP2 (XI1942_I182_XG_p1 I1942_G31_24 I1942_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I182_XG_MP0 (VDD I1942_P31_24 XI1942_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I182_XG_MP1 (XI1942_I182_XG_p1 I1942_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I125_XG_MP2 (XI1942_I125_XG_p1 I1942_G29_28 I1942_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I125_XG_MP0 (VDD I1942_P29_28 XI1942_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I125_XG_MP1 (XI1942_I125_XG_p1 I1942_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I123_XG_MP2 (XI1942_I123_XG_p1 I1942_G27_26 I1942_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I123_XG_MP0 (VDD I1942_P27_26 XI1942_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I123_XG_MP1 (XI1942_I123_XG_p1 I1942_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I177_XG_MP2 (XI1896_I177_XG_p1 I1896_G26_19 I1896_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I177_XG_MP0 (VDD I1896_P26_19 XI1896_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I177_XG_MP1 (XI1896_I177_XG_p1 I1896_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I179_XG_MP2 (XI1896_I179_XG_p1 I1896_G28_21 I1896_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I179_XG_MP0 (VDD I1896_P28_21 XI1896_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I179_XG_MP1 (XI1896_I179_XG_p1 I1896_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I122_XG_MP2 (XI1896_I122_XG_p1 I1896_G26_25 I1896_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I122_XG_MP0 (VDD I1896_P26_25 XI1896_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I122_XG_MP1 (XI1896_I122_XG_p1 I1896_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I124_XG_MP2 (XI1896_I124_XG_p1 I1896_G28_27 I1896_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I124_XG_MP0 (VDD I1896_P28_27 XI1896_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I124_XG_MP1 (XI1896_I124_XG_p1 I1896_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I178_XG_MP2 (XI654_I178_XG_p1 I654_G27_20 I654_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I178_XG_MP0 (VDD I654_P27_20 XI654_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I178_XG_MP1 (XI654_I178_XG_p1 I654_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I121_XG_MP2 (XI654_I121_XG_p1 I654_G25_24 I654_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I121_XG_MP0 (VDD I654_P25_24 XI654_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I121_XG_MP1 (XI654_I121_XG_p1 I654_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I181_XG_MP2 (XI654_I181_XG_p1 I654_G30_23 I654_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I181_XG_MP0 (VDD I654_P30_23 XI654_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I181_XG_MP1 (XI654_I181_XG_p1 I654_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I122_XG_MP2 (XI654_I122_XG_p1 I654_G26_25 I654_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I122_XG_MP0 (VDD I654_P26_25 XI654_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I122_XG_MP1 (XI654_I122_XG_p1 I654_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I174_XG_MP2 (XI608_I174_XG_p1 I608_G23_16 I608_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I174_XG_MP0 (VDD I608_P23_16 XI608_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I174_XG_MP1 (XI608_I174_XG_p1 I608_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I178_XG_MP2 (XI608_I178_XG_p1 I608_G27_20 I608_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I178_XG_MP0 (VDD I608_P27_20 XI608_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I178_XG_MP1 (XI608_I178_XG_p1 I608_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I121_XG_MP2 (XI608_I121_XG_p1 I608_G25_24 I608_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I121_XG_MP0 (VDD I608_P25_24 XI608_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I121_XG_MP1 (XI608_I121_XG_p1 I608_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I119_XG_MP2 (XI608_I119_XG_p1 I608_G23_22 I608_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I119_XG_MP0 (VDD I608_P23_22 XI608_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I119_XG_MP1 (XI608_I119_XG_p1 I608_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I122_XG_MP2 (XI608_I122_XG_p1 I608_G26_25 I608_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I122_XG_MP0 (VDD I608_P26_25 XI608_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I122_XG_MP1 (XI608_I122_XG_p1 I608_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I124_XG_MP2 (XI562_I124_XG_p1 I562_G28_27 I562_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I124_XG_MP0 (VDD I562_P28_27 XI562_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I124_XG_MP1 (XI562_I124_XG_p1 I562_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I125_XG_MP2 (XI562_I125_XG_p1 I562_G29_28 I562_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I125_XG_MP0 (VDD I562_P29_28 XI562_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I125_XG_MP1 (XI562_I125_XG_p1 I562_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I123_XG_MP2 (XI562_I123_XG_p1 I562_G27_26 I562_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I123_XG_MP0 (VDD I562_P27_26 XI562_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I123_XG_MP1 (XI562_I123_XG_p1 I562_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2224_MP2 (XI2224_p1 nrk18 nrkn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2224_MP0 (VDD A_31_b3_8 XI2224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2224_MP1 (XI2224_p1 ru18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2227_MP2 (XI2227_p1 nrk19 nrkn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2227_MP0 (VDD A_31_b3_8 XI2227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2227_MP1 (XI2227_p1 ru19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2221_MP2 (XI2221_p1 nrk17 nrkn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2221_MP0 (VDD A_31_b3_8 XI2221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2221_MP1 (XI2221_p1 ru17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2218_MP2 (XI2218_p1 nrk16 nrkn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2218_MP0 (VDD A_31_b3_8 XI2218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2218_MP1 (XI2218_p1 ru16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I182_XG_MP2 (XI2066_I182_XG_p1 I2066_G31_24 I2066_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I182_XG_MP0 (VDD I2066_P31_24 XI2066_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I182_XG_MP1 (XI2066_I182_XG_p1 I2066_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I180_XG_MP2 (XI2066_I180_XG_p1 I2066_G29_22 I2066_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I180_XG_MP0 (VDD I2066_P29_22 XI2066_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I180_XG_MP1 (XI2066_I180_XG_p1 I2066_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I123_XG_MP2 (XI2066_I123_XG_p1 I2066_G27_26 I2066_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I123_XG_MP0 (VDD I2066_P27_26 XI2066_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I123_XG_MP1 (XI2066_I123_XG_p1 I2066_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I121_XG_MP2 (XI2066_I121_XG_p1 I2066_G25_24 I2066_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I121_XG_MP0 (VDD I2066_P25_24 XI2066_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I121_XG_MP1 (XI2066_I121_XG_p1 I2066_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I124_XG_MP2 (XI2066_I124_XG_p1 I2066_G28_27 I2066_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I124_XG_MP0 (VDD I2066_P28_27 XI2066_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I124_XG_MP1 (XI2066_I124_XG_p1 I2066_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I182_XG_MP2 (XI1988_I182_XG_p1 I1988_G31_24 I1988_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I182_XG_MP0 (VDD I1988_P31_24 XI1988_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I182_XG_MP1 (XI1988_I182_XG_p1 I1988_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I123_XG_MP2 (XI1988_I123_XG_p1 I1988_G27_26 I1988_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I123_XG_MP0 (VDD I1988_P27_26 XI1988_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I123_XG_MP1 (XI1988_I123_XG_p1 I1988_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I179_XG_MP2 (XI1942_I179_XG_p1 I1942_G28_21 I1942_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I179_XG_MP0 (VDD I1942_P28_21 XI1942_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I179_XG_MP1 (XI1942_I179_XG_p1 I1942_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I122_XG_MP2 (XI1942_I122_XG_p1 I1942_G26_25 I1942_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I122_XG_MP0 (VDD I1942_P26_25 XI1942_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I122_XG_MP1 (XI1942_I122_XG_p1 I1942_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I120_XG_MP2 (XI1942_I120_XG_p1 I1942_G24_23 I1942_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I120_XG_MP0 (VDD I1942_P24_23 XI1942_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I120_XG_MP1 (XI1942_I120_XG_p1 I1942_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I180_XG_MP2 (XI1942_I180_XG_p1 I1942_G29_22 I1942_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I180_XG_MP0 (VDD I1942_P29_22 XI1942_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I180_XG_MP1 (XI1942_I180_XG_p1 I1942_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I121_XG_MP2 (XI1942_I121_XG_p1 I1942_G25_24 I1942_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I121_XG_MP0 (VDD I1942_P25_24 XI1942_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I121_XG_MP1 (XI1942_I121_XG_p1 I1942_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I173_XG_MP2 (XI1896_I173_XG_p1 I1896_G22_15 I1896_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I173_XG_MP0 (VDD I1896_P22_15 XI1896_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I173_XG_MP1 (XI1896_I173_XG_p1 I1896_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I175_XG_MP2 (XI1896_I175_XG_p1 I1896_G24_17 I1896_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I175_XG_MP0 (VDD I1896_P24_17 XI1896_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I175_XG_MP1 (XI1896_I175_XG_p1 I1896_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I118_XG_MP2 (XI1896_I118_XG_p1 I1896_G22_21 I1896_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I118_XG_MP0 (VDD I1896_P22_21 XI1896_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I118_XG_MP1 (XI1896_I118_XG_p1 I1896_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I120_XG_MP2 (XI1896_I120_XG_p1 I1896_G24_23 I1896_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I120_XG_MP0 (VDD I1896_P24_23 XI1896_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I120_XG_MP1 (XI1896_I120_XG_p1 I1896_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I180_XG_MP2 (XI1896_I180_XG_p1 I1896_G29_22 I1896_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I180_XG_MP0 (VDD I1896_P29_22 XI1896_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I180_XG_MP1 (XI1896_I180_XG_p1 I1896_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I125_XG_MP2 (XI1896_I125_XG_p1 I1896_G29_28 I1896_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I125_XG_MP0 (VDD I1896_P29_28 XI1896_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I125_XG_MP1 (XI1896_I125_XG_p1 I1896_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I174_XG_MP2 (XI654_I174_XG_p1 I654_G23_16 I654_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I174_XG_MP0 (VDD I654_P23_16 XI654_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I174_XG_MP1 (XI654_I174_XG_p1 I654_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I180_XG_MP2 (XI654_I180_XG_p1 I654_G29_22 I654_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I180_XG_MP0 (VDD I654_P29_22 XI654_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I180_XG_MP1 (XI654_I180_XG_p1 I654_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I119_XG_MP2 (XI654_I119_XG_p1 I654_G23_22 I654_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I119_XG_MP0 (VDD I654_P23_22 XI654_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I119_XG_MP1 (XI654_I119_XG_p1 I654_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I179_XG_MP2 (XI654_I179_XG_p1 I654_G28_21 I654_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I179_XG_MP0 (VDD I654_P28_21 XI654_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I179_XG_MP1 (XI654_I179_XG_p1 I654_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I120_XG_MP2 (XI654_I120_XG_p1 I654_G24_23 I654_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I120_XG_MP0 (VDD I654_P24_23 XI654_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I120_XG_MP1 (XI654_I120_XG_p1 I654_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I118_XG_MP2 (XI654_I118_XG_p1 I654_G22_21 I654_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I118_XG_MP0 (VDD I654_P22_21 XI654_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I118_XG_MP1 (XI654_I118_XG_p1 I654_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I180_XG_MP2 (XI608_I180_XG_p1 I608_G29_22 I608_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I180_XG_MP0 (VDD I608_P29_22 XI608_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I180_XG_MP1 (XI608_I180_XG_p1 I608_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I181_XG_MP2 (XI608_I181_XG_p1 I608_G30_23 I608_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I181_XG_MP0 (VDD I608_P30_23 XI608_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I181_XG_MP1 (XI608_I181_XG_p1 I608_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I120_XG_MP2 (XI608_I120_XG_p1 I608_G24_23 I608_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I120_XG_MP0 (VDD I608_P24_23 XI608_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I120_XG_MP1 (XI608_I120_XG_p1 I608_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I122_XG_MP2 (XI562_I122_XG_p1 I562_G26_25 I562_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I122_XG_MP0 (VDD I562_P26_25 XI562_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I122_XG_MP1 (XI562_I122_XG_p1 I562_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I121_XG_MP2 (XI562_I121_XG_p1 I562_G25_24 I562_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I121_XG_MP0 (VDD I562_P25_24 XI562_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I121_XG_MP1 (XI562_I121_XG_p1 I562_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I182_XG_MP2 (XI562_I182_XG_p1 I562_G31_24 I562_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I182_XG_MP0 (VDD I562_P31_24 XI562_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I182_XG_MP1 (XI562_I182_XG_p1 I562_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2215_MP2 (XI2215_p1 nrk15 nrkn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2215_MP0 (VDD A_31_b3_8 XI2215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2215_MP1 (XI2215_p1 ru15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I174_XG_MP2 (XI2066_I174_XG_p1 I2066_G23_16 I2066_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I174_XG_MP0 (VDD I2066_P23_16 XI2066_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I174_XG_MP1 (XI2066_I174_XG_p1 I2066_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I119_XG_MP2 (XI2066_I119_XG_p1 I2066_G23_22 I2066_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I119_XG_MP0 (VDD I2066_P23_22 XI2066_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I119_XG_MP1 (XI2066_I119_XG_p1 I2066_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I181_XG_MP2 (XI2066_I181_XG_p1 I2066_G30_23 I2066_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I181_XG_MP0 (VDD I2066_P30_23 XI2066_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I181_XG_MP1 (XI2066_I181_XG_p1 I2066_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I122_XG_MP2 (XI2066_I122_XG_p1 I2066_G26_25 I2066_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I122_XG_MP0 (VDD I2066_P26_25 XI2066_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I122_XG_MP1 (XI2066_I122_XG_p1 I2066_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I181_XG_MP2 (XI1988_I181_XG_p1 I1988_G30_23 I1988_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I181_XG_MP0 (VDD I1988_P30_23 XI1988_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I181_XG_MP1 (XI1988_I181_XG_p1 I1988_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I122_XG_MP2 (XI1988_I122_XG_p1 I1988_G26_25 I1988_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I122_XG_MP0 (VDD I1988_P26_25 XI1988_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I122_XG_MP1 (XI1988_I122_XG_p1 I1988_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I120_XG_MP2 (XI1988_I120_XG_p1 I1988_G24_23 I1988_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I120_XG_MP0 (VDD I1988_P24_23 XI1988_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I120_XG_MP1 (XI1988_I120_XG_p1 I1988_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I180_XG_MP2 (XI1988_I180_XG_p1 I1988_G29_22 I1988_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I180_XG_MP0 (VDD I1988_P29_22 XI1988_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I180_XG_MP1 (XI1988_I180_XG_p1 I1988_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I121_XG_MP2 (XI1988_I121_XG_p1 I1988_G25_24 I1988_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I121_XG_MP0 (VDD I1988_P25_24 XI1988_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I121_XG_MP1 (XI1988_I121_XG_p1 I1988_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I177_XG_MP2 (XI1942_I177_XG_p1 I1942_G26_19 I1942_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I177_XG_MP0 (VDD I1942_P26_19 XI1942_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I177_XG_MP1 (XI1942_I177_XG_p1 I1942_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I173_XG_MP2 (XI1942_I173_XG_p1 I1942_G22_15 I1942_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I173_XG_MP0 (VDD I1942_P22_15 XI1942_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I173_XG_MP1 (XI1942_I173_XG_p1 I1942_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I118_XG_MP2 (XI1942_I118_XG_p1 I1942_G22_21 I1942_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I118_XG_MP0 (VDD I1942_P22_21 XI1942_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I118_XG_MP1 (XI1942_I118_XG_p1 I1942_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I178_XG_MP2 (XI1942_I178_XG_p1 I1942_G27_20 I1942_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I178_XG_MP0 (VDD I1942_P27_20 XI1942_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I178_XG_MP1 (XI1942_I178_XG_p1 I1942_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I174_XG_MP2 (XI1942_I174_XG_p1 I1942_G23_16 I1942_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I174_XG_MP0 (VDD I1942_P23_16 XI1942_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I174_XG_MP1 (XI1942_I174_XG_p1 I1942_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I119_XG_MP2 (XI1942_I119_XG_p1 I1942_G23_22 I1942_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I119_XG_MP0 (VDD I1942_P23_22 XI1942_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I119_XG_MP1 (XI1942_I119_XG_p1 I1942_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I171_XG_MP2 (XI1896_I171_XG_p1 I1896_G20_13 I1896_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I171_XG_MP0 (VDD I1896_P20_13 XI1896_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I171_XG_MP1 (XI1896_I171_XG_p1 I1896_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I165_XG_MP2 (XI1896_I165_XG_p1 I1896_G14_7 I1896_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I165_XG_MP0 (VDD I1896_P14_7 XI1896_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I165_XG_MP1 (XI1896_I165_XG_p1 I1896_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I116_XG_MP2 (XI1896_I116_XG_p1 I1896_G20_19 I1896_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I116_XG_MP0 (VDD I1896_P20_19 XI1896_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I116_XG_MP1 (XI1896_I116_XG_p1 I1896_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I176_XG_MP2 (XI1896_I176_XG_p1 I1896_G25_18 I1896_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I176_XG_MP0 (VDD I1896_P25_18 XI1896_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I176_XG_MP1 (XI1896_I176_XG_p1 I1896_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I121_XG_MP2 (XI1896_I121_XG_p1 I1896_G25_24 I1896_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I121_XG_MP0 (VDD I1896_P25_24 XI1896_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I121_XG_MP1 (XI1896_I121_XG_p1 I1896_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I123_XG_MP2 (XI1896_I123_XG_p1 I1896_G27_26 I1896_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I123_XG_MP0 (VDD I1896_P27_26 XI1896_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I123_XG_MP1 (XI1896_I123_XG_p1 I1896_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I127_XG_MP2 (XI1896_I127_XG_p1 I1896_G31_30 I1896_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I127_XG_MP0 (VDD I1896_P31_30 XI1896_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I127_XG_MP1 (XI1896_I127_XG_p1 I1896_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I127_XG_MP2 (XI700_I127_XG_p1 I700_G31_30 I700_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I127_XG_MP0 (VDD I700_P31_30 XI700_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I127_XG_MP1 (XI700_I127_XG_p1 I700_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I172_XG_MP2 (XI654_I172_XG_p1 I654_G21_14 I654_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I172_XG_MP0 (VDD I654_P21_14 XI654_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I172_XG_MP1 (XI654_I172_XG_p1 I654_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I117_XG_MP2 (XI654_I117_XG_p1 I654_G21_20 I654_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I117_XG_MP0 (VDD I654_P21_20 XI654_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I117_XG_MP1 (XI654_I117_XG_p1 I654_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I173_XG_MP2 (XI654_I173_XG_p1 I654_G22_15 I654_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I173_XG_MP0 (VDD I654_P22_15 XI654_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I173_XG_MP1 (XI654_I173_XG_p1 I654_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I172_XG_MP2 (XI608_I172_XG_p1 I608_G21_14 I608_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I172_XG_MP0 (VDD I608_P21_14 XI608_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I172_XG_MP1 (XI608_I172_XG_p1 I608_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I117_XG_MP2 (XI608_I117_XG_p1 I608_G21_20 I608_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I117_XG_MP0 (VDD I608_P21_20 XI608_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I117_XG_MP1 (XI608_I117_XG_p1 I608_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I173_XG_MP2 (XI608_I173_XG_p1 I608_G22_15 I608_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I173_XG_MP0 (VDD I608_P22_15 XI608_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I173_XG_MP1 (XI608_I173_XG_p1 I608_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I179_XG_MP2 (XI608_I179_XG_p1 I608_G28_21 I608_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I179_XG_MP0 (VDD I608_P28_21 XI608_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I179_XG_MP1 (XI608_I179_XG_p1 I608_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I118_XG_MP2 (XI608_I118_XG_p1 I608_G22_21 I608_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I118_XG_MP0 (VDD I608_P22_21 XI608_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I118_XG_MP1 (XI608_I118_XG_p1 I608_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I120_XG_MP2 (XI562_I120_XG_p1 I562_G24_23 I562_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I120_XG_MP0 (VDD I562_P24_23 XI562_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I120_XG_MP1 (XI562_I120_XG_p1 I562_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I118_XG_MP2 (XI562_I118_XG_p1 I562_G22_21 I562_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I118_XG_MP0 (VDD I562_P22_21 XI562_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I118_XG_MP1 (XI562_I118_XG_p1 I562_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I181_XG_MP2 (XI562_I181_XG_p1 I562_G30_23 I562_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I181_XG_MP0 (VDD I562_P30_23 XI562_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I181_XG_MP1 (XI562_I181_XG_p1 I562_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I119_XG_MP2 (XI562_I119_XG_p1 I562_G23_22 I562_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I119_XG_MP0 (VDD I562_P23_22 XI562_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I119_XG_MP1 (XI562_I119_XG_p1 I562_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I180_XG_MP2 (XI562_I180_XG_p1 I562_G29_22 I562_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I180_XG_MP0 (VDD I562_P29_22 XI562_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I180_XG_MP1 (XI562_I180_XG_p1 I562_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I174_XG_MP2 (XI562_I174_XG_p1 I562_G23_16 I562_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I174_XG_MP0 (VDD I562_P23_16 XI562_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I174_XG_MP1 (XI562_I174_XG_p1 I562_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2212_MP2 (XI2212_p1 nrk14 nrkn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2212_MP0 (VDD A_31_b3_8 XI2212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2212_MP1 (XI2212_p1 ru14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I166_XG_MP2 (XI2066_I166_XG_p1 I2066_G15_8 I2066_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I166_XG_MP0 (VDD I2066_P15_8 XI2066_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I166_XG_MP1 (XI2066_I166_XG_p1 I2066_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I178_XG_MP2 (XI2066_I178_XG_p1 I2066_G27_20 I2066_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I178_XG_MP0 (VDD I2066_P27_20 XI2066_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I178_XG_MP1 (XI2066_I178_XG_p1 I2066_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I173_XG_MP2 (XI2066_I173_XG_p1 I2066_G22_15 I2066_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I173_XG_MP0 (VDD I2066_P22_15 XI2066_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I173_XG_MP1 (XI2066_I173_XG_p1 I2066_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I165_XG_MP2 (XI2066_I165_XG_p1 I2066_G14_7 I2066_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I165_XG_MP0 (VDD I2066_P14_7 XI2066_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I165_XG_MP1 (XI2066_I165_XG_p1 I2066_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I120_XG_MP2 (XI2066_I120_XG_p1 I2066_G24_23 I2066_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I120_XG_MP0 (VDD I2066_P24_23 XI2066_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I120_XG_MP1 (XI2066_I120_XG_p1 I2066_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I179_XG_MP2 (XI1988_I179_XG_p1 I1988_G28_21 I1988_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I179_XG_MP0 (VDD I1988_P28_21 XI1988_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I179_XG_MP1 (XI1988_I179_XG_p1 I1988_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I118_XG_MP2 (XI1988_I118_XG_p1 I1988_G22_21 I1988_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I118_XG_MP0 (VDD I1988_P22_21 XI1988_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I118_XG_MP1 (XI1988_I118_XG_p1 I1988_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I174_XG_MP2 (XI1988_I174_XG_p1 I1988_G23_16 I1988_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I174_XG_MP0 (VDD I1988_P23_16 XI1988_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I174_XG_MP1 (XI1988_I174_XG_p1 I1988_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I119_XG_MP2 (XI1988_I119_XG_p1 I1988_G23_22 I1988_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I119_XG_MP0 (VDD I1988_P23_22 XI1988_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I119_XG_MP1 (XI1988_I119_XG_p1 I1988_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I165_XG_MP2 (XI1942_I165_XG_p1 I1942_G14_7 I1942_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I165_XG_MP0 (VDD I1942_P14_7 XI1942_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I165_XG_MP1 (XI1942_I165_XG_p1 I1942_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I166_XG_MP2 (XI1942_I166_XG_p1 I1942_G15_8 I1942_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I166_XG_MP0 (VDD I1942_P15_8 XI1942_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I166_XG_MP1 (XI1942_I166_XG_p1 I1942_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I176_XG_MP2 (XI1942_I176_XG_p1 I1942_G25_18 I1942_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I176_XG_MP0 (VDD I1942_P25_18 XI1942_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I176_XG_MP1 (XI1942_I176_XG_p1 I1942_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I117_XG_MP2 (XI1942_I117_XG_p1 I1942_G21_20 I1942_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I117_XG_MP0 (VDD I1942_P21_20 XI1942_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I117_XG_MP1 (XI1942_I117_XG_p1 I1942_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I160_XG_MP2 (XI1896_I160_XG_p1 I1896_G10_3 I1896_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I160_XG_MP0 (VDD I1896_P10_3 XI1896_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I160_XG_MP1 (XI1896_I160_XG_p1 I1896_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I163_XG_MP2 (XI1896_I163_XG_p1 I1896_G12_5 I1896_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I163_XG_MP0 (VDD I1896_P12_5 XI1896_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I163_XG_MP1 (XI1896_I163_XG_p1 I1896_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I169_XG_MP2 (XI1896_I169_XG_p1 I1896_G18_11 I1896_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I169_XG_MP0 (VDD I1896_P18_11 XI1896_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I169_XG_MP1 (XI1896_I169_XG_p1 I1896_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I114_XG_MP2 (XI1896_I114_XG_p1 I1896_G18_17 I1896_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I114_XG_MP0 (VDD I1896_P18_17 XI1896_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I114_XG_MP1 (XI1896_I114_XG_p1 I1896_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I172_XG_MP2 (XI1896_I172_XG_p1 I1896_G21_14 I1896_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I172_XG_MP0 (VDD I1896_P21_14 XI1896_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I172_XG_MP1 (XI1896_I172_XG_p1 I1896_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I117_XG_MP2 (XI1896_I117_XG_p1 I1896_G21_20 I1896_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I117_XG_MP0 (VDD I1896_P21_20 XI1896_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I117_XG_MP1 (XI1896_I117_XG_p1 I1896_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I119_XG_MP2 (XI1896_I119_XG_p1 I1896_G23_22 I1896_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I119_XG_MP0 (VDD I1896_P23_22 XI1896_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I119_XG_MP1 (XI1896_I119_XG_p1 I1896_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I125_XG_MP2 (XI700_I125_XG_p1 I700_G29_28 I700_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I125_XG_MP0 (VDD I700_P29_28 XI700_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I125_XG_MP1 (XI700_I125_XG_p1 I700_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I123_XG_MP2 (XI700_I123_XG_p1 I700_G27_26 I700_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I123_XG_MP0 (VDD I700_P27_26 XI700_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I123_XG_MP1 (XI700_I123_XG_p1 I700_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I121_XG_MP2 (XI700_I121_XG_p1 I700_G25_24 I700_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I121_XG_MP0 (VDD I700_P25_24 XI700_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I121_XG_MP1 (XI700_I121_XG_p1 I700_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I166_XG_MP2 (XI654_I166_XG_p1 I654_G15_8 I654_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I166_XG_MP0 (VDD I654_P15_8 XI654_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I166_XG_MP1 (XI654_I166_XG_p1 I654_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I170_XG_MP2 (XI654_I170_XG_p1 I654_G19_12 I654_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I170_XG_MP0 (VDD I654_P19_12 XI654_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I170_XG_MP1 (XI654_I170_XG_p1 I654_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I176_XG_MP2 (XI654_I176_XG_p1 I654_G25_18 I654_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I176_XG_MP0 (VDD I654_P25_18 XI654_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I176_XG_MP1 (XI654_I176_XG_p1 I654_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I115_XG_MP2 (XI654_I115_XG_p1 I654_G19_18 I654_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I115_XG_MP0 (VDD I654_P19_18 XI654_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I115_XG_MP1 (XI654_I115_XG_p1 I654_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I165_XG_MP2 (XI654_I165_XG_p1 I654_G14_7 I654_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I165_XG_MP0 (VDD I654_P14_7 XI654_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I165_XG_MP1 (XI654_I165_XG_p1 I654_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I175_XG_MP2 (XI654_I175_XG_p1 I654_G24_17 I654_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I175_XG_MP0 (VDD I654_P24_17 XI654_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I175_XG_MP1 (XI654_I175_XG_p1 I654_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I177_XG_MP2 (XI654_I177_XG_p1 I654_G26_19 I654_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I177_XG_MP0 (VDD I654_P26_19 XI654_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I177_XG_MP1 (XI654_I177_XG_p1 I654_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I114_XG_MP2 (XI654_I114_XG_p1 I654_G18_17 I654_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I114_XG_MP0 (VDD I654_P18_17 XI654_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I114_XG_MP1 (XI654_I114_XG_p1 I654_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I116_XG_MP2 (XI654_I116_XG_p1 I654_G20_19 I654_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I116_XG_MP0 (VDD I654_P20_19 XI654_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I116_XG_MP1 (XI654_I116_XG_p1 I654_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I166_XG_MP2 (XI608_I166_XG_p1 I608_G15_8 I608_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I166_XG_MP0 (VDD I608_P15_8 XI608_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I166_XG_MP1 (XI608_I166_XG_p1 I608_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I176_XG_MP2 (XI608_I176_XG_p1 I608_G25_18 I608_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I176_XG_MP0 (VDD I608_P25_18 XI608_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I176_XG_MP1 (XI608_I176_XG_p1 I608_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I115_XG_MP2 (XI608_I115_XG_p1 I608_G19_18 I608_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I115_XG_MP0 (VDD I608_P19_18 XI608_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I115_XG_MP1 (XI608_I115_XG_p1 I608_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I177_XG_MP2 (XI608_I177_XG_p1 I608_G26_19 I608_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I177_XG_MP0 (VDD I608_P26_19 XI608_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I177_XG_MP1 (XI608_I177_XG_p1 I608_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I116_XG_MP2 (XI608_I116_XG_p1 I608_G20_19 I608_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I116_XG_MP0 (VDD I608_P20_19 XI608_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I116_XG_MP1 (XI608_I116_XG_p1 I608_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I173_XG_MP2 (XI562_I173_XG_p1 I562_G22_15 I562_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I173_XG_MP0 (VDD I562_P22_15 XI562_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I173_XG_MP1 (XI562_I173_XG_p1 I562_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I117_XG_MP2 (XI562_I117_XG_p1 I562_G21_20 I562_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I117_XG_MP0 (VDD I562_P21_20 XI562_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I117_XG_MP1 (XI562_I117_XG_p1 I562_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I172_XG_MP2 (XI562_I172_XG_p1 I562_G21_14 I562_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I172_XG_MP0 (VDD I562_P21_14 XI562_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I172_XG_MP1 (XI562_I172_XG_p1 I562_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I178_XG_MP2 (XI562_I178_XG_p1 I562_G27_20 I562_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I178_XG_MP0 (VDD I562_P27_20 XI562_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I178_XG_MP1 (XI562_I178_XG_p1 I562_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2209_MP2 (XI2209_p1 nrk13 nrkn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2209_MP0 (VDD A_31_b3_7 XI2209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2209_MP1 (XI2209_p1 ru13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2206_MP2 (XI2206_p1 nrk12 nrkn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2206_MP0 (VDD A_31_b3_7 XI2206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2206_MP1 (XI2206_p1 ru12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I172_XG_MP2 (XI2066_I172_XG_p1 I2066_G21_14 I2066_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I172_XG_MP0 (VDD I2066_P21_14 XI2066_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I172_XG_MP1 (XI2066_I172_XG_p1 I2066_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I117_XG_MP2 (XI2066_I117_XG_p1 I2066_G21_20 I2066_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I117_XG_MP0 (VDD I2066_P21_20 XI2066_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I117_XG_MP1 (XI2066_I117_XG_p1 I2066_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I177_XG_MP2 (XI2066_I177_XG_p1 I2066_G26_19 I2066_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I177_XG_MP0 (VDD I2066_P26_19 XI2066_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I177_XG_MP1 (XI2066_I177_XG_p1 I2066_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I118_XG_MP2 (XI2066_I118_XG_p1 I2066_G22_21 I2066_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I118_XG_MP0 (VDD I2066_P22_21 XI2066_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I118_XG_MP1 (XI2066_I118_XG_p1 I2066_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I177_XG_MP2 (XI1988_I177_XG_p1 I1988_G26_19 I1988_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I177_XG_MP0 (VDD I1988_P26_19 XI1988_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I177_XG_MP1 (XI1988_I177_XG_p1 I1988_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I166_XG_MP2 (XI1988_I166_XG_p1 I1988_G15_8 I1988_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I166_XG_MP0 (VDD I1988_P15_8 XI1988_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I166_XG_MP1 (XI1988_I166_XG_p1 I1988_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I178_XG_MP2 (XI1988_I178_XG_p1 I1988_G27_20 I1988_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I178_XG_MP0 (VDD I1988_P27_20 XI1988_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I178_XG_MP1 (XI1988_I178_XG_p1 I1988_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I117_XG_MP2 (XI1988_I117_XG_p1 I1988_G21_20 I1988_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I117_XG_MP0 (VDD I1988_P21_20 XI1988_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I117_XG_MP1 (XI1988_I117_XG_p1 I1988_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I175_XG_MP2 (XI1942_I175_XG_p1 I1942_G24_17 I1942_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I175_XG_MP0 (VDD I1942_P24_17 XI1942_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I175_XG_MP1 (XI1942_I175_XG_p1 I1942_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I116_XG_MP2 (XI1942_I116_XG_p1 I1942_G20_19 I1942_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I116_XG_MP0 (VDD I1942_P20_19 XI1942_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I116_XG_MP1 (XI1942_I116_XG_p1 I1942_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I164_XG_MP2 (XI1942_I164_XG_p1 I1942_G13_6 I1942_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I164_XG_MP0 (VDD I1942_P13_6 XI1942_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I164_XG_MP1 (XI1942_I164_XG_p1 I1942_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I172_XG_MP2 (XI1942_I172_XG_p1 I1942_G21_14 I1942_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I172_XG_MP0 (VDD I1942_P21_14 XI1942_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I172_XG_MP1 (XI1942_I172_XG_p1 I1942_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I115_XG_MP2 (XI1942_I115_XG_p1 I1942_G19_18 I1942_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I115_XG_MP0 (VDD I1942_P19_18 XI1942_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I115_XG_MP1 (XI1942_I115_XG_p1 I1942_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I110_XG_MP2 (XI1896_I110_XG_p1 I1896_G14_13 I1896_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I110_XG_MP0 (VDD I1896_P14_13 XI1896_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I110_XG_MP1 (XI1896_I110_XG_p1 I1896_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I112_XG_MP2 (XI1896_I112_XG_p1 I1896_G16_15 I1896_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I112_XG_MP0 (VDD I1896_P16_15 XI1896_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I112_XG_MP1 (XI1896_I112_XG_p1 I1896_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I164_XG_MP2 (XI1896_I164_XG_p1 I1896_G13_6 I1896_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I164_XG_MP0 (VDD I1896_P13_6 XI1896_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I164_XG_MP1 (XI1896_I164_XG_p1 I1896_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I115_XG_MP2 (XI1896_I115_XG_p1 I1896_G19_18 I1896_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I115_XG_MP0 (VDD I1896_P19_18 XI1896_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I115_XG_MP1 (XI1896_I115_XG_p1 I1896_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I178_XG_MP2 (XI1896_I178_XG_p1 I1896_G27_20 I1896_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I178_XG_MP0 (VDD I1896_P27_20 XI1896_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I178_XG_MP1 (XI1896_I178_XG_p1 I1896_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I119_XG_MP2 (XI700_I119_XG_p1 I700_G23_22 I700_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I119_XG_MP0 (VDD I700_P23_22 XI700_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I119_XG_MP1 (XI700_I119_XG_p1 I700_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I182_XG_MP2 (XI700_I182_XG_p1 I700_G31_24 I700_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I182_XG_MP0 (VDD I700_P31_24 XI700_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I182_XG_MP1 (XI700_I182_XG_p1 I700_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I162_XG_MP2 (XI654_I162_XG_p1 I654_G11_4 I654_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I162_XG_MP0 (VDD I654_P11_4 XI654_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I162_XG_MP1 (XI654_I162_XG_p1 I654_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I113_XG_MP2 (XI654_I113_XG_p1 I654_G17_16 I654_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I113_XG_MP0 (VDD I654_P17_16 XI654_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I113_XG_MP1 (XI654_I113_XG_p1 I654_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I171_XG_MP2 (XI654_I171_XG_p1 I654_G20_13 I654_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I171_XG_MP0 (VDD I654_P20_13 XI654_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I171_XG_MP1 (XI654_I171_XG_p1 I654_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I112_XG_MP2 (XI654_I112_XG_p1 I654_G16_15 I654_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I112_XG_MP0 (VDD I654_P16_15 XI654_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I112_XG_MP1 (XI654_I112_XG_p1 I654_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I164_XG_MP2 (XI608_I164_XG_p1 I608_G13_6 I608_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I164_XG_MP0 (VDD I608_P13_6 XI608_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I164_XG_MP1 (XI608_I164_XG_p1 I608_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I113_XG_MP2 (XI608_I113_XG_p1 I608_G17_16 I608_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I113_XG_MP0 (VDD I608_P17_16 XI608_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I113_XG_MP1 (XI608_I113_XG_p1 I608_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I165_XG_MP2 (XI608_I165_XG_p1 I608_G14_7 I608_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I165_XG_MP0 (VDD I608_P14_7 XI608_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I165_XG_MP1 (XI608_I165_XG_p1 I608_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I114_XG_MP2 (XI608_I114_XG_p1 I608_G18_17 I608_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I114_XG_MP0 (VDD I608_P18_17 XI608_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I114_XG_MP1 (XI608_I114_XG_p1 I608_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I179_XG_MP2 (XI562_I179_XG_p1 I562_G28_21 I562_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I179_XG_MP0 (VDD I562_P28_21 XI562_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I179_XG_MP1 (XI562_I179_XG_p1 I562_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I177_XG_MP2 (XI562_I177_XG_p1 I562_G26_19 I562_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I177_XG_MP0 (VDD I562_P26_19 XI562_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I177_XG_MP1 (XI562_I177_XG_p1 I562_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I165_XG_MP2 (XI562_I165_XG_p1 I562_G14_7 I562_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I165_XG_MP0 (VDD I562_P14_7 XI562_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I165_XG_MP1 (XI562_I165_XG_p1 I562_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I164_XG_MP2 (XI562_I164_XG_p1 I562_G13_6 I562_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I164_XG_MP0 (VDD I562_P13_6 XI562_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I164_XG_MP1 (XI562_I164_XG_p1 I562_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I115_XG_MP2 (XI562_I115_XG_p1 I562_G19_18 I562_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I115_XG_MP0 (VDD I562_P19_18 XI562_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I115_XG_MP1 (XI562_I115_XG_p1 I562_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I176_XG_MP2 (XI562_I176_XG_p1 I562_G25_18 I562_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I176_XG_MP0 (VDD I562_P25_18 XI562_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I176_XG_MP1 (XI562_I176_XG_p1 I562_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I166_XG_MP2 (XI562_I166_XG_p1 I562_G15_8 I562_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I166_XG_MP0 (VDD I562_P15_8 XI562_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I166_XG_MP1 (XI562_I166_XG_p1 I562_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2203_MP2 (XI2203_p1 nrk11 nrkn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2203_MP0 (VDD A_31_b3_7 XI2203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2203_MP1 (XI2203_p1 ru11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I170_XG_MP2 (XI2066_I170_XG_p1 I2066_G19_12 I2066_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I170_XG_MP0 (VDD I2066_P19_12 XI2066_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I170_XG_MP1 (XI2066_I170_XG_p1 I2066_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I164_XG_MP2 (XI2066_I164_XG_p1 I2066_G13_6 I2066_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I164_XG_MP0 (VDD I2066_P13_6 XI2066_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I164_XG_MP1 (XI2066_I164_XG_p1 I2066_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I176_XG_MP2 (XI2066_I176_XG_p1 I2066_G25_18 I2066_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I176_XG_MP0 (VDD I2066_P25_18 XI2066_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I176_XG_MP1 (XI2066_I176_XG_p1 I2066_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I113_XG_MP2 (XI2066_I113_XG_p1 I2066_G17_16 I2066_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I113_XG_MP0 (VDD I2066_P17_16 XI2066_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I113_XG_MP1 (XI2066_I113_XG_p1 I2066_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I115_XG_MP2 (XI2066_I115_XG_p1 I2066_G19_18 I2066_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I115_XG_MP0 (VDD I2066_P19_18 XI2066_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I115_XG_MP1 (XI2066_I115_XG_p1 I2066_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I171_XG_MP2 (XI2066_I171_XG_p1 I2066_G20_13 I2066_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I171_XG_MP0 (VDD I2066_P20_13 XI2066_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I171_XG_MP1 (XI2066_I171_XG_p1 I2066_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I179_XG_MP2 (XI2066_I179_XG_p1 I2066_G28_21 I2066_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I179_XG_MP0 (VDD I2066_P28_21 XI2066_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I179_XG_MP1 (XI2066_I179_XG_p1 I2066_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I116_XG_MP2 (XI2066_I116_XG_p1 I2066_G20_19 I2066_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I116_XG_MP0 (VDD I2066_P20_19 XI2066_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I116_XG_MP1 (XI2066_I116_XG_p1 I2066_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I173_XG_MP2 (XI1988_I173_XG_p1 I1988_G22_15 I1988_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I173_XG_MP0 (VDD I1988_P22_15 XI1988_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I173_XG_MP1 (XI1988_I173_XG_p1 I1988_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I114_XG_MP2 (XI1988_I114_XG_p1 I1988_G18_17 I1988_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I114_XG_MP0 (VDD I1988_P18_17 XI1988_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I114_XG_MP1 (XI1988_I114_XG_p1 I1988_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I116_XG_MP2 (XI1988_I116_XG_p1 I1988_G20_19 I1988_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I116_XG_MP0 (VDD I1988_P20_19 XI1988_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I116_XG_MP1 (XI1988_I116_XG_p1 I1988_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I172_XG_MP2 (XI1988_I172_XG_p1 I1988_G21_14 I1988_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I172_XG_MP0 (VDD I1988_P21_14 XI1988_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I172_XG_MP1 (XI1988_I172_XG_p1 I1988_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I115_XG_MP2 (XI1988_I115_XG_p1 I1988_G19_18 I1988_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I115_XG_MP0 (VDD I1988_P19_18 XI1988_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I115_XG_MP1 (XI1988_I115_XG_p1 I1988_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I171_XG_MP2 (XI1942_I171_XG_p1 I1942_G20_13 I1942_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I171_XG_MP0 (VDD I1942_P20_13 XI1942_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I171_XG_MP1 (XI1942_I171_XG_p1 I1942_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I114_XG_MP2 (XI1942_I114_XG_p1 I1942_G18_17 I1942_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I114_XG_MP0 (VDD I1942_P18_17 XI1942_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I114_XG_MP1 (XI1942_I114_XG_p1 I1942_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I112_XG_MP2 (XI1942_I112_XG_p1 I1942_G16_15 I1942_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I112_XG_MP0 (VDD I1942_P16_15 XI1942_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I112_XG_MP1 (XI1942_I112_XG_p1 I1942_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I111_XG_MP2 (XI1942_I111_XG_p1 I1942_G15_14 I1942_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I111_XG_MP0 (VDD I1942_P15_14 XI1942_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I111_XG_MP1 (XI1942_I111_XG_p1 I1942_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I113_XG_MP2 (XI1942_I113_XG_p1 I1942_G17_16 I1942_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I113_XG_MP0 (VDD I1942_P17_16 XI1942_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I113_XG_MP1 (XI1942_I113_XG_p1 I1942_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I167_XG_MP2 (XI1896_I167_XG_p1 I1896_G16_9 I1896_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I167_XG_MP0 (VDD I1896_P16_9 XI1896_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I167_XG_MP1 (XI1896_I167_XG_p1 I1896_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I168_XG_MP2 (XI1896_I168_XG_p1 I1896_G17_10 I1896_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I168_XG_MP0 (VDD I1896_P17_10 XI1896_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I168_XG_MP1 (XI1896_I168_XG_p1 I1896_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I108_XG_MP2 (XI1896_I108_XG_p1 I1896_G12_11 I1896_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I108_XG_MP0 (VDD I1896_P12_11 XI1896_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I108_XG_MP1 (XI1896_I108_XG_p1 I1896_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I113_XG_MP2 (XI1896_I113_XG_p1 I1896_G17_16 I1896_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I113_XG_MP0 (VDD I1896_P17_16 XI1896_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I113_XG_MP1 (XI1896_I113_XG_p1 I1896_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I170_XG_MP2 (XI1896_I170_XG_p1 I1896_G19_12 I1896_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I170_XG_MP0 (VDD I1896_P19_12 XI1896_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I170_XG_MP1 (XI1896_I170_XG_p1 I1896_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I174_XG_MP2 (XI1896_I174_XG_p1 I1896_G23_16 I1896_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I174_XG_MP0 (VDD I1896_P23_16 XI1896_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I174_XG_MP1 (XI1896_I174_XG_p1 I1896_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I182_XG_MP2 (XI1896_I182_XG_p1 I1896_G31_24 I1896_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I182_XG_MP0 (VDD I1896_P31_24 XI1896_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I182_XG_MP1 (XI1896_I182_XG_p1 I1896_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I117_XG_MP2 (XI700_I117_XG_p1 I700_G21_20 I700_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I117_XG_MP0 (VDD I700_P21_20 XI700_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I117_XG_MP1 (XI700_I117_XG_p1 I700_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I115_XG_MP2 (XI700_I115_XG_p1 I700_G19_18 I700_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I115_XG_MP0 (VDD I700_P19_18 XI700_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I115_XG_MP1 (XI700_I115_XG_p1 I700_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I164_XG_MP2 (XI654_I164_XG_p1 I654_G13_6 I654_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I164_XG_MP0 (VDD I654_P13_6 XI654_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I164_XG_MP1 (XI654_I164_XG_p1 I654_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I111_XG_MP2 (XI654_I111_XG_p1 I654_G15_14 I654_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I111_XG_MP0 (VDD I654_P15_14 XI654_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I111_XG_MP1 (XI654_I111_XG_p1 I654_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I109_XG_MP2 (XI654_I109_XG_p1 I654_G13_12 I654_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I109_XG_MP0 (VDD I654_P13_12 XI654_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I109_XG_MP1 (XI654_I109_XG_p1 I654_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I110_XG_MP2 (XI654_I110_XG_p1 I654_G14_13 I654_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I110_XG_MP0 (VDD I654_P14_13 XI654_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I110_XG_MP1 (XI654_I110_XG_p1 I654_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I170_XG_MP2 (XI608_I170_XG_p1 I608_G19_12 I608_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I170_XG_MP0 (VDD I608_P19_12 XI608_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I170_XG_MP1 (XI608_I170_XG_p1 I608_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I111_XG_MP2 (XI608_I111_XG_p1 I608_G15_14 I608_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I111_XG_MP0 (VDD I608_P15_14 XI608_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I111_XG_MP1 (XI608_I111_XG_p1 I608_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I171_XG_MP2 (XI608_I171_XG_p1 I608_G20_13 I608_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I171_XG_MP0 (VDD I608_P20_13 XI608_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I171_XG_MP1 (XI608_I171_XG_p1 I608_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I112_XG_MP2 (XI608_I112_XG_p1 I608_G16_15 I608_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I112_XG_MP0 (VDD I608_P16_15 XI608_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I112_XG_MP1 (XI608_I112_XG_p1 I608_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I116_XG_MP2 (XI562_I116_XG_p1 I562_G20_19 I562_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I116_XG_MP0 (VDD I562_P20_19 XI562_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I116_XG_MP1 (XI562_I116_XG_p1 I562_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I114_XG_MP2 (XI562_I114_XG_p1 I562_G18_17 I562_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I114_XG_MP0 (VDD I562_P18_17 XI562_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I114_XG_MP1 (XI562_I114_XG_p1 I562_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I113_XG_MP2 (XI562_I113_XG_p1 I562_G17_16 I562_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I113_XG_MP0 (VDD I562_P17_16 XI562_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I113_XG_MP1 (XI562_I113_XG_p1 I562_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I111_XG_MP2 (XI562_I111_XG_p1 I562_G15_14 I562_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I111_XG_MP0 (VDD I562_P15_14 XI562_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I111_XG_MP1 (XI562_I111_XG_p1 I562_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I170_XG_MP2 (XI562_I170_XG_p1 I562_G19_12 I562_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I170_XG_MP0 (VDD I562_P19_12 XI562_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I170_XG_MP1 (XI562_I170_XG_p1 I562_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2200_MP2 (XI2200_p1 nrk10 nrkn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2200_MP0 (VDD A_31_b3_7 XI2200_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2200_MP1 (XI2200_p1 ru10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I162_XG_MP2 (XI2066_I162_XG_p1 I2066_G11_4 I2066_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I162_XG_MP0 (VDD I2066_P11_4 XI2066_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I162_XG_MP1 (XI2066_I162_XG_p1 I2066_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I111_XG_MP2 (XI2066_I111_XG_p1 I2066_G15_14 I2066_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I111_XG_MP0 (VDD I2066_P15_14 XI2066_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I111_XG_MP1 (XI2066_I111_XG_p1 I2066_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I163_XG_MP2 (XI2066_I163_XG_p1 I2066_G12_5 I2066_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I163_XG_MP0 (VDD I2066_P12_5 XI2066_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I163_XG_MP1 (XI2066_I163_XG_p1 I2066_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I114_XG_MP2 (XI2066_I114_XG_p1 I2066_G18_17 I2066_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I114_XG_MP0 (VDD I2066_P18_17 XI2066_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I114_XG_MP1 (XI2066_I114_XG_p1 I2066_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I112_XG_MP2 (XI2066_I112_XG_p1 I2066_G16_15 I2066_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I112_XG_MP0 (VDD I2066_P16_15 XI2066_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I112_XG_MP1 (XI2066_I112_XG_p1 I2066_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I171_XG_MP2 (XI1988_I171_XG_p1 I1988_G20_13 I1988_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I171_XG_MP0 (VDD I1988_P20_13 XI1988_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I171_XG_MP1 (XI1988_I171_XG_p1 I1988_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I165_XG_MP2 (XI1988_I165_XG_p1 I1988_G14_7 I1988_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I165_XG_MP0 (VDD I1988_P14_7 XI1988_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I165_XG_MP1 (XI1988_I165_XG_p1 I1988_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I112_XG_MP2 (XI1988_I112_XG_p1 I1988_G16_15 I1988_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I112_XG_MP0 (VDD I1988_P16_15 XI1988_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I112_XG_MP1 (XI1988_I112_XG_p1 I1988_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I111_XG_MP2 (XI1988_I111_XG_p1 I1988_G15_14 I1988_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I111_XG_MP0 (VDD I1988_P15_14 XI1988_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I111_XG_MP1 (XI1988_I111_XG_p1 I1988_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I113_XG_MP2 (XI1988_I113_XG_p1 I1988_G17_16 I1988_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I113_XG_MP0 (VDD I1988_P17_16 XI1988_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I113_XG_MP1 (XI1988_I113_XG_p1 I1988_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I163_XG_MP2 (XI1942_I163_XG_p1 I1942_G12_5 I1942_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I163_XG_MP0 (VDD I1942_P12_5 XI1942_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I163_XG_MP1 (XI1942_I163_XG_p1 I1942_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I110_XG_MP2 (XI1942_I110_XG_p1 I1942_G14_13 I1942_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I110_XG_MP0 (VDD I1942_P14_13 XI1942_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I110_XG_MP1 (XI1942_I110_XG_p1 I1942_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I170_XG_MP2 (XI1942_I170_XG_p1 I1942_G19_12 I1942_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I170_XG_MP0 (VDD I1942_P19_12 XI1942_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I170_XG_MP1 (XI1942_I170_XG_p1 I1942_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I109_XG_MP2 (XI1942_I109_XG_p1 I1942_G13_12 I1942_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I109_XG_MP0 (VDD I1942_P13_12 XI1942_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I109_XG_MP1 (XI1942_I109_XG_p1 I1942_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I157_XG_MP2 (XI1896_I157_XG_p1 I1896_G8_1 I1896_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I157_XG_MP0 (VDD I1896_P8_1 XI1896_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I157_XG_MP1 (XI1896_I157_XG_p1 I1896_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I158_XG_MP2 (XI1896_I158_XG_p1 I1896_G9_2 I1896_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I158_XG_MP0 (VDD I1896_P9_2 XI1896_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I158_XG_MP1 (XI1896_I158_XG_p1 I1896_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I106_XG_MP2 (XI1896_I106_XG_p1 I1896_G10_9 I1896_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I106_XG_MP0 (VDD I1896_P10_9 XI1896_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I106_XG_MP1 (XI1896_I106_XG_p1 I1896_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I109_XG_MP2 (XI1896_I109_XG_p1 I1896_G13_12 I1896_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I109_XG_MP0 (VDD I1896_P13_12 XI1896_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I109_XG_MP1 (XI1896_I109_XG_p1 I1896_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I111_XG_MP2 (XI1896_I111_XG_p1 I1896_G15_14 I1896_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I111_XG_MP0 (VDD I1896_P15_14 XI1896_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I111_XG_MP1 (XI1896_I111_XG_p1 I1896_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I162_XG_MP2 (XI1896_I162_XG_p1 I1896_G11_4 I1896_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I162_XG_MP0 (VDD I1896_P11_4 XI1896_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I162_XG_MP1 (XI1896_I162_XG_p1 I1896_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I166_XG_MP2 (XI1896_I166_XG_p1 I1896_G15_8 I1896_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I166_XG_MP0 (VDD I1896_P15_8 XI1896_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I166_XG_MP1 (XI1896_I166_XG_p1 I1896_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I180_XG_MP2 (XI700_I180_XG_p1 I700_G29_22 I700_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I180_XG_MP0 (VDD I700_P29_22 XI700_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I180_XG_MP1 (XI700_I180_XG_p1 I700_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I178_XG_MP2 (XI700_I178_XG_p1 I700_G27_20 I700_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I178_XG_MP0 (VDD I700_P27_20 XI700_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I178_XG_MP1 (XI700_I178_XG_p1 I700_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I113_XG_MP2 (XI700_I113_XG_p1 I700_G17_16 I700_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I113_XG_MP0 (VDD I700_P17_16 XI700_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I113_XG_MP1 (XI700_I113_XG_p1 I700_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I168_XG_MP2 (XI654_I168_XG_p1 I654_G17_10 I654_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I168_XG_MP0 (VDD I654_P17_10 XI654_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I168_XG_MP1 (XI654_I168_XG_p1 I654_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I107_XG_MP2 (XI654_I107_XG_p1 I654_G11_10 I654_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I107_XG_MP0 (VDD I654_P11_10 XI654_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I107_XG_MP1 (XI654_I107_XG_p1 I654_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I169_XG_MP2 (XI654_I169_XG_p1 I654_G18_11 I654_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I169_XG_MP0 (VDD I654_P18_11 XI654_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I169_XG_MP1 (XI654_I169_XG_p1 I654_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I163_XG_MP2 (XI654_I163_XG_p1 I654_G12_5 I654_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I163_XG_MP0 (VDD I654_P12_5 XI654_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I163_XG_MP1 (XI654_I163_XG_p1 I654_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I108_XG_MP2 (XI654_I108_XG_p1 I654_G12_11 I654_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I108_XG_MP0 (VDD I654_P12_11 XI654_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I108_XG_MP1 (XI654_I108_XG_p1 I654_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I162_XG_MP2 (XI608_I162_XG_p1 I608_G11_4 I608_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I162_XG_MP0 (VDD I608_P11_4 XI608_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I162_XG_MP1 (XI608_I162_XG_p1 I608_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I109_XG_MP2 (XI608_I109_XG_p1 I608_G13_12 I608_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I109_XG_MP0 (VDD I608_P13_12 XI608_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I109_XG_MP1 (XI608_I109_XG_p1 I608_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I163_XG_MP2 (XI608_I163_XG_p1 I608_G12_5 I608_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I163_XG_MP0 (VDD I608_P12_5 XI608_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I163_XG_MP1 (XI608_I163_XG_p1 I608_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I175_XG_MP2 (XI608_I175_XG_p1 I608_G24_17 I608_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I175_XG_MP0 (VDD I608_P24_17 XI608_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I175_XG_MP1 (XI608_I175_XG_p1 I608_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I169_XG_MP2 (XI608_I169_XG_p1 I608_G18_11 I608_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I169_XG_MP0 (VDD I608_P18_11 XI608_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I169_XG_MP1 (XI608_I169_XG_p1 I608_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I110_XG_MP2 (XI608_I110_XG_p1 I608_G14_13 I608_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I110_XG_MP0 (VDD I608_P14_13 XI608_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I110_XG_MP1 (XI608_I110_XG_p1 I608_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I112_XG_MP2 (XI562_I112_XG_p1 I562_G16_15 I562_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I112_XG_MP0 (VDD I562_P16_15 XI562_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I112_XG_MP1 (XI562_I112_XG_p1 I562_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I109_XG_MP2 (XI562_I109_XG_p1 I562_G13_12 I562_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I109_XG_MP0 (VDD I562_P13_12 XI562_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I109_XG_MP1 (XI562_I109_XG_p1 I562_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I162_XG_MP2 (XI562_I162_XG_p1 I562_G11_4 I562_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I162_XG_MP0 (VDD I562_P11_4 XI562_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I162_XG_MP1 (XI562_I162_XG_p1 I562_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2197_MP2 (XI2197_p1 nrk9 nrkn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2197_MP0 (VDD A_31_b3_7 XI2197_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2197_MP1 (XI2197_p1 ru9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I168_XG_MP2 (XI2066_I168_XG_p1 I2066_G17_10 I2066_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I168_XG_MP0 (VDD I2066_P17_10 XI2066_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I168_XG_MP1 (XI2066_I168_XG_p1 I2066_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I109_XG_MP2 (XI2066_I109_XG_p1 I2066_G13_12 I2066_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I109_XG_MP0 (VDD I2066_P13_12 XI2066_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I109_XG_MP1 (XI2066_I109_XG_p1 I2066_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I160_XG_MP2 (XI2066_I160_XG_p1 I2066_G10_3 I2066_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I160_XG_MP0 (VDD I2066_P10_3 XI2066_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I160_XG_MP1 (XI2066_I160_XG_p1 I2066_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I169_XG_MP2 (XI2066_I169_XG_p1 I2066_G18_11 I2066_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I169_XG_MP0 (VDD I2066_P18_11 XI2066_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I169_XG_MP1 (XI2066_I169_XG_p1 I2066_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I175_XG_MP2 (XI2066_I175_XG_p1 I2066_G24_17 I2066_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I175_XG_MP0 (VDD I2066_P24_17 XI2066_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I175_XG_MP1 (XI2066_I175_XG_p1 I2066_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I110_XG_MP2 (XI2066_I110_XG_p1 I2066_G14_13 I2066_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I110_XG_MP0 (VDD I2066_P14_13 XI2066_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I110_XG_MP1 (XI2066_I110_XG_p1 I2066_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I163_XG_MP2 (XI1988_I163_XG_p1 I1988_G12_5 I1988_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I163_XG_MP0 (VDD I1988_P12_5 XI1988_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I163_XG_MP1 (XI1988_I163_XG_p1 I1988_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I110_XG_MP2 (XI1988_I110_XG_p1 I1988_G14_13 I1988_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I110_XG_MP0 (VDD I1988_P14_13 XI1988_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I110_XG_MP1 (XI1988_I110_XG_p1 I1988_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I164_XG_MP2 (XI1988_I164_XG_p1 I1988_G13_6 I1988_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I164_XG_MP0 (VDD I1988_P13_6 XI1988_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I164_XG_MP1 (XI1988_I164_XG_p1 I1988_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I176_XG_MP2 (XI1988_I176_XG_p1 I1988_G25_18 I1988_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I176_XG_MP0 (VDD I1988_P25_18 XI1988_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I176_XG_MP1 (XI1988_I176_XG_p1 I1988_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I169_XG_MP2 (XI1942_I169_XG_p1 I1942_G18_11 I1942_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I169_XG_MP0 (VDD I1942_P18_11 XI1942_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I169_XG_MP1 (XI1942_I169_XG_p1 I1942_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I108_XG_MP2 (XI1942_I108_XG_p1 I1942_G12_11 I1942_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I108_XG_MP0 (VDD I1942_P12_11 XI1942_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I108_XG_MP1 (XI1942_I108_XG_p1 I1942_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I162_XG_MP2 (XI1942_I162_XG_p1 I1942_G11_4 I1942_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I162_XG_MP0 (VDD I1942_P11_4 XI1942_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I162_XG_MP1 (XI1942_I162_XG_p1 I1942_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I107_XG_MP2 (XI1942_I107_XG_p1 I1942_G11_10 I1942_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I107_XG_MP0 (VDD I1942_P11_10 XI1942_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I107_XG_MP1 (XI1942_I107_XG_p1 I1942_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I104_XG_MP2 (XI1896_I104_XG_p1 I1896_G8_7 I1896_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I104_XG_MP0 (VDD I1896_P8_7 XI1896_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I104_XG_MP1 (XI1896_I104_XG_p1 I1896_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I103_XG_MP2 (XI1896_I103_XG_p1 I1896_G7_6 I1896_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I103_XG_MP0 (VDD I1896_P7_6 XI1896_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I103_XG_MP1 (XI1896_I103_XG_p1 I1896_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I105_XG_MP2 (XI1896_I105_XG_p1 I1896_G9_8 I1896_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I105_XG_MP0 (VDD I1896_P9_8 XI1896_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I105_XG_MP1 (XI1896_I105_XG_p1 I1896_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I107_XG_MP2 (XI1896_I107_XG_p1 I1896_G11_10 I1896_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I107_XG_MP0 (VDD I1896_P11_10 XI1896_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I107_XG_MP1 (XI1896_I107_XG_p1 I1896_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I174_XG_MP2 (XI700_I174_XG_p1 I700_G23_16 I700_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I174_XG_MP0 (VDD I700_P23_16 XI700_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I174_XG_MP1 (XI700_I174_XG_p1 I700_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I166_XG_MP2 (XI700_I166_XG_p1 I700_G15_8 I700_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I166_XG_MP0 (VDD I700_P15_8 XI700_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I166_XG_MP1 (XI700_I166_XG_p1 I700_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I111_XG_MP2 (XI700_I111_XG_p1 I700_G15_14 I700_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I111_XG_MP0 (VDD I700_P15_14 XI700_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I111_XG_MP1 (XI700_I111_XG_p1 I700_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I158_XG_MP2 (XI654_I158_XG_p1 I654_G9_2 I654_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I158_XG_MP0 (VDD I654_P9_2 XI654_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I158_XG_MP1 (XI654_I158_XG_p1 I654_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I160_XG_MP2 (XI654_I160_XG_p1 I654_G10_3 I654_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I160_XG_MP0 (VDD I654_P10_3 XI654_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I160_XG_MP1 (XI654_I160_XG_p1 I654_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I167_XG_MP2 (XI654_I167_XG_p1 I654_G16_9 I654_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I167_XG_MP0 (VDD I654_P16_9 XI654_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I167_XG_MP1 (XI654_I167_XG_p1 I654_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I106_XG_MP2 (XI654_I106_XG_p1 I654_G10_9 I654_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I106_XG_MP0 (VDD I654_P10_9 XI654_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I106_XG_MP1 (XI654_I106_XG_p1 I654_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I168_XG_MP2 (XI608_I168_XG_p1 I608_G17_10 I608_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I168_XG_MP0 (VDD I608_P17_10 XI608_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I168_XG_MP1 (XI608_I168_XG_p1 I608_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I107_XG_MP2 (XI608_I107_XG_p1 I608_G11_10 I608_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I107_XG_MP0 (VDD I608_P11_10 XI608_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I107_XG_MP1 (XI608_I107_XG_p1 I608_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I160_XG_MP2 (XI608_I160_XG_p1 I608_G10_3 I608_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I160_XG_MP0 (VDD I608_P10_3 XI608_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I160_XG_MP1 (XI608_I160_XG_p1 I608_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I108_XG_MP2 (XI608_I108_XG_p1 I608_G12_11 I608_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I108_XG_MP0 (VDD I608_P12_11 XI608_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I108_XG_MP1 (XI608_I108_XG_p1 I608_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I171_XG_MP2 (XI562_I171_XG_p1 I562_G20_13 I562_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I171_XG_MP0 (VDD I562_P20_13 XI562_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I171_XG_MP1 (XI562_I171_XG_p1 I562_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I169_XG_MP2 (XI562_I169_XG_p1 I562_G18_11 I562_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I169_XG_MP0 (VDD I562_P18_11 XI562_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I169_XG_MP1 (XI562_I169_XG_p1 I562_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I110_XG_MP2 (XI562_I110_XG_p1 I562_G14_13 I562_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I110_XG_MP0 (VDD I562_P14_13 XI562_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I110_XG_MP1 (XI562_I110_XG_p1 I562_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I168_XG_MP2 (XI562_I168_XG_p1 I562_G17_10 I562_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I168_XG_MP0 (VDD I562_P17_10 XI562_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I168_XG_MP1 (XI562_I168_XG_p1 I562_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I107_XG_MP2 (XI562_I107_XG_p1 I562_G11_10 I562_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I107_XG_MP0 (VDD I562_P11_10 XI562_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I107_XG_MP1 (XI562_I107_XG_p1 I562_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2194_MP2 (XI2194_p1 nrk8 nrkn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2194_MP0 (VDD A_31_b3_7 XI2194_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2194_MP1 (XI2194_p1 ru8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I158_XG_MP2 (XI2066_I158_XG_p1 I2066_G9_2 I2066_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I158_XG_MP0 (VDD I2066_P9_2 XI2066_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I158_XG_MP1 (XI2066_I158_XG_p1 I2066_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I107_XG_MP2 (XI2066_I107_XG_p1 I2066_G11_10 I2066_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I107_XG_MP0 (VDD I2066_P11_10 XI2066_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I107_XG_MP1 (XI2066_I107_XG_p1 I2066_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I108_XG_MP2 (XI2066_I108_XG_p1 I2066_G12_11 I2066_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I108_XG_MP0 (VDD I2066_P12_11 XI2066_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I108_XG_MP1 (XI2066_I108_XG_p1 I2066_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I169_XG_MP2 (XI1988_I169_XG_p1 I1988_G18_11 I1988_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I169_XG_MP0 (VDD I1988_P18_11 XI1988_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I169_XG_MP1 (XI1988_I169_XG_p1 I1988_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I175_XG_MP2 (XI1988_I175_XG_p1 I1988_G24_17 I1988_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I175_XG_MP0 (VDD I1988_P24_17 XI1988_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I175_XG_MP1 (XI1988_I175_XG_p1 I1988_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I162_XG_MP2 (XI1988_I162_XG_p1 I1988_G11_4 I1988_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I162_XG_MP0 (VDD I1988_P11_4 XI1988_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I162_XG_MP1 (XI1988_I162_XG_p1 I1988_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I170_XG_MP2 (XI1988_I170_XG_p1 I1988_G19_12 I1988_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I170_XG_MP0 (VDD I1988_P19_12 XI1988_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I170_XG_MP1 (XI1988_I170_XG_p1 I1988_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I109_XG_MP2 (XI1988_I109_XG_p1 I1988_G13_12 I1988_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I109_XG_MP0 (VDD I1988_P13_12 XI1988_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I109_XG_MP1 (XI1988_I109_XG_p1 I1988_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I160_XG_MP2 (XI1942_I160_XG_p1 I1942_G10_3 I1942_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I160_XG_MP0 (VDD I1942_P10_3 XI1942_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I160_XG_MP1 (XI1942_I160_XG_p1 I1942_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I106_XG_MP2 (XI1942_I106_XG_p1 I1942_G10_9 I1942_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I106_XG_MP0 (VDD I1942_P10_9 XI1942_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I106_XG_MP1 (XI1942_I106_XG_p1 I1942_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I168_XG_MP2 (XI1942_I168_XG_p1 I1942_G17_10 I1942_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I168_XG_MP0 (VDD I1942_P17_10 XI1942_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I168_XG_MP1 (XI1942_I168_XG_p1 I1942_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I105_XG_MP2 (XI1942_I105_XG_p1 I1942_G9_8 I1942_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I105_XG_MP0 (VDD I1942_P9_8 XI1942_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I105_XG_MP1 (XI1942_I105_XG_p1 I1942_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I101_XG_MP2 (XI1896_I101_XG_p1 I1896_G5_4 I1896_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I101_XG_MP0 (VDD I1896_P5_4 XI1896_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I101_XG_MP1 (XI1896_I101_XG_p1 I1896_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I102_XG_MP2 (XI1896_I102_XG_p1 I1896_G6_5 I1896_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I102_XG_MP0 (VDD I1896_P6_5 XI1896_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I102_XG_MP1 (XI1896_I102_XG_p1 I1896_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I162_XG_MP2 (XI1850_I162_XG_p1 I1850_G11_4 I1850_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I162_XG_MP0 (VDD I1850_P11_4 XI1850_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I162_XG_MP1 (XI1850_I162_XG_p1 I1850_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I170_XG_MP2 (XI1850_I170_XG_p1 I1850_G19_12 I1850_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I170_XG_MP0 (VDD I1850_P19_12 XI1850_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I170_XG_MP1 (XI1850_I170_XG_p1 I1850_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I166_XG_MP2 (XI1850_I166_XG_p1 I1850_G15_8 I1850_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I166_XG_MP0 (VDD I1850_P15_8 XI1850_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I166_XG_MP1 (XI1850_I166_XG_p1 I1850_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I174_XG_MP2 (XI1850_I174_XG_p1 I1850_G23_16 I1850_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I174_XG_MP0 (VDD I1850_P23_16 XI1850_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I174_XG_MP1 (XI1850_I174_XG_p1 I1850_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I178_XG_MP2 (XI1850_I178_XG_p1 I1850_G27_20 I1850_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I178_XG_MP0 (VDD I1850_P27_20 XI1850_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I178_XG_MP1 (XI1850_I178_XG_p1 I1850_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I182_XG_MP2 (XI1850_I182_XG_p1 I1850_G31_24 I1850_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I182_XG_MP0 (VDD I1850_P31_24 XI1850_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I182_XG_MP1 (XI1850_I182_XG_p1 I1850_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I126_XG_MP2 (XI700_I126_XG_p1 I700_G30_29 I700_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I126_XG_MP0 (VDD I700_P30_29 XI700_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I126_XG_MP1 (XI700_I126_XG_p1 I700_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I172_XG_MP2 (XI700_I172_XG_p1 I700_G21_14 I700_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I172_XG_MP0 (VDD I700_P21_14 XI700_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I172_XG_MP1 (XI700_I172_XG_p1 I700_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I176_XG_MP2 (XI700_I176_XG_p1 I700_G25_18 I700_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I176_XG_MP0 (VDD I700_P25_18 XI700_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I176_XG_MP1 (XI700_I176_XG_p1 I700_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I109_XG_MP2 (XI700_I109_XG_p1 I700_G13_12 I700_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I109_XG_MP0 (VDD I700_P13_12 XI700_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I109_XG_MP1 (XI700_I109_XG_p1 I700_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I103_XG_MP2 (XI654_I103_XG_p1 I654_G7_6 I654_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I103_XG_MP0 (VDD I654_P7_6 XI654_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I103_XG_MP1 (XI654_I103_XG_p1 I654_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I105_XG_MP2 (XI654_I105_XG_p1 I654_G9_8 I654_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I105_XG_MP0 (VDD I654_P9_8 XI654_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I105_XG_MP1 (XI654_I105_XG_p1 I654_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I157_XG_MP2 (XI654_I157_XG_p1 I654_G8_1 I654_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I157_XG_MP0 (VDD I654_P8_1 XI654_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I157_XG_MP1 (XI654_I157_XG_p1 I654_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I104_XG_MP2 (XI654_I104_XG_p1 I654_G8_7 I654_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I104_XG_MP0 (VDD I654_P8_7 XI654_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I104_XG_MP1 (XI654_I104_XG_p1 I654_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I158_XG_MP2 (XI608_I158_XG_p1 I608_G9_2 I608_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I158_XG_MP0 (VDD I608_P9_2 XI608_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I158_XG_MP1 (XI608_I158_XG_p1 I608_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I105_XG_MP2 (XI608_I105_XG_p1 I608_G9_8 I608_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I105_XG_MP0 (VDD I608_P9_8 XI608_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I105_XG_MP1 (XI608_I105_XG_p1 I608_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I157_XG_MP2 (XI608_I157_XG_p1 I608_G8_1 I608_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I157_XG_MP0 (VDD I608_P8_1 XI608_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I157_XG_MP1 (XI608_I157_XG_p1 I608_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I167_XG_MP2 (XI608_I167_XG_p1 I608_G16_9 I608_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I167_XG_MP0 (VDD I608_P16_9 XI608_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I167_XG_MP1 (XI608_I167_XG_p1 I608_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I106_XG_MP2 (XI608_I106_XG_p1 I608_G10_9 I608_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I106_XG_MP0 (VDD I608_P10_9 XI608_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I106_XG_MP1 (XI608_I106_XG_p1 I608_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I175_XG_MP2 (XI562_I175_XG_p1 I562_G24_17 I562_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I175_XG_MP0 (VDD I562_P24_17 XI562_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I175_XG_MP1 (XI562_I175_XG_p1 I562_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I163_XG_MP2 (XI562_I163_XG_p1 I562_G12_5 I562_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I163_XG_MP0 (VDD I562_P12_5 XI562_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I163_XG_MP1 (XI562_I163_XG_p1 I562_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I160_XG_MP2 (XI562_I160_XG_p1 I562_G10_3 I562_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I160_XG_MP0 (VDD I562_P10_3 XI562_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I160_XG_MP1 (XI562_I160_XG_p1 I562_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I108_XG_MP2 (XI562_I108_XG_p1 I562_G12_11 I562_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I108_XG_MP0 (VDD I562_P12_11 XI562_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I108_XG_MP1 (XI562_I108_XG_p1 I562_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I158_XG_MP2 (XI562_I158_XG_p1 I562_G9_2 I562_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I158_XG_MP0 (VDD I562_P9_2 XI562_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I158_XG_MP1 (XI562_I158_XG_p1 I562_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2191_MP2 (XI2191_p1 nrk7 nrkn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2191_MP0 (VDD A_31_b3_6 XI2191_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2191_MP1 (XI2191_p1 ru7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2188_MP2 (XI2188_p1 nrk6 nrkn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2188_MP0 (VDD A_31_b3_6 XI2188_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2188_MP1 (XI2188_p1 ru6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I103_XG_MP2 (XI2066_I103_XG_p1 I2066_G7_6 I2066_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I103_XG_MP0 (VDD I2066_P7_6 XI2066_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I103_XG_MP1 (XI2066_I103_XG_p1 I2066_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I105_XG_MP2 (XI2066_I105_XG_p1 I2066_G9_8 I2066_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I105_XG_MP0 (VDD I2066_P9_8 XI2066_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I105_XG_MP1 (XI2066_I105_XG_p1 I2066_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I167_XG_MP2 (XI2066_I167_XG_p1 I2066_G16_9 I2066_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I167_XG_MP0 (VDD I2066_P16_9 XI2066_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I167_XG_MP1 (XI2066_I167_XG_p1 I2066_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I106_XG_MP2 (XI2066_I106_XG_p1 I2066_G10_9 I2066_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I106_XG_MP0 (VDD I2066_P10_9 XI2066_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I106_XG_MP1 (XI2066_I106_XG_p1 I2066_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I160_XG_MP2 (XI1988_I160_XG_p1 I1988_G10_3 I1988_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I160_XG_MP0 (VDD I1988_P10_3 XI1988_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I160_XG_MP1 (XI1988_I160_XG_p1 I1988_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I108_XG_MP2 (XI1988_I108_XG_p1 I1988_G12_11 I1988_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I108_XG_MP0 (VDD I1988_P12_11 XI1988_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I108_XG_MP1 (XI1988_I108_XG_p1 I1988_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I106_XG_MP2 (XI1988_I106_XG_p1 I1988_G10_9 I1988_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I106_XG_MP0 (VDD I1988_P10_9 XI1988_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I106_XG_MP1 (XI1988_I106_XG_p1 I1988_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I168_XG_MP2 (XI1988_I168_XG_p1 I1988_G17_10 I1988_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I168_XG_MP0 (VDD I1988_P17_10 XI1988_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I168_XG_MP1 (XI1988_I168_XG_p1 I1988_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I107_XG_MP2 (XI1988_I107_XG_p1 I1988_G11_10 I1988_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I107_XG_MP0 (VDD I1988_P11_10 XI1988_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I107_XG_MP1 (XI1988_I107_XG_p1 I1988_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I167_XG_MP2 (XI1942_I167_XG_p1 I1942_G16_9 I1942_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I167_XG_MP0 (VDD I1942_P16_9 XI1942_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I167_XG_MP1 (XI1942_I167_XG_p1 I1942_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I104_XG_MP2 (XI1942_I104_XG_p1 I1942_G8_7 I1942_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I104_XG_MP0 (VDD I1942_P8_7 XI1942_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I104_XG_MP1 (XI1942_I104_XG_p1 I1942_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I158_XG_MP2 (XI1942_I158_XG_p1 I1942_G9_2 I1942_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I158_XG_MP0 (VDD I1942_P9_2 XI1942_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I158_XG_MP1 (XI1942_I158_XG_p1 I1942_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I99_XG_MP2 (XI1896_I99_XG_p1 I1896_G3_2 I1896_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I99_XG_MP0 (VDD I1896_P3_2 XI1896_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I99_XG_MP1 (XI1896_I99_XG_p1 I1896_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I100_XG_MP2 (XI1896_I100_XG_p1 I1896_G4_3 I1896_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I100_XG_MP0 (VDD I1896_P4_3 XI1896_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I100_XG_MP1 (XI1896_I100_XG_p1 I1896_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I124_XG_MP2 (XI700_I124_XG_p1 I700_G28_27 I700_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I124_XG_MP0 (VDD I700_P28_27 XI700_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I124_XG_MP1 (XI700_I124_XG_p1 I700_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I170_XG_MP2 (XI700_I170_XG_p1 I700_G19_12 I700_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I170_XG_MP0 (VDD I700_P19_12 XI700_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I170_XG_MP1 (XI700_I170_XG_p1 I700_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I164_XG_MP2 (XI700_I164_XG_p1 I700_G13_6 I700_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I164_XG_MP0 (VDD I700_P13_6 XI700_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I164_XG_MP1 (XI700_I164_XG_p1 I700_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I162_XG_MP2 (XI700_I162_XG_p1 I700_G11_4 I700_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I162_XG_MP0 (VDD I700_P11_4 XI700_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I162_XG_MP1 (XI700_I162_XG_p1 I700_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I107_XG_MP2 (XI700_I107_XG_p1 I700_G11_10 I700_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I107_XG_MP0 (VDD I700_P11_10 XI700_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I107_XG_MP1 (XI700_I107_XG_p1 I700_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I101_XG_MP2 (XI654_I101_XG_p1 I654_G5_4 I654_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I101_XG_MP0 (VDD I654_P5_4 XI654_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I101_XG_MP1 (XI654_I101_XG_p1 I654_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I102_XG_MP2 (XI654_I102_XG_p1 I654_G6_5 I654_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I102_XG_MP0 (VDD I654_P6_5 XI654_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I102_XG_MP1 (XI654_I102_XG_p1 I654_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I103_XG_MP2 (XI608_I103_XG_p1 I608_G7_6 I608_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I103_XG_MP0 (VDD I608_P7_6 XI608_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I103_XG_MP1 (XI608_I103_XG_p1 I608_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I102_XG_MP2 (XI608_I102_XG_p1 I608_G6_5 I608_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I102_XG_MP0 (VDD I608_P6_5 XI608_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I102_XG_MP1 (XI608_I102_XG_p1 I608_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I104_XG_MP2 (XI608_I104_XG_p1 I608_G8_7 I608_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I104_XG_MP0 (VDD I608_P8_7 XI608_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I104_XG_MP1 (XI608_I104_XG_p1 I608_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I157_XG_MP2 (XI562_I157_XG_p1 I562_G8_1 I562_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I157_XG_MP0 (VDD I562_P8_1 XI562_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I157_XG_MP1 (XI562_I157_XG_p1 I562_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I167_XG_MP2 (XI562_I167_XG_p1 I562_G16_9 I562_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I167_XG_MP0 (VDD I562_P16_9 XI562_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I167_XG_MP1 (XI562_I167_XG_p1 I562_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I104_XG_MP2 (XI562_I104_XG_p1 I562_G8_7 I562_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I104_XG_MP0 (VDD I562_P8_7 XI562_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I104_XG_MP1 (XI562_I104_XG_p1 I562_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I106_XG_MP2 (XI562_I106_XG_p1 I562_G10_9 I562_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I106_XG_MP0 (VDD I562_P10_9 XI562_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I106_XG_MP1 (XI562_I106_XG_p1 I562_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I105_XG_MP2 (XI562_I105_XG_p1 I562_G9_8 I562_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I105_XG_MP0 (VDD I562_P9_8 XI562_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I105_XG_MP1 (XI562_I105_XG_p1 I562_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2185_MP2 (XI2185_p1 nrk5 nrkn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2185_MP0 (VDD A_31_b3_6 XI2185_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2185_MP1 (XI2185_p1 ru5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2182_MP2 (XI2182_p1 nrk4 nrkn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2182_MP0 (VDD A_31_b3_6 XI2182_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2182_MP1 (XI2182_p1 ru4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I99_XG_MP2 (XI2066_I99_XG_p1 I2066_G3_2 I2066_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I99_XG_MP0 (VDD I2066_P3_2 XI2066_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I99_XG_MP1 (XI2066_I99_XG_p1 I2066_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I101_XG_MP2 (XI2066_I101_XG_p1 I2066_G5_4 I2066_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I101_XG_MP0 (VDD I2066_P5_4 XI2066_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I101_XG_MP1 (XI2066_I101_XG_p1 I2066_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I157_XG_MP2 (XI2066_I157_XG_p1 I2066_G8_1 I2066_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I157_XG_MP0 (VDD I2066_P8_1 XI2066_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I157_XG_MP1 (XI2066_I157_XG_p1 I2066_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I104_XG_MP2 (XI2066_I104_XG_p1 I2066_G8_7 I2066_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I104_XG_MP0 (VDD I2066_P8_7 XI2066_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I104_XG_MP1 (XI2066_I104_XG_p1 I2066_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I167_XG_MP2 (XI1988_I167_XG_p1 I1988_G16_9 I1988_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I167_XG_MP0 (VDD I1988_P16_9 XI1988_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I167_XG_MP1 (XI1988_I167_XG_p1 I1988_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I158_XG_MP2 (XI1988_I158_XG_p1 I1988_G9_2 I1988_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I158_XG_MP0 (VDD I1988_P9_2 XI1988_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I158_XG_MP1 (XI1988_I158_XG_p1 I1988_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I105_XG_MP2 (XI1988_I105_XG_p1 I1988_G9_8 I1988_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I105_XG_MP0 (VDD I1988_P9_8 XI1988_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I105_XG_MP1 (XI1988_I105_XG_p1 I1988_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I157_XG_MP2 (XI1942_I157_XG_p1 I1942_G8_1 I1942_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I157_XG_MP0 (VDD I1942_P8_1 XI1942_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I157_XG_MP1 (XI1942_I157_XG_p1 I1942_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I102_XG_MP2 (XI1942_I102_XG_p1 I1942_G6_5 I1942_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I102_XG_MP0 (VDD I1942_P6_5 XI1942_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I102_XG_MP1 (XI1942_I102_XG_p1 I1942_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I103_XG_MP2 (XI1942_I103_XG_p1 I1942_G7_6 I1942_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I103_XG_MP0 (VDD I1942_P7_6 XI1942_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I103_XG_MP1 (XI1942_I103_XG_p1 I1942_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1896_I98_XG_MP2 (XI1896_I98_XG_p1 I1896_G2_1 I1896_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1896_I98_XG_MP0 (VDD I1896_P2_1 XI1896_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1896_I98_XG_MP1 (XI1896_I98_XG_p1 I1896_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I158_XG_MP2 (XI1850_I158_XG_p1 I1850_G9_2 I1850_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I158_XG_MP0 (VDD I1850_P9_2 XI1850_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I158_XG_MP1 (XI1850_I158_XG_p1 I1850_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I168_XG_MP2 (XI1850_I168_XG_p1 I1850_G17_10 I1850_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I168_XG_MP0 (VDD I1850_P17_10 XI1850_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I168_XG_MP1 (XI1850_I168_XG_p1 I1850_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I164_XG_MP2 (XI1850_I164_XG_p1 I1850_G13_6 I1850_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I164_XG_MP0 (VDD I1850_P13_6 XI1850_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I164_XG_MP1 (XI1850_I164_XG_p1 I1850_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I172_XG_MP2 (XI1850_I172_XG_p1 I1850_G21_14 I1850_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I172_XG_MP0 (VDD I1850_P21_14 XI1850_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I172_XG_MP1 (XI1850_I172_XG_p1 I1850_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I176_XG_MP2 (XI1850_I176_XG_p1 I1850_G25_18 I1850_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I176_XG_MP0 (VDD I1850_P25_18 XI1850_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I176_XG_MP1 (XI1850_I176_XG_p1 I1850_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I180_XG_MP2 (XI1850_I180_XG_p1 I1850_G29_22 I1850_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I180_XG_MP0 (VDD I1850_P29_22 XI1850_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I180_XG_MP1 (XI1850_I180_XG_p1 I1850_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I122_XG_MP2 (XI700_I122_XG_p1 I700_G26_25 I700_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I122_XG_MP0 (VDD I700_P26_25 XI700_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I122_XG_MP1 (XI700_I122_XG_p1 I700_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I120_XG_MP2 (XI700_I120_XG_p1 I700_G24_23 I700_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I120_XG_MP0 (VDD I700_P24_23 XI700_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I120_XG_MP1 (XI700_I120_XG_p1 I700_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I118_XG_MP2 (XI700_I118_XG_p1 I700_G22_21 I700_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I118_XG_MP0 (VDD I700_P22_21 XI700_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I118_XG_MP1 (XI700_I118_XG_p1 I700_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I168_XG_MP2 (XI700_I168_XG_p1 I700_G17_10 I700_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I168_XG_MP0 (VDD I700_P17_10 XI700_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I168_XG_MP1 (XI700_I168_XG_p1 I700_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I105_XG_MP2 (XI700_I105_XG_p1 I700_G9_8 I700_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I105_XG_MP0 (VDD I700_P9_8 XI700_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I105_XG_MP1 (XI700_I105_XG_p1 I700_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I99_XG_MP2 (XI654_I99_XG_p1 I654_G3_2 I654_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I99_XG_MP0 (VDD I654_P3_2 XI654_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I99_XG_MP1 (XI654_I99_XG_p1 I654_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I100_XG_MP2 (XI654_I100_XG_p1 I654_G4_3 I654_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I100_XG_MP0 (VDD I654_P4_3 XI654_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I100_XG_MP1 (XI654_I100_XG_p1 I654_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I99_XG_MP2 (XI608_I99_XG_p1 I608_G3_2 I608_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I99_XG_MP0 (VDD I608_P3_2 XI608_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I99_XG_MP1 (XI608_I99_XG_p1 I608_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I101_XG_MP2 (XI608_I101_XG_p1 I608_G5_4 I608_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I101_XG_MP0 (VDD I608_P5_4 XI608_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I101_XG_MP1 (XI608_I101_XG_p1 I608_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I98_XG_MP2 (XI608_I98_XG_p1 I608_G2_1 I608_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I98_XG_MP0 (VDD I608_P2_1 XI608_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I98_XG_MP1 (XI608_I98_XG_p1 I608_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI608_I100_XG_MP2 (XI608_I100_XG_p1 I608_G4_3 I608_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI608_I100_XG_MP0 (VDD I608_P4_3 XI608_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI608_I100_XG_MP1 (XI608_I100_XG_p1 I608_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I98_XG_MP2 (XI562_I98_XG_p1 I562_G2_1 I562_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I98_XG_MP0 (VDD I562_P2_1 XI562_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I98_XG_MP1 (XI562_I98_XG_p1 I562_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I100_XG_MP2 (XI562_I100_XG_p1 I562_G4_3 I562_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I100_XG_MP0 (VDD I562_P4_3 XI562_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I100_XG_MP1 (XI562_I100_XG_p1 I562_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I102_XG_MP2 (XI562_I102_XG_p1 I562_G6_5 I562_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I102_XG_MP0 (VDD I562_P6_5 XI562_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I102_XG_MP1 (XI562_I102_XG_p1 I562_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I99_XG_MP2 (XI562_I99_XG_p1 I562_G3_2 I562_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I99_XG_MP0 (VDD I562_P3_2 XI562_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I99_XG_MP1 (XI562_I99_XG_p1 I562_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I101_XG_MP2 (XI562_I101_XG_p1 I562_G5_4 I562_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I101_XG_MP0 (VDD I562_P5_4 XI562_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I101_XG_MP1 (XI562_I101_XG_p1 I562_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI562_I103_XG_MP2 (XI562_I103_XG_p1 I562_G7_6 I562_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI562_I103_XG_MP0 (VDD I562_P7_6 XI562_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI562_I103_XG_MP1 (XI562_I103_XG_p1 I562_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2179_MP2 (XI2179_p1 nrk3 nrkn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2179_MP0 (VDD A_31_b3_6 XI2179_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2179_MP1 (XI2179_p1 ru3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2176_MP2 (XI2176_p1 nrk2 nrkn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2176_MP0 (VDD A_31_b3_6 XI2176_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2176_MP1 (XI2176_p1 ru2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I98_XG_MP2 (XI2066_I98_XG_p1 I2066_G2_1 I2066_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I98_XG_MP0 (VDD I2066_P2_1 XI2066_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I98_XG_MP1 (XI2066_I98_XG_p1 I2066_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I100_XG_MP2 (XI2066_I100_XG_p1 I2066_G4_3 I2066_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I100_XG_MP0 (VDD I2066_P4_3 XI2066_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I100_XG_MP1 (XI2066_I100_XG_p1 I2066_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2066_I102_XG_MP2 (XI2066_I102_XG_p1 I2066_G6_5 I2066_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2066_I102_XG_MP0 (VDD I2066_P6_5 XI2066_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2066_I102_XG_MP1 (XI2066_I102_XG_p1 I2066_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I157_XG_MP2 (XI1988_I157_XG_p1 I1988_G8_1 I1988_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I157_XG_MP0 (VDD I1988_P8_1 XI1988_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I157_XG_MP1 (XI1988_I157_XG_p1 I1988_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I104_XG_MP2 (XI1988_I104_XG_p1 I1988_G8_7 I1988_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I104_XG_MP0 (VDD I1988_P8_7 XI1988_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I104_XG_MP1 (XI1988_I104_XG_p1 I1988_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I103_XG_MP2 (XI1988_I103_XG_p1 I1988_G7_6 I1988_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I103_XG_MP0 (VDD I1988_P7_6 XI1988_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I103_XG_MP1 (XI1988_I103_XG_p1 I1988_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I100_XG_MP2 (XI1942_I100_XG_p1 I1942_G4_3 I1942_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I100_XG_MP0 (VDD I1942_P4_3 XI1942_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I100_XG_MP1 (XI1942_I100_XG_p1 I1942_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I99_XG_MP2 (XI1942_I99_XG_p1 I1942_G3_2 I1942_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I99_XG_MP0 (VDD I1942_P3_2 XI1942_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I99_XG_MP1 (XI1942_I99_XG_p1 I1942_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I101_XG_MP2 (XI1942_I101_XG_p1 I1942_G5_4 I1942_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I101_XG_MP0 (VDD I1942_P5_4 XI1942_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I101_XG_MP1 (XI1942_I101_XG_p1 I1942_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I101_XG_MP2 (XI1850_I101_XG_p1 I1850_G5_4 I1850_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I101_XG_MP0 (VDD I1850_P5_4 XI1850_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I101_XG_MP1 (XI1850_I101_XG_p1 I1850_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I103_XG_MP2 (XI1850_I103_XG_p1 I1850_G7_6 I1850_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I103_XG_MP0 (VDD I1850_P7_6 XI1850_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I103_XG_MP1 (XI1850_I103_XG_p1 I1850_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I105_XG_MP2 (XI1850_I105_XG_p1 I1850_G9_8 I1850_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I105_XG_MP0 (VDD I1850_P9_8 XI1850_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I105_XG_MP1 (XI1850_I105_XG_p1 I1850_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I107_XG_MP2 (XI1850_I107_XG_p1 I1850_G11_10 I1850_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I107_XG_MP0 (VDD I1850_P11_10 XI1850_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I107_XG_MP1 (XI1850_I107_XG_p1 I1850_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I109_XG_MP2 (XI1850_I109_XG_p1 I1850_G13_12 I1850_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I109_XG_MP0 (VDD I1850_P13_12 XI1850_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I109_XG_MP1 (XI1850_I109_XG_p1 I1850_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I111_XG_MP2 (XI1850_I111_XG_p1 I1850_G15_14 I1850_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I111_XG_MP0 (VDD I1850_P15_14 XI1850_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I111_XG_MP1 (XI1850_I111_XG_p1 I1850_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I113_XG_MP2 (XI1850_I113_XG_p1 I1850_G17_16 I1850_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I113_XG_MP0 (VDD I1850_P17_16 XI1850_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I113_XG_MP1 (XI1850_I113_XG_p1 I1850_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I115_XG_MP2 (XI1850_I115_XG_p1 I1850_G19_18 I1850_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I115_XG_MP0 (VDD I1850_P19_18 XI1850_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I115_XG_MP1 (XI1850_I115_XG_p1 I1850_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I117_XG_MP2 (XI1850_I117_XG_p1 I1850_G21_20 I1850_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I117_XG_MP0 (VDD I1850_P21_20 XI1850_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I117_XG_MP1 (XI1850_I117_XG_p1 I1850_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I119_XG_MP2 (XI1850_I119_XG_p1 I1850_G23_22 I1850_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I119_XG_MP0 (VDD I1850_P23_22 XI1850_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I119_XG_MP1 (XI1850_I119_XG_p1 I1850_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I121_XG_MP2 (XI1850_I121_XG_p1 I1850_G25_24 I1850_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I121_XG_MP0 (VDD I1850_P25_24 XI1850_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I121_XG_MP1 (XI1850_I121_XG_p1 I1850_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I123_XG_MP2 (XI1850_I123_XG_p1 I1850_G27_26 I1850_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I123_XG_MP0 (VDD I1850_P27_26 XI1850_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I123_XG_MP1 (XI1850_I123_XG_p1 I1850_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I125_XG_MP2 (XI1850_I125_XG_p1 I1850_G29_28 I1850_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I125_XG_MP0 (VDD I1850_P29_28 XI1850_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I125_XG_MP1 (XI1850_I125_XG_p1 I1850_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I127_XG_MP2 (XI1850_I127_XG_p1 I1850_G31_30 I1850_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I127_XG_MP0 (VDD I1850_P31_30 XI1850_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I127_XG_MP1 (XI1850_I127_XG_p1 I1850_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I181_XG_MP2 (XI700_I181_XG_p1 I700_G30_23 I700_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I181_XG_MP0 (VDD I700_P30_23 XI700_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I181_XG_MP1 (XI700_I181_XG_p1 I700_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I116_XG_MP2 (XI700_I116_XG_p1 I700_G20_19 I700_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I116_XG_MP0 (VDD I700_P20_19 XI700_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I116_XG_MP1 (XI700_I116_XG_p1 I700_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I114_XG_MP2 (XI700_I114_XG_p1 I700_G18_17 I700_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I114_XG_MP0 (VDD I700_P18_17 XI700_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I114_XG_MP1 (XI700_I114_XG_p1 I700_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I112_XG_MP2 (XI700_I112_XG_p1 I700_G16_15 I700_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I112_XG_MP0 (VDD I700_P16_15 XI700_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I112_XG_MP1 (XI700_I112_XG_p1 I700_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I158_XG_MP2 (XI700_I158_XG_p1 I700_G9_2 I700_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I158_XG_MP0 (VDD I700_P9_2 XI700_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I158_XG_MP1 (XI700_I158_XG_p1 I700_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I103_XG_MP2 (XI700_I103_XG_p1 I700_G7_6 I700_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I103_XG_MP0 (VDD I700_P7_6 XI700_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I103_XG_MP1 (XI700_I103_XG_p1 I700_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I101_XG_MP2 (XI700_I101_XG_p1 I700_G5_4 I700_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I101_XG_MP0 (VDD I700_P5_4 XI700_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I101_XG_MP1 (XI700_I101_XG_p1 I700_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI654_I98_XG_MP2 (XI654_I98_XG_p1 I654_G2_1 I654_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI654_I98_XG_MP0 (VDD I654_P2_1 XI654_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI654_I98_XG_MP1 (XI654_I98_XG_p1 I654_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI180_MP2 (XI180_p1 nbk4 nbkn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI180_MP0 (VDD B_31_b3_0 XI180_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI180_MP1 (XI180_p1 B_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI193_MP2 (XI193_p1 nbk5 nbkn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI193_MP0 (VDD B_31_b3_0 XI193_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI193_MP1 (XI193_p1 B_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI206_MP2 (XI206_p1 nbk6 nbkn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI206_MP0 (VDD B_31_b3_1 XI206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI206_MP1 (XI206_p1 B_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI219_MP2 (XI219_p1 nbk7 nbkn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI219_MP0 (VDD B_31_b3_1 XI219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI219_MP1 (XI219_p1 B_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI232_MP2 (XI232_p1 nbk8 nbkn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI232_MP0 (VDD B_31_b3_1 XI232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI232_MP1 (XI232_p1 B_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2173_MP2 (XI2173_p1 nrk1 nrkn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2173_MP0 (VDD A_31_b3_5 XI2173_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2173_MP1 (XI2173_p1 ru1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I98_XG_MP2 (XI1988_I98_XG_p1 I1988_G2_1 I1988_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I98_XG_MP0 (VDD I1988_P2_1 XI1988_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I98_XG_MP1 (XI1988_I98_XG_p1 I1988_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I100_XG_MP2 (XI1988_I100_XG_p1 I1988_G4_3 I1988_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I100_XG_MP0 (VDD I1988_P4_3 XI1988_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I100_XG_MP1 (XI1988_I100_XG_p1 I1988_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I102_XG_MP2 (XI1988_I102_XG_p1 I1988_G6_5 I1988_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I102_XG_MP0 (VDD I1988_P6_5 XI1988_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I102_XG_MP1 (XI1988_I102_XG_p1 I1988_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I99_XG_MP2 (XI1988_I99_XG_p1 I1988_G3_2 I1988_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I99_XG_MP0 (VDD I1988_P3_2 XI1988_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I99_XG_MP1 (XI1988_I99_XG_p1 I1988_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1988_I101_XG_MP2 (XI1988_I101_XG_p1 I1988_G5_4 I1988_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1988_I101_XG_MP0 (VDD I1988_P5_4 XI1988_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1988_I101_XG_MP1 (XI1988_I101_XG_p1 I1988_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1942_I98_XG_MP2 (XI1942_I98_XG_p1 I1942_G2_1 I1942_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1942_I98_XG_MP0 (VDD I1942_P2_1 XI1942_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1942_I98_XG_MP1 (XI1942_I98_XG_p1 I1942_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I99_XG_MP2 (XI1850_I99_XG_p1 I1850_G3_2 I1850_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I99_XG_MP0 (VDD I1850_P3_2 XI1850_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I99_XG_MP1 (XI1850_I99_XG_p1 I1850_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I157_XG_MP2 (XI1850_I157_XG_p1 I1850_G8_1 I1850_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I157_XG_MP0 (VDD I1850_P8_1 XI1850_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I157_XG_MP1 (XI1850_I157_XG_p1 I1850_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I167_XG_MP2 (XI1850_I167_XG_p1 I1850_G16_9 I1850_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I167_XG_MP0 (VDD I1850_P16_9 XI1850_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I167_XG_MP1 (XI1850_I167_XG_p1 I1850_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I160_XG_MP2 (XI1850_I160_XG_p1 I1850_G10_3 I1850_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I160_XG_MP0 (VDD I1850_P10_3 XI1850_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I160_XG_MP1 (XI1850_I160_XG_p1 I1850_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I169_XG_MP2 (XI1850_I169_XG_p1 I1850_G18_11 I1850_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I169_XG_MP0 (VDD I1850_P18_11 XI1850_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I169_XG_MP1 (XI1850_I169_XG_p1 I1850_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I175_XG_MP2 (XI1850_I175_XG_p1 I1850_G24_17 I1850_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I175_XG_MP0 (VDD I1850_P24_17 XI1850_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I175_XG_MP1 (XI1850_I175_XG_p1 I1850_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I173_XG_MP2 (XI700_I173_XG_p1 I700_G22_15 I700_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I173_XG_MP0 (VDD I700_P22_15 XI700_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I173_XG_MP1 (XI700_I173_XG_p1 I700_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I165_XG_MP2 (XI700_I165_XG_p1 I700_G14_7 I700_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I165_XG_MP0 (VDD I700_P14_7 XI700_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I165_XG_MP1 (XI700_I165_XG_p1 I700_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I110_XG_MP2 (XI700_I110_XG_p1 I700_G14_13 I700_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I110_XG_MP0 (VDD I700_P14_13 XI700_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I110_XG_MP1 (XI700_I110_XG_p1 I700_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I108_XG_MP2 (XI700_I108_XG_p1 I700_G12_11 I700_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I108_XG_MP0 (VDD I700_P12_11 XI700_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I108_XG_MP1 (XI700_I108_XG_p1 I700_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I106_XG_MP2 (XI700_I106_XG_p1 I700_G10_9 I700_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I106_XG_MP0 (VDD I700_P10_9 XI700_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I106_XG_MP1 (XI700_I106_XG_p1 I700_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I99_XG_MP2 (XI700_I99_XG_p1 I700_G3_2 I700_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I99_XG_MP0 (VDD I700_P3_2 XI700_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I99_XG_MP1 (XI700_I99_XG_p1 I700_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2165_MP2 (XI2165_p1 nqk29 nqkn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2165_MP0 (VDD sq_b3_5 XI2165_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2165_MP1 (XI2165_p1 qu29_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2168_MP2 (XI2168_p1 nqk30 nqkn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2168_MP0 (VDD sq_b3_5 XI2168_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2168_MP1 (XI2168_p1 qu30_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI123_MP2 (XI123_p1 nak29 nakn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI123_MP0 (VDD A_31_b3_4 XI123_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI123_MP1 (XI123_p1 A_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI126_MP2 (XI126_p1 nak30 nakn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI126_MP0 (VDD A_31_b3_5 XI126_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI126_MP1 (XI126_p1 A_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI167_MP2 (XI167_p1 nbk3 nbkn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI167_MP0 (VDD B_31_b3_0 XI167_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI167_MP1 (XI167_p1 B_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI245_MP2 (XI245_p1 nbk9 nbkn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI245_MP0 (VDD B_31_b3_1 XI245_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI245_MP1 (XI245_p1 B_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI310_MP2 (XI310_p1 nbk14 nbkn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI310_MP0 (VDD B_31_b3_2 XI310_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI310_MP1 (XI310_p1 B_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI323_MP2 (XI323_p1 nbk15 nbkn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI323_MP0 (VDD B_31_b3_2 XI323_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI323_MP1 (XI323_p1 B_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2081_MP2 (XI2081_p1 nqk1 nqkn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2081_MP0 (VDD sq_b3_0 XI2081_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2081_MP1 (XI2081_p1 qu1_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2084_MP2 (XI2084_p1 nqk2 nqkn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2084_MP0 (VDD sq_b3_0 XI2084_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2084_MP1 (XI2084_p1 qu2_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I98_XG_MP2 (XI1850_I98_XG_p1 I1850_G2_1 I1850_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I98_XG_MP0 (VDD I1850_P2_1 XI1850_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I98_XG_MP1 (XI1850_I98_XG_p1 I1850_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I100_XG_MP2 (XI1850_I100_XG_p1 I1850_G4_3 I1850_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I100_XG_MP0 (VDD I1850_P4_3 XI1850_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I100_XG_MP1 (XI1850_I100_XG_p1 I1850_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I163_XG_MP2 (XI1850_I163_XG_p1 I1850_G12_5 I1850_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I163_XG_MP0 (VDD I1850_P12_5 XI1850_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I163_XG_MP1 (XI1850_I163_XG_p1 I1850_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I171_XG_MP2 (XI1850_I171_XG_p1 I1850_G20_13 I1850_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I171_XG_MP0 (VDD I1850_P20_13 XI1850_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I171_XG_MP1 (XI1850_I171_XG_p1 I1850_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I165_XG_MP2 (XI1850_I165_XG_p1 I1850_G14_7 I1850_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I165_XG_MP0 (VDD I1850_P14_7 XI1850_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I165_XG_MP1 (XI1850_I165_XG_p1 I1850_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I173_XG_MP2 (XI1850_I173_XG_p1 I1850_G22_15 I1850_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I173_XG_MP0 (VDD I1850_P22_15 XI1850_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I173_XG_MP1 (XI1850_I173_XG_p1 I1850_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I177_XG_MP2 (XI1850_I177_XG_p1 I1850_G26_19 I1850_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I177_XG_MP0 (VDD I1850_P26_19 XI1850_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I177_XG_MP1 (XI1850_I177_XG_p1 I1850_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I179_XG_MP2 (XI1850_I179_XG_p1 I1850_G28_21 I1850_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I179_XG_MP0 (VDD I1850_P28_21 XI1850_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I179_XG_MP1 (XI1850_I179_XG_p1 I1850_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I179_XG_MP2 (XI700_I179_XG_p1 I700_G28_21 I700_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I179_XG_MP0 (VDD I700_P28_21 XI700_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I179_XG_MP1 (XI700_I179_XG_p1 I700_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I177_XG_MP2 (XI700_I177_XG_p1 I700_G26_19 I700_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I177_XG_MP0 (VDD I700_P26_19 XI700_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I177_XG_MP1 (XI700_I177_XG_p1 I700_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I175_XG_MP2 (XI700_I175_XG_p1 I700_G24_17 I700_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I175_XG_MP0 (VDD I700_P24_17 XI700_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I175_XG_MP1 (XI700_I175_XG_p1 I700_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I169_XG_MP2 (XI700_I169_XG_p1 I700_G18_11 I700_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I169_XG_MP0 (VDD I700_P18_11 XI700_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I169_XG_MP1 (XI700_I169_XG_p1 I700_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I160_XG_MP2 (XI700_I160_XG_p1 I700_G10_3 I700_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I160_XG_MP0 (VDD I700_P10_3 XI700_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I160_XG_MP1 (XI700_I160_XG_p1 I700_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I167_XG_MP2 (XI700_I167_XG_p1 I700_G16_9 I700_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I167_XG_MP0 (VDD I700_P16_9 XI700_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I167_XG_MP1 (XI700_I167_XG_p1 I700_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I104_XG_MP2 (XI700_I104_XG_p1 I700_G8_7 I700_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I104_XG_MP0 (VDD I700_P8_7 XI700_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I104_XG_MP1 (XI700_I104_XG_p1 I700_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I102_XG_MP2 (XI700_I102_XG_p1 I700_G6_5 I700_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I102_XG_MP0 (VDD I700_P6_5 XI700_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I102_XG_MP1 (XI700_I102_XG_p1 I700_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I100_XG_MP2 (XI700_I100_XG_p1 I700_G4_3 I700_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I100_XG_MP0 (VDD I700_P4_3 XI700_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I100_XG_MP1 (XI700_I100_XG_p1 I700_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI120_MP2 (XI120_p1 nak28 nakn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI120_MP0 (VDD A_31_b3_4 XI120_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI120_MP1 (XI120_p1 A_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI141_MP2 (XI141_p1 nbk1 nbkn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI141_MP0 (VDD B_31_b3_0 XI141_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI141_MP1 (XI141_p1 B_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI154_MP2 (XI154_p1 nbk2 nbkn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI154_MP0 (VDD B_31_b3_0 XI154_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI154_MP1 (XI154_p1 B_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI258_MP2 (XI258_p1 nbk10 nbkn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI258_MP0 (VDD B_31_b3_1 XI258_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI258_MP1 (XI258_p1 B_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI271_MP2 (XI271_p1 nbk11 nbkn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI271_MP0 (VDD B_31_b3_1 XI271_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI271_MP1 (XI271_p1 B_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI284_MP2 (XI284_p1 nbk12 nbkn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI284_MP0 (VDD B_31_b3_2 XI284_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI284_MP1 (XI284_p1 B_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI297_MP2 (XI297_p1 nbk13 nbkn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI297_MP0 (VDD B_31_b3_2 XI297_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI297_MP1 (XI297_p1 B_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI336_MP2 (XI336_p1 nbk16 nbkn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI336_MP0 (VDD B_31_b3_2 XI336_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI336_MP1 (XI336_p1 B_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI349_MP2 (XI349_p1 nbk17 nbkn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI349_MP0 (VDD B_31_b3_3 XI349_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI349_MP1 (XI349_p1 B_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI362_MP2 (XI362_p1 nbk18 nbkn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI362_MP0 (VDD B_31_b3_3 XI362_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI362_MP1 (XI362_p1 B_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI375_MP2 (XI375_p1 nbk19 nbkn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI375_MP0 (VDD B_31_b3_3 XI375_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI375_MP1 (XI375_p1 B_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI388_MP2 (XI388_p1 nbk20 nbkn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI388_MP0 (VDD B_31_b3_3 XI388_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI388_MP1 (XI388_p1 B_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I102_XG_MP2 (XI1850_I102_XG_p1 I1850_G6_5 I1850_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I102_XG_MP0 (VDD I1850_P6_5 XI1850_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I102_XG_MP1 (XI1850_I102_XG_p1 I1850_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I104_XG_MP2 (XI1850_I104_XG_p1 I1850_G8_7 I1850_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I104_XG_MP0 (VDD I1850_P8_7 XI1850_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I104_XG_MP1 (XI1850_I104_XG_p1 I1850_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I106_XG_MP2 (XI1850_I106_XG_p1 I1850_G10_9 I1850_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I106_XG_MP0 (VDD I1850_P10_9 XI1850_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I106_XG_MP1 (XI1850_I106_XG_p1 I1850_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I108_XG_MP2 (XI1850_I108_XG_p1 I1850_G12_11 I1850_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I108_XG_MP0 (VDD I1850_P12_11 XI1850_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I108_XG_MP1 (XI1850_I108_XG_p1 I1850_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I110_XG_MP2 (XI1850_I110_XG_p1 I1850_G14_13 I1850_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I110_XG_MP0 (VDD I1850_P14_13 XI1850_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I110_XG_MP1 (XI1850_I110_XG_p1 I1850_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I112_XG_MP2 (XI1850_I112_XG_p1 I1850_G16_15 I1850_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I112_XG_MP0 (VDD I1850_P16_15 XI1850_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I112_XG_MP1 (XI1850_I112_XG_p1 I1850_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I181_XG_MP2 (XI1850_I181_XG_p1 I1850_G30_23 I1850_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I181_XG_MP0 (VDD I1850_P30_23 XI1850_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I181_XG_MP1 (XI1850_I181_XG_p1 I1850_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I171_XG_MP2 (XI700_I171_XG_p1 I700_G20_13 I700_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I171_XG_MP0 (VDD I700_P20_13 XI700_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I171_XG_MP1 (XI700_I171_XG_p1 I700_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I163_XG_MP2 (XI700_I163_XG_p1 I700_G12_5 I700_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I163_XG_MP0 (VDD I700_P12_5 XI700_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I163_XG_MP1 (XI700_I163_XG_p1 I700_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I157_XG_MP2 (XI700_I157_XG_p1 I700_G8_1 I700_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I157_XG_MP0 (VDD I700_P8_1 XI700_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I157_XG_MP1 (XI700_I157_XG_p1 I700_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI700_I98_XG_MP2 (XI700_I98_XG_p1 I700_G2_1 I700_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI700_I98_XG_MP0 (VDD I700_P2_1 XI700_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI700_I98_XG_MP1 (XI700_I98_XG_p1 I700_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI117_MP2 (XI117_p1 nak27 nakn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI117_MP0 (VDD A_31_b3_4 XI117_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI117_MP1 (XI117_p1 A_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI114_MP2 (XI114_p1 nak26 nakn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI114_MP0 (VDD A_31_b3_4 XI114_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI114_MP1 (XI114_p1 A_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI111_MP2 (XI111_p1 nak25 nakn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI111_MP0 (VDD A_31_b3_4 XI111_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI111_MP1 (XI111_p1 A_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI108_MP2 (XI108_p1 nak24 nakn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI108_MP0 (VDD A_31_b3_4 XI108_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI108_MP1 (XI108_p1 A_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI414_MP2 (XI414_p1 nbk22 nbkn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI414_MP0 (VDD B_31_b3_3 XI414_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI414_MP1 (XI414_p1 B_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI401_MP2 (XI401_p1 nbk21 nbkn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI401_MP0 (VDD B_31_b3_3 XI401_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI401_MP1 (XI401_p1 B_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI39_MP2 (XI39_p1 nak1 nakn2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI39_MP0 (VDD A_31_b3_0 XI39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI39_MP1 (XI39_p1 A_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2087_MP2 (XI2087_p1 nqk3 nqkn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2087_MP0 (VDD sq_b3_0 XI2087_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2087_MP1 (XI2087_p1 qu3_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I114_XG_MP2 (XI1850_I114_XG_p1 I1850_G18_17 I1850_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I114_XG_MP0 (VDD I1850_P18_17 XI1850_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I114_XG_MP1 (XI1850_I114_XG_p1 I1850_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I116_XG_MP2 (XI1850_I116_XG_p1 I1850_G20_19 I1850_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I116_XG_MP0 (VDD I1850_P20_19 XI1850_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I116_XG_MP1 (XI1850_I116_XG_p1 I1850_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I118_XG_MP2 (XI1850_I118_XG_p1 I1850_G22_21 I1850_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I118_XG_MP0 (VDD I1850_P22_21 XI1850_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I118_XG_MP1 (XI1850_I118_XG_p1 I1850_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I120_XG_MP2 (XI1850_I120_XG_p1 I1850_G24_23 I1850_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I120_XG_MP0 (VDD I1850_P24_23 XI1850_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I120_XG_MP1 (XI1850_I120_XG_p1 I1850_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I122_XG_MP2 (XI1850_I122_XG_p1 I1850_G26_25 I1850_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I122_XG_MP0 (VDD I1850_P26_25 XI1850_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I122_XG_MP1 (XI1850_I122_XG_p1 I1850_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I124_XG_MP2 (XI1850_I124_XG_p1 I1850_G28_27 I1850_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I124_XG_MP0 (VDD I1850_P28_27 XI1850_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I124_XG_MP1 (XI1850_I124_XG_p1 I1850_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1850_I126_XG_MP2 (XI1850_I126_XG_p1 I1850_G30_29 I1850_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1850_I126_XG_MP0 (VDD I1850_P30_29 XI1850_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1850_I126_XG_MP1 (XI1850_I126_XG_p1 I1850_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2162_MP2 (XI2162_p1 nqk28 nqkn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2162_MP0 (VDD sq_b3_5 XI2162_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2162_MP1 (XI2162_p1 qu28_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI518_MP2 (XI518_p1 nbk30 nbkn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI518_MP0 (VDD B_31_b3_5 XI518_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI518_MP1 (XI518_p1 B_30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI505_MP2 (XI505_p1 nbk29 nbkn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI505_MP0 (VDD B_31_b3_5 XI505_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI505_MP1 (XI505_p1 B_29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI427_MP2 (XI427_p1 nbk23 nbkn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI427_MP0 (VDD B_31_b3_4 XI427_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI427_MP1 (XI427_p1 B_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI42_MP2 (XI42_p1 nak2 nakn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI42_MP0 (VDD A_31_b3_0 XI42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI42_MP1 (XI42_p1 A_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI45_MP2 (XI45_p1 nak3 nakn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI45_MP0 (VDD A_31_b3_0 XI45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI45_MP1 (XI45_p1 A_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI48_MP2 (XI48_p1 nak4 nakn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI48_MP0 (VDD A_31_b3_0 XI48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI48_MP1 (XI48_p1 A_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI51_MP2 (XI51_p1 nak5 nakn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI51_MP0 (VDD A_31_b3_0 XI51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI51_MP1 (XI51_p1 A_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2090_MP2 (XI2090_p1 nqk4 nqkn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2090_MP0 (VDD sq_b3_0 XI2090_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2090_MP1 (XI2090_p1 qu4_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2159_MP2 (XI2159_p1 nqk27 nqkn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2159_MP0 (VDD sq_b3_5 XI2159_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2159_MP1 (XI2159_p1 qu27_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI492_MP2 (XI492_p1 nbk28 nbkn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI492_MP0 (VDD B_31_b3_4 XI492_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI492_MP1 (XI492_p1 B_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI440_MP2 (XI440_p1 nbk24 nbkn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI440_MP0 (VDD B_31_b3_4 XI440_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI440_MP1 (XI440_p1 B_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2093_MP2 (XI2093_p1 nqk5 nqkn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2093_MP0 (VDD sq_b3_0 XI2093_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI2093_MP1 (XI2093_p1 qu5_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I99_XG_MP2 (XI792_I99_XG_p1 I792_G3_2 I792_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I99_XG_MP0 (VDD I792_P3_2 XI792_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I99_XG_MP1 (XI792_I99_XG_p1 I792_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I100_XG_MP2 (XI792_I100_XG_p1 I792_G4_3 I792_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I100_XG_MP0 (VDD I792_P4_3 XI792_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I100_XG_MP1 (XI792_I100_XG_p1 I792_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I98_XG_MP2 (XI792_I98_XG_p1 I792_G2_1 I792_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I98_XG_MP0 (VDD I792_P2_1 XI792_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I98_XG_MP1 (XI792_I98_XG_p1 I792_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I100_XG_MP2 (XI838_I100_XG_p1 I838_G4_3 I838_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I100_XG_MP0 (VDD I838_P4_3 XI838_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I100_XG_MP1 (XI838_I100_XG_p1 I838_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I98_XG_MP2 (XI838_I98_XG_p1 I838_G2_1 I838_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I98_XG_MP0 (VDD I838_P2_1 XI838_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I98_XG_MP1 (XI838_I98_XG_p1 I838_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI479_MP2 (XI479_p1 nbk27 nbkn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI479_MP0 (VDD B_31_b3_4 XI479_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI479_MP1 (XI479_p1 B_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI466_MP2 (XI466_p1 nbk26 nbkn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI466_MP0 (VDD B_31_b3_4 XI466_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI466_MP1 (XI466_p1 B_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI453_MP2 (XI453_p1 nbk25 nbkn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI453_MP0 (VDD B_31_b3_4 XI453_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI453_MP1 (XI453_p1 B_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I98_XG_MP2 (XI1712_I98_XG_p1 I1712_G2_1 I1712_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I98_XG_MP0 (VDD I1712_P2_1 XI1712_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I98_XG_MP1 (XI1712_I98_XG_p1 I1712_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I99_XG_MP2 (XI1804_I99_XG_p1 I1804_G3_2 I1804_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I99_XG_MP0 (VDD I1804_P3_2 XI1804_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I99_XG_MP1 (XI1804_I99_XG_p1 I1804_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I98_XG_MP2 (XI1804_I98_XG_p1 I1804_G2_1 I1804_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I98_XG_MP0 (VDD I1804_P2_1 XI1804_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I98_XG_MP1 (XI1804_I98_XG_p1 I1804_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I100_XG_MP2 (XI1804_I100_XG_p1 I1804_G4_3 I1804_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I100_XG_MP0 (VDD I1804_P4_3 XI1804_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I100_XG_MP1 (XI1804_I100_XG_p1 I1804_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I107_XG_MP2 (XI746_I107_XG_p1 I746_G11_10 I746_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I107_XG_MP0 (VDD I746_P11_10 XI746_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I107_XG_MP1 (XI746_I107_XG_p1 I746_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I105_XG_MP2 (XI746_I105_XG_p1 I746_G9_8 I746_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I105_XG_MP0 (VDD I746_P9_8 XI746_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I105_XG_MP1 (XI746_I105_XG_p1 I746_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I103_XG_MP2 (XI746_I103_XG_p1 I746_G7_6 I746_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I103_XG_MP0 (VDD I746_P7_6 XI746_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I103_XG_MP1 (XI746_I103_XG_p1 I746_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I101_XG_MP2 (XI746_I101_XG_p1 I746_G5_4 I746_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I101_XG_MP0 (VDD I746_P5_4 XI746_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I101_XG_MP1 (XI746_I101_XG_p1 I746_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I99_XG_MP2 (XI746_I99_XG_p1 I746_G3_2 I746_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I99_XG_MP0 (VDD I746_P3_2 XI746_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I99_XG_MP1 (XI746_I99_XG_p1 I746_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I103_XG_MP2 (XI792_I103_XG_p1 I792_G7_6 I792_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I103_XG_MP0 (VDD I792_P7_6 XI792_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I103_XG_MP1 (XI792_I103_XG_p1 I792_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I101_XG_MP2 (XI792_I101_XG_p1 I792_G5_4 I792_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I101_XG_MP0 (VDD I792_P5_4 XI792_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I101_XG_MP1 (XI792_I101_XG_p1 I792_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I104_XG_MP2 (XI792_I104_XG_p1 I792_G8_7 I792_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I104_XG_MP0 (VDD I792_P8_7 XI792_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I104_XG_MP1 (XI792_I104_XG_p1 I792_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I102_XG_MP2 (XI792_I102_XG_p1 I792_G6_5 I792_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I102_XG_MP0 (VDD I792_P6_5 XI792_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I102_XG_MP1 (XI792_I102_XG_p1 I792_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I103_XG_MP2 (XI838_I103_XG_p1 I838_G7_6 I838_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I103_XG_MP0 (VDD I838_P7_6 XI838_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I103_XG_MP1 (XI838_I103_XG_p1 I838_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I101_XG_MP2 (XI838_I101_XG_p1 I838_G5_4 I838_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I101_XG_MP0 (VDD I838_P5_4 XI838_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I101_XG_MP1 (XI838_I101_XG_p1 I838_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I99_XG_MP2 (XI838_I99_XG_p1 I838_G3_2 I838_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I99_XG_MP0 (VDD I838_P3_2 XI838_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I99_XG_MP1 (XI838_I99_XG_p1 I838_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I102_XG_MP2 (XI838_I102_XG_p1 I838_G6_5 I838_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I102_XG_MP0 (VDD I838_P6_5 XI838_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I102_XG_MP1 (XI838_I102_XG_p1 I838_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I104_XG_MP2 (XI838_I104_XG_p1 I838_G8_7 I838_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I104_XG_MP0 (VDD I838_P8_7 XI838_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I104_XG_MP1 (XI838_I104_XG_p1 I838_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I157_XG_MP2 (XI838_I157_XG_p1 I838_G8_1 I838_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I157_XG_MP0 (VDD I838_P8_1 XI838_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I157_XG_MP1 (XI838_I157_XG_p1 I838_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I98_XG_MP2 (XI884_I98_XG_p1 I884_G2_1 I884_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I98_XG_MP0 (VDD I884_P2_1 XI884_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I98_XG_MP1 (XI884_I98_XG_p1 I884_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I99_XG_MP2 (XI884_I99_XG_p1 I884_G3_2 I884_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I99_XG_MP0 (VDD I884_P3_2 XI884_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I99_XG_MP1 (XI884_I99_XG_p1 I884_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I101_XG_MP2 (XI884_I101_XG_p1 I884_G5_4 I884_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I101_XG_MP0 (VDD I884_P5_4 XI884_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I101_XG_MP1 (XI884_I101_XG_p1 I884_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I100_XG_MP2 (XI1712_I100_XG_p1 I1712_G4_3 I1712_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I100_XG_MP0 (VDD I1712_P4_3 XI1712_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I100_XG_MP1 (XI1712_I100_XG_p1 I1712_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I99_XG_MP2 (XI1712_I99_XG_p1 I1712_G3_2 I1712_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I99_XG_MP0 (VDD I1712_P3_2 XI1712_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I99_XG_MP1 (XI1712_I99_XG_p1 I1712_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I100_XG_MP2 (XI1758_I100_XG_p1 I1758_G4_3 I1758_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I100_XG_MP0 (VDD I1758_P4_3 XI1758_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I100_XG_MP1 (XI1758_I100_XG_p1 I1758_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I98_XG_MP2 (XI1758_I98_XG_p1 I1758_G2_1 I1758_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I98_XG_MP0 (VDD I1758_P2_1 XI1758_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I98_XG_MP1 (XI1758_I98_XG_p1 I1758_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I99_XG_MP2 (XI1758_I99_XG_p1 I1758_G3_2 I1758_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I99_XG_MP0 (VDD I1758_P3_2 XI1758_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I99_XG_MP1 (XI1758_I99_XG_p1 I1758_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I101_XG_MP2 (XI1804_I101_XG_p1 I1804_G5_4 I1804_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I101_XG_MP0 (VDD I1804_P5_4 XI1804_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I101_XG_MP1 (XI1804_I101_XG_p1 I1804_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I102_XG_MP2 (XI1804_I102_XG_p1 I1804_G6_5 I1804_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I102_XG_MP0 (VDD I1804_P6_5 XI1804_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I102_XG_MP1 (XI1804_I102_XG_p1 I1804_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I157_XG_MP2 (XI1804_I157_XG_p1 I1804_G8_1 I1804_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I157_XG_MP0 (VDD I1804_P8_1 XI1804_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I157_XG_MP1 (XI1804_I157_XG_p1 I1804_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I167_XG_MP2 (XI1804_I167_XG_p1 I1804_G16_9 I1804_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I167_XG_MP0 (VDD I1804_P16_9 XI1804_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I167_XG_MP1 (XI1804_I167_XG_p1 I1804_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I174_XG_MP2 (XI746_I174_XG_p1 I746_G23_16 I746_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I174_XG_MP0 (VDD I746_P23_16 XI746_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I174_XG_MP1 (XI746_I174_XG_p1 I746_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I166_XG_MP2 (XI746_I166_XG_p1 I746_G15_8 I746_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I166_XG_MP0 (VDD I746_P15_8 XI746_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I166_XG_MP1 (XI746_I166_XG_p1 I746_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I162_XG_MP2 (XI746_I162_XG_p1 I746_G11_4 I746_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I162_XG_MP0 (VDD I746_P11_4 XI746_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I162_XG_MP1 (XI746_I162_XG_p1 I746_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I113_XG_MP2 (XI746_I113_XG_p1 I746_G17_16 I746_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I113_XG_MP0 (VDD I746_P17_16 XI746_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I113_XG_MP1 (XI746_I113_XG_p1 I746_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I111_XG_MP2 (XI746_I111_XG_p1 I746_G15_14 I746_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I111_XG_MP0 (VDD I746_P15_14 XI746_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I111_XG_MP1 (XI746_I111_XG_p1 I746_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I109_XG_MP2 (XI746_I109_XG_p1 I746_G13_12 I746_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I109_XG_MP0 (VDD I746_P13_12 XI746_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I109_XG_MP1 (XI746_I109_XG_p1 I746_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I158_XG_MP2 (XI746_I158_XG_p1 I746_G9_2 I746_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I158_XG_MP0 (VDD I746_P9_2 XI746_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I158_XG_MP1 (XI746_I158_XG_p1 I746_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I102_XG_MP2 (XI746_I102_XG_p1 I746_G6_5 I746_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I102_XG_MP0 (VDD I746_P6_5 XI746_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I102_XG_MP1 (XI746_I102_XG_p1 I746_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I100_XG_MP2 (XI746_I100_XG_p1 I746_G4_3 I746_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I100_XG_MP0 (VDD I746_P4_3 XI746_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I100_XG_MP1 (XI746_I100_XG_p1 I746_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I98_XG_MP2 (XI746_I98_XG_p1 I746_G2_1 I746_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I98_XG_MP0 (VDD I746_P2_1 XI746_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I98_XG_MP1 (XI746_I98_XG_p1 I746_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I105_XG_MP2 (XI792_I105_XG_p1 I792_G9_8 I792_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I105_XG_MP0 (VDD I792_P9_8 XI792_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I105_XG_MP1 (XI792_I105_XG_p1 I792_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I158_XG_MP2 (XI792_I158_XG_p1 I792_G9_2 I792_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I158_XG_MP0 (VDD I792_P9_2 XI792_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I158_XG_MP1 (XI792_I158_XG_p1 I792_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I157_XG_MP2 (XI792_I157_XG_p1 I792_G8_1 I792_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I157_XG_MP0 (VDD I792_P8_1 XI792_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I157_XG_MP1 (XI792_I157_XG_p1 I792_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I105_XG_MP2 (XI838_I105_XG_p1 I838_G9_8 I838_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I105_XG_MP0 (VDD I838_P9_8 XI838_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I105_XG_MP1 (XI838_I105_XG_p1 I838_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I158_XG_MP2 (XI838_I158_XG_p1 I838_G9_2 I838_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I158_XG_MP0 (VDD I838_P9_2 XI838_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I158_XG_MP1 (XI838_I158_XG_p1 I838_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I106_XG_MP2 (XI838_I106_XG_p1 I838_G10_9 I838_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I106_XG_MP0 (VDD I838_P10_9 XI838_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I106_XG_MP1 (XI838_I106_XG_p1 I838_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I167_XG_MP2 (XI838_I167_XG_p1 I838_G16_9 I838_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I167_XG_MP0 (VDD I838_P16_9 XI838_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I167_XG_MP1 (XI838_I167_XG_p1 I838_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I104_XG_MP2 (XI884_I104_XG_p1 I884_G8_7 I884_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I104_XG_MP0 (VDD I884_P8_7 XI884_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I104_XG_MP1 (XI884_I104_XG_p1 I884_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I102_XG_MP2 (XI884_I102_XG_p1 I884_G6_5 I884_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I102_XG_MP0 (VDD I884_P6_5 XI884_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I102_XG_MP1 (XI884_I102_XG_p1 I884_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I100_XG_MP2 (XI884_I100_XG_p1 I884_G4_3 I884_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I100_XG_MP0 (VDD I884_P4_3 XI884_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I100_XG_MP1 (XI884_I100_XG_p1 I884_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I157_XG_MP2 (XI884_I157_XG_p1 I884_G8_1 I884_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I157_XG_MP0 (VDD I884_P8_1 XI884_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I157_XG_MP1 (XI884_I157_XG_p1 I884_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I103_XG_MP2 (XI884_I103_XG_p1 I884_G7_6 I884_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I103_XG_MP0 (VDD I884_P7_6 XI884_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I103_XG_MP1 (XI884_I103_XG_p1 I884_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I167_XG_MP2 (XI1712_I167_XG_p1 I1712_G16_9 I1712_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I167_XG_MP0 (VDD I1712_P16_9 XI1712_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I167_XG_MP1 (XI1712_I167_XG_p1 I1712_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I157_XG_MP2 (XI1712_I157_XG_p1 I1712_G8_1 I1712_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I157_XG_MP0 (VDD I1712_P8_1 XI1712_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I157_XG_MP1 (XI1712_I157_XG_p1 I1712_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I104_XG_MP2 (XI1712_I104_XG_p1 I1712_G8_7 I1712_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I104_XG_MP0 (VDD I1712_P8_7 XI1712_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I104_XG_MP1 (XI1712_I104_XG_p1 I1712_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I102_XG_MP2 (XI1712_I102_XG_p1 I1712_G6_5 I1712_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I102_XG_MP0 (VDD I1712_P6_5 XI1712_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I102_XG_MP1 (XI1712_I102_XG_p1 I1712_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I101_XG_MP2 (XI1712_I101_XG_p1 I1712_G5_4 I1712_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I101_XG_MP0 (VDD I1712_P5_4 XI1712_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I101_XG_MP1 (XI1712_I101_XG_p1 I1712_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I104_XG_MP2 (XI1758_I104_XG_p1 I1758_G8_7 I1758_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I104_XG_MP0 (VDD I1758_P8_7 XI1758_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I104_XG_MP1 (XI1758_I104_XG_p1 I1758_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I102_XG_MP2 (XI1758_I102_XG_p1 I1758_G6_5 I1758_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I102_XG_MP0 (VDD I1758_P6_5 XI1758_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I102_XG_MP1 (XI1758_I102_XG_p1 I1758_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I167_XG_MP2 (XI1758_I167_XG_p1 I1758_G16_9 I1758_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I167_XG_MP0 (VDD I1758_P16_9 XI1758_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I167_XG_MP1 (XI1758_I167_XG_p1 I1758_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I157_XG_MP2 (XI1758_I157_XG_p1 I1758_G8_1 I1758_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I157_XG_MP0 (VDD I1758_P8_1 XI1758_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I157_XG_MP1 (XI1758_I157_XG_p1 I1758_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I101_XG_MP2 (XI1758_I101_XG_p1 I1758_G5_4 I1758_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I101_XG_MP0 (VDD I1758_P5_4 XI1758_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I101_XG_MP1 (XI1758_I101_XG_p1 I1758_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI54_MP2 (XI54_p1 nak6 nakn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI54_MP0 (VDD A_31_b3_1 XI54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI54_MP1 (XI54_p1 A_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I103_XG_MP2 (XI1804_I103_XG_p1 I1804_G7_6 I1804_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I103_XG_MP0 (VDD I1804_P7_6 XI1804_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I103_XG_MP1 (XI1804_I103_XG_p1 I1804_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I104_XG_MP2 (XI1804_I104_XG_p1 I1804_G8_7 I1804_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I104_XG_MP0 (VDD I1804_P8_7 XI1804_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I104_XG_MP1 (XI1804_I104_XG_p1 I1804_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I106_XG_MP2 (XI1804_I106_XG_p1 I1804_G10_9 I1804_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I106_XG_MP0 (VDD I1804_P10_9 XI1804_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I106_XG_MP1 (XI1804_I106_XG_p1 I1804_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I160_XG_MP2 (XI1804_I160_XG_p1 I1804_G10_3 I1804_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I160_XG_MP0 (VDD I1804_P10_3 XI1804_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I160_XG_MP1 (XI1804_I160_XG_p1 I1804_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I169_XG_MP2 (XI1804_I169_XG_p1 I1804_G18_11 I1804_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I169_XG_MP0 (VDD I1804_P18_11 XI1804_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I169_XG_MP1 (XI1804_I169_XG_p1 I1804_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I170_XG_MP2 (XI746_I170_XG_p1 I746_G19_12 I746_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I170_XG_MP0 (VDD I746_P19_12 XI746_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I170_XG_MP1 (XI746_I170_XG_p1 I746_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I115_XG_MP2 (XI746_I115_XG_p1 I746_G19_18 I746_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I115_XG_MP0 (VDD I746_P19_18 XI746_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I115_XG_MP1 (XI746_I115_XG_p1 I746_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I168_XG_MP2 (XI746_I168_XG_p1 I746_G17_10 I746_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I168_XG_MP0 (VDD I746_P17_10 XI746_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I168_XG_MP1 (XI746_I168_XG_p1 I746_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I106_XG_MP2 (XI746_I106_XG_p1 I746_G10_9 I746_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I106_XG_MP0 (VDD I746_P10_9 XI746_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I106_XG_MP1 (XI746_I106_XG_p1 I746_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I104_XG_MP2 (XI746_I104_XG_p1 I746_G8_7 I746_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I104_XG_MP0 (VDD I746_P8_7 XI746_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I104_XG_MP1 (XI746_I104_XG_p1 I746_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I107_XG_MP2 (XI792_I107_XG_p1 I792_G11_10 I792_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I107_XG_MP0 (VDD I792_P11_10 XI792_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I107_XG_MP1 (XI792_I107_XG_p1 I792_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I168_XG_MP2 (XI792_I168_XG_p1 I792_G17_10 I792_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I168_XG_MP0 (VDD I792_P17_10 XI792_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I168_XG_MP1 (XI792_I168_XG_p1 I792_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I106_XG_MP2 (XI792_I106_XG_p1 I792_G10_9 I792_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I106_XG_MP0 (VDD I792_P10_9 XI792_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I106_XG_MP1 (XI792_I106_XG_p1 I792_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I167_XG_MP2 (XI792_I167_XG_p1 I792_G16_9 I792_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I167_XG_MP0 (VDD I792_P16_9 XI792_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I167_XG_MP1 (XI792_I167_XG_p1 I792_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I107_XG_MP2 (XI838_I107_XG_p1 I838_G11_10 I838_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I107_XG_MP0 (VDD I838_P11_10 XI838_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I107_XG_MP1 (XI838_I107_XG_p1 I838_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I168_XG_MP2 (XI838_I168_XG_p1 I838_G17_10 I838_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I168_XG_MP0 (VDD I838_P17_10 XI838_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I168_XG_MP1 (XI838_I168_XG_p1 I838_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I108_XG_MP2 (XI838_I108_XG_p1 I838_G12_11 I838_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I108_XG_MP0 (VDD I838_P12_11 XI838_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I108_XG_MP1 (XI838_I108_XG_p1 I838_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I160_XG_MP2 (XI838_I160_XG_p1 I838_G10_3 I838_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I160_XG_MP0 (VDD I838_P10_3 XI838_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I160_XG_MP1 (XI838_I160_XG_p1 I838_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I169_XG_MP2 (XI838_I169_XG_p1 I838_G18_11 I838_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I169_XG_MP0 (VDD I838_P18_11 XI838_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I169_XG_MP1 (XI838_I169_XG_p1 I838_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I106_XG_MP2 (XI884_I106_XG_p1 I884_G10_9 I884_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I106_XG_MP0 (VDD I884_P10_9 XI884_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I106_XG_MP1 (XI884_I106_XG_p1 I884_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I167_XG_MP2 (XI884_I167_XG_p1 I884_G16_9 I884_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I167_XG_MP0 (VDD I884_P16_9 XI884_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I167_XG_MP1 (XI884_I167_XG_p1 I884_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I105_XG_MP2 (XI884_I105_XG_p1 I884_G9_8 I884_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I105_XG_MP0 (VDD I884_P9_8 XI884_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I105_XG_MP1 (XI884_I105_XG_p1 I884_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI884_I158_XG_MP2 (XI884_I158_XG_p1 I884_G9_2 I884_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI884_I158_XG_MP0 (VDD I884_P9_2 XI884_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI884_I158_XG_MP1 (XI884_I158_XG_p1 I884_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I171_XG_MP2 (XI1712_I171_XG_p1 I1712_G20_13 I1712_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I171_XG_MP0 (VDD I1712_P20_13 XI1712_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I171_XG_MP1 (XI1712_I171_XG_p1 I1712_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I163_XG_MP2 (XI1712_I163_XG_p1 I1712_G12_5 I1712_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I163_XG_MP0 (VDD I1712_P12_5 XI1712_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I163_XG_MP1 (XI1712_I163_XG_p1 I1712_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I106_XG_MP2 (XI1712_I106_XG_p1 I1712_G10_9 I1712_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I106_XG_MP0 (VDD I1712_P10_9 XI1712_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I106_XG_MP1 (XI1712_I106_XG_p1 I1712_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1712_I103_XG_MP2 (XI1712_I103_XG_p1 I1712_G7_6 I1712_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1712_I103_XG_MP0 (VDD I1712_P7_6 XI1712_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1712_I103_XG_MP1 (XI1712_I103_XG_p1 I1712_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I106_XG_MP2 (XI1758_I106_XG_p1 I1758_G10_9 I1758_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I106_XG_MP0 (VDD I1758_P10_9 XI1758_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I106_XG_MP1 (XI1758_I106_XG_p1 I1758_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I105_XG_MP2 (XI1758_I105_XG_p1 I1758_G9_8 I1758_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I105_XG_MP0 (VDD I1758_P9_8 XI1758_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I105_XG_MP1 (XI1758_I105_XG_p1 I1758_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1758_I103_XG_MP2 (XI1758_I103_XG_p1 I1758_G7_6 I1758_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1758_I103_XG_MP0 (VDD I1758_P7_6 XI1758_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1758_I103_XG_MP1 (XI1758_I103_XG_p1 I1758_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I105_XG_MP2 (XI1804_I105_XG_p1 I1804_G9_8 I1804_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I105_XG_MP0 (VDD I1804_P9_8 XI1804_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I105_XG_MP1 (XI1804_I105_XG_p1 I1804_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I158_XG_MP2 (XI1804_I158_XG_p1 I1804_G9_2 I1804_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I158_XG_MP0 (VDD I1804_P9_2 XI1804_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I158_XG_MP1 (XI1804_I158_XG_p1 I1804_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I108_XG_MP2 (XI1804_I108_XG_p1 I1804_G12_11 I1804_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I108_XG_MP0 (VDD I1804_P12_11 XI1804_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I108_XG_MP1 (XI1804_I108_XG_p1 I1804_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I163_XG_MP2 (XI1804_I163_XG_p1 I1804_G12_5 I1804_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I163_XG_MP0 (VDD I1804_P12_5 XI1804_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I163_XG_MP1 (XI1804_I163_XG_p1 I1804_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I171_XG_MP2 (XI1804_I171_XG_p1 I1804_G20_13 I1804_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I171_XG_MP0 (VDD I1804_P20_13 XI1804_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I171_XG_MP1 (XI1804_I171_XG_p1 I1804_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1804_I175_XG_MP2 (XI1804_I175_XG_p1 I1804_G24_17 I1804_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1804_I175_XG_MP0 (VDD I1804_P24_17 XI1804_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1804_I175_XG_MP1 (XI1804_I175_XG_p1 I1804_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I182_XG_MP2 (XI746_I182_XG_p1 I746_G31_24 I746_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I182_XG_MP0 (VDD I746_P31_24 XI746_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I182_XG_MP1 (XI746_I182_XG_p1 I746_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I178_XG_MP2 (XI746_I178_XG_p1 I746_G27_20 I746_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I178_XG_MP0 (VDD I746_P27_20 XI746_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I178_XG_MP1 (XI746_I178_XG_p1 I746_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I119_XG_MP2 (XI746_I119_XG_p1 I746_G23_22 I746_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I119_XG_MP0 (VDD I746_P23_22 XI746_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I119_XG_MP1 (XI746_I119_XG_p1 I746_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I117_XG_MP2 (XI746_I117_XG_p1 I746_G21_20 I746_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I117_XG_MP0 (VDD I746_P21_20 XI746_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I117_XG_MP1 (XI746_I117_XG_p1 I746_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I172_XG_MP2 (XI746_I172_XG_p1 I746_G21_14 I746_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I172_XG_MP0 (VDD I746_P21_14 XI746_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I172_XG_MP1 (XI746_I172_XG_p1 I746_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I176_XG_MP2 (XI746_I176_XG_p1 I746_G25_18 I746_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I176_XG_MP0 (VDD I746_P25_18 XI746_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I176_XG_MP1 (XI746_I176_XG_p1 I746_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I164_XG_MP2 (XI746_I164_XG_p1 I746_G13_6 I746_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I164_XG_MP0 (VDD I746_P13_6 XI746_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I164_XG_MP1 (XI746_I164_XG_p1 I746_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I110_XG_MP2 (XI746_I110_XG_p1 I746_G14_13 I746_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I110_XG_MP0 (VDD I746_P14_13 XI746_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I110_XG_MP1 (XI746_I110_XG_p1 I746_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I108_XG_MP2 (XI746_I108_XG_p1 I746_G12_11 I746_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I108_XG_MP0 (VDD I746_P12_11 XI746_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I108_XG_MP1 (XI746_I108_XG_p1 I746_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I167_XG_MP2 (XI746_I167_XG_p1 I746_G16_9 I746_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I167_XG_MP0 (VDD I746_P16_9 XI746_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I167_XG_MP1 (XI746_I167_XG_p1 I746_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI746_I157_XG_MP2 (XI746_I157_XG_p1 I746_G8_1 I746_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI746_I157_XG_MP0 (VDD I746_P8_1 XI746_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI746_I157_XG_MP1 (XI746_I157_XG_p1 I746_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I109_XG_MP2 (XI792_I109_XG_p1 I792_G13_12 I792_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I109_XG_MP0 (VDD I792_P13_12 XI792_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I109_XG_MP1 (XI792_I109_XG_p1 I792_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I110_XG_MP2 (XI792_I110_XG_p1 I792_G14_13 I792_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I110_XG_MP0 (VDD I792_P14_13 XI792_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I110_XG_MP1 (XI792_I110_XG_p1 I792_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I108_XG_MP2 (XI792_I108_XG_p1 I792_G12_11 I792_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I108_XG_MP0 (VDD I792_P12_11 XI792_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I108_XG_MP1 (XI792_I108_XG_p1 I792_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI792_I160_XG_MP2 (XI792_I160_XG_p1 I792_G10_3 I792_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI792_I160_XG_MP0 (VDD I792_P10_3 XI792_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI792_I160_XG_MP1 (XI792_I160_XG_p1 I792_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I109_XG_MP2 (XI838_I109_XG_p1 I838_G13_12 I838_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I109_XG_MP0 (VDD I838_P13_12 XI838_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I109_XG_MP1 (XI838_I109_XG_p1 I838_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I176_XG_MP2 (XI838_I176_XG_p1 I838_G25_18 I838_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI838_I176_XG_MP0 (VDD I838_P25_18 XI838_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI838_I176_XG_MP1 (XI838_I176_XG_p1 I838_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI838_I175_XG_MP2 (XI838_I175_XG_p1 I838_G24_17 I838_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
