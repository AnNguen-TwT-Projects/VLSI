    I_MXI1322_MP2 (VDD dd10_b3_3 XI1322_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1322_MP3 (XI1322_p1 qu15_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1322_MP0 (VDD dd10_b3_3 XI1322_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1323_MP1 (VDD qu15_b3_1 XI1323_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1323_MP5 (b17_11 XI1323_Bn XI1323_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1323_MP4 (XI1323_p1 XI1323_An b17_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1323_MP2 (VDD dd11_b3_3 XI1323_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1323_MP3 (XI1323_p1 qu15_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1323_MP0 (VDD dd11_b3_3 XI1323_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1369_MP1 (VDD qu14_b3_1 XI1369_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1369_MP5 (b18_11 XI1369_Bn XI1369_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1369_MP4 (XI1369_p1 XI1369_An b18_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1369_MP2 (VDD dd11_b3_3 XI1369_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1369_MP3 (XI1369_p1 qu14_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1369_MP0 (VDD dd11_b3_3 XI1369_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I212_MP1 (VDD I1390_G8_0n XI1390_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I212_MP5 (p18_9 XI1390_I212_Bn XI1390_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I212_MP4 (XI1390_I212_p1 XI1390_I212_An p18_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I212_MP2 (VDD I1390_pn9 XI1390_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I212_MP3 (XI1390_I212_p1 I1390_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I212_MP0 (VDD I1390_pn9 XI1390_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1414_MP1 (VDD qu13_b3_1 XI1414_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1414_MP5 (b19_10 XI1414_Bn XI1414_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1414_MP4 (XI1414_p1 XI1414_An b19_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1414_MP2 (VDD dd10_b3_3 XI1414_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1414_MP3 (XI1414_p1 qu13_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1414_MP0 (VDD dd10_b3_3 XI1414_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1415_MP1 (VDD qu13_b3_1 XI1415_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1415_MP5 (b19_11 XI1415_Bn XI1415_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1415_MP4 (XI1415_p1 XI1415_An b19_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1415_MP2 (VDD dd11_b3_3 XI1415_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1415_MP3 (XI1415_p1 qu13_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1415_MP0 (VDD dd11_b3_3 XI1415_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I212_MP1 (VDD I1436_G8_0n XI1436_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I212_MP5 (p19_9 XI1436_I212_Bn XI1436_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I212_MP4 (XI1436_I212_p1 XI1436_I212_An p19_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I212_MP2 (VDD I1436_pn9 XI1436_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I212_MP3 (XI1436_I212_p1 I1436_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I212_MP0 (VDD I1436_pn9 XI1436_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1508_MP1 (VDD qu11_b3_2 XI1508_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1508_MP5 (b21_12 XI1508_Bn XI1508_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1508_MP4 (XI1508_p1 XI1508_An b21_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1508_MP2 (VDD dd12_b3_3 XI1508_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1508_MP3 (XI1508_p1 qu11_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1508_MP0 (VDD dd12_b3_3 XI1508_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1461_MP1 (VDD qu12_b3_1 XI1461_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1461_MP5 (b20_11 XI1461_Bn XI1461_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1461_MP4 (XI1461_p1 XI1461_An b20_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1461_MP2 (VDD dd11_b3_3 XI1461_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1461_MP3 (XI1461_p1 qu12_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1461_MP0 (VDD dd11_b3_3 XI1461_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1460_MP1 (VDD qu12_b3_1 XI1460_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1460_MP5 (b20_10 XI1460_Bn XI1460_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1460_MP4 (XI1460_p1 XI1460_An b20_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1460_MP2 (VDD dd10_b3_3 XI1460_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1460_MP3 (XI1460_p1 qu12_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1460_MP0 (VDD dd10_b3_3 XI1460_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I213_MP1 (VDD I1482_G9_0n XI1482_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I213_MP5 (p20_10 XI1482_I213_Bn XI1482_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I213_MP4 (XI1482_I213_p1 XI1482_I213_An p20_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I213_MP2 (VDD I1482_pn10 XI1482_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I213_MP3 (XI1482_I213_p1 I1482_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I213_MP0 (VDD I1482_pn10 XI1482_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I212_MP1 (VDD I1482_G8_0n XI1482_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I212_MP5 (p20_9 XI1482_I212_Bn XI1482_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I212_MP4 (XI1482_I212_p1 XI1482_I212_An p20_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I212_MP2 (VDD I1482_pn9 XI1482_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I212_MP3 (XI1482_I212_p1 I1482_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I212_MP0 (VDD I1482_pn9 XI1482_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I217_MP1 (VDD I1528_G13_0n XI1528_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I217_MP5 (p21_14 XI1528_I217_Bn XI1528_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I217_MP4 (XI1528_I217_p1 XI1528_I217_An p21_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I217_MP2 (VDD I1528_pn14 XI1528_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I217_MP3 (XI1528_I217_p1 I1528_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I217_MP0 (VDD I1528_pn14 XI1528_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I207_MP1 (VDD I1160_G3_0n XI1160_I207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I207_MP5 (p13_4 XI1160_I207_Bn XI1160_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I207_MP4 (XI1160_I207_p1 XI1160_I207_An p13_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I207_MP2 (VDD I1160_pn4 XI1160_I207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I207_MP3 (XI1160_I207_p1 I1160_G3_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I207_MP0 (VDD I1160_pn4 XI1160_I207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I206_MP1 (VDD I1160_G2_0n XI1160_I206_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I206_MP5 (p13_3 XI1160_I206_Bn XI1160_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I206_MP4 (XI1160_I206_p1 XI1160_I206_An p13_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I206_MP2 (VDD I1160_pn3 XI1160_I206_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I206_MP3 (XI1160_I206_p1 I1160_G2_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I206_MP0 (VDD I1160_pn3 XI1160_I206_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1183_MP1 (VDD qu18_b3_1 XI1183_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1183_MP5 (b14_9 XI1183_Bn XI1183_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1183_MP4 (XI1183_p1 XI1183_An b14_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1183_MP2 (VDD dd9_b3_2 XI1183_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1183_MP3 (XI1183_p1 qu18_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1183_MP0 (VDD dd9_b3_2 XI1183_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1184_MP1 (VDD qu18_b3_1 XI1184_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1184_MP5 (b14_10 XI1184_Bn XI1184_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1184_MP4 (XI1184_p1 XI1184_An b14_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1184_MP2 (VDD dd10_b3_2 XI1184_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1184_MP3 (XI1184_p1 qu18_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1184_MP0 (VDD dd10_b3_2 XI1184_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1229_MP1 (VDD qu17_b3_1 XI1229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1229_MP5 (b15_9 XI1229_Bn XI1229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1229_MP4 (XI1229_p1 XI1229_An b15_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1229_MP2 (VDD dd9_b3_2 XI1229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1229_MP3 (XI1229_p1 qu17_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1229_MP0 (VDD dd9_b3_2 XI1229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1230_MP1 (VDD qu17_b3_1 XI1230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1230_MP5 (b15_10 XI1230_Bn XI1230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1230_MP4 (XI1230_p1 XI1230_An b15_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1230_MP2 (VDD dd10_b3_2 XI1230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1230_MP3 (XI1230_p1 qu17_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1230_MP0 (VDD dd10_b3_2 XI1230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1276_MP1 (VDD qu16_b3_1 XI1276_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1276_MP5 (b16_10 XI1276_Bn XI1276_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1276_MP4 (XI1276_p1 XI1276_An b16_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1276_MP2 (VDD dd10_b3_2 XI1276_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1276_MP3 (XI1276_p1 qu16_b3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1276_MP0 (VDD dd10_b3_2 XI1276_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I213_MP1 (VDD I1298_G9_0n XI1298_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I213_MP5 (p16_10 XI1298_I213_Bn XI1298_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I213_MP4 (XI1298_I213_p1 XI1298_I213_An p16_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I213_MP2 (VDD I1298_pn10 XI1298_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I213_MP3 (XI1298_I213_p1 I1298_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I213_MP0 (VDD I1298_pn10 XI1298_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I214_MP1 (VDD I1344_G10_0n XI1344_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I214_MP5 (p17_11 XI1344_I214_Bn XI1344_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I214_MP4 (XI1344_I214_p1 XI1344_I214_An p17_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I214_MP2 (VDD I1344_pn11 XI1344_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I214_MP3 (XI1344_I214_p1 I1344_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I214_MP0 (VDD I1344_pn11 XI1344_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I213_MP1 (VDD I1344_G9_0n XI1344_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I213_MP5 (p17_10 XI1344_I213_Bn XI1344_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I213_MP4 (XI1344_I213_p1 XI1344_I213_An p17_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I213_MP2 (VDD I1344_pn10 XI1344_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I213_MP3 (XI1344_I213_p1 I1344_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I213_MP0 (VDD I1344_pn10 XI1344_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1370_MP1 (VDD qu14_b3_2 XI1370_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1370_MP5 (b18_12 XI1370_Bn XI1370_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1370_MP4 (XI1370_p1 XI1370_An b18_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1370_MP2 (VDD dd12_b3_3 XI1370_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1370_MP3 (XI1370_p1 qu14_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1370_MP0 (VDD dd12_b3_3 XI1370_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I214_MP1 (VDD I1390_G10_0n XI1390_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I214_MP5 (p18_11 XI1390_I214_Bn XI1390_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I214_MP4 (XI1390_I214_p1 XI1390_I214_An p18_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I214_MP2 (VDD I1390_pn11 XI1390_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I214_MP3 (XI1390_I214_p1 I1390_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I214_MP0 (VDD I1390_pn11 XI1390_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I213_MP1 (VDD I1390_G9_0n XI1390_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I213_MP5 (p18_10 XI1390_I213_Bn XI1390_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I213_MP4 (XI1390_I213_p1 XI1390_I213_An p18_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I213_MP2 (VDD I1390_pn10 XI1390_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I213_MP3 (XI1390_I213_p1 I1390_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I213_MP0 (VDD I1390_pn10 XI1390_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I213_MP1 (VDD I1436_G9_0n XI1436_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I213_MP5 (p19_10 XI1436_I213_Bn XI1436_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I213_MP4 (XI1436_I213_p1 XI1436_I213_An p19_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I213_MP2 (VDD I1436_pn10 XI1436_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I213_MP3 (XI1436_I213_p1 I1436_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I213_MP0 (VDD I1436_pn10 XI1436_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1510_MP1 (VDD qu11_b3_2 XI1510_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1510_MP5 (b21_14 XI1510_Bn XI1510_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1510_MP4 (XI1510_p1 XI1510_An b21_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1510_MP2 (VDD dd14_b3_3 XI1510_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1510_MP3 (XI1510_p1 qu11_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1510_MP0 (VDD dd14_b3_3 XI1510_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1509_MP1 (VDD qu11_b3_2 XI1509_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1509_MP5 (b21_13 XI1509_Bn XI1509_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1509_MP4 (XI1509_p1 XI1509_An b21_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1509_MP2 (VDD dd13_b3_3 XI1509_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1509_MP3 (XI1509_p1 qu11_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1509_MP0 (VDD dd13_b3_3 XI1509_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I215_MP1 (VDD I1482_G11_0n XI1482_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I215_MP5 (p20_12 XI1482_I215_Bn XI1482_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I215_MP4 (XI1482_I215_p1 XI1482_I215_An p20_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I215_MP2 (VDD I1482_pn12 XI1482_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I215_MP3 (XI1482_I215_p1 I1482_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I215_MP0 (VDD I1482_pn12 XI1482_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I218_MP1 (VDD I1528_G14_0n XI1528_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I218_MP5 (p21_15 XI1528_I218_Bn XI1528_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I218_MP4 (XI1528_I218_p1 XI1528_I218_An p21_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I218_MP2 (VDD I1528_pn15 XI1528_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I218_MP3 (XI1528_I218_p1 I1528_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I218_MP0 (VDD I1528_pn15 XI1528_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1162_MP1 (VDD c13_o XI1162_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1162_MP5 (p13_32 XI1162_Bn XI1162_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1162_MP4 (XI1162_p1 XI1162_An p13_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1162_MP2 (VDD h13 XI1162_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1162_MP3 (XI1162_p1 c13_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1162_MP0 (VDD h13 XI1162_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I219_MP1 (VDD I1160_G15_0n XI1160_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I219_MP5 (p13_16 XI1160_I219_Bn XI1160_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I219_MP4 (XI1160_I219_p1 XI1160_I219_An p13_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I219_MP2 (VDD I1160_pn16 XI1160_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I219_MP3 (XI1160_I219_p1 I1160_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I219_MP0 (VDD I1160_pn16 XI1160_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I212_MP1 (VDD I1252_G8_0n XI1252_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I212_MP5 (p15_9 XI1252_I212_Bn XI1252_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I212_MP4 (XI1252_I212_p1 XI1252_I212_An p15_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I212_MP2 (VDD I1252_pn9 XI1252_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I212_MP3 (XI1252_I212_p1 I1252_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I212_MP0 (VDD I1252_pn9 XI1252_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I213_MP1 (VDD I1252_G9_0n XI1252_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I213_MP5 (p15_10 XI1252_I213_Bn XI1252_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I213_MP4 (XI1252_I213_p1 XI1252_I213_An p15_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I213_MP2 (VDD I1252_pn10 XI1252_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I213_MP3 (XI1252_I213_p1 I1252_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I213_MP0 (VDD I1252_pn10 XI1252_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1278_MP1 (VDD qu16_b3_2 XI1278_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1278_MP5 (b16_12 XI1278_Bn XI1278_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1278_MP4 (XI1278_p1 XI1278_An b16_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1278_MP2 (VDD dd12_b3_2 XI1278_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1278_MP3 (XI1278_p1 qu16_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1278_MP0 (VDD dd12_b3_2 XI1278_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I214_MP1 (VDD I1298_G10_0n XI1298_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I214_MP5 (p16_11 XI1298_I214_Bn XI1298_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I214_MP4 (XI1298_I214_p1 XI1298_I214_An p16_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I214_MP2 (VDD I1298_pn11 XI1298_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I214_MP3 (XI1298_I214_p1 I1298_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I214_MP0 (VDD I1298_pn11 XI1298_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I215_MP1 (VDD I1298_G11_0n XI1298_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I215_MP5 (p16_12 XI1298_I215_Bn XI1298_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I215_MP4 (XI1298_I215_p1 XI1298_I215_An p16_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I215_MP2 (VDD I1298_pn12 XI1298_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I215_MP3 (XI1298_I215_p1 I1298_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I215_MP0 (VDD I1298_pn12 XI1298_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I215_MP1 (VDD I1344_G11_0n XI1344_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I215_MP5 (p17_12 XI1344_I215_Bn XI1344_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I215_MP4 (XI1344_I215_p1 XI1344_I215_An p17_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I215_MP2 (VDD I1344_pn12 XI1344_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I215_MP3 (XI1344_I215_p1 I1344_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I215_MP0 (VDD I1344_pn12 XI1344_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1325_MP1 (VDD qu15_b3_2 XI1325_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1325_MP5 (b17_13 XI1325_Bn XI1325_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1325_MP4 (XI1325_p1 XI1325_An b17_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1325_MP2 (VDD dd13_b3_3 XI1325_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1325_MP3 (XI1325_p1 qu15_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1325_MP0 (VDD dd13_b3_3 XI1325_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1324_MP1 (VDD qu15_b3_2 XI1324_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1324_MP5 (b17_12 XI1324_Bn XI1324_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1324_MP4 (XI1324_p1 XI1324_An b17_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1324_MP2 (VDD dd12_b3_3 XI1324_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1324_MP3 (XI1324_p1 qu15_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1324_MP0 (VDD dd12_b3_3 XI1324_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1371_MP1 (VDD qu14_b3_2 XI1371_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1371_MP5 (b18_13 XI1371_Bn XI1371_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1371_MP4 (XI1371_p1 XI1371_An b18_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1371_MP2 (VDD dd13_b3_3 XI1371_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1371_MP3 (XI1371_p1 qu14_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1371_MP0 (VDD dd13_b3_3 XI1371_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I215_MP1 (VDD I1390_G11_0n XI1390_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I215_MP5 (p18_12 XI1390_I215_Bn XI1390_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I215_MP4 (XI1390_I215_p1 XI1390_I215_An p18_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I215_MP2 (VDD I1390_pn12 XI1390_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I215_MP3 (XI1390_I215_p1 I1390_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I215_MP0 (VDD I1390_pn12 XI1390_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1416_MP1 (VDD qu13_b3_2 XI1416_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1416_MP5 (b19_12 XI1416_Bn XI1416_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1416_MP4 (XI1416_p1 XI1416_An b19_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1416_MP2 (VDD dd12_b3_3 XI1416_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1416_MP3 (XI1416_p1 qu13_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1416_MP0 (VDD dd12_b3_3 XI1416_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1417_MP1 (VDD qu13_b3_2 XI1417_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1417_MP5 (b19_13 XI1417_Bn XI1417_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1417_MP4 (XI1417_p1 XI1417_An b19_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1417_MP2 (VDD dd13_b3_3 XI1417_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1417_MP3 (XI1417_p1 qu13_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1417_MP0 (VDD dd13_b3_3 XI1417_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I214_MP1 (VDD I1436_G10_0n XI1436_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I214_MP5 (p19_11 XI1436_I214_Bn XI1436_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I214_MP4 (XI1436_I214_p1 XI1436_I214_An p19_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I214_MP2 (VDD I1436_pn11 XI1436_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I214_MP3 (XI1436_I214_p1 I1436_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I214_MP0 (VDD I1436_pn11 XI1436_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I215_MP1 (VDD I1436_G11_0n XI1436_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I215_MP5 (p19_12 XI1436_I215_Bn XI1436_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I215_MP4 (XI1436_I215_p1 XI1436_I215_An p19_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I215_MP2 (VDD I1436_pn12 XI1436_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I215_MP3 (XI1436_I215_p1 I1436_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I215_MP0 (VDD I1436_pn12 XI1436_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1462_MP1 (VDD qu12_b3_2 XI1462_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1462_MP5 (b20_12 XI1462_Bn XI1462_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1462_MP4 (XI1462_p1 XI1462_An b20_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1462_MP2 (VDD dd12_b3_3 XI1462_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1462_MP3 (XI1462_p1 qu12_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1462_MP0 (VDD dd12_b3_3 XI1462_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1511_MP1 (VDD qu11_b3_2 XI1511_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1511_MP5 (b21_15 XI1511_Bn XI1511_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1511_MP4 (XI1511_p1 XI1511_An b21_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1511_MP2 (VDD dd15_b3_3 XI1511_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1511_MP3 (XI1511_p1 qu11_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1511_MP0 (VDD dd15_b3_3 XI1511_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1463_MP1 (VDD qu12_b3_2 XI1463_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1463_MP5 (b20_13 XI1463_Bn XI1463_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1463_MP4 (XI1463_p1 XI1463_An b20_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1463_MP2 (VDD dd13_b3_3 XI1463_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1463_MP3 (XI1463_p1 qu12_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1463_MP0 (VDD dd13_b3_3 XI1463_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I214_MP1 (VDD I1482_G10_0n XI1482_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I214_MP5 (p20_11 XI1482_I214_Bn XI1482_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I214_MP4 (XI1482_I214_p1 XI1482_I214_An p20_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I214_MP2 (VDD I1482_pn11 XI1482_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I214_MP3 (XI1482_I214_p1 I1482_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I214_MP0 (VDD I1482_pn11 XI1482_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I217_MP1 (VDD I1160_G13_0n XI1160_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I217_MP5 (p13_14 XI1160_I217_Bn XI1160_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I217_MP4 (XI1160_I217_p1 XI1160_I217_An p13_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I217_MP2 (VDD I1160_pn14 XI1160_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I217_MP3 (XI1160_I217_p1 I1160_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I217_MP0 (VDD I1160_pn14 XI1160_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I215_MP1 (VDD I1160_G11_0n XI1160_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I215_MP5 (p13_12 XI1160_I215_Bn XI1160_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I215_MP4 (XI1160_I215_p1 XI1160_I215_An p13_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I215_MP2 (VDD I1160_pn12 XI1160_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I215_MP3 (XI1160_I215_p1 I1160_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I215_MP0 (VDD I1160_pn12 XI1160_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I213_MP1 (VDD I1160_G9_0n XI1160_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I213_MP5 (p13_10 XI1160_I213_Bn XI1160_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I213_MP4 (XI1160_I213_p1 XI1160_I213_An p13_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I213_MP2 (VDD I1160_pn10 XI1160_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I213_MP3 (XI1160_I213_p1 I1160_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I213_MP0 (VDD I1160_pn10 XI1160_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I212_MP1 (VDD I1206_G8_0n XI1206_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I212_MP5 (p14_9 XI1206_I212_Bn XI1206_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I212_MP4 (XI1206_I212_p1 XI1206_I212_An p14_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I212_MP2 (VDD I1206_pn9 XI1206_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I212_MP3 (XI1206_I212_p1 I1206_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I212_MP0 (VDD I1206_pn9 XI1206_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1232_MP1 (VDD qu17_b3_2 XI1232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1232_MP5 (b15_12 XI1232_Bn XI1232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1232_MP4 (XI1232_p1 XI1232_An b15_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1232_MP2 (VDD dd12_b3_2 XI1232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1232_MP3 (XI1232_p1 qu17_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1232_MP0 (VDD dd12_b3_2 XI1232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1233_MP1 (VDD qu17_b3_2 XI1233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1233_MP5 (b15_13 XI1233_Bn XI1233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1233_MP4 (XI1233_p1 XI1233_An b15_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1233_MP2 (VDD dd13_b3_2 XI1233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1233_MP3 (XI1233_p1 qu17_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1233_MP0 (VDD dd13_b3_2 XI1233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I214_MP1 (VDD I1252_G10_0n XI1252_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I214_MP5 (p15_11 XI1252_I214_Bn XI1252_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I214_MP4 (XI1252_I214_p1 XI1252_I214_An p15_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I214_MP2 (VDD I1252_pn11 XI1252_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I214_MP3 (XI1252_I214_p1 I1252_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I214_MP0 (VDD I1252_pn11 XI1252_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I215_MP1 (VDD I1252_G11_0n XI1252_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I215_MP5 (p15_12 XI1252_I215_Bn XI1252_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I215_MP4 (XI1252_I215_p1 XI1252_I215_An p15_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I215_MP2 (VDD I1252_pn12 XI1252_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I215_MP3 (XI1252_I215_p1 I1252_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I215_MP0 (VDD I1252_pn12 XI1252_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1279_MP1 (VDD qu16_b3_2 XI1279_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1279_MP5 (b16_13 XI1279_Bn XI1279_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1279_MP4 (XI1279_p1 XI1279_An b16_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1279_MP2 (VDD dd13_b3_2 XI1279_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1279_MP3 (XI1279_p1 qu16_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1279_MP0 (VDD dd13_b3_2 XI1279_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I216_MP1 (VDD I1344_G12_0n XI1344_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I216_MP5 (p17_13 XI1344_I216_Bn XI1344_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I216_MP4 (XI1344_I216_p1 XI1344_I216_An p17_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I216_MP2 (VDD I1344_pn13 XI1344_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I216_MP3 (XI1344_I216_p1 I1344_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I216_MP0 (VDD I1344_pn13 XI1344_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1326_MP1 (VDD qu15_b3_2 XI1326_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1326_MP5 (b17_14 XI1326_Bn XI1326_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1326_MP4 (XI1326_p1 XI1326_An b17_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1326_MP2 (VDD dd14_b3_3 XI1326_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1326_MP3 (XI1326_p1 qu15_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1326_MP0 (VDD dd14_b3_3 XI1326_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1372_MP1 (VDD qu14_b3_2 XI1372_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1372_MP5 (b18_14 XI1372_Bn XI1372_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1372_MP4 (XI1372_p1 XI1372_An b18_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1372_MP2 (VDD dd14_b3_3 XI1372_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1372_MP3 (XI1372_p1 qu14_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1372_MP0 (VDD dd14_b3_3 XI1372_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1373_MP1 (VDD qu14_b3_2 XI1373_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1373_MP5 (b18_15 XI1373_Bn XI1373_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1373_MP4 (XI1373_p1 XI1373_An b18_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1373_MP2 (VDD dd15_b3_3 XI1373_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1373_MP3 (XI1373_p1 qu14_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1373_MP0 (VDD dd15_b3_3 XI1373_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I216_MP1 (VDD I1390_G12_0n XI1390_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I216_MP5 (p18_13 XI1390_I216_Bn XI1390_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I216_MP4 (XI1390_I216_p1 XI1390_I216_An p18_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I216_MP2 (VDD I1390_pn13 XI1390_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I216_MP3 (XI1390_I216_p1 I1390_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I216_MP0 (VDD I1390_pn13 XI1390_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1418_MP1 (VDD qu13_b3_2 XI1418_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1418_MP5 (b19_14 XI1418_Bn XI1418_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1418_MP4 (XI1418_p1 XI1418_An b19_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1418_MP2 (VDD dd14_b3_3 XI1418_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1418_MP3 (XI1418_p1 qu13_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1418_MP0 (VDD dd14_b3_3 XI1418_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I216_MP1 (VDD I1436_G12_0n XI1436_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I216_MP5 (p19_13 XI1436_I216_Bn XI1436_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I216_MP4 (XI1436_I216_p1 XI1436_I216_An p19_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I216_MP2 (VDD I1436_pn13 XI1436_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I216_MP3 (XI1436_I216_p1 I1436_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I216_MP0 (VDD I1436_pn13 XI1436_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1512_MP1 (VDD qu11_b3_2 XI1512_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1512_MP5 (b21_16 XI1512_Bn XI1512_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1512_MP4 (XI1512_p1 XI1512_An b21_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1512_MP2 (VDD dd16_b3_3 XI1512_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1512_MP3 (XI1512_p1 qu11_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1512_MP0 (VDD dd16_b3_3 XI1512_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1513_MP1 (VDD qu11_b3_2 XI1513_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1513_MP5 (b21_17 XI1513_Bn XI1513_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1513_MP4 (XI1513_p1 XI1513_An b21_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1513_MP2 (VDD dd17_b3_3 XI1513_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1513_MP3 (XI1513_p1 qu11_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1513_MP0 (VDD dd17_b3_3 XI1513_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1464_MP1 (VDD qu12_b3_2 XI1464_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1464_MP5 (b20_14 XI1464_Bn XI1464_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1464_MP4 (XI1464_p1 XI1464_An b20_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1464_MP2 (VDD dd14_b3_3 XI1464_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1464_MP3 (XI1464_p1 qu12_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1464_MP0 (VDD dd14_b3_3 XI1464_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I216_MP1 (VDD I1482_G12_0n XI1482_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I216_MP5 (p20_13 XI1482_I216_Bn XI1482_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I216_MP4 (XI1482_I216_p1 XI1482_I216_An p20_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I216_MP2 (VDD I1482_pn13 XI1482_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I216_MP3 (XI1482_I216_p1 I1482_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I216_MP0 (VDD I1482_pn13 XI1482_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I219_MP1 (VDD I1528_G15_0n XI1528_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1528_I219_MP5 (p21_16 XI1528_I219_Bn XI1528_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1528_I219_MP4 (XI1528_I219_p1 XI1528_I219_An p21_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I219_MP2 (VDD I1528_pn16 XI1528_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1528_I219_MP3 (XI1528_I219_p1 I1528_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1528_I219_MP0 (VDD I1528_pn16 XI1528_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I212_MP1 (VDD I1160_G8_0n XI1160_I212_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I212_MP5 (p13_9 XI1160_I212_Bn XI1160_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I212_MP4 (XI1160_I212_p1 XI1160_I212_An p13_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I212_MP2 (VDD I1160_pn9 XI1160_I212_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I212_MP3 (XI1160_I212_p1 I1160_G8_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I212_MP0 (VDD I1160_pn9 XI1160_I212_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1187_MP1 (VDD qu18_b3_2 XI1187_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1187_MP5 (b14_13 XI1187_Bn XI1187_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1187_MP4 (XI1187_p1 XI1187_An b14_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1187_MP2 (VDD dd13_b3_2 XI1187_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1187_MP3 (XI1187_p1 qu18_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1187_MP0 (VDD dd13_b3_2 XI1187_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I214_MP1 (VDD I1206_G10_0n XI1206_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I214_MP5 (p14_11 XI1206_I214_Bn XI1206_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I214_MP4 (XI1206_I214_p1 XI1206_I214_An p14_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I214_MP2 (VDD I1206_pn11 XI1206_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I214_MP3 (XI1206_I214_p1 I1206_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I214_MP0 (VDD I1206_pn11 XI1206_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1234_MP1 (VDD qu17_b3_2 XI1234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1234_MP5 (b15_14 XI1234_Bn XI1234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1234_MP4 (XI1234_p1 XI1234_An b15_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1234_MP2 (VDD dd14_b3_2 XI1234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1234_MP3 (XI1234_p1 qu17_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1234_MP0 (VDD dd14_b3_2 XI1234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I216_MP1 (VDD I1252_G12_0n XI1252_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I216_MP5 (p15_13 XI1252_I216_Bn XI1252_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I216_MP4 (XI1252_I216_p1 XI1252_I216_An p15_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I216_MP2 (VDD I1252_pn13 XI1252_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I216_MP3 (XI1252_I216_p1 I1252_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I216_MP0 (VDD I1252_pn13 XI1252_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1280_MP1 (VDD qu16_b3_2 XI1280_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1280_MP5 (b16_14 XI1280_Bn XI1280_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1280_MP4 (XI1280_p1 XI1280_An b16_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1280_MP2 (VDD dd14_b3_2 XI1280_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1280_MP3 (XI1280_p1 qu16_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1280_MP0 (VDD dd14_b3_2 XI1280_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1281_MP1 (VDD qu16_b3_2 XI1281_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1281_MP5 (b16_15 XI1281_Bn XI1281_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1281_MP4 (XI1281_p1 XI1281_An b16_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1281_MP2 (VDD dd15_b3_2 XI1281_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1281_MP3 (XI1281_p1 qu16_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1281_MP0 (VDD dd15_b3_2 XI1281_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I216_MP1 (VDD I1298_G12_0n XI1298_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I216_MP5 (p16_13 XI1298_I216_Bn XI1298_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I216_MP4 (XI1298_I216_p1 XI1298_I216_An p16_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I216_MP2 (VDD I1298_pn13 XI1298_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I216_MP3 (XI1298_I216_p1 I1298_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I216_MP0 (VDD I1298_pn13 XI1298_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I217_MP1 (VDD I1298_G13_0n XI1298_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I217_MP5 (p16_14 XI1298_I217_Bn XI1298_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I217_MP4 (XI1298_I217_p1 XI1298_I217_An p16_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I217_MP2 (VDD I1298_pn14 XI1298_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I217_MP3 (XI1298_I217_p1 I1298_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I217_MP0 (VDD I1298_pn14 XI1298_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1327_MP1 (VDD qu15_b3_2 XI1327_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1327_MP5 (b17_15 XI1327_Bn XI1327_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1327_MP4 (XI1327_p1 XI1327_An b17_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1327_MP2 (VDD dd15_b3_3 XI1327_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1327_MP3 (XI1327_p1 qu15_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1327_MP0 (VDD dd15_b3_3 XI1327_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I217_MP1 (VDD I1344_G13_0n XI1344_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I217_MP5 (p17_14 XI1344_I217_Bn XI1344_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I217_MP4 (XI1344_I217_p1 XI1344_I217_An p17_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I217_MP2 (VDD I1344_pn14 XI1344_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I217_MP3 (XI1344_I217_p1 I1344_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I217_MP0 (VDD I1344_pn14 XI1344_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1328_MP1 (VDD qu15_b3_2 XI1328_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1328_MP5 (b17_16 XI1328_Bn XI1328_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1328_MP4 (XI1328_p1 XI1328_An b17_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1328_MP2 (VDD dd16_b3_3 XI1328_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1328_MP3 (XI1328_p1 qu15_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1328_MP0 (VDD dd16_b3_3 XI1328_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1374_MP1 (VDD qu14_b3_2 XI1374_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1374_MP5 (b18_16 XI1374_Bn XI1374_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1374_MP4 (XI1374_p1 XI1374_An b18_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1374_MP2 (VDD dd16_b3_3 XI1374_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1374_MP3 (XI1374_p1 qu14_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1374_MP0 (VDD dd16_b3_3 XI1374_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I217_MP1 (VDD I1390_G13_0n XI1390_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I217_MP5 (p18_14 XI1390_I217_Bn XI1390_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I217_MP4 (XI1390_I217_p1 XI1390_I217_An p18_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I217_MP2 (VDD I1390_pn14 XI1390_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I217_MP3 (XI1390_I217_p1 I1390_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I217_MP0 (VDD I1390_pn14 XI1390_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1419_MP1 (VDD qu13_b3_2 XI1419_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1419_MP5 (b19_15 XI1419_Bn XI1419_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1419_MP4 (XI1419_p1 XI1419_An b19_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1419_MP2 (VDD dd15_b3_3 XI1419_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1419_MP3 (XI1419_p1 qu13_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1419_MP0 (VDD dd15_b3_3 XI1419_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1420_MP1 (VDD qu13_b3_2 XI1420_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1420_MP5 (b19_16 XI1420_Bn XI1420_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1420_MP4 (XI1420_p1 XI1420_An b19_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1420_MP2 (VDD dd16_b3_3 XI1420_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1420_MP3 (XI1420_p1 qu13_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1420_MP0 (VDD dd16_b3_3 XI1420_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I217_MP1 (VDD I1436_G13_0n XI1436_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I217_MP5 (p19_14 XI1436_I217_Bn XI1436_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I217_MP4 (XI1436_I217_p1 XI1436_I217_An p19_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I217_MP2 (VDD I1436_pn14 XI1436_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I217_MP3 (XI1436_I217_p1 I1436_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I217_MP0 (VDD I1436_pn14 XI1436_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1466_MP1 (VDD qu12_b3_2 XI1466_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1466_MP5 (b20_16 XI1466_Bn XI1466_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1466_MP4 (XI1466_p1 XI1466_An b20_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1466_MP2 (VDD dd16_b3_3 XI1466_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1466_MP3 (XI1466_p1 qu12_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1466_MP0 (VDD dd16_b3_3 XI1466_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1465_MP1 (VDD qu12_b3_2 XI1465_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1465_MP5 (b20_15 XI1465_Bn XI1465_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1465_MP4 (XI1465_p1 XI1465_An b20_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1465_MP2 (VDD dd15_b3_3 XI1465_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1465_MP3 (XI1465_p1 qu12_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1465_MP0 (VDD dd15_b3_3 XI1465_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I217_MP1 (VDD I1482_G13_0n XI1482_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I217_MP5 (p20_14 XI1482_I217_Bn XI1482_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I217_MP4 (XI1482_I217_p1 XI1482_I217_An p20_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I217_MP2 (VDD I1482_pn14 XI1482_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I217_MP3 (XI1482_I217_p1 I1482_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I217_MP0 (VDD I1482_pn14 XI1482_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I218_MP1 (VDD I1482_G14_0n XI1482_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I218_MP5 (p20_15 XI1482_I218_Bn XI1482_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I218_MP4 (XI1482_I218_p1 XI1482_I218_An p20_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I218_MP2 (VDD I1482_pn15 XI1482_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I218_MP3 (XI1482_I218_p1 I1482_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I218_MP0 (VDD I1482_pn15 XI1482_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1152_MP1 (VDD qu19_b3_4 XI1152_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1152_MP5 (b13_24 XI1152_Bn XI1152_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1152_MP4 (XI1152_p1 XI1152_An b13_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1152_MP2 (VDD dd24_b3_2 XI1152_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1152_MP3 (XI1152_p1 qu19_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1152_MP0 (VDD dd24_b3_2 XI1152_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I214_MP1 (VDD I1160_G10_0n XI1160_I214_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I214_MP5 (p13_11 XI1160_I214_Bn XI1160_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I214_MP4 (XI1160_I214_p1 XI1160_I214_An p13_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I214_MP2 (VDD I1160_pn11 XI1160_I214_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I214_MP3 (XI1160_I214_p1 I1160_G10_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I214_MP0 (VDD I1160_pn11 XI1160_I214_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1190_MP1 (VDD qu18_b3_2 XI1190_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1190_MP5 (b14_16 XI1190_Bn XI1190_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1190_MP4 (XI1190_p1 XI1190_An b14_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1190_MP2 (VDD dd16_b3_2 XI1190_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1190_MP3 (XI1190_p1 qu18_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1190_MP0 (VDD dd16_b3_2 XI1190_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1188_MP1 (VDD qu18_b3_2 XI1188_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1188_MP5 (b14_14 XI1188_Bn XI1188_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1188_MP4 (XI1188_p1 XI1188_An b14_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1188_MP2 (VDD dd14_b3_2 XI1188_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1188_MP3 (XI1188_p1 qu18_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1188_MP0 (VDD dd14_b3_2 XI1188_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1189_MP1 (VDD qu18_b3_2 XI1189_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1189_MP5 (b14_15 XI1189_Bn XI1189_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1189_MP4 (XI1189_p1 XI1189_An b14_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1189_MP2 (VDD dd15_b3_2 XI1189_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1189_MP3 (XI1189_p1 qu18_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1189_MP0 (VDD dd15_b3_2 XI1189_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1186_MP1 (VDD qu18_b3_2 XI1186_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1186_MP5 (b14_12 XI1186_Bn XI1186_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1186_MP4 (XI1186_p1 XI1186_An b14_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1186_MP2 (VDD dd12_b3_2 XI1186_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1186_MP3 (XI1186_p1 qu18_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1186_MP0 (VDD dd12_b3_2 XI1186_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I215_MP1 (VDD I1206_G11_0n XI1206_I215_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I215_MP5 (p14_12 XI1206_I215_Bn XI1206_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I215_MP4 (XI1206_I215_p1 XI1206_I215_An p14_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I215_MP2 (VDD I1206_pn12 XI1206_I215_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I215_MP3 (XI1206_I215_p1 I1206_G11_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I215_MP0 (VDD I1206_pn12 XI1206_I215_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I213_MP1 (VDD I1206_G9_0n XI1206_I213_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I213_MP5 (p14_10 XI1206_I213_Bn XI1206_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I213_MP4 (XI1206_I213_p1 XI1206_I213_An p14_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I213_MP2 (VDD I1206_pn10 XI1206_I213_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I213_MP3 (XI1206_I213_p1 I1206_G9_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I213_MP0 (VDD I1206_pn10 XI1206_I213_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I216_MP1 (VDD I1206_G12_0n XI1206_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I216_MP5 (p14_13 XI1206_I216_Bn XI1206_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I216_MP4 (XI1206_I216_p1 XI1206_I216_An p14_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I216_MP2 (VDD I1206_pn13 XI1206_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I216_MP3 (XI1206_I216_p1 I1206_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I216_MP0 (VDD I1206_pn13 XI1206_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1236_MP1 (VDD qu17_b3_2 XI1236_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1236_MP5 (b15_16 XI1236_Bn XI1236_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1236_MP4 (XI1236_p1 XI1236_An b15_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1236_MP2 (VDD dd16_b3_2 XI1236_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1236_MP3 (XI1236_p1 qu17_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1236_MP0 (VDD dd16_b3_2 XI1236_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1235_MP1 (VDD qu17_b3_2 XI1235_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1235_MP5 (b15_15 XI1235_Bn XI1235_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1235_MP4 (XI1235_p1 XI1235_An b15_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1235_MP2 (VDD dd15_b3_2 XI1235_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1235_MP3 (XI1235_p1 qu17_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1235_MP0 (VDD dd15_b3_2 XI1235_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I218_MP1 (VDD I1252_G14_0n XI1252_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I218_MP5 (p15_15 XI1252_I218_Bn XI1252_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I218_MP4 (XI1252_I218_p1 XI1252_I218_An p15_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I218_MP2 (VDD I1252_pn15 XI1252_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I218_MP3 (XI1252_I218_p1 I1252_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I218_MP0 (VDD I1252_pn15 XI1252_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I217_MP1 (VDD I1252_G13_0n XI1252_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I217_MP5 (p15_14 XI1252_I217_Bn XI1252_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I217_MP4 (XI1252_I217_p1 XI1252_I217_An p15_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I217_MP2 (VDD I1252_pn14 XI1252_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I217_MP3 (XI1252_I217_p1 I1252_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I217_MP0 (VDD I1252_pn14 XI1252_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1283_MP1 (VDD qu16_b3_2 XI1283_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1283_MP5 (b16_17 XI1283_Bn XI1283_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1283_MP4 (XI1283_p1 XI1283_An b16_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1283_MP2 (VDD dd17_b3_2 XI1283_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1283_MP3 (XI1283_p1 qu16_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1283_MP0 (VDD dd17_b3_2 XI1283_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1282_MP1 (VDD qu16_b3_2 XI1282_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1282_MP5 (b16_16 XI1282_Bn XI1282_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1282_MP4 (XI1282_p1 XI1282_An b16_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1282_MP2 (VDD dd16_b3_2 XI1282_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1282_MP3 (XI1282_p1 qu16_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1282_MP0 (VDD dd16_b3_2 XI1282_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I218_MP1 (VDD I1298_G14_0n XI1298_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I218_MP5 (p16_15 XI1298_I218_Bn XI1298_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I218_MP4 (XI1298_I218_p1 XI1298_I218_An p16_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I218_MP2 (VDD I1298_pn15 XI1298_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I218_MP3 (XI1298_I218_p1 I1298_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I218_MP0 (VDD I1298_pn15 XI1298_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I219_MP1 (VDD I1298_G15_0n XI1298_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1298_I219_MP5 (p16_16 XI1298_I219_Bn XI1298_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1298_I219_MP4 (XI1298_I219_p1 XI1298_I219_An p16_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I219_MP2 (VDD I1298_pn16 XI1298_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1298_I219_MP3 (XI1298_I219_p1 I1298_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1298_I219_MP0 (VDD I1298_pn16 XI1298_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I218_MP1 (VDD I1344_G14_0n XI1344_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I218_MP5 (p17_15 XI1344_I218_Bn XI1344_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I218_MP4 (XI1344_I218_p1 XI1344_I218_An p17_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I218_MP2 (VDD I1344_pn15 XI1344_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I218_MP3 (XI1344_I218_p1 I1344_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I218_MP0 (VDD I1344_pn15 XI1344_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1329_MP1 (VDD qu15_b3_2 XI1329_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1329_MP5 (b17_17 XI1329_Bn XI1329_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1329_MP4 (XI1329_p1 XI1329_An b17_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1329_MP2 (VDD dd17_b3_3 XI1329_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1329_MP3 (XI1329_p1 qu15_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1329_MP0 (VDD dd17_b3_3 XI1329_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I219_MP1 (VDD I1344_G15_0n XI1344_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1344_I219_MP5 (p17_16 XI1344_I219_Bn XI1344_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1344_I219_MP4 (XI1344_I219_p1 XI1344_I219_An p17_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I219_MP2 (VDD I1344_pn16 XI1344_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1344_I219_MP3 (XI1344_I219_p1 I1344_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1344_I219_MP0 (VDD I1344_pn16 XI1344_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1375_MP1 (VDD qu14_b3_2 XI1375_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1375_MP5 (b18_17 XI1375_Bn XI1375_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1375_MP4 (XI1375_p1 XI1375_An b18_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1375_MP2 (VDD dd17_b3_3 XI1375_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1375_MP3 (XI1375_p1 qu14_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1375_MP0 (VDD dd17_b3_3 XI1375_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I218_MP1 (VDD I1390_G14_0n XI1390_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I218_MP5 (p18_15 XI1390_I218_Bn XI1390_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I218_MP4 (XI1390_I218_p1 XI1390_I218_An p18_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I218_MP2 (VDD I1390_pn15 XI1390_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I218_MP3 (XI1390_I218_p1 I1390_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I218_MP0 (VDD I1390_pn15 XI1390_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1421_MP1 (VDD qu13_b3_2 XI1421_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1421_MP5 (b19_17 XI1421_Bn XI1421_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1421_MP4 (XI1421_p1 XI1421_An b19_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1421_MP2 (VDD dd17_b3_3 XI1421_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1421_MP3 (XI1421_p1 qu13_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1421_MP0 (VDD dd17_b3_3 XI1421_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I218_MP1 (VDD I1436_G14_0n XI1436_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I218_MP5 (p19_15 XI1436_I218_Bn XI1436_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I218_MP4 (XI1436_I218_p1 XI1436_I218_An p19_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I218_MP2 (VDD I1436_pn15 XI1436_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I218_MP3 (XI1436_I218_p1 I1436_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I218_MP0 (VDD I1436_pn15 XI1436_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1467_MP1 (VDD qu12_b3_2 XI1467_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1467_MP5 (b20_17 XI1467_Bn XI1467_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1467_MP4 (XI1467_p1 XI1467_An b20_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1467_MP2 (VDD dd17_b3_3 XI1467_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1467_MP3 (XI1467_p1 qu12_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1467_MP0 (VDD dd17_b3_3 XI1467_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I219_MP1 (VDD I1482_G15_0n XI1482_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1482_I219_MP5 (p20_16 XI1482_I219_Bn XI1482_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1482_I219_MP4 (XI1482_I219_p1 XI1482_I219_An p20_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I219_MP2 (VDD I1482_pn16 XI1482_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1482_I219_MP3 (XI1482_I219_p1 I1482_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1482_I219_MP0 (VDD I1482_pn16 XI1482_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1514_MP1 (VDD qu11_b3_3 XI1514_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1514_MP5 (b21_18 XI1514_Bn XI1514_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1514_MP4 (XI1514_p1 XI1514_An b21_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1514_MP2 (VDD dd18_b3_3 XI1514_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1514_MP3 (XI1514_p1 qu11_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1514_MP0 (VDD dd18_b3_3 XI1514_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1515_MP1 (VDD qu11_b3_3 XI1515_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1515_MP5 (b21_19 XI1515_Bn XI1515_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1515_MP4 (XI1515_p1 XI1515_An b21_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1515_MP2 (VDD dd19_b3_3 XI1515_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1515_MP3 (XI1515_p1 qu11_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1515_MP0 (VDD dd19_b3_3 XI1515_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1153_MP1 (VDD qu19_b3_4 XI1153_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1153_MP5 (b13_25 XI1153_Bn XI1153_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1153_MP4 (XI1153_p1 XI1153_An b13_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1153_MP2 (VDD dd25_b3_2 XI1153_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1153_MP3 (XI1153_p1 qu19_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1153_MP0 (VDD dd25_b3_2 XI1153_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I216_MP1 (VDD I1160_G12_0n XI1160_I216_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I216_MP5 (p13_13 XI1160_I216_Bn XI1160_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I216_MP4 (XI1160_I216_p1 XI1160_I216_An p13_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I216_MP2 (VDD I1160_pn13 XI1160_I216_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I216_MP3 (XI1160_I216_p1 I1160_G12_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I216_MP0 (VDD I1160_pn13 XI1160_I216_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1191_MP1 (VDD qu18_b3_2 XI1191_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1191_MP5 (b14_17 XI1191_Bn XI1191_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1191_MP4 (XI1191_p1 XI1191_An b14_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1191_MP2 (VDD dd17_b3_2 XI1191_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1191_MP3 (XI1191_p1 qu18_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1191_MP0 (VDD dd17_b3_2 XI1191_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I217_MP1 (VDD I1206_G13_0n XI1206_I217_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I217_MP5 (p14_14 XI1206_I217_Bn XI1206_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I217_MP4 (XI1206_I217_p1 XI1206_I217_An p14_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I217_MP2 (VDD I1206_pn14 XI1206_I217_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I217_MP3 (XI1206_I217_p1 I1206_G13_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I217_MP0 (VDD I1206_pn14 XI1206_I217_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1237_MP1 (VDD qu17_b3_2 XI1237_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1237_MP5 (b15_17 XI1237_Bn XI1237_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1237_MP4 (XI1237_p1 XI1237_An b15_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1237_MP2 (VDD dd17_b3_2 XI1237_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1237_MP3 (XI1237_p1 qu17_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1237_MP0 (VDD dd17_b3_2 XI1237_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I219_MP1 (VDD I1252_G15_0n XI1252_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1252_I219_MP5 (p15_16 XI1252_I219_Bn XI1252_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1252_I219_MP4 (XI1252_I219_p1 XI1252_I219_An p15_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I219_MP2 (VDD I1252_pn16 XI1252_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1252_I219_MP3 (XI1252_I219_p1 I1252_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1252_I219_MP0 (VDD I1252_pn16 XI1252_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1330_MP1 (VDD qu15_b3_3 XI1330_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1330_MP5 (b17_18 XI1330_Bn XI1330_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1330_MP4 (XI1330_p1 XI1330_An b17_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1330_MP2 (VDD dd18_b3_3 XI1330_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1330_MP3 (XI1330_p1 qu15_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1330_MP0 (VDD dd18_b3_3 XI1330_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1376_MP1 (VDD qu14_b3_3 XI1376_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1376_MP5 (b18_18 XI1376_Bn XI1376_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1376_MP4 (XI1376_p1 XI1376_An b18_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1376_MP2 (VDD dd18_b3_3 XI1376_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1376_MP3 (XI1376_p1 qu14_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1376_MP0 (VDD dd18_b3_3 XI1376_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I219_MP1 (VDD I1390_G15_0n XI1390_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1390_I219_MP5 (p18_16 XI1390_I219_Bn XI1390_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1390_I219_MP4 (XI1390_I219_p1 XI1390_I219_An p18_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I219_MP2 (VDD I1390_pn16 XI1390_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1390_I219_MP3 (XI1390_I219_p1 I1390_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1390_I219_MP0 (VDD I1390_pn16 XI1390_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1422_MP1 (VDD qu13_b3_3 XI1422_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1422_MP5 (b19_18 XI1422_Bn XI1422_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1422_MP4 (XI1422_p1 XI1422_An b19_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1422_MP2 (VDD dd18_b3_3 XI1422_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1422_MP3 (XI1422_p1 qu13_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1422_MP0 (VDD dd18_b3_3 XI1422_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I219_MP1 (VDD I1436_G15_0n XI1436_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1436_I219_MP5 (p19_16 XI1436_I219_Bn XI1436_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1436_I219_MP4 (XI1436_I219_p1 XI1436_I219_An p19_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I219_MP2 (VDD I1436_pn16 XI1436_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1436_I219_MP3 (XI1436_I219_p1 I1436_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1436_I219_MP0 (VDD I1436_pn16 XI1436_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1468_MP1 (VDD qu12_b3_3 XI1468_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1468_MP5 (b20_18 XI1468_Bn XI1468_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1468_MP4 (XI1468_p1 XI1468_An b20_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1468_MP2 (VDD dd18_b3_3 XI1468_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1468_MP3 (XI1468_p1 qu12_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1468_MP0 (VDD dd18_b3_3 XI1468_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1516_MP1 (VDD qu11_b3_3 XI1516_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1516_MP5 (b21_20 XI1516_Bn XI1516_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1516_MP4 (XI1516_p1 XI1516_An b21_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1516_MP2 (VDD dd20_b3_3 XI1516_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1516_MP3 (XI1516_p1 qu11_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1516_MP0 (VDD dd20_b3_3 XI1516_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1530_MP1 (VDD c21_o XI1530_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1530_MP5 (p21_32 XI1530_Bn XI1530_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1530_MP4 (XI1530_p1 XI1530_An p21_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1530_MP2 (VDD h21 XI1530_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1530_MP3 (XI1530_p1 c21_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1530_MP0 (VDD h21 XI1530_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I218_MP1 (VDD I1160_G14_0n XI1160_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1160_I218_MP5 (p13_15 XI1160_I218_Bn XI1160_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1160_I218_MP4 (XI1160_I218_p1 XI1160_I218_An p13_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I218_MP2 (VDD I1160_pn15 XI1160_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1160_I218_MP3 (XI1160_I218_p1 I1160_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1160_I218_MP0 (VDD I1160_pn15 XI1160_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1192_MP1 (VDD qu18_b3_3 XI1192_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1192_MP5 (b14_18 XI1192_Bn XI1192_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1192_MP4 (XI1192_p1 XI1192_An b14_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1192_MP2 (VDD dd18_b3_2 XI1192_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1192_MP3 (XI1192_p1 qu18_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1192_MP0 (VDD dd18_b3_2 XI1192_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I218_MP1 (VDD I1206_G14_0n XI1206_I218_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I218_MP5 (p14_15 XI1206_I218_Bn XI1206_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I218_MP4 (XI1206_I218_p1 XI1206_I218_An p14_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I218_MP2 (VDD I1206_pn15 XI1206_I218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I218_MP3 (XI1206_I218_p1 I1206_G14_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I218_MP0 (VDD I1206_pn15 XI1206_I218_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1238_MP1 (VDD qu17_b3_3 XI1238_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1238_MP5 (b15_18 XI1238_Bn XI1238_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1238_MP4 (XI1238_p1 XI1238_An b15_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1238_MP2 (VDD dd18_b3_2 XI1238_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1238_MP3 (XI1238_p1 qu17_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1238_MP0 (VDD dd18_b3_2 XI1238_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1285_MP1 (VDD qu16_b3_3 XI1285_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1285_MP5 (b16_19 XI1285_Bn XI1285_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1285_MP4 (XI1285_p1 XI1285_An b16_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1285_MP2 (VDD dd19_b3_2 XI1285_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1285_MP3 (XI1285_p1 qu16_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1285_MP0 (VDD dd19_b3_2 XI1285_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1284_MP1 (VDD qu16_b3_3 XI1284_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1284_MP5 (b16_18 XI1284_Bn XI1284_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1284_MP4 (XI1284_p1 XI1284_An b16_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1284_MP2 (VDD dd18_b3_2 XI1284_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1284_MP3 (XI1284_p1 qu16_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1284_MP0 (VDD dd18_b3_2 XI1284_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1331_MP1 (VDD qu15_b3_3 XI1331_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1331_MP5 (b17_19 XI1331_Bn XI1331_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1331_MP4 (XI1331_p1 XI1331_An b17_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1331_MP2 (VDD dd19_b3_3 XI1331_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1331_MP3 (XI1331_p1 qu15_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1331_MP0 (VDD dd19_b3_3 XI1331_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1332_MP1 (VDD qu15_b3_3 XI1332_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1332_MP5 (b17_20 XI1332_Bn XI1332_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1332_MP4 (XI1332_p1 XI1332_An b17_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1332_MP2 (VDD dd20_b3_3 XI1332_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1332_MP3 (XI1332_p1 qu15_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1332_MP0 (VDD dd20_b3_3 XI1332_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1378_MP1 (VDD qu14_b3_3 XI1378_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1378_MP5 (b18_20 XI1378_Bn XI1378_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1378_MP4 (XI1378_p1 XI1378_An b18_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1378_MP2 (VDD dd20_b3_3 XI1378_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1378_MP3 (XI1378_p1 qu14_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1378_MP0 (VDD dd20_b3_3 XI1378_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1377_MP1 (VDD qu14_b3_3 XI1377_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1377_MP5 (b18_19 XI1377_Bn XI1377_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1377_MP4 (XI1377_p1 XI1377_An b18_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1377_MP2 (VDD dd19_b3_3 XI1377_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1377_MP3 (XI1377_p1 qu14_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1377_MP0 (VDD dd19_b3_3 XI1377_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1423_MP1 (VDD qu13_b3_3 XI1423_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1423_MP5 (b19_19 XI1423_Bn XI1423_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1423_MP4 (XI1423_p1 XI1423_An b19_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1423_MP2 (VDD dd19_b3_3 XI1423_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1423_MP3 (XI1423_p1 qu13_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1423_MP0 (VDD dd19_b3_3 XI1423_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1424_MP1 (VDD qu13_b3_3 XI1424_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1424_MP5 (b19_20 XI1424_Bn XI1424_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1424_MP4 (XI1424_p1 XI1424_An b19_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1424_MP2 (VDD dd20_b3_3 XI1424_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1424_MP3 (XI1424_p1 qu13_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1424_MP0 (VDD dd20_b3_3 XI1424_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1469_MP1 (VDD qu12_b3_3 XI1469_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1469_MP5 (b20_19 XI1469_Bn XI1469_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1469_MP4 (XI1469_p1 XI1469_An b20_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1469_MP2 (VDD dd19_b3_3 XI1469_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1469_MP3 (XI1469_p1 qu12_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1469_MP0 (VDD dd19_b3_3 XI1469_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1470_MP1 (VDD qu12_b3_3 XI1470_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1470_MP5 (b20_20 XI1470_Bn XI1470_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1470_MP4 (XI1470_p1 XI1470_An b20_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1470_MP2 (VDD dd20_b3_3 XI1470_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1470_MP3 (XI1470_p1 qu12_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1470_MP0 (VDD dd20_b3_3 XI1470_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1517_MP1 (VDD qu11_b3_3 XI1517_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1517_MP5 (b21_21 XI1517_Bn XI1517_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1517_MP4 (XI1517_p1 XI1517_An b21_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1517_MP2 (VDD dd21_b3_3 XI1517_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1517_MP3 (XI1517_p1 qu11_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1517_MP0 (VDD dd21_b3_3 XI1517_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1518_MP1 (VDD qu11_b3_3 XI1518_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1518_MP5 (b21_22 XI1518_Bn XI1518_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1518_MP4 (XI1518_p1 XI1518_An b21_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1518_MP2 (VDD dd22_b3_3 XI1518_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1518_MP3 (XI1518_p1 qu11_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1518_MP0 (VDD dd22_b3_3 XI1518_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1157_MP1 (VDD qu19_b3_4 XI1157_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1157_MP5 (b13_29 XI1157_Bn XI1157_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1157_MP4 (XI1157_p1 XI1157_An b13_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1157_MP2 (VDD dd29_b3_2 XI1157_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1157_MP3 (XI1157_p1 qu19_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1157_MP0 (VDD dd29_b3_2 XI1157_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1156_MP1 (VDD qu19_b3_4 XI1156_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1156_MP5 (b13_28 XI1156_Bn XI1156_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1156_MP4 (XI1156_p1 XI1156_An b13_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1156_MP2 (VDD dd28_b3_2 XI1156_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1156_MP3 (XI1156_p1 qu19_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1156_MP0 (VDD dd28_b3_2 XI1156_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1154_MP1 (VDD qu19_b3_4 XI1154_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1154_MP5 (b13_26 XI1154_Bn XI1154_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1154_MP4 (XI1154_p1 XI1154_An b13_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1154_MP2 (VDD dd26_b3_2 XI1154_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1154_MP3 (XI1154_p1 qu19_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1154_MP0 (VDD dd26_b3_2 XI1154_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1195_MP1 (VDD qu18_b3_3 XI1195_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1195_MP5 (b14_21 XI1195_Bn XI1195_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1195_MP4 (XI1195_p1 XI1195_An b14_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1195_MP2 (VDD dd21_b3_2 XI1195_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1195_MP3 (XI1195_p1 qu18_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1195_MP0 (VDD dd21_b3_2 XI1195_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1193_MP1 (VDD qu18_b3_3 XI1193_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1193_MP5 (b14_19 XI1193_Bn XI1193_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1193_MP4 (XI1193_p1 XI1193_An b14_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1193_MP2 (VDD dd19_b3_2 XI1193_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1193_MP3 (XI1193_p1 qu18_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1193_MP0 (VDD dd19_b3_2 XI1193_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1194_MP1 (VDD qu18_b3_3 XI1194_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1194_MP5 (b14_20 XI1194_Bn XI1194_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1194_MP4 (XI1194_p1 XI1194_An b14_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1194_MP2 (VDD dd20_b3_2 XI1194_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1194_MP3 (XI1194_p1 qu18_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1194_MP0 (VDD dd20_b3_2 XI1194_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I219_MP1 (VDD I1206_G15_0n XI1206_I219_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1206_I219_MP5 (p14_16 XI1206_I219_Bn XI1206_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1206_I219_MP4 (XI1206_I219_p1 XI1206_I219_An p14_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I219_MP2 (VDD I1206_pn16 XI1206_I219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1206_I219_MP3 (XI1206_I219_p1 I1206_G15_0n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1206_I219_MP0 (VDD I1206_pn16 XI1206_I219_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1239_MP1 (VDD qu17_b3_3 XI1239_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1239_MP5 (b15_19 XI1239_Bn XI1239_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1239_MP4 (XI1239_p1 XI1239_An b15_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1239_MP2 (VDD dd19_b3_2 XI1239_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1239_MP3 (XI1239_p1 qu17_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1239_MP0 (VDD dd19_b3_2 XI1239_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1241_MP1 (VDD qu17_b3_3 XI1241_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1241_MP5 (b15_21 XI1241_Bn XI1241_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1241_MP4 (XI1241_p1 XI1241_An b15_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1241_MP2 (VDD dd21_b3_2 XI1241_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1241_MP3 (XI1241_p1 qu17_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1241_MP0 (VDD dd21_b3_2 XI1241_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1240_MP1 (VDD qu17_b3_3 XI1240_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1240_MP5 (b15_20 XI1240_Bn XI1240_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1240_MP4 (XI1240_p1 XI1240_An b15_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1240_MP2 (VDD dd20_b3_2 XI1240_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1240_MP3 (XI1240_p1 qu17_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1240_MP0 (VDD dd20_b3_2 XI1240_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1287_MP1 (VDD qu16_b3_3 XI1287_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1287_MP5 (b16_21 XI1287_Bn XI1287_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1287_MP4 (XI1287_p1 XI1287_An b16_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1287_MP2 (VDD dd21_b3_2 XI1287_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1287_MP3 (XI1287_p1 qu16_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1287_MP0 (VDD dd21_b3_2 XI1287_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1286_MP1 (VDD qu16_b3_3 XI1286_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1286_MP5 (b16_20 XI1286_Bn XI1286_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1286_MP4 (XI1286_p1 XI1286_An b16_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1286_MP2 (VDD dd20_b3_2 XI1286_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1286_MP3 (XI1286_p1 qu16_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1286_MP0 (VDD dd20_b3_2 XI1286_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1333_MP1 (VDD qu15_b3_3 XI1333_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1333_MP5 (b17_21 XI1333_Bn XI1333_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1333_MP4 (XI1333_p1 XI1333_An b17_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1333_MP2 (VDD dd21_b3_3 XI1333_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1333_MP3 (XI1333_p1 qu15_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1333_MP0 (VDD dd21_b3_3 XI1333_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1334_MP1 (VDD qu15_b3_3 XI1334_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1334_MP5 (b17_22 XI1334_Bn XI1334_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1334_MP4 (XI1334_p1 XI1334_An b17_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1334_MP2 (VDD dd22_b3_3 XI1334_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1334_MP3 (XI1334_p1 qu15_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1334_MP0 (VDD dd22_b3_3 XI1334_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1379_MP1 (VDD qu14_b3_3 XI1379_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1379_MP5 (b18_21 XI1379_Bn XI1379_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1379_MP4 (XI1379_p1 XI1379_An b18_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1379_MP2 (VDD dd21_b3_3 XI1379_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1379_MP3 (XI1379_p1 qu14_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1379_MP0 (VDD dd21_b3_3 XI1379_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1380_MP1 (VDD qu14_b3_3 XI1380_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1380_MP5 (b18_22 XI1380_Bn XI1380_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1380_MP4 (XI1380_p1 XI1380_An b18_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1380_MP2 (VDD dd22_b3_3 XI1380_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1380_MP3 (XI1380_p1 qu14_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1380_MP0 (VDD dd22_b3_3 XI1380_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1425_MP1 (VDD qu13_b3_3 XI1425_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1425_MP5 (b19_21 XI1425_Bn XI1425_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1425_MP4 (XI1425_p1 XI1425_An b19_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1425_MP2 (VDD dd21_b3_3 XI1425_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1425_MP3 (XI1425_p1 qu13_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1425_MP0 (VDD dd21_b3_3 XI1425_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1426_MP1 (VDD qu13_b3_3 XI1426_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1426_MP5 (b19_22 XI1426_Bn XI1426_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1426_MP4 (XI1426_p1 XI1426_An b19_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1426_MP2 (VDD dd22_b3_3 XI1426_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1426_MP3 (XI1426_p1 qu13_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1426_MP0 (VDD dd22_b3_3 XI1426_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1472_MP1 (VDD qu12_b3_3 XI1472_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1472_MP5 (b20_22 XI1472_Bn XI1472_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1472_MP4 (XI1472_p1 XI1472_An b20_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1472_MP2 (VDD dd22_b3_3 XI1472_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1472_MP3 (XI1472_p1 qu12_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1472_MP0 (VDD dd22_b3_3 XI1472_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1471_MP1 (VDD qu12_b3_3 XI1471_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1471_MP5 (b20_21 XI1471_Bn XI1471_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1471_MP4 (XI1471_p1 XI1471_An b20_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1471_MP2 (VDD dd21_b3_3 XI1471_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1471_MP3 (XI1471_p1 qu12_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1471_MP0 (VDD dd21_b3_3 XI1471_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1529_MP1 (VDD qu11_b3_5 XI1529_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1529_MP5 (h21 XI1529_Bn XI1529_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1529_MP4 (XI1529_p1 XI1529_An h21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1529_MP2 (VDD p20_31 XI1529_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1529_MP3 (XI1529_p1 qu11_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1529_MP0 (VDD p20_31 XI1529_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1519_MP1 (VDD qu11_b3_3 XI1519_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1519_MP5 (b21_23 XI1519_Bn XI1519_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1519_MP4 (XI1519_p1 XI1519_An b21_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1519_MP2 (VDD dd23_b3_3 XI1519_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1519_MP3 (XI1519_p1 qu11_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1519_MP0 (VDD dd23_b3_3 XI1519_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1155_MP1 (VDD qu19_b3_4 XI1155_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1155_MP5 (b13_27 XI1155_Bn XI1155_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1155_MP4 (XI1155_p1 XI1155_An b13_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1155_MP2 (VDD dd27_b3_2 XI1155_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1155_MP3 (XI1155_p1 qu19_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1155_MP0 (VDD dd27_b3_2 XI1155_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1207_MP1 (VDD qu18_b3_5 XI1207_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1207_MP5 (h14 XI1207_Bn XI1207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1207_MP4 (XI1207_p1 XI1207_An h14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1207_MP2 (VDD p13_31 XI1207_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1207_MP3 (XI1207_p1 qu18_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1207_MP0 (VDD p13_31 XI1207_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1196_MP1 (VDD qu18_b3_3 XI1196_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1196_MP5 (b14_22 XI1196_Bn XI1196_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1196_MP4 (XI1196_p1 XI1196_An b14_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1196_MP2 (VDD dd22_b3_2 XI1196_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1196_MP3 (XI1196_p1 qu18_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1196_MP0 (VDD dd22_b3_2 XI1196_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1208_MP1 (VDD c14_o XI1208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1208_MP5 (p14_32 XI1208_Bn XI1208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1208_MP4 (XI1208_p1 XI1208_An p14_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1208_MP2 (VDD h14 XI1208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1208_MP3 (XI1208_p1 c14_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1208_MP0 (VDD h14 XI1208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1243_MP1 (VDD qu17_b3_3 XI1243_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1243_MP5 (b15_23 XI1243_Bn XI1243_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1243_MP4 (XI1243_p1 XI1243_An b15_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1243_MP2 (VDD dd23_b3_2 XI1243_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1243_MP3 (XI1243_p1 qu17_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1243_MP0 (VDD dd23_b3_2 XI1243_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1242_MP1 (VDD qu17_b3_3 XI1242_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1242_MP5 (b15_22 XI1242_Bn XI1242_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1242_MP4 (XI1242_p1 XI1242_An b15_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1242_MP2 (VDD dd22_b3_2 XI1242_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1242_MP3 (XI1242_p1 qu17_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1242_MP0 (VDD dd22_b3_2 XI1242_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1289_MP1 (VDD qu16_b3_3 XI1289_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1289_MP5 (b16_23 XI1289_Bn XI1289_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1289_MP4 (XI1289_p1 XI1289_An b16_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1289_MP2 (VDD dd23_b3_2 XI1289_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1289_MP3 (XI1289_p1 qu16_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1289_MP0 (VDD dd23_b3_2 XI1289_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1288_MP1 (VDD qu16_b3_3 XI1288_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1288_MP5 (b16_22 XI1288_Bn XI1288_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1288_MP4 (XI1288_p1 XI1288_An b16_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1288_MP2 (VDD dd22_b3_2 XI1288_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1288_MP3 (XI1288_p1 qu16_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1288_MP0 (VDD dd22_b3_2 XI1288_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1335_MP1 (VDD qu15_b3_3 XI1335_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1335_MP5 (b17_23 XI1335_Bn XI1335_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1335_MP4 (XI1335_p1 XI1335_An b17_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1335_MP2 (VDD dd23_b3_3 XI1335_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1335_MP3 (XI1335_p1 qu15_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1335_MP0 (VDD dd23_b3_3 XI1335_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1381_MP1 (VDD qu14_b3_3 XI1381_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1381_MP5 (b18_23 XI1381_Bn XI1381_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1381_MP4 (XI1381_p1 XI1381_An b18_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1381_MP2 (VDD dd23_b3_3 XI1381_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1381_MP3 (XI1381_p1 qu14_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1381_MP0 (VDD dd23_b3_3 XI1381_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1427_MP1 (VDD qu13_b3_3 XI1427_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1427_MP5 (b19_23 XI1427_Bn XI1427_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1427_MP4 (XI1427_p1 XI1427_An b19_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1427_MP2 (VDD dd23_b3_3 XI1427_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1427_MP3 (XI1427_p1 qu13_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1427_MP0 (VDD dd23_b3_3 XI1427_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1473_MP1 (VDD qu12_b3_3 XI1473_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1473_MP5 (b20_23 XI1473_Bn XI1473_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1473_MP4 (XI1473_p1 XI1473_An b20_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1473_MP2 (VDD dd23_b3_3 XI1473_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1473_MP3 (XI1473_p1 qu12_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1473_MP0 (VDD dd23_b3_3 XI1473_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1520_MP1 (VDD qu11_b3_4 XI1520_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1520_MP5 (b21_24 XI1520_Bn XI1520_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1520_MP4 (XI1520_p1 XI1520_An b21_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1520_MP2 (VDD dd24_b3_3 XI1520_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1520_MP3 (XI1520_p1 qu11_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1520_MP0 (VDD dd24_b3_3 XI1520_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1521_MP1 (VDD qu11_b3_4 XI1521_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1521_MP5 (b21_25 XI1521_Bn XI1521_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1521_MP4 (XI1521_p1 XI1521_An b21_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1521_MP2 (VDD dd25_b3_3 XI1521_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1521_MP3 (XI1521_p1 qu11_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1521_MP0 (VDD dd25_b3_3 XI1521_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1522_MP1 (VDD qu11_b3_4 XI1522_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1522_MP5 (b21_26 XI1522_Bn XI1522_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1522_MP4 (XI1522_p1 XI1522_An b21_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1522_MP2 (VDD dd26_b3_3 XI1522_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1522_MP3 (XI1522_p1 qu11_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1522_MP0 (VDD dd26_b3_3 XI1522_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1199_MP1 (VDD qu18_b3_4 XI1199_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1199_MP5 (b14_25 XI1199_Bn XI1199_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1199_MP4 (XI1199_p1 XI1199_An b14_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1199_MP2 (VDD dd25_b3_2 XI1199_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1199_MP3 (XI1199_p1 qu18_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1199_MP0 (VDD dd25_b3_2 XI1199_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1197_MP1 (VDD qu18_b3_3 XI1197_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1197_MP5 (b14_23 XI1197_Bn XI1197_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1197_MP4 (XI1197_p1 XI1197_An b14_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1197_MP2 (VDD dd23_b3_2 XI1197_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1197_MP3 (XI1197_p1 qu18_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1197_MP0 (VDD dd23_b3_2 XI1197_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1198_MP1 (VDD qu18_b3_4 XI1198_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1198_MP5 (b14_24 XI1198_Bn XI1198_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1198_MP4 (XI1198_p1 XI1198_An b14_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1198_MP2 (VDD dd24_b3_2 XI1198_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1198_MP3 (XI1198_p1 qu18_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1198_MP0 (VDD dd24_b3_2 XI1198_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1244_MP1 (VDD qu17_b3_4 XI1244_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1244_MP5 (b15_24 XI1244_Bn XI1244_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1244_MP4 (XI1244_p1 XI1244_An b15_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1244_MP2 (VDD dd24_b3_2 XI1244_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1244_MP3 (XI1244_p1 qu17_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1244_MP0 (VDD dd24_b3_2 XI1244_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1290_MP1 (VDD qu16_b3_4 XI1290_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1290_MP5 (b16_24 XI1290_Bn XI1290_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1290_MP4 (XI1290_p1 XI1290_An b16_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1290_MP2 (VDD dd24_b3_2 XI1290_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1290_MP3 (XI1290_p1 qu16_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1290_MP0 (VDD dd24_b3_2 XI1290_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1336_MP1 (VDD qu15_b3_4 XI1336_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1336_MP5 (b17_24 XI1336_Bn XI1336_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1336_MP4 (XI1336_p1 XI1336_An b17_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1336_MP2 (VDD dd24_b3_3 XI1336_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1336_MP3 (XI1336_p1 qu15_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1336_MP0 (VDD dd24_b3_3 XI1336_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1382_MP1 (VDD qu14_b3_4 XI1382_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1382_MP5 (b18_24 XI1382_Bn XI1382_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1382_MP4 (XI1382_p1 XI1382_An b18_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1382_MP2 (VDD dd24_b3_3 XI1382_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1382_MP3 (XI1382_p1 qu14_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1382_MP0 (VDD dd24_b3_3 XI1382_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1428_MP1 (VDD qu13_b3_4 XI1428_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1428_MP5 (b19_24 XI1428_Bn XI1428_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1428_MP4 (XI1428_p1 XI1428_An b19_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1428_MP2 (VDD dd24_b3_3 XI1428_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1428_MP3 (XI1428_p1 qu13_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1428_MP0 (VDD dd24_b3_3 XI1428_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1523_MP1 (VDD qu11_b3_4 XI1523_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1523_MP5 (b21_27 XI1523_Bn XI1523_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1523_MP4 (XI1523_p1 XI1523_An b21_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1523_MP2 (VDD dd27_b3_3 XI1523_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1523_MP3 (XI1523_p1 qu11_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1523_MP0 (VDD dd27_b3_3 XI1523_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1525_MP1 (VDD qu11_b3_4 XI1525_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1525_MP5 (b21_29 XI1525_Bn XI1525_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1525_MP4 (XI1525_p1 XI1525_An b21_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1525_MP2 (VDD dd29_b3_3 XI1525_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1525_MP3 (XI1525_p1 qu11_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1525_MP0 (VDD dd29_b3_3 XI1525_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1204_MP1 (VDD qu18_b3_5 XI1204_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1204_MP5 (b14_30 XI1204_Bn XI1204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1204_MP4 (XI1204_p1 XI1204_An b14_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1204_MP2 (VDD dd30_b3_2 XI1204_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1204_MP3 (XI1204_p1 qu18_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1204_MP0 (VDD dd30_b3_2 XI1204_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1200_MP1 (VDD qu18_b3_4 XI1200_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1200_MP5 (b14_26 XI1200_Bn XI1200_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1200_MP4 (XI1200_p1 XI1200_An b14_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1200_MP2 (VDD dd26_b3_2 XI1200_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1200_MP3 (XI1200_p1 qu18_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1200_MP0 (VDD dd26_b3_2 XI1200_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1201_MP1 (VDD qu18_b3_4 XI1201_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1201_MP5 (b14_27 XI1201_Bn XI1201_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1201_MP4 (XI1201_p1 XI1201_An b14_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1201_MP2 (VDD dd27_b3_2 XI1201_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1201_MP3 (XI1201_p1 qu18_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1201_MP0 (VDD dd27_b3_2 XI1201_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1246_MP1 (VDD qu17_b3_4 XI1246_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1246_MP5 (b15_26 XI1246_Bn XI1246_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1246_MP4 (XI1246_p1 XI1246_An b15_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1246_MP2 (VDD dd26_b3_2 XI1246_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1246_MP3 (XI1246_p1 qu17_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1246_MP0 (VDD dd26_b3_2 XI1246_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1245_MP1 (VDD qu17_b3_4 XI1245_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1245_MP5 (b15_25 XI1245_Bn XI1245_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1245_MP4 (XI1245_p1 XI1245_An b15_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1245_MP2 (VDD dd25_b3_2 XI1245_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1245_MP3 (XI1245_p1 qu17_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1245_MP0 (VDD dd25_b3_2 XI1245_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1292_MP1 (VDD qu16_b3_4 XI1292_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1292_MP5 (b16_26 XI1292_Bn XI1292_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1292_MP4 (XI1292_p1 XI1292_An b16_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1292_MP2 (VDD dd26_b3_2 XI1292_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1292_MP3 (XI1292_p1 qu16_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1292_MP0 (VDD dd26_b3_2 XI1292_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1293_MP1 (VDD qu16_b3_4 XI1293_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1293_MP5 (b16_27 XI1293_Bn XI1293_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1293_MP4 (XI1293_p1 XI1293_An b16_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1293_MP2 (VDD dd27_b3_2 XI1293_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1293_MP3 (XI1293_p1 qu16_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1293_MP0 (VDD dd27_b3_2 XI1293_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1291_MP1 (VDD qu16_b3_4 XI1291_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1291_MP5 (b16_25 XI1291_Bn XI1291_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1291_MP4 (XI1291_p1 XI1291_An b16_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1291_MP2 (VDD dd25_b3_2 XI1291_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1291_MP3 (XI1291_p1 qu16_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1291_MP0 (VDD dd25_b3_2 XI1291_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1338_MP1 (VDD qu15_b3_4 XI1338_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1338_MP5 (b17_26 XI1338_Bn XI1338_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1338_MP4 (XI1338_p1 XI1338_An b17_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1338_MP2 (VDD dd26_b3_3 XI1338_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1338_MP3 (XI1338_p1 qu15_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1338_MP0 (VDD dd26_b3_3 XI1338_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1337_MP1 (VDD qu15_b3_4 XI1337_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1337_MP5 (b17_25 XI1337_Bn XI1337_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1337_MP4 (XI1337_p1 XI1337_An b17_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1337_MP2 (VDD dd25_b3_3 XI1337_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1337_MP3 (XI1337_p1 qu15_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1337_MP0 (VDD dd25_b3_3 XI1337_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1383_MP1 (VDD qu14_b3_4 XI1383_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1383_MP5 (b18_25 XI1383_Bn XI1383_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1383_MP4 (XI1383_p1 XI1383_An b18_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1383_MP2 (VDD dd25_b3_3 XI1383_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1383_MP3 (XI1383_p1 qu14_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1383_MP0 (VDD dd25_b3_3 XI1383_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1384_MP1 (VDD qu14_b3_4 XI1384_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1384_MP5 (b18_26 XI1384_Bn XI1384_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1384_MP4 (XI1384_p1 XI1384_An b18_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1384_MP2 (VDD dd26_b3_3 XI1384_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1384_MP3 (XI1384_p1 qu14_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1384_MP0 (VDD dd26_b3_3 XI1384_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1429_MP1 (VDD qu13_b3_4 XI1429_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1429_MP5 (b19_25 XI1429_Bn XI1429_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1429_MP4 (XI1429_p1 XI1429_An b19_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1429_MP2 (VDD dd25_b3_3 XI1429_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1429_MP3 (XI1429_p1 qu13_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1429_MP0 (VDD dd25_b3_3 XI1429_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1430_MP1 (VDD qu13_b3_4 XI1430_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1430_MP5 (b19_26 XI1430_Bn XI1430_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1430_MP4 (XI1430_p1 XI1430_An b19_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1430_MP2 (VDD dd26_b3_3 XI1430_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1430_MP3 (XI1430_p1 qu13_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1430_MP0 (VDD dd26_b3_3 XI1430_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1474_MP1 (VDD qu12_b3_4 XI1474_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1474_MP5 (b20_24 XI1474_Bn XI1474_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1474_MP4 (XI1474_p1 XI1474_An b20_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1474_MP2 (VDD dd24_b3_3 XI1474_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1474_MP3 (XI1474_p1 qu12_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1474_MP0 (VDD dd24_b3_3 XI1474_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1475_MP1 (VDD qu12_b3_4 XI1475_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1475_MP5 (b20_25 XI1475_Bn XI1475_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1475_MP4 (XI1475_p1 XI1475_An b20_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1475_MP2 (VDD dd25_b3_3 XI1475_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1475_MP3 (XI1475_p1 qu12_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1475_MP0 (VDD dd25_b3_3 XI1475_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1476_MP1 (VDD qu12_b3_4 XI1476_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1476_MP5 (b20_26 XI1476_Bn XI1476_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1476_MP4 (XI1476_p1 XI1476_An b20_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1476_MP2 (VDD dd26_b3_3 XI1476_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1476_MP3 (XI1476_p1 qu12_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1476_MP0 (VDD dd26_b3_3 XI1476_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1524_MP1 (VDD qu11_b3_4 XI1524_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1524_MP5 (b21_28 XI1524_Bn XI1524_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1524_MP4 (XI1524_p1 XI1524_An b21_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1524_MP2 (VDD dd28_b3_3 XI1524_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1524_MP3 (XI1524_p1 qu11_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1524_MP0 (VDD dd28_b3_3 XI1524_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1526_MP1 (VDD qu11_b3_5 XI1526_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1526_MP5 (b21_30 XI1526_Bn XI1526_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1526_MP4 (XI1526_p1 XI1526_An b21_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1526_MP2 (VDD dd30_b3_3 XI1526_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1526_MP3 (XI1526_p1 qu11_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1526_MP0 (VDD dd30_b3_3 XI1526_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1205_MP1 (VDD qu18_b3_5 XI1205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1205_MP5 (b14_31 XI1205_Bn XI1205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1205_MP4 (XI1205_p1 XI1205_An b14_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1205_MP2 (VDD dd31_b3_2 XI1205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1205_MP3 (XI1205_p1 qu18_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1205_MP0 (VDD dd31_b3_2 XI1205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1203_MP1 (VDD qu18_b3_4 XI1203_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1203_MP5 (b14_29 XI1203_Bn XI1203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1203_MP4 (XI1203_p1 XI1203_An b14_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1203_MP2 (VDD dd29_b3_2 XI1203_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1203_MP3 (XI1203_p1 qu18_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1203_MP0 (VDD dd29_b3_2 XI1203_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1202_MP1 (VDD qu18_b3_4 XI1202_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1202_MP5 (b14_28 XI1202_Bn XI1202_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1202_MP4 (XI1202_p1 XI1202_An b14_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1202_MP2 (VDD dd28_b3_2 XI1202_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1202_MP3 (XI1202_p1 qu18_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1202_MP0 (VDD dd28_b3_2 XI1202_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1248_MP1 (VDD qu17_b3_4 XI1248_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1248_MP5 (b15_28 XI1248_Bn XI1248_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1248_MP4 (XI1248_p1 XI1248_An b15_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1248_MP2 (VDD dd28_b3_2 XI1248_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1248_MP3 (XI1248_p1 qu17_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1248_MP0 (VDD dd28_b3_2 XI1248_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1247_MP1 (VDD qu17_b3_4 XI1247_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1247_MP5 (b15_27 XI1247_Bn XI1247_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1247_MP4 (XI1247_p1 XI1247_An b15_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1247_MP2 (VDD dd27_b3_2 XI1247_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1247_MP3 (XI1247_p1 qu17_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1247_MP0 (VDD dd27_b3_2 XI1247_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1254_MP1 (VDD c15_o XI1254_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1254_MP5 (p15_32 XI1254_Bn XI1254_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1254_MP4 (XI1254_p1 XI1254_An p15_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1254_MP2 (VDD h15 XI1254_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1254_MP3 (XI1254_p1 c15_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1254_MP0 (VDD h15 XI1254_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1295_MP1 (VDD qu16_b3_4 XI1295_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1295_MP5 (b16_29 XI1295_Bn XI1295_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1295_MP4 (XI1295_p1 XI1295_An b16_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1295_MP2 (VDD dd29_b3_2 XI1295_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1295_MP3 (XI1295_p1 qu16_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1295_MP0 (VDD dd29_b3_2 XI1295_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1294_MP1 (VDD qu16_b3_4 XI1294_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1294_MP5 (b16_28 XI1294_Bn XI1294_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1294_MP4 (XI1294_p1 XI1294_An b16_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1294_MP2 (VDD dd28_b3_2 XI1294_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1294_MP3 (XI1294_p1 qu16_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1294_MP0 (VDD dd28_b3_2 XI1294_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1300_MP1 (VDD c16_o XI1300_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1300_MP5 (p16_32 XI1300_Bn XI1300_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1300_MP4 (XI1300_p1 XI1300_An p16_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1300_MP2 (VDD h16 XI1300_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1300_MP3 (XI1300_p1 c16_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1300_MP0 (VDD h16 XI1300_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1346_MP1 (VDD c17_o XI1346_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1346_MP5 (p17_32 XI1346_Bn XI1346_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1346_MP4 (XI1346_p1 XI1346_An p17_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1346_MP2 (VDD h17 XI1346_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1346_MP3 (XI1346_p1 c17_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1346_MP0 (VDD h17 XI1346_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1341_MP1 (VDD qu15_b3_4 XI1341_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1341_MP5 (b17_29 XI1341_Bn XI1341_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1341_MP4 (XI1341_p1 XI1341_An b17_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1341_MP2 (VDD dd29_b3_3 XI1341_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1341_MP3 (XI1341_p1 qu15_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1341_MP0 (VDD dd29_b3_3 XI1341_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1339_MP1 (VDD qu15_b3_4 XI1339_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1339_MP5 (b17_27 XI1339_Bn XI1339_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1339_MP4 (XI1339_p1 XI1339_An b17_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1339_MP2 (VDD dd27_b3_3 XI1339_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1339_MP3 (XI1339_p1 qu15_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1339_MP0 (VDD dd27_b3_3 XI1339_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1385_MP1 (VDD qu14_b3_4 XI1385_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1385_MP5 (b18_27 XI1385_Bn XI1385_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1385_MP4 (XI1385_p1 XI1385_An b18_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1385_MP2 (VDD dd27_b3_3 XI1385_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1385_MP3 (XI1385_p1 qu14_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1385_MP0 (VDD dd27_b3_3 XI1385_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1386_MP1 (VDD qu14_b3_4 XI1386_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1386_MP5 (b18_28 XI1386_Bn XI1386_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1386_MP4 (XI1386_p1 XI1386_An b18_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1386_MP2 (VDD dd28_b3_3 XI1386_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1386_MP3 (XI1386_p1 qu14_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1386_MP0 (VDD dd28_b3_3 XI1386_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1391_MP1 (VDD qu14_b3_5 XI1391_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1391_MP5 (h18 XI1391_Bn XI1391_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1391_MP4 (XI1391_p1 XI1391_An h18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1391_MP2 (VDD p17_31 XI1391_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1391_MP3 (XI1391_p1 qu14_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1391_MP0 (VDD p17_31 XI1391_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1392_MP1 (VDD c18_o XI1392_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1392_MP5 (p18_32 XI1392_Bn XI1392_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1392_MP4 (XI1392_p1 XI1392_An p18_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1392_MP2 (VDD h18 XI1392_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1392_MP3 (XI1392_p1 c18_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1392_MP0 (VDD h18 XI1392_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1432_MP1 (VDD qu13_b3_4 XI1432_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1432_MP5 (b19_28 XI1432_Bn XI1432_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1432_MP4 (XI1432_p1 XI1432_An b19_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1432_MP2 (VDD dd28_b3_3 XI1432_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1432_MP3 (XI1432_p1 qu13_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1432_MP0 (VDD dd28_b3_3 XI1432_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1431_MP1 (VDD qu13_b3_4 XI1431_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1431_MP5 (b19_27 XI1431_Bn XI1431_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1431_MP4 (XI1431_p1 XI1431_An b19_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1431_MP2 (VDD dd27_b3_3 XI1431_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1431_MP3 (XI1431_p1 qu13_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1431_MP0 (VDD dd27_b3_3 XI1431_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1483_MP1 (VDD qu12_b3_5 XI1483_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1483_MP5 (h20 XI1483_Bn XI1483_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1483_MP4 (XI1483_p1 XI1483_An h20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1483_MP2 (VDD p19_31 XI1483_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1483_MP3 (XI1483_p1 qu12_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1483_MP0 (VDD p19_31 XI1483_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1481_MP1 (VDD qu12_b3_5 XI1481_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1481_MP5 (b20_31 XI1481_Bn XI1481_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1481_MP4 (XI1481_p1 XI1481_An b20_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1481_MP2 (VDD dd31_b3_3 XI1481_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1481_MP3 (XI1481_p1 qu12_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1481_MP0 (VDD dd31_b3_3 XI1481_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1484_MP1 (VDD c20_o XI1484_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1484_MP5 (p20_32 XI1484_Bn XI1484_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1484_MP4 (XI1484_p1 XI1484_An p20_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1484_MP2 (VDD h20 XI1484_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1484_MP3 (XI1484_p1 c20_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1484_MP0 (VDD h20 XI1484_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1480_MP1 (VDD qu12_b3_5 XI1480_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1480_MP5 (b20_30 XI1480_Bn XI1480_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1480_MP4 (XI1480_p1 XI1480_An b20_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1480_MP2 (VDD dd30_b3_3 XI1480_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1480_MP3 (XI1480_p1 qu12_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1480_MP0 (VDD dd30_b3_3 XI1480_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1477_MP1 (VDD qu12_b3_4 XI1477_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1477_MP5 (b20_27 XI1477_Bn XI1477_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1477_MP4 (XI1477_p1 XI1477_An b20_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1477_MP2 (VDD dd27_b3_3 XI1477_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1477_MP3 (XI1477_p1 qu12_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1477_MP0 (VDD dd27_b3_3 XI1477_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1527_MP1 (VDD qu11_b3_5 XI1527_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1527_MP5 (b21_31 XI1527_Bn XI1527_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1527_MP4 (XI1527_p1 XI1527_An b21_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1527_MP2 (VDD dd31_b3_3 XI1527_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1527_MP3 (XI1527_p1 qu11_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1527_MP0 (VDD dd31_b3_3 XI1527_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1249_MP1 (VDD qu17_b3_4 XI1249_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1249_MP5 (b15_29 XI1249_Bn XI1249_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1249_MP4 (XI1249_p1 XI1249_An b15_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1249_MP2 (VDD dd29_b3_2 XI1249_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1249_MP3 (XI1249_p1 qu17_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1249_MP0 (VDD dd29_b3_2 XI1249_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1250_MP1 (VDD qu17_b3_5 XI1250_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1250_MP5 (b15_30 XI1250_Bn XI1250_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1250_MP4 (XI1250_p1 XI1250_An b15_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1250_MP2 (VDD dd30_b3_2 XI1250_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1250_MP3 (XI1250_p1 qu17_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1250_MP0 (VDD dd30_b3_2 XI1250_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1251_MP1 (VDD qu17_b3_5 XI1251_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1251_MP5 (b15_31 XI1251_Bn XI1251_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1251_MP4 (XI1251_p1 XI1251_An b15_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1251_MP2 (VDD dd31_b3_2 XI1251_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1251_MP3 (XI1251_p1 qu17_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1251_MP0 (VDD dd31_b3_2 XI1251_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1253_MP1 (VDD qu17_b3_5 XI1253_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1253_MP5 (h15 XI1253_Bn XI1253_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1253_MP4 (XI1253_p1 XI1253_An h15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1253_MP2 (VDD p14_31 XI1253_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1253_MP3 (XI1253_p1 qu17_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1253_MP0 (VDD p14_31 XI1253_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1299_MP1 (VDD qu16_b3_5 XI1299_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1299_MP5 (h16 XI1299_Bn XI1299_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1299_MP4 (XI1299_p1 XI1299_An h16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1299_MP2 (VDD p15_31 XI1299_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1299_MP3 (XI1299_p1 qu16_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1299_MP0 (VDD p15_31 XI1299_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1297_MP1 (VDD qu16_b3_5 XI1297_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1297_MP5 (b16_31 XI1297_Bn XI1297_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1297_MP4 (XI1297_p1 XI1297_An b16_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1297_MP2 (VDD dd31_b3_2 XI1297_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1297_MP3 (XI1297_p1 qu16_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1297_MP0 (VDD dd31_b3_2 XI1297_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1296_MP1 (VDD qu16_b3_5 XI1296_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1296_MP5 (b16_30 XI1296_Bn XI1296_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1296_MP4 (XI1296_p1 XI1296_An b16_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1296_MP2 (VDD dd30_b3_2 XI1296_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1296_MP3 (XI1296_p1 qu16_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1296_MP0 (VDD dd30_b3_2 XI1296_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1345_MP1 (VDD qu15_b3_5 XI1345_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1345_MP5 (h17 XI1345_Bn XI1345_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1345_MP4 (XI1345_p1 XI1345_An h17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1345_MP2 (VDD p16_31 XI1345_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1345_MP3 (XI1345_p1 qu15_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1345_MP0 (VDD p16_31 XI1345_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1340_MP1 (VDD qu15_b3_4 XI1340_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1340_MP5 (b17_28 XI1340_Bn XI1340_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1340_MP4 (XI1340_p1 XI1340_An b17_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1340_MP2 (VDD dd28_b3_3 XI1340_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1340_MP3 (XI1340_p1 qu15_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1340_MP0 (VDD dd28_b3_3 XI1340_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1342_MP1 (VDD qu15_b3_5 XI1342_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1342_MP5 (b17_30 XI1342_Bn XI1342_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1342_MP4 (XI1342_p1 XI1342_An b17_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1342_MP2 (VDD dd30_b3_3 XI1342_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1342_MP3 (XI1342_p1 qu15_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1342_MP0 (VDD dd30_b3_3 XI1342_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1343_MP1 (VDD qu15_b3_5 XI1343_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1343_MP5 (b17_31 XI1343_Bn XI1343_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1343_MP4 (XI1343_p1 XI1343_An b17_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1343_MP2 (VDD dd31_b3_3 XI1343_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1343_MP3 (XI1343_p1 qu15_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1343_MP0 (VDD dd31_b3_3 XI1343_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1387_MP1 (VDD qu14_b3_4 XI1387_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1387_MP5 (b18_29 XI1387_Bn XI1387_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1387_MP4 (XI1387_p1 XI1387_An b18_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1387_MP2 (VDD dd29_b3_3 XI1387_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1387_MP3 (XI1387_p1 qu14_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1387_MP0 (VDD dd29_b3_3 XI1387_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1388_MP1 (VDD qu14_b3_5 XI1388_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1388_MP5 (b18_30 XI1388_Bn XI1388_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1388_MP4 (XI1388_p1 XI1388_An b18_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1388_MP2 (VDD dd30_b3_3 XI1388_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1388_MP3 (XI1388_p1 qu14_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1388_MP0 (VDD dd30_b3_3 XI1388_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1389_MP1 (VDD qu14_b3_5 XI1389_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1389_MP5 (b18_31 XI1389_Bn XI1389_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1389_MP4 (XI1389_p1 XI1389_An b18_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1389_MP2 (VDD dd31_b3_3 XI1389_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1389_MP3 (XI1389_p1 qu14_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1389_MP0 (VDD dd31_b3_3 XI1389_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1437_MP1 (VDD qu13_b3_5 XI1437_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1437_MP5 (h19 XI1437_Bn XI1437_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1437_MP4 (XI1437_p1 XI1437_An h19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1437_MP2 (VDD p18_31 XI1437_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1437_MP3 (XI1437_p1 qu13_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1437_MP0 (VDD p18_31 XI1437_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1433_MP1 (VDD qu13_b3_4 XI1433_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1433_MP5 (b19_29 XI1433_Bn XI1433_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1433_MP4 (XI1433_p1 XI1433_An b19_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1433_MP2 (VDD dd29_b3_3 XI1433_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1433_MP3 (XI1433_p1 qu13_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1433_MP0 (VDD dd29_b3_3 XI1433_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1434_MP1 (VDD qu13_b3_5 XI1434_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1434_MP5 (b19_30 XI1434_Bn XI1434_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1434_MP4 (XI1434_p1 XI1434_An b19_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1434_MP2 (VDD dd30_b3_3 XI1434_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1434_MP3 (XI1434_p1 qu13_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1434_MP0 (VDD dd30_b3_3 XI1434_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1435_MP1 (VDD qu13_b3_5 XI1435_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1435_MP5 (b19_31 XI1435_Bn XI1435_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1435_MP4 (XI1435_p1 XI1435_An b19_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1435_MP2 (VDD dd31_b3_3 XI1435_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1435_MP3 (XI1435_p1 qu13_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1435_MP0 (VDD dd31_b3_3 XI1435_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1438_MP1 (VDD c19_o XI1438_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1438_MP5 (p19_32 XI1438_Bn XI1438_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1438_MP4 (XI1438_p1 XI1438_An p19_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1438_MP2 (VDD h19 XI1438_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1438_MP3 (XI1438_p1 c19_o VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1438_MP0 (VDD h19 XI1438_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1479_MP1 (VDD qu12_b3_4 XI1479_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1479_MP5 (b20_29 XI1479_Bn XI1479_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1479_MP4 (XI1479_p1 XI1479_An b20_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1479_MP2 (VDD dd29_b3_3 XI1479_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1479_MP3 (XI1479_p1 qu12_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1479_MP0 (VDD dd29_b3_3 XI1479_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1478_MP1 (VDD qu12_b3_4 XI1478_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_MXI1478_MP5 (b20_28 XI1478_Bn XI1478_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.92u ps=1.64u
    I_MXI1478_MP4 (XI1478_p1 XI1478_An b20_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1478_MP2 (VDD dd28_b3_3 XI1478_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.92u ps=0.92u
    I_MXI1478_MP3 (XI1478_p1 qu12_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.64u ps=0.92u
    I_MXI1478_MP0 (VDD dd28_b3_3 XI1478_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.16u ps=1.16u
    I_C1 (VDD VSS) capacitor c=5.796E-12
    I_C2 (A_0 VSS) capacitor c=1.284E-14
    I_C3 (A_1 VSS) capacitor c=1.305E-14
    I_C4 (A_10 VSS) capacitor c=5.651E-15
    I_C5 (A_11 VSS) capacitor c=8.256E-15
    I_C6 (A_12 VSS) capacitor c=1.135E-14
    I_C7 (A_13 VSS) capacitor c=1.407E-14
    I_C8 (A_14 VSS) capacitor c=1.575E-14
    I_C9 (A_15 VSS) capacitor c=1.071E-14
    I_C10 (A_16 VSS) capacitor c=1.104E-14
    I_C11 (A_17 VSS) capacitor c=1.183E-14
    I_C12 (A_18 VSS) capacitor c=1.124E-14
    I_C13 (A_19 VSS) capacitor c=9.772E-15
    I_C14 (A_2 VSS) capacitor c=1.101E-14
    I_C15 (A_20 VSS) capacitor c=8.989E-15
    I_C16 (A_21 VSS) capacitor c=1.125E-14
    I_C17 (A_22 VSS) capacitor c=1.059E-14
    I_C18 (A_23 VSS) capacitor c=1.388E-14
    I_C19 (A_24 VSS) capacitor c=8.614E-15
    I_C20 (A_25 VSS) capacitor c=9.188E-15
    I_C21 (A_26 VSS) capacitor c=1.094E-14
    I_C22 (A_27 VSS) capacitor c=1.112E-14
    I_C23 (A_28 VSS) capacitor c=1.842E-14
    I_C24 (A_29 VSS) capacitor c=1.385E-14
    I_C25 (A_3 VSS) capacitor c=1.498E-14
    I_C26 (A_30 VSS) capacitor c=1.547E-14
    I_C27 (A_31 VSS) capacitor c=1.104E-15
    I_C28 (A_4 VSS) capacitor c=8.470E-15
    I_C29 (A_5 VSS) capacitor c=1.408E-14
    I_C30 (A_6 VSS) capacitor c=8.359E-15
    I_C31 (A_7 VSS) capacitor c=9.054E-15
    I_C32 (A_8 VSS) capacitor c=6.573E-15
    I_C33 (A_9 VSS) capacitor c=6.448E-15
    I_C34 (B_0 VSS) capacitor c=1.017E-14
    I_C35 (B_1 VSS) capacitor c=1.124E-14
    I_C36 (B_10 VSS) capacitor c=9.573E-15
    I_C37 (B_11 VSS) capacitor c=8.189E-15
    I_C38 (B_12 VSS) capacitor c=1.268E-14
    I_C39 (B_13 VSS) capacitor c=1.185E-14
    I_C40 (B_14 VSS) capacitor c=9.599E-15
    I_C41 (B_15 VSS) capacitor c=1.055E-14
    I_C42 (B_16 VSS) capacitor c=1.441E-14
    I_C43 (B_17 VSS) capacitor c=1.634E-14
    I_C44 (B_18 VSS) capacitor c=1.504E-14
    I_C45 (B_19 VSS) capacitor c=1.255E-14
    I_C46 (B_2 VSS) capacitor c=1.150E-14
    I_C47 (B_20 VSS) capacitor c=1.739E-14
    I_C48 (B_21 VSS) capacitor c=1.231E-14
    I_C49 (B_22 VSS) capacitor c=9.718E-15
    I_C50 (B_23 VSS) capacitor c=1.143E-14
    I_C51 (B_24 VSS) capacitor c=1.739E-14
    I_C52 (B_25 VSS) capacitor c=1.416E-14
    I_C53 (B_26 VSS) capacitor c=1.343E-14
    I_C54 (B_27 VSS) capacitor c=1.651E-14
    I_C55 (B_28 VSS) capacitor c=1.340E-14
    I_C56 (B_29 VSS) capacitor c=1.006E-14
    I_C57 (B_3 VSS) capacitor c=1.146E-14
    I_C58 (B_30 VSS) capacitor c=1.100E-14
    I_C59 (B_31 VSS) capacitor c=1.247E-14
    I_C60 (B_4 VSS) capacitor c=1.074E-14
    I_C61 (B_5 VSS) capacitor c=1.119E-14
    I_C62 (B_6 VSS) capacitor c=1.287E-14
    I_C63 (B_7 VSS) capacitor c=9.783E-15
    I_C64 (B_8 VSS) capacitor c=1.140E-14
    I_C65 (B_9 VSS) capacitor c=1.361E-14
    I_C66 (DZ VSS) capacitor c=1.192E-14
    I_C67 (Q_0 VSS) capacitor c=1.227E-14
    I_C68 (Q_1 VSS) capacitor c=1.257E-14
    I_C69 (Q_10 VSS) capacitor c=4.999E-15
    I_C70 (Q_11 VSS) capacitor c=5.167E-15
    I_C71 (Q_12 VSS) capacitor c=7.089E-15
    I_C72 (Q_13 VSS) capacitor c=1.203E-14
    I_C73 (Q_14 VSS) capacitor c=7.678E-15
    I_C74 (Q_15 VSS) capacitor c=8.918E-15
    I_C75 (Q_16 VSS) capacitor c=1.041E-14
    I_C76 (Q_17 VSS) capacitor c=8.264E-15
    I_C77 (Q_18 VSS) capacitor c=1.359E-14
    I_C78 (Q_19 VSS) capacitor c=1.001E-14
    I_C79 (Q_2 VSS) capacitor c=6.725E-15
    I_C80 (Q_20 VSS) capacitor c=7.874E-15
    I_C81 (Q_21 VSS) capacitor c=1.229E-14
    I_C82 (Q_22 VSS) capacitor c=7.117E-15
    I_C83 (Q_23 VSS) capacitor c=9.247E-15
    I_C84 (Q_24 VSS) capacitor c=8.777E-15
    I_C85 (Q_25 VSS) capacitor c=7.820E-15
    I_C86 (Q_26 VSS) capacitor c=7.657E-15
    I_C87 (Q_27 VSS) capacitor c=7.624E-15
    I_C88 (Q_28 VSS) capacitor c=7.505E-15
    I_C89 (Q_29 VSS) capacitor c=1.273E-14
    I_C90 (Q_3 VSS) capacitor c=8.476E-15
    I_C91 (Q_30 VSS) capacitor c=8.899E-15
    I_C92 (Q_31 VSS) capacitor c=1.251E-14
    I_C93 (Q_4 VSS) capacitor c=5.827E-15
    I_C94 (Q_5 VSS) capacitor c=1.102E-14
    I_C95 (Q_6 VSS) capacitor c=8.944E-15
    I_C96 (Q_7 VSS) capacitor c=6.122E-15
    I_C97 (Q_8 VSS) capacitor c=4.928E-15
    I_C98 (Q_9 VSS) capacitor c=6.103E-15
    I_C99 (R_0 VSS) capacitor c=1.084E-14
    I_C100 (R_1 VSS) capacitor c=9.660E-15
    I_C101 (R_10 VSS) capacitor c=6.018E-15
    I_C102 (R_11 VSS) capacitor c=7.094E-15
    I_C103 (R_12 VSS) capacitor c=7.126E-15
    I_C104 (R_13 VSS) capacitor c=3.464E-15
    I_C105 (R_14 VSS) capacitor c=3.582E-15
    I_C106 (R_15 VSS) capacitor c=3.097E-15
    I_C107 (R_16 VSS) capacitor c=3.021E-15
    I_C108 (R_17 VSS) capacitor c=2.190E-15
    I_C109 (R_18 VSS) capacitor c=3.513E-15
    I_C110 (R_19 VSS) capacitor c=2.454E-15
    I_C111 (R_2 VSS) capacitor c=1.169E-14
    I_C112 (R_20 VSS) capacitor c=1.563E-15
    I_C113 (R_21 VSS) capacitor c=8.078E-16
    I_C114 (R_22 VSS) capacitor c=9.070E-16
    I_C115 (R_23 VSS) capacitor c=1.165E-15
    I_C116 (R_24 VSS) capacitor c=8.017E-16
    I_C117 (R_25 VSS) capacitor c=1.502E-15
    I_C118 (R_26 VSS) capacitor c=1.496E-15
    I_C119 (R_27 VSS) capacitor c=1.203E-15
    I_C120 (R_28 VSS) capacitor c=7.738E-16
    I_C121 (R_29 VSS) capacitor c=1.372E-15
    I_C122 (R_3 VSS) capacitor c=1.042E-14
    I_C123 (R_30 VSS) capacitor c=1.269E-15
    I_C124 (R_31 VSS) capacitor c=1.097E-15
    I_C125 (R_4 VSS) capacitor c=9.746E-15
    I_C126 (R_5 VSS) capacitor c=8.646E-15
    I_C127 (R_6 VSS) capacitor c=9.106E-15
    I_C128 (R_7 VSS) capacitor c=7.382E-15
    I_C129 (R_8 VSS) capacitor c=6.924E-15
    I_C130 (R_9 VSS) capacitor c=6.201E-15
    I_C131 (V VSS) capacitor c=6.376E-15
    I_C132 (dd28_b3_3 VSS) capacitor c=3.178E-14
    I_C133 (qu12_b3_4 VSS) capacitor c=1.208E-14
    I_C134 (b20_28 VSS) capacitor c=2.081E-15
    I_C135 (dd29_b3_3 VSS) capacitor c=3.458E-14
    I_C136 (b20_29 VSS) capacitor c=1.967E-15
    I_C137 (h19 VSS) capacitor c=4.968E-15
    I_C138 (c19_o VSS) capacitor c=2.407E-15
    I_C139 (p19_32 VSS) capacitor c=1.347E-15
    I_C140 (dd31_b3_3 VSS) capacitor c=2.868E-14
    I_C141 (qu13_b3_5 VSS) capacitor c=1.846E-14
    I_C142 (b19_31 VSS) capacitor c=2.283E-15
    I_C143 (dd30_b3_3 VSS) capacitor c=2.612E-14
    I_C144 (b19_30 VSS) capacitor c=2.495E-15
    I_C145 (qu13_b3_4 VSS) capacitor c=9.997E-15
    I_C146 (b19_29 VSS) capacitor c=2.196E-15
    I_C147 (p18_31 VSS) capacitor c=3.112E-15
    I_C148 (qu14_b3_5 VSS) capacitor c=2.130E-14
    I_C149 (b18_31 VSS) capacitor c=2.318E-15
    I_C150 (b18_30 VSS) capacitor c=2.199E-15
    I_C151 (qu14_b3_4 VSS) capacitor c=9.953E-15
    I_C152 (b18_29 VSS) capacitor c=2.522E-15
    I_C153 (qu15_b3_5 VSS) capacitor c=2.003E-14
    I_C154 (b17_31 VSS) capacitor c=4.562E-15
    I_C155 (b17_30 VSS) capacitor c=5.557E-15
    I_C156 (qu15_b3_4 VSS) capacitor c=9.574E-15
    I_C157 (b17_28 VSS) capacitor c=5.333E-15
    I_C158 (p16_31 VSS) capacitor c=4.419E-15
    I_C159 (h17 VSS) capacitor c=2.180E-15
    I_C160 (dd30_b3_2 VSS) capacitor c=4.751E-14
    I_C161 (qu16_b3_5 VSS) capacitor c=1.821E-14
    I_C162 (b16_30 VSS) capacitor c=2.400E-15
    I_C163 (dd31_b3_2 VSS) capacitor c=4.346E-14
    I_C164 (b16_31 VSS) capacitor c=2.529E-15
    I_C165 (p15_31 VSS) capacitor c=2.393E-15
    I_C166 (h16 VSS) capacitor c=5.107E-15
    I_C167 (p14_31 VSS) capacitor c=5.593E-15
    I_C168 (qu17_b3_5 VSS) capacitor c=2.714E-14
    I_C169 (h15 VSS) capacitor c=2.091E-15
    I_C170 (b15_31 VSS) capacitor c=2.139E-15
    I_C171 (b15_30 VSS) capacitor c=2.046E-15
    I_C172 (dd29_b3_2 VSS) capacitor c=4.251E-14
    I_C173 (qu17_b3_4 VSS) capacitor c=8.908E-15
    I_C174 (b15_29 VSS) capacitor c=2.011E-15
    I_C175 (qu11_b3_5 VSS) capacitor c=1.825E-14
    I_C176 (b21_31 VSS) capacitor c=2.122E-15
    I_C177 (dd27_b3_3 VSS) capacitor c=3.263E-14
    I_C178 (b20_27 VSS) capacitor c=2.003E-15
    I_C179 (qu12_b3_5 VSS) capacitor c=1.747E-14
    I_C180 (b20_30 VSS) capacitor c=2.256E-15
    I_C181 (h20 VSS) capacitor c=2.003E-15
    I_C182 (c20_o VSS) capacitor c=2.028E-15
    I_C183 (p20_32 VSS) capacitor c=1.709E-15
    I_C184 (b20_31 VSS) capacitor c=2.466E-15
    I_C185 (p19_31 VSS) capacitor c=2.157E-15
    I_C186 (b19_27 VSS) capacitor c=2.519E-15
    I_C187 (b19_28 VSS) capacitor c=2.216E-15
    I_C188 (h18 VSS) capacitor c=2.435E-15
    I_C189 (c18_o VSS) capacitor c=2.418E-15
    I_C190 (p18_32 VSS) capacitor c=1.731E-15
    I_C191 (p17_31 VSS) capacitor c=7.548E-15
    I_C192 (b18_28 VSS) capacitor c=1.916E-15
    I_C193 (b18_27 VSS) capacitor c=2.192E-15
    I_C194 (b17_27 VSS) capacitor c=5.652E-15
    I_C195 (b17_29 VSS) capacitor c=3.582E-15
    I_C196 (c17_o VSS) capacitor c=2.486E-15
    I_C197 (p17_32 VSS) capacitor c=2.067E-15
    I_C198 (c16_o VSS) capacitor c=2.143E-15
    I_C199 (p16_32 VSS) capacitor c=1.593E-15
    I_C200 (dd28_b3_2 VSS) capacitor c=5.889E-14
    I_C201 (qu16_b3_4 VSS) capacitor c=8.663E-15
    I_C202 (b16_28 VSS) capacitor c=1.926E-15
    I_C203 (b16_29 VSS) capacitor c=2.180E-15
    I_C204 (c15_o VSS) capacitor c=3.172E-15
    I_C205 (p15_32 VSS) capacitor c=1.131E-15
    I_C206 (dd27_b3_2 VSS) capacitor c=4.543E-14
    I_C207 (b15_27 VSS) capacitor c=1.750E-15
    I_C208 (b15_28 VSS) capacitor c=2.349E-15
    I_C209 (qu18_b3_4 VSS) capacitor c=1.063E-14
    I_C210 (b14_28 VSS) capacitor c=2.317E-15
    I_C211 (b14_29 VSS) capacitor c=2.096E-15
    I_C212 (qu18_b3_5 VSS) capacitor c=2.434E-14
    I_C213 (b14_31 VSS) capacitor c=2.202E-15
    I_C214 (b21_30 VSS) capacitor c=2.659E-15
    I_C215 (qu11_b3_4 VSS) capacitor c=9.930E-15
    I_C216 (b21_28 VSS) capacitor c=3.708E-15
    I_C217 (dd26_b3_3 VSS) capacitor c=3.837E-14
    I_C218 (b20_26 VSS) capacitor c=1.791E-15
    I_C219 (dd25_b3_3 VSS) capacitor c=3.590E-14
    I_C220 (b20_25 VSS) capacitor c=2.283E-15
    I_C221 (dd24_b3_3 VSS) capacitor c=2.783E-14
    I_C222 (b20_24 VSS) capacitor c=2.368E-15
    I_C223 (b19_26 VSS) capacitor c=2.147E-15
    I_C224 (b19_25 VSS) capacitor c=2.084E-15
    I_C225 (b18_26 VSS) capacitor c=1.999E-15
    I_C226 (b18_25 VSS) capacitor c=2.302E-15
    I_C227 (b17_25 VSS) capacitor c=4.410E-15
    I_C228 (b17_26 VSS) capacitor c=6.484E-15
    I_C229 (dd25_b3_2 VSS) capacitor c=4.427E-14
    I_C230 (b16_25 VSS) capacitor c=2.367E-15
    I_C231 (b16_27 VSS) capacitor c=2.489E-15
    I_C232 (dd26_b3_2 VSS) capacitor c=4.424E-14
    I_C233 (b16_26 VSS) capacitor c=2.951E-15
    I_C234 (b15_25 VSS) capacitor c=1.771E-15
    I_C235 (b15_26 VSS) capacitor c=2.271E-15
    I_C236 (b14_27 VSS) capacitor c=2.498E-15
    I_C237 (b14_26 VSS) capacitor c=2.733E-15
    I_C238 (b14_30 VSS) capacitor c=2.140E-15
    I_C239 (b21_29 VSS) capacitor c=1.995E-15
    I_C240 (b21_27 VSS) capacitor c=3.620E-15
    I_C241 (b19_24 VSS) capacitor c=2.135E-15
    I_C242 (b18_24 VSS) capacitor c=1.694E-15
    I_C243 (b17_24 VSS) capacitor c=4.812E-15
    I_C244 (dd24_b3_2 VSS) capacitor c=4.441E-14
    I_C245 (b16_24 VSS) capacitor c=2.224E-15
    I_C246 (b15_24 VSS) capacitor c=2.627E-15
    I_C247 (b14_24 VSS) capacitor c=2.729E-15
    I_C248 (dd23_b3_2 VSS) capacitor c=4.335E-14
    I_C249 (qu18_b3_3 VSS) capacitor c=1.178E-14
    I_C250 (b14_23 VSS) capacitor c=2.396E-15
    I_C251 (b14_25 VSS) capacitor c=2.157E-15
    I_C252 (b21_26 VSS) capacitor c=1.915E-15
    I_C253 (b21_25 VSS) capacitor c=2.324E-15
    I_C254 (b21_24 VSS) capacitor c=2.763E-15
    I_C255 (dd23_b3_3 VSS) capacitor c=2.691E-14
    I_C256 (qu12_b3_3 VSS) capacitor c=9.947E-15
    I_C257 (b20_23 VSS) capacitor c=2.028E-15
    I_C258 (qu13_b3_3 VSS) capacitor c=9.064E-15
    I_C259 (b19_23 VSS) capacitor c=1.881E-15
    I_C260 (qu14_b3_3 VSS) capacitor c=8.981E-15
    I_C261 (b18_23 VSS) capacitor c=2.180E-15
    I_C262 (qu15_b3_3 VSS) capacitor c=9.428E-15
    I_C263 (b17_23 VSS) capacitor c=3.655E-15
    I_C264 (dd22_b3_2 VSS) capacitor c=4.999E-14
    I_C265 (qu16_b3_3 VSS) capacitor c=1.103E-14
    I_C266 (b16_22 VSS) capacitor c=2.365E-15
    I_C267 (b16_23 VSS) capacitor c=2.275E-15
    I_C268 (qu17_b3_3 VSS) capacitor c=9.912E-15
    I_C269 (b15_22 VSS) capacitor c=1.871E-15
    I_C270 (b15_23 VSS) capacitor c=2.187E-15
    I_C271 (h14 VSS) capacitor c=3.721E-15
    I_C272 (c14_o VSS) capacitor c=1.854E-15
    I_C273 (p14_32 VSS) capacitor c=2.752E-15
    I_C274 (b14_22 VSS) capacitor c=2.662E-15
    I_C275 (p13_31 VSS) capacitor c=2.861E-15
    I_C276 (qu19_b3_4 VSS) capacitor c=1.291E-14
    I_C277 (b13_27 VSS) capacitor c=2.040E-15
    I_C278 (qu11_b3_3 VSS) capacitor c=1.054E-14
    I_C279 (b21_23 VSS) capacitor c=2.093E-15
    I_C280 (p20_31 VSS) capacitor c=2.177E-15
    I_C281 (h21 VSS) capacitor c=2.621E-15
    I_C282 (dd21_b3_3 VSS) capacitor c=2.865E-14
    I_C283 (b20_21 VSS) capacitor c=2.288E-15
    I_C284 (dd22_b3_3 VSS) capacitor c=2.847E-14
    I_C285 (b20_22 VSS) capacitor c=2.589E-15
    I_C286 (b19_22 VSS) capacitor c=2.231E-15
    I_C287 (b19_21 VSS) capacitor c=2.219E-15
    I_C288 (b18_22 VSS) capacitor c=2.233E-15
    I_C289 (b18_21 VSS) capacitor c=2.309E-15
    I_C290 (b17_22 VSS) capacitor c=4.307E-15
    I_C291 (b17_21 VSS) capacitor c=4.967E-15
    I_C292 (dd20_b3_2 VSS) capacitor c=4.406E-14
    I_C293 (b16_20 VSS) capacitor c=2.650E-15
    I_C294 (dd21_b3_2 VSS) capacitor c=4.727E-14
    I_C295 (b16_21 VSS) capacitor c=2.599E-15
    I_C296 (b15_20 VSS) capacitor c=2.491E-15
    I_C297 (b15_21 VSS) capacitor c=2.676E-15
    I_C298 (dd19_b3_2 VSS) capacitor c=3.787E-14
    I_C299 (b15_19 VSS) capacitor c=2.160E-15
    I_C300 (I1206_pn16 VSS) capacitor c=4.933E-15
    I_C301 (I1206_G15_0n VSS) capacitor c=5.026E-15
    I_C302 (p14_16 VSS) capacitor c=6.595E-15
    I_C303 (b14_20 VSS) capacitor c=2.021E-15
    I_C304 (b14_19 VSS) capacitor c=1.905E-15
    I_C305 (b14_21 VSS) capacitor c=2.303E-15
    I_C306 (b13_26 VSS) capacitor c=2.355E-15
    I_C307 (b13_28 VSS) capacitor c=2.539E-15
    I_C308 (b13_29 VSS) capacitor c=4.158E-15
    I_C309 (b21_22 VSS) capacitor c=2.323E-15
    I_C310 (b21_21 VSS) capacitor c=2.633E-15
    I_C311 (dd20_b3_3 VSS) capacitor c=2.380E-14
    I_C312 (b20_20 VSS) capacitor c=1.971E-15
    I_C313 (dd19_b3_3 VSS) capacitor c=2.411E-14
    I_C314 (b20_19 VSS) capacitor c=2.164E-15
    I_C315 (b19_20 VSS) capacitor c=2.125E-15
    I_C316 (b19_19 VSS) capacitor c=2.249E-15
    I_C317 (b18_19 VSS) capacitor c=2.883E-15
    I_C318 (b18_20 VSS) capacitor c=2.015E-15
    I_C319 (b17_20 VSS) capacitor c=4.541E-15
    I_C320 (b17_19 VSS) capacitor c=4.834E-15
    I_C321 (dd18_b3_2 VSS) capacitor c=4.162E-14
    I_C322 (b16_18 VSS) capacitor c=2.478E-15
    I_C323 (b16_19 VSS) capacitor c=2.221E-15
    I_C324 (b15_18 VSS) capacitor c=2.199E-15
    I_C325 (I1206_pn15 VSS) capacitor c=5.341E-15
    I_C326 (I1206_G14_0n VSS) capacitor c=6.104E-15
    I_C327 (p14_15 VSS) capacitor c=6.156E-15
    I_C328 (b14_18 VSS) capacitor c=2.193E-15
    I_C329 (I1160_pn15 VSS) capacitor c=7.342E-15
    I_C330 (I1160_G14_0n VSS) capacitor c=3.297E-15
    I_C331 (p13_15 VSS) capacitor c=4.253E-15
    I_C332 (c21_o VSS) capacitor c=3.709E-15
    I_C333 (p21_32 VSS) capacitor c=9.597E-15
    I_C334 (b21_20 VSS) capacitor c=2.416E-15
    I_C335 (dd18_b3_3 VSS) capacitor c=2.742E-14
    I_C336 (b20_18 VSS) capacitor c=2.469E-15
    I_C337 (I1436_pn16 VSS) capacitor c=7.096E-15
    I_C338 (I1436_G15_0n VSS) capacitor c=5.076E-15
    I_C339 (p19_16 VSS) capacitor c=2.838E-15
    I_C340 (b19_18 VSS) capacitor c=2.070E-15
    I_C341 (I1390_pn16 VSS) capacitor c=8.650E-15
    I_C342 (I1390_G15_0n VSS) capacitor c=4.582E-15
    I_C343 (p18_16 VSS) capacitor c=2.700E-15
    I_C344 (b18_18 VSS) capacitor c=1.888E-15
    I_C345 (b17_18 VSS) capacitor c=4.409E-15
    I_C346 (I1252_pn16 VSS) capacitor c=8.549E-15
    I_C347 (I1252_G15_0n VSS) capacitor c=6.244E-15
    I_C348 (p15_16 VSS) capacitor c=3.089E-15
    I_C349 (dd17_b3_2 VSS) capacitor c=3.551E-14
    I_C350 (qu17_b3_2 VSS) capacitor c=1.019E-14
    I_C351 (b15_17 VSS) capacitor c=2.298E-15
    I_C352 (I1206_pn14 VSS) capacitor c=5.045E-15
    I_C353 (I1206_G13_0n VSS) capacitor c=6.882E-15
    I_C354 (p14_14 VSS) capacitor c=6.565E-15
    I_C355 (qu18_b3_2 VSS) capacitor c=9.904E-15
    I_C356 (b14_17 VSS) capacitor c=2.079E-15
    I_C357 (I1160_pn13 VSS) capacitor c=5.766E-15
    I_C358 (I1160_G12_0n VSS) capacitor c=4.164E-15
    I_C359 (p13_13 VSS) capacitor c=3.722E-15
    I_C360 (b13_25 VSS) capacitor c=3.054E-15
    I_C361 (b21_19 VSS) capacitor c=2.262E-15
    I_C362 (b21_18 VSS) capacitor c=2.624E-15
    I_C363 (I1482_pn16 VSS) capacitor c=5.530E-15
    I_C364 (I1482_G15_0n VSS) capacitor c=6.884E-15
    I_C365 (p20_16 VSS) capacitor c=5.895E-15
    I_C366 (dd17_b3_3 VSS) capacitor c=2.435E-14
    I_C367 (qu12_b3_2 VSS) capacitor c=1.043E-14
    I_C368 (b20_17 VSS) capacitor c=1.861E-15
    I_C369 (I1436_pn15 VSS) capacitor c=6.799E-15
    I_C370 (I1436_G14_0n VSS) capacitor c=5.951E-15
    I_C371 (p19_15 VSS) capacitor c=3.838E-15
    I_C372 (qu13_b3_2 VSS) capacitor c=9.713E-15
    I_C373 (b19_17 VSS) capacitor c=2.302E-15
    I_C374 (I1390_pn15 VSS) capacitor c=5.715E-15
    I_C375 (I1390_G14_0n VSS) capacitor c=3.755E-15
    I_C376 (p18_15 VSS) capacitor c=5.433E-15
    I_C377 (qu14_b3_2 VSS) capacitor c=1.032E-14
    I_C378 (b18_17 VSS) capacitor c=1.774E-15
    I_C379 (I1344_pn16 VSS) capacitor c=5.445E-15
    I_C380 (I1344_G15_0n VSS) capacitor c=6.547E-15
    I_C381 (p17_16 VSS) capacitor c=2.652E-15
    I_C382 (qu15_b3_2 VSS) capacitor c=9.254E-15
    I_C383 (b17_17 VSS) capacitor c=5.019E-15
    I_C384 (I1344_pn15 VSS) capacitor c=5.035E-15
    I_C385 (I1344_G14_0n VSS) capacitor c=5.621E-15
    I_C386 (p17_15 VSS) capacitor c=5.872E-15
    I_C387 (I1298_pn16 VSS) capacitor c=6.537E-15
    I_C388 (I1298_G15_0n VSS) capacitor c=7.036E-15
    I_C389 (p16_16 VSS) capacitor c=3.939E-15
    I_C390 (I1298_pn15 VSS) capacitor c=7.061E-15
    I_C391 (I1298_G14_0n VSS) capacitor c=4.466E-15
    I_C392 (p16_15 VSS) capacitor c=4.855E-15
    I_C393 (dd16_b3_2 VSS) capacitor c=3.019E-14
    I_C394 (qu16_b3_2 VSS) capacitor c=9.359E-15
    I_C395 (b16_16 VSS) capacitor c=1.853E-15
    I_C396 (b16_17 VSS) capacitor c=2.310E-15
    I_C397 (I1252_pn14 VSS) capacitor c=7.952E-15
    I_C398 (I1252_G13_0n VSS) capacitor c=6.684E-15
    I_C399 (p15_14 VSS) capacitor c=3.284E-15
    I_C400 (I1252_pn15 VSS) capacitor c=5.141E-15
    I_C401 (I1252_G14_0n VSS) capacitor c=5.527E-15
    I_C402 (p15_15 VSS) capacitor c=4.435E-15
    I_C403 (dd15_b3_2 VSS) capacitor c=2.930E-14
    I_C404 (b15_15 VSS) capacitor c=2.079E-15
    I_C405 (b15_16 VSS) capacitor c=2.616E-15
    I_C406 (I1206_pn13 VSS) capacitor c=7.762E-15
    I_C407 (I1206_G12_0n VSS) capacitor c=6.298E-15
    I_C408 (p14_13 VSS) capacitor c=2.333E-15
    I_C409 (I1206_pn10 VSS) capacitor c=4.518E-15
    I_C410 (I1206_G9_0n VSS) capacitor c=6.427E-15
    I_C411 (p14_10 VSS) capacitor c=6.673E-15
    I_C412 (I1206_pn12 VSS) capacitor c=4.627E-15
    I_C413 (I1206_G11_0n VSS) capacitor c=6.040E-15
    I_C414 (p14_12 VSS) capacitor c=6.811E-15
    I_C415 (dd12_b3_2 VSS) capacitor c=3.832E-14
    I_C416 (b14_12 VSS) capacitor c=2.146E-15
    I_C417 (b14_15 VSS) capacitor c=2.440E-15
    I_C418 (dd14_b3_2 VSS) capacitor c=3.124E-14
    I_C419 (b14_14 VSS) capacitor c=2.060E-15
    I_C420 (b14_16 VSS) capacitor c=3.217E-15
    I_C421 (I1160_pn11 VSS) capacitor c=5.613E-15
    I_C422 (I1160_G10_0n VSS) capacitor c=4.196E-15
    I_C423 (p13_11 VSS) capacitor c=4.034E-15
    I_C424 (b13_24 VSS) capacitor c=2.509E-15
    I_C425 (I1482_pn15 VSS) capacitor c=6.137E-15
    I_C426 (I1482_G14_0n VSS) capacitor c=4.583E-15
    I_C427 (p20_15 VSS) capacitor c=3.849E-15
    I_C428 (I1482_pn14 VSS) capacitor c=4.631E-15
    I_C429 (I1482_G13_0n VSS) capacitor c=4.749E-15
    I_C430 (p20_14 VSS) capacitor c=5.193E-15
    I_C431 (dd15_b3_3 VSS) capacitor c=2.117E-14
    I_C432 (b20_15 VSS) capacitor c=2.035E-15
    I_C433 (dd16_b3_3 VSS) capacitor c=1.624E-14
    I_C434 (b20_16 VSS) capacitor c=2.213E-15
    I_C435 (I1436_pn14 VSS) capacitor c=5.856E-15
    I_C436 (I1436_G13_0n VSS) capacitor c=5.042E-15
    I_C437 (p19_14 VSS) capacitor c=3.629E-15
    I_C438 (b19_16 VSS) capacitor c=2.434E-15
    I_C439 (b19_15 VSS) capacitor c=2.305E-15
    I_C440 (I1390_pn14 VSS) capacitor c=8.283E-15
    I_C441 (I1390_G13_0n VSS) capacitor c=4.995E-15
    I_C442 (p18_14 VSS) capacitor c=3.140E-15
    I_C443 (b18_16 VSS) capacitor c=2.419E-15
    I_C444 (b17_16 VSS) capacitor c=5.233E-15
    I_C445 (I1344_pn14 VSS) capacitor c=5.456E-15
    I_C446 (I1344_G13_0n VSS) capacitor c=7.974E-15
    I_C447 (p17_14 VSS) capacitor c=3.521E-15
    I_C448 (b17_15 VSS) capacitor c=5.038E-15
    I_C449 (I1298_pn14 VSS) capacitor c=7.888E-15
    I_C450 (I1298_G13_0n VSS) capacitor c=5.288E-15
    I_C451 (p16_14 VSS) capacitor c=4.420E-15
    I_C452 (I1298_pn13 VSS) capacitor c=5.482E-15
    I_C453 (I1298_G12_0n VSS) capacitor c=4.304E-15
    I_C454 (p16_13 VSS) capacitor c=6.525E-15
    I_C455 (b16_15 VSS) capacitor c=2.568E-15
    I_C456 (b16_14 VSS) capacitor c=2.550E-15
    I_C457 (I1252_pn13 VSS) capacitor c=6.618E-15
    I_C458 (I1252_G12_0n VSS) capacitor c=6.205E-15
    I_C459 (p15_13 VSS) capacitor c=3.905E-15
    I_C460 (b15_14 VSS) capacitor c=2.510E-15
    I_C461 (I1206_pn11 VSS) capacitor c=6.068E-15
    I_C462 (I1206_G10_0n VSS) capacitor c=7.871E-15
    I_C463 (p14_11 VSS) capacitor c=4.709E-15
    I_C464 (dd13_b3_2 VSS) capacitor c=3.241E-14
    I_C465 (b14_13 VSS) capacitor c=2.663E-15
    I_C466 (I1160_pn9 VSS) capacitor c=5.959E-15
    I_C467 (I1160_G8_0n VSS) capacitor c=5.381E-15
    I_C468 (p13_9 VSS) capacitor c=3.354E-15
    I_C469 (I1528_pn16 VSS) capacitor c=4.976E-15
    I_C470 (I1528_G15_0n VSS) capacitor c=3.437E-15
    I_C471 (p21_16 VSS) capacitor c=1.519E-14
    I_C472 (I1482_pn13 VSS) capacitor c=6.206E-15
    I_C473 (I1482_G12_0n VSS) capacitor c=5.955E-15
    I_C474 (p20_13 VSS) capacitor c=3.453E-15
    I_C475 (dd14_b3_3 VSS) capacitor c=2.335E-14
    I_C476 (b20_14 VSS) capacitor c=2.071E-15
    I_C477 (qu11_b3_2 VSS) capacitor c=1.023E-14
    I_C478 (b21_17 VSS) capacitor c=7.820E-15
    I_C479 (b21_16 VSS) capacitor c=7.720E-15
    I_C480 (I1436_pn13 VSS) capacitor c=6.110E-15
    I_C481 (I1436_G12_0n VSS) capacitor c=5.443E-15
    I_C482 (p19_13 VSS) capacitor c=4.730E-15
    I_C483 (b19_14 VSS) capacitor c=1.950E-15
    I_C484 (I1390_pn13 VSS) capacitor c=6.057E-15
    I_C485 (I1390_G12_0n VSS) capacitor c=5.333E-15
    I_C486 (p18_13 VSS) capacitor c=4.541E-15
    I_C487 (b18_15 VSS) capacitor c=2.259E-15
    I_C488 (b18_14 VSS) capacitor c=1.983E-15
    I_C489 (b17_14 VSS) capacitor c=4.026E-15
    I_C490 (I1344_pn13 VSS) capacitor c=3.942E-15
    I_C491 (I1344_G12_0n VSS) capacitor c=5.422E-15
    I_C492 (p17_13 VSS) capacitor c=5.561E-15
    I_C493 (b16_13 VSS) capacitor c=2.270E-15
    I_C494 (I1252_pn12 VSS) capacitor c=7.763E-15
    I_C495 (I1252_G11_0n VSS) capacitor c=6.566E-15
    I_C496 (p15_12 VSS) capacitor c=2.885E-15
    I_C497 (I1252_pn11 VSS) capacitor c=6.287E-15
    I_C498 (I1252_G10_0n VSS) capacitor c=6.239E-15
    I_C499 (p15_11 VSS) capacitor c=5.375E-15
    I_C500 (b15_13 VSS) capacitor c=2.200E-15
    I_C501 (b15_12 VSS) capacitor c=1.959E-15
    I_C502 (I1206_pn9 VSS) capacitor c=8.545E-15
    I_C503 (I1206_G8_0n VSS) capacitor c=5.218E-15
    I_C504 (p14_9 VSS) capacitor c=3.458E-15
    I_C505 (I1160_pn10 VSS) capacitor c=6.367E-15
    I_C506 (I1160_G9_0n VSS) capacitor c=4.722E-15
    I_C507 (p13_10 VSS) capacitor c=3.668E-15
    I_C508 (I1160_pn12 VSS) capacitor c=6.815E-15
    I_C509 (I1160_G11_0n VSS) capacitor c=6.862E-15
    I_C510 (p13_12 VSS) capacitor c=4.480E-15
    I_C511 (I1160_pn14 VSS) capacitor c=4.628E-15
    I_C512 (I1160_G13_0n VSS) capacitor c=3.945E-15
    I_C513 (p13_14 VSS) capacitor c=6.308E-15
    I_C514 (I1482_pn11 VSS) capacitor c=6.796E-15
    I_C515 (I1482_G10_0n VSS) capacitor c=4.321E-15
    I_C516 (p20_11 VSS) capacitor c=2.994E-15
    I_C517 (dd13_b3_3 VSS) capacitor c=1.917E-14
    I_C518 (b20_13 VSS) capacitor c=2.456E-15
    I_C519 (b21_15 VSS) capacitor c=6.924E-15
    I_C520 (dd12_b3_3 VSS) capacitor c=2.194E-14
    I_C521 (b20_12 VSS) capacitor c=3.433E-15
    I_C522 (I1436_pn12 VSS) capacitor c=7.441E-15
    I_C523 (I1436_G11_0n VSS) capacitor c=9.225E-15
    I_C524 (p19_12 VSS) capacitor c=3.760E-15
    I_C525 (I1436_pn11 VSS) capacitor c=6.846E-15
    I_C526 (I1436_G10_0n VSS) capacitor c=5.472E-15
    I_C527 (p19_11 VSS) capacitor c=4.723E-15
    I_C528 (b19_13 VSS) capacitor c=2.347E-15
    I_C529 (b19_12 VSS) capacitor c=2.292E-15
    I_C530 (I1390_pn12 VSS) capacitor c=7.776E-15
    I_C531 (I1390_G11_0n VSS) capacitor c=6.026E-15
    I_C532 (p18_12 VSS) capacitor c=3.440E-15
    I_C533 (b18_13 VSS) capacitor c=2.016E-15
    I_C534 (b17_12 VSS) capacitor c=4.855E-15
    I_C535 (b17_13 VSS) capacitor c=4.499E-15
    I_C536 (I1344_pn12 VSS) capacitor c=4.459E-15
    I_C537 (I1344_G11_0n VSS) capacitor c=5.414E-15
    I_C538 (p17_12 VSS) capacitor c=3.774E-15
    I_C539 (I1298_pn12 VSS) capacitor c=6.165E-15
    I_C540 (I1298_G11_0n VSS) capacitor c=7.406E-15
    I_C541 (p16_12 VSS) capacitor c=3.379E-15
    I_C542 (I1298_pn11 VSS) capacitor c=6.815E-15
    I_C543 (I1298_G10_0n VSS) capacitor c=4.879E-15
    I_C544 (p16_11 VSS) capacitor c=5.756E-15
    I_C545 (b16_12 VSS) capacitor c=2.361E-15
    I_C546 (I1252_pn10 VSS) capacitor c=8.189E-15
    I_C547 (I1252_G9_0n VSS) capacitor c=3.980E-15
    I_C548 (p15_10 VSS) capacitor c=2.561E-15
    I_C549 (I1252_pn9 VSS) capacitor c=6.159E-15
    I_C550 (I1252_G8_0n VSS) capacitor c=3.413E-15
    I_C551 (p15_9 VSS) capacitor c=5.143E-15
    I_C552 (I1160_pn16 VSS) capacitor c=6.487E-15
    I_C553 (I1160_G15_0n VSS) capacitor c=7.082E-15
    I_C554 (p13_16 VSS) capacitor c=7.471E-15
    I_C555 (h13 VSS) capacitor c=3.347E-15
    I_C556 (c13_o VSS) capacitor c=1.786E-15
    I_C557 (p13_32 VSS) capacitor c=1.395E-15
    I_C558 (I1528_pn15 VSS) capacitor c=5.833E-15
    I_C559 (I1528_G14_0n VSS) capacitor c=4.372E-15
    I_C560 (p21_15 VSS) capacitor c=1.437E-14
    I_C561 (I1482_pn12 VSS) capacitor c=5.704E-15
    I_C562 (I1482_G11_0n VSS) capacitor c=7.089E-15
    I_C563 (p20_12 VSS) capacitor c=4.438E-15
    I_C564 (b21_13 VSS) capacitor c=5.741E-15
    I_C565 (b21_14 VSS) capacitor c=5.106E-15
    I_C566 (I1436_pn10 VSS) capacitor c=6.772E-15
    I_C567 (I1436_G9_0n VSS) capacitor c=1.069E-14
    I_C568 (p19_10 VSS) capacitor c=2.390E-15
    I_C569 (I1390_pn10 VSS) capacitor c=7.498E-15
    I_C570 (I1390_G9_0n VSS) capacitor c=3.599E-15
    I_C571 (p18_10 VSS) capacitor c=3.044E-15
    I_C572 (I1390_pn11 VSS) capacitor c=5.322E-15
    I_C573 (I1390_G10_0n VSS) capacitor c=5.582E-15
    I_C574 (p18_11 VSS) capacitor c=3.680E-15
    I_C575 (b18_12 VSS) capacitor c=2.418E-15
    I_C576 (I1344_pn10 VSS) capacitor c=6.241E-15
    I_C577 (I1344_G9_0n VSS) capacitor c=5.615E-15
    I_C578 (p17_10 VSS) capacitor c=2.938E-15
    I_C579 (I1344_pn11 VSS) capacitor c=3.728E-15
    I_C580 (I1344_G10_0n VSS) capacitor c=6.690E-15
    I_C581 (p17_11 VSS) capacitor c=3.857E-15
    I_C582 (I1298_pn10 VSS) capacitor c=6.677E-15
    I_C583 (I1298_G9_0n VSS) capacitor c=6.397E-15
    I_C584 (p16_10 VSS) capacitor c=4.085E-15
    I_C585 (dd10_b3_2 VSS) capacitor c=2.728E-14
    I_C586 (qu16_b3_1 VSS) capacitor c=9.552E-15
    I_C587 (b16_10 VSS) capacitor c=2.480E-15
    I_C588 (qu17_b3_1 VSS) capacitor c=9.166E-15
    I_C589 (b15_10 VSS) capacitor c=2.672E-15
    I_C590 (dd9_b3_2 VSS) capacitor c=3.141E-14
    I_C591 (b15_9 VSS) capacitor c=2.757E-15
    I_C592 (qu18_b3_1 VSS) capacitor c=8.834E-15
    I_C593 (b14_10 VSS) capacitor c=4.223E-15
    I_C594 (b14_9 VSS) capacitor c=2.986E-15
    I_C595 (I1160_pn3 VSS) capacitor c=5.197E-15
    I_C596 (I1160_G2_0n VSS) capacitor c=8.685E-15
    I_C597 (p13_3 VSS) capacitor c=3.716E-15
    I_C598 (I1160_pn4 VSS) capacitor c=5.792E-15
    I_C599 (I1160_G3_0n VSS) capacitor c=8.519E-15
    I_C600 (p13_4 VSS) capacitor c=3.778E-15
    I_C601 (I1528_pn14 VSS) capacitor c=6.107E-15
    I_C602 (I1528_G13_0n VSS) capacitor c=4.492E-15
    I_C603 (p21_14 VSS) capacitor c=1.509E-14
    I_C604 (I1482_pn9 VSS) capacitor c=5.598E-15
    I_C605 (I1482_G8_0n VSS) capacitor c=6.062E-15
    I_C606 (p20_9 VSS) capacitor c=3.167E-15
    I_C607 (I1482_pn10 VSS) capacitor c=5.621E-15
    I_C608 (I1482_G9_0n VSS) capacitor c=6.225E-15
    I_C609 (p20_10 VSS) capacitor c=4.391E-15
    I_C610 (dd10_b3_3 VSS) capacitor c=1.792E-14
    I_C611 (qu12_b3_1 VSS) capacitor c=1.000E-14
    I_C612 (b20_10 VSS) capacitor c=1.989E-15
    I_C613 (dd11_b3_3 VSS) capacitor c=2.083E-14
    I_C614 (b20_11 VSS) capacitor c=2.288E-15
    I_C615 (b21_12 VSS) capacitor c=5.665E-15
    I_C616 (I1436_pn9 VSS) capacitor c=4.574E-15
    I_C617 (I1436_G8_0n VSS) capacitor c=5.085E-15
    I_C618 (p19_9 VSS) capacitor c=4.226E-15
    I_C619 (qu13_b3_1 VSS) capacitor c=9.711E-15
    I_C620 (b19_11 VSS) capacitor c=2.376E-15
    I_C621 (b19_10 VSS) capacitor c=2.589E-15
    I_C622 (I1390_pn9 VSS) capacitor c=5.368E-15
    I_C623 (I1390_G8_0n VSS) capacitor c=4.446E-15
    I_C624 (p18_9 VSS) capacitor c=4.583E-15
    I_C625 (qu14_b3_1 VSS) capacitor c=1.089E-14
    I_C626 (b18_11 VSS) capacitor c=2.111E-15
    I_C627 (qu15_b3_1 VSS) capacitor c=9.233E-15
    I_C628 (b17_11 VSS) capacitor c=3.716E-15
    I_C629 (b17_10 VSS) capacitor c=3.961E-15
    I_C630 (I1344_pn9 VSS) capacitor c=4.683E-15
    I_C631 (I1344_G8_0n VSS) capacitor c=4.579E-15
    I_C632 (p17_9 VSS) capacitor c=4.615E-15
    I_C633 (I1298_pn9 VSS) capacitor c=5.596E-15
    I_C634 (I1298_G8_0n VSS) capacitor c=3.993E-15
    I_C635 (p16_9 VSS) capacitor c=5.891E-15
    I_C636 (b16_9 VSS) capacitor c=2.017E-15
    I_C637 (dd11_b3_2 VSS) capacitor c=3.092E-14
    I_C638 (b16_11 VSS) capacitor c=2.549E-15
    I_C639 (dd8_b3_2 VSS) capacitor c=3.639E-14
    I_C640 (b16_8 VSS) capacitor c=1.973E-15
    I_C641 (b15_8 VSS) capacitor c=2.540E-15
    I_C642 (b15_11 VSS) capacitor c=2.766E-15
    I_C643 (dd7_b3_2 VSS) capacitor c=3.268E-14
    I_C644 (b15_7 VSS) capacitor c=2.933E-15
    I_C645 (I1206_pn3 VSS) capacitor c=4.024E-15
    I_C646 (I1206_G2_0n VSS) capacitor c=1.045E-14
    I_C647 (p14_3 VSS) capacitor c=4.859E-15
    I_C648 (I1206_pn4 VSS) capacitor c=4.346E-15
    I_C649 (I1206_G3_0n VSS) capacitor c=1.091E-14
    I_C650 (p14_4 VSS) capacitor c=4.127E-15
    I_C651 (b14_7 VSS) capacitor c=2.764E-15
    I_C652 (dd6_b3_2 VSS) capacitor c=3.592E-14
    I_C653 (b14_6 VSS) capacitor c=3.513E-15
    I_C654 (b14_8 VSS) capacitor c=3.504E-15
    I_C655 (b14_11 VSS) capacitor c=4.336E-15
    I_C656 (qu19_b3_1 VSS) capacitor c=1.018E-14
    I_C657 (b13_8 VSS) capacitor c=2.593E-15
    I_C658 (b13_10 VSS) capacitor c=3.000E-15
    I_C659 (b13_9 VSS) capacitor c=2.972E-15
    I_C660 (qu19_b3_5 VSS) capacitor c=2.227E-14
    I_C661 (b13_31 VSS) capacitor c=2.081E-15
    I_C662 (b13_30 VSS) capacitor c=2.206E-15
    I_C663 (I1528_pn12 VSS) capacitor c=5.578E-15
    I_C664 (I1528_G11_0n VSS) capacitor c=4.407E-15
    I_C665 (p21_12 VSS) capacitor c=1.444E-14
    I_C666 (I1528_pn13 VSS) capacitor c=6.143E-15
    I_C667 (I1528_G12_0n VSS) capacitor c=4.142E-15
    I_C668 (p21_13 VSS) capacitor c=1.685E-14
    I_C669 (I1528_pn11 VSS) capacitor c=6.697E-15
    I_C670 (I1528_G10_0n VSS) capacitor c=5.766E-15
    I_C671 (p21_11 VSS) capacitor c=1.467E-14
    I_C672 (dd9_b3_3 VSS) capacitor c=1.794E-14
    I_C673 (b20_9 VSS) capacitor c=2.279E-15
    I_C674 (qu11_b3_1 VSS) capacitor c=1.060E-14
    I_C675 (b21_10 VSS) capacitor c=5.396E-15
    I_C676 (b21_11 VSS) capacitor c=7.408E-15
    I_C677 (b19_9 VSS) capacitor c=2.311E-15
    I_C678 (dd8_b3_3 VSS) capacitor c=1.778E-14
    I_C679 (b19_8 VSS) capacitor c=2.378E-15
    I_C680 (b18_9 VSS) capacitor c=2.119E-15
    I_C681 (b18_10 VSS) capacitor c=2.373E-15
    I_C682 (b18_8 VSS) capacitor c=2.205E-15
    I_C683 (b17_9 VSS) capacitor c=3.927E-15
    I_C684 (b17_8 VSS) capacitor c=4.337E-15
    I_C685 (b16_6 VSS) capacitor c=2.074E-15
    I_C686 (b16_7 VSS) capacitor c=2.832E-15
    I_C687 (I1252_pn4 VSS) capacitor c=5.931E-15
    I_C688 (I1252_G3_0n VSS) capacitor c=7.202E-15
    I_C689 (p15_4 VSS) capacitor c=2.535E-15
    I_C690 (I1252_pn3 VSS) capacitor c=5.048E-15
    I_C691 (I1252_G2_0n VSS) capacitor c=7.028E-15
    I_C692 (p15_3 VSS) capacitor c=4.355E-15
    I_C693 (dd5_b3_2 VSS) capacitor c=3.523E-14
    I_C694 (qu17_b3_0 VSS) capacitor c=1.106E-14
    I_C695 (b15_5 VSS) capacitor c=2.258E-15
    I_C696 (b15_6 VSS) capacitor c=3.109E-15
    I_C697 (qu18_b3_0 VSS) capacitor c=1.017E-14
    I_C698 (b14_5 VSS) capacitor c=3.378E-15
    I_C699 (b13_11 VSS) capacitor c=3.320E-15
    I_C700 (qu19_b3_2 VSS) capacitor c=8.298E-15
    I_C701 (b13_17 VSS) capacitor c=3.373E-15
    I_C702 (b13_14 VSS) capacitor c=3.306E-15
    I_C703 (qu19_b3_3 VSS) capacitor c=1.049E-14
    I_C704 (b13_18 VSS) capacitor c=2.356E-15
    I_C705 (b13_22 VSS) capacitor c=2.381E-15
    I_C706 (b13_23 VSS) capacitor c=2.476E-15
    I_C707 (p12_31 VSS) capacitor c=4.113E-15
    I_C708 (b21_9 VSS) capacitor c=4.226E-15
    I_C709 (dd7_b3_3 VSS) capacitor c=1.991E-14
    I_C710 (b21_7 VSS) capacitor c=4.384E-15
    I_C711 (b20_7 VSS) capacitor c=3.083E-15
    I_C712 (dd6_b3_3 VSS) capacitor c=1.539E-14
    I_C713 (b20_6 VSS) capacitor c=2.402E-15
    I_C714 (b20_8 VSS) capacitor c=2.531E-15
    I_C715 (I1436_pn4 VSS) capacitor c=5.885E-15
    I_C716 (I1436_G3_0n VSS) capacitor c=7.731E-15
    I_C717 (p19_4 VSS) capacitor c=2.693E-15
    I_C718 (b19_7 VSS) capacitor c=2.566E-15
    I_C719 (I1390_pn4 VSS) capacitor c=5.482E-15
    I_C720 (I1390_G3_0n VSS) capacitor c=7.106E-15
    I_C721 (p18_4 VSS) capacitor c=2.965E-15
    I_C722 (b18_7 VSS) capacitor c=1.952E-15
    I_C723 (b17_7 VSS) capacitor c=5.384E-15
    I_C724 (b17_6 VSS) capacitor c=6.114E-15
    I_C725 (I1344_pn4 VSS) capacitor c=5.386E-15
    I_C726 (I1344_G3_0n VSS) capacitor c=6.239E-15
    I_C727 (p17_4 VSS) capacitor c=4.286E-15
    I_C728 (I1298_pn4 VSS) capacitor c=5.701E-15
    I_C729 (I1298_G3_0n VSS) capacitor c=6.678E-15
    I_C730 (p16_4 VSS) capacitor c=4.388E-15
    I_C731 (I1298_pn3 VSS) capacitor c=6.637E-15
    I_C732 (I1298_G2_0n VSS) capacitor c=5.988E-15
    I_C733 (p16_3 VSS) capacitor c=5.429E-15
    I_C734 (dd3_b3_2 VSS) capacitor c=3.110E-14
    I_C735 (qu16_b3_0 VSS) capacitor c=1.020E-14
    I_C736 (b16_3 VSS) capacitor c=2.315E-15
    I_C737 (dd4_b3_2 VSS) capacitor c=3.146E-14
    I_C738 (b16_4 VSS) capacitor c=2.248E-15
    I_C739 (b16_5 VSS) capacitor c=2.525E-15
    I_C740 (b15_3 VSS) capacitor c=2.205E-15
    I_C741 (b15_4 VSS) capacitor c=2.206E-15
    I_C742 (dd2_b3_2 VSS) capacitor c=3.172E-14
    I_C743 (b14_2 VSS) capacitor c=2.205E-15
    I_C744 (b14_4 VSS) capacitor c=2.894E-15
    I_C745 (qu19_b3_0 VSS) capacitor c=9.047E-15
    I_C746 (b13_3 VSS) capacitor c=1.868E-15
    I_C747 (b13_6 VSS) capacitor c=2.626E-15
    I_C748 (b13_7 VSS) capacitor c=2.715E-15
    I_C749 (b13_13 VSS) capacitor c=4.198E-15
    I_C750 (b13_15 VSS) capacitor c=3.620E-15
    I_C751 (b13_12 VSS) capacitor c=3.308E-15
    I_C752 (b13_16 VSS) capacitor c=3.888E-15
    I_C753 (I1114_pn12 VSS) capacitor c=7.508E-15
    I_C754 (I1114_G11_0n VSS) capacitor c=5.040E-15
    I_C755 (p12_12 VSS) capacitor c=2.517E-15
    I_C756 (I1114_pn16 VSS) capacitor c=8.831E-15
    I_C757 (I1114_G15_0n VSS) capacitor c=4.889E-15
    I_C758 (p12_16 VSS) capacitor c=3.106E-15
    I_C759 (b13_19 VSS) capacitor c=2.549E-15
    I_C760 (b13_20 VSS) capacitor c=1.949E-15
    I_C761 (b13_21 VSS) capacitor c=2.421E-15
    I_C762 (h12 VSS) capacitor c=1.807E-15
    I_C763 (c12_o VSS) capacitor c=1.997E-15
    I_C764 (p12_32 VSS) capacitor c=1.345E-15
    I_C765 (I1528_pn10 VSS) capacitor c=6.249E-15
    I_C766 (I1528_G9_0n VSS) capacitor c=3.510E-15
    I_C767 (p21_10 VSS) capacitor c=1.524E-14
    I_C768 (I1482_pn3 VSS) capacitor c=4.991E-15
    I_C769 (I1482_G2_0n VSS) capacitor c=9.590E-15
    I_C770 (p20_3 VSS) capacitor c=3.356E-15
    I_C771 (I1482_pn4 VSS) capacitor c=6.614E-15
    I_C772 (I1482_G3_0n VSS) capacitor c=9.367E-15
    I_C773 (p20_4 VSS) capacitor c=3.274E-15
    I_C774 (dd5_b3_3 VSS) capacitor c=1.770E-14
    I_C775 (qu11_b3_0 VSS) capacitor c=9.369E-15
    I_C776 (b21_5 VSS) capacitor c=4.064E-15
    I_C777 (b21_8 VSS) capacitor c=4.815E-15
    I_C778 (b21_6 VSS) capacitor c=5.849E-15
    I_C779 (qu12_b3_0 VSS) capacitor c=1.056E-14
    I_C780 (b20_5 VSS) capacitor c=2.223E-15
    I_C781 (I1436_pn3 VSS) capacitor c=4.683E-15
    I_C782 (I1436_G2_0n VSS) capacitor c=5.440E-15
    I_C783 (p19_3 VSS) capacitor c=2.971E-15
    I_C784 (b19_6 VSS) capacitor c=2.874E-15
    I_C785 (I1390_pn3 VSS) capacitor c=5.611E-15
    I_C786 (I1390_G2_0n VSS) capacitor c=7.105E-15
    I_C787 (p18_3 VSS) capacitor c=3.890E-15
    I_C788 (qu14_b3_0 VSS) capacitor c=1.164E-14
    I_C789 (b18_5 VSS) capacitor c=2.065E-15
    I_C790 (b18_6 VSS) capacitor c=2.373E-15
    I_C791 (qu15_b3_0 VSS) capacitor c=9.756E-15
    I_C792 (b17_5 VSS) capacitor c=5.187E-15
    I_C793 (I1344_pn3 VSS) capacitor c=4.128E-15
    I_C794 (I1344_G2_0n VSS) capacitor c=6.142E-15
    I_C795 (p17_3 VSS) capacitor c=5.653E-15
    I_C796 (b16_2 VSS) capacitor c=2.590E-15
    I_C797 (B_0_b3_2 VSS) capacitor c=1.715E-14
    I_C798 (b16_0 VSS) capacitor c=5.019E-15
    I_C799 (dd1_b3_2 VSS) capacitor c=2.855E-14
    I_C800 (b16_1 VSS) capacitor c=3.617E-15
    I_C801 (b15_2 VSS) capacitor c=2.214E-15
    I_C802 (b14_1 VSS) capacitor c=2.811E-15
    I_C803 (b14_0 VSS) capacitor c=2.433E-15
    I_C804 (b14_3 VSS) capacitor c=2.732E-15
    I_C805 (b13_0 VSS) capacitor c=2.202E-15
    I_C806 (b13_1 VSS) capacitor c=2.310E-15
    I_C807 (b13_2 VSS) capacitor c=2.538E-15
    I_C808 (b13_5 VSS) capacitor c=2.771E-15
    I_C809 (b13_4 VSS) capacitor c=2.294E-15
    I_C810 (I1114_pn4 VSS) capacitor c=6.324E-15
    I_C811 (I1114_G3_0n VSS) capacitor c=7.330E-15
    I_C812 (p12_4 VSS) capacitor c=2.163E-15
    I_C813 (I1114_pn10 VSS) capacitor c=7.151E-15
    I_C814 (I1114_G9_0n VSS) capacitor c=5.487E-15
    I_C815 (p12_10 VSS) capacitor c=4.314E-15
    I_C816 (I1114_pn14 VSS) capacitor c=9.061E-15
    I_C817 (I1114_G13_0n VSS) capacitor c=5.082E-15
    I_C818 (p12_14 VSS) capacitor c=3.311E-15
    I_C819 (p11_31 VSS) capacitor c=7.606E-15
    I_C820 (qu20_b3_5 VSS) capacitor c=2.360E-14
    I_C821 (I1528_pn4 VSS) capacitor c=6.332E-15
    I_C822 (I1528_G3_0n VSS) capacitor c=5.331E-15
    I_C823 (p21_4 VSS) capacitor c=1.479E-14
    I_C824 (I1528_pn9 VSS) capacitor c=5.989E-15
    I_C825 (I1528_G8_0n VSS) capacitor c=2.772E-15
    I_C826 (p21_9 VSS) capacitor c=1.201E-14
    I_C827 (dd4_b3_3 VSS) capacitor c=1.751E-14
    I_C828 (b21_4 VSS) capacitor c=4.304E-15
    I_C829 (dd2_b3_3 VSS) capacitor c=1.557E-14
    I_C830 (b20_2 VSS) capacitor c=2.189E-15
    I_C831 (dd3_b3_3 VSS) capacitor c=1.743E-14
    I_C832 (b20_3 VSS) capacitor c=2.702E-15
    I_C833 (b20_4 VSS) capacitor c=2.612E-15
    I_C834 (qu13_b3_0 VSS) capacitor c=1.229E-14
    I_C835 (b19_2 VSS) capacitor c=3.083E-15
    I_C836 (b19_5 VSS) capacitor c=2.612E-15
    I_C837 (b19_3 VSS) capacitor c=2.403E-15
    I_C838 (b19_4 VSS) capacitor c=2.122E-15
    I_C839 (dd1_b3_3 VSS) capacitor c=1.601E-14
    I_C840 (b18_1 VSS) capacitor c=1.829E-15
    I_C841 (b18_4 VSS) capacitor c=2.702E-15
    I_C842 (b17_1 VSS) capacitor c=4.844E-15
    I_C843 (b17_2 VSS) capacitor c=4.949E-15
    I_C844 (b17_3 VSS) capacitor c=5.456E-15
    I_C845 (b17_4 VSS) capacitor c=6.054E-15
    I_C846 (p8_31 VSS) capacitor c=4.018E-15
    I_C847 (qu23_b3_5 VSS) capacitor c=2.633E-14
    I_C848 (h9 VSS) capacitor c=5.239E-15
    I_C849 (c9_o VSS) capacitor c=2.054E-15
    I_C850 (p9_32 VSS) capacitor c=2.304E-15
    I_C851 (b15_0 VSS) capacitor c=2.207E-15
    I_C852 (b15_1 VSS) capacitor c=2.582E-15
    I_C853 (I1114_pn3 VSS) capacitor c=4.199E-15
    I_C854 (I1114_G2_0n VSS) capacitor c=6.801E-15
    I_C855 (p12_3 VSS) capacitor c=2.491E-15
    I_C856 (dd28_b3_4 VSS) capacitor c=4.081E-14
    I_C857 (qu10_b3_4 VSS) capacitor c=1.311E-14
    I_C858 (b22_28 VSS) capacitor c=2.989E-15
    I_C859 (dd29_b3_4 VSS) capacitor c=3.911E-14
    I_C860 (b22_29 VSS) capacitor c=2.117E-15
    I_C861 (I1528_pn3 VSS) capacitor c=5.883E-15
    I_C862 (I1528_G2_0n VSS) capacitor c=6.940E-15
    I_C863 (p21_3 VSS) capacitor c=1.204E-14
    I_C864 (b21_2 VSS) capacitor c=4.163E-15
    I_C865 (b21_1 VSS) capacitor c=2.697E-15
    I_C866 (b21_3 VSS) capacitor c=4.311E-15
    I_C867 (b20_1 VSS) capacitor c=2.890E-15
    I_C868 (B_0_b3_3 VSS) capacitor c=3.128E-14
    I_C869 (b20_0 VSS) capacitor c=2.460E-15
    I_C870 (b19_1 VSS) capacitor c=2.321E-15
    I_C871 (b19_0 VSS) capacitor c=2.140E-15
    I_C872 (b18_2 VSS) capacitor c=3.104E-15
    I_C873 (b18_0 VSS) capacitor c=2.236E-15
    I_C874 (b18_3 VSS) capacitor c=2.841E-15
    I_C875 (b17_0 VSS) capacitor c=2.481E-15
    I_C876 (dd29_b3_1 VSS) capacitor c=2.733E-14
    I_C877 (qu24_b3_4 VSS) capacitor c=9.656E-15
    I_C878 (b8_29 VSS) capacitor c=4.451E-15
    I_C879 (qu23_b3_4 VSS) capacitor c=8.385E-15
    I_C880 (b9_29 VSS) capacitor c=2.768E-15
    I_C881 (dd30_b3_1 VSS) capacitor c=3.198E-14
    I_C882 (qu24_b3_5 VSS) capacitor c=3.182E-14
    I_C883 (b8_30 VSS) capacitor c=5.161E-15
    I_C884 (b9_30 VSS) capacitor c=2.831E-15
    I_C885 (dd31_b3_1 VSS) capacitor c=2.630E-14
    I_C886 (b9_31 VSS) capacitor c=3.150E-15
    I_C887 (qu22_b3_4 VSS) capacitor c=8.817E-15
    I_C888 (b10_29 VSS) capacitor c=3.520E-15
    I_C889 (qu22_b3_5 VSS) capacitor c=2.295E-14
    I_C890 (b10_30 VSS) capacitor c=1.936E-15
    I_C891 (b10_31 VSS) capacitor c=2.368E-15
    I_C892 (p9_31 VSS) capacitor c=5.447E-15
    I_C893 (h10 VSS) capacitor c=4.725E-15
    I_C894 (qu20_b3_0 VSS) capacitor c=1.077E-14
    I_C895 (b12_0 VSS) capacitor c=2.091E-15
    I_C896 (b12_1 VSS) capacitor c=1.973E-15
    I_C897 (I1114_pn9 VSS) capacitor c=4.991E-15
    I_C898 (I1114_G8_0n VSS) capacitor c=4.604E-15
    I_C899 (p12_9 VSS) capacitor c=5.027E-15
    I_C900 (I1114_pn11 VSS) capacitor c=5.695E-15
    I_C901 (I1114_G10_0n VSS) capacitor c=4.353E-15
    I_C902 (p12_11 VSS) capacitor c=3.946E-15
    I_C903 (dd27_b3_4 VSS) capacitor c=4.748E-14
    I_C904 (b22_27 VSS) capacitor c=2.576E-15
    I_C905 (dd26_b3_4 VSS) capacitor c=3.990E-14
    I_C906 (b22_26 VSS) capacitor c=2.317E-15
    I_C907 (dd31_b3_4 VSS) capacitor c=3.233E-14
    I_C908 (qu10_b3_5 VSS) capacitor c=1.794E-14
    I_C909 (b22_31 VSS) capacitor c=3.400E-15
    I_C910 (b21_0 VSS) capacitor c=2.626E-15
    I_C911 (qu9_b3_4 VSS) capacitor c=1.147E-14
    I_C912 (b23_28 VSS) capacitor c=2.295E-15
    I_C913 (b23_29 VSS) capacitor c=2.120E-15
    I_C914 (qu8_b3_4 VSS) capacitor c=1.217E-14
    I_C915 (b24_29 VSS) capacitor c=2.527E-15
    I_C916 (dd28_b3_1 VSS) capacitor c=3.115E-14
    I_C917 (b8_28 VSS) capacitor c=4.379E-15
    I_C918 (dd27_b3_1 VSS) capacitor c=2.603E-14
    I_C919 (b8_27 VSS) capacitor c=4.842E-15
    I_C920 (b9_28 VSS) capacitor c=2.463E-15
    I_C921 (b9_27 VSS) capacitor c=2.020E-15
    I_C922 (b8_31 VSS) capacitor c=4.947E-15
    I_C923 (b10_28 VSS) capacitor c=2.491E-15
    I_C924 (b10_27 VSS) capacitor c=2.356E-15
    I_C925 (b12_2 VSS) capacitor c=2.069E-15
    I_C926 (I1114_pn13 VSS) capacitor c=6.002E-15
    I_C927 (I1114_G12_0n VSS) capacitor c=5.551E-15
    I_C928 (p12_13 VSS) capacitor c=4.638E-15
    I_C929 (I1114_pn15 VSS) capacitor c=6.038E-15
    I_C930 (I1114_G14_0n VSS) capacitor c=5.365E-15
    I_C931 (p12_15 VSS) capacitor c=4.151E-15
    I_C932 (dd25_b3_4 VSS) capacitor c=3.953E-14
    I_C933 (b22_25 VSS) capacitor c=3.230E-15
    I_C934 (p21_31 VSS) capacitor c=7.383E-15
    I_C935 (h22 VSS) capacitor c=2.212E-15
    I_C936 (dd30_b3_4 VSS) capacitor c=3.068E-14
    I_C937 (b22_30 VSS) capacitor c=4.131E-15
    I_C938 (p22_31 VSS) capacitor c=3.732E-15
    I_C939 (qu9_b3_5 VSS) capacitor c=2.479E-14
    I_C940 (h23 VSS) capacitor c=6.175E-15
    I_C941 (b23_25 VSS) capacitor c=2.532E-15
    I_C942 (b23_26 VSS) capacitor c=2.347E-15
    I_C943 (b23_27 VSS) capacitor c=2.578E-15
    I_C944 (b23_30 VSS) capacitor c=2.427E-15
    I_C945 (b23_31 VSS) capacitor c=2.529E-15
    I_C946 (c23_o VSS) capacitor c=1.970E-15
    I_C947 (p23_32 VSS) capacitor c=1.791E-15
    I_C948 (p23_31 VSS) capacitor c=2.679E-15
    I_C949 (qu8_b3_5 VSS) capacitor c=2.449E-14
    I_C950 (h24 VSS) capacitor c=2.709E-15
    I_C951 (b24_31 VSS) capacitor c=2.490E-15
    I_C952 (b24_30 VSS) capacitor c=2.549E-15
    I_C953 (b24_28 VSS) capacitor c=2.135E-15
    I_C954 (b24_27 VSS) capacitor c=2.817E-15
    I_C955 (b24_26 VSS) capacitor c=2.888E-15
    I_C956 (b24_25 VSS) capacitor c=1.916E-15
    I_C957 (dd26_b3_1 VSS) capacitor c=3.129E-14
    I_C958 (b8_26 VSS) capacitor c=3.272E-15
    I_C959 (dd25_b3_1 VSS) capacitor c=3.123E-14
    I_C960 (b8_25 VSS) capacitor c=5.164E-15
    I_C961 (dd24_b3_1 VSS) capacitor c=2.852E-14
    I_C962 (b9_24 VSS) capacitor c=2.391E-15
    I_C963 (b9_26 VSS) capacitor c=2.864E-15
    I_C964 (b10_25 VSS) capacitor c=2.194E-15
    I_C965 (b10_26 VSS) capacitor c=2.576E-15
    I_C966 (qu21_b3_0 VSS) capacitor c=1.827E-14
    I_C967 (b11_0 VSS) capacitor c=2.254E-15
    I_C968 (b12_4 VSS) capacitor c=2.550E-15
    I_C969 (b12_3 VSS) capacitor c=2.432E-15
    I_C970 (b12_31 VSS) capacitor c=2.543E-15
    I_C971 (dd24_b3_4 VSS) capacitor c=3.917E-14
    I_C972 (b22_24 VSS) capacitor c=2.283E-15
    I_C973 (c22_o VSS) capacitor c=2.379E-15
    I_C974 (p22_32 VSS) capacitor c=1.658E-15
    I_C975 (b23_24 VSS) capacitor c=1.907E-15
    I_C976 (c24_o VSS) capacitor c=1.796E-15
    I_C977 (p24_32 VSS) capacitor c=1.425E-15
    I_C978 (b24_24 VSS) capacitor c=1.901E-15
    I_C979 (b8_24 VSS) capacitor c=3.700E-15
    I_C980 (b9_25 VSS) capacitor c=2.543E-15
    I_C981 (dd23_b3_1 VSS) capacitor c=2.415E-14
    I_C982 (qu23_b3_3 VSS) capacitor c=1.066E-14
    I_C983 (b9_23 VSS) capacitor c=1.806E-15
    I_C984 (b10_24 VSS) capacitor c=2.777E-15
    I_C985 (qu22_b3_3 VSS) capacitor c=1.035E-14
    I_C986 (b10_23 VSS) capacitor c=2.459E-15
    I_C987 (c10_o VSS) capacitor c=2.176E-15
    I_C988 (p10_32 VSS) capacitor c=1.897E-15
    I_C989 (b12_5 VSS) capacitor c=2.771E-15
    I_C990 (qu20_b3_1 VSS) capacitor c=9.479E-15
    I_C991 (b12_6 VSS) capacitor c=2.068E-15
    I_C992 (b12_30 VSS) capacitor c=2.003E-15
    I_C993 (dd23_b3_4 VSS) capacitor c=3.095E-14
    I_C994 (qu10_b3_3 VSS) capacitor c=8.438E-15
    I_C995 (b22_23 VSS) capacitor c=6.031E-15
    I_C996 (dd22_b3_4 VSS) capacitor c=2.926E-14
    I_C997 (b22_22 VSS) capacitor c=4.551E-15
    I_C998 (qu9_b3_3 VSS) capacitor c=9.705E-15
    I_C999 (b23_22 VSS) capacitor c=2.361E-15
    I_C1000 (b23_23 VSS) capacitor c=2.250E-15
    I_C1001 (qu8_b3_3 VSS) capacitor c=9.960E-15
    I_C1002 (b24_23 VSS) capacitor c=2.227E-15
    I_C1003 (b24_22 VSS) capacitor c=2.417E-15
    I_C1004 (qu24_b3_3 VSS) capacitor c=8.950E-15
    I_C1005 (b8_23 VSS) capacitor c=4.403E-15
    I_C1006 (dd22_b3_1 VSS) capacitor c=2.024E-14
    I_C1007 (b8_22 VSS) capacitor c=3.464E-15
    I_C1008 (b9_22 VSS) capacitor c=2.125E-15
    I_C1009 (b10_22 VSS) capacitor c=3.169E-15
    I_C1010 (b12_11 VSS) capacitor c=4.009E-15
    I_C1011 (b12_7 VSS) capacitor c=2.826E-15
    I_C1012 (b12_10 VSS) capacitor c=3.371E-15
    I_C1013 (b12_9 VSS) capacitor c=3.017E-15
    I_C1014 (dd20_b3_4 VSS) capacitor c=3.272E-14
    I_C1015 (b22_20 VSS) capacitor c=4.656E-15
    I_C1016 (dd21_b3_4 VSS) capacitor c=3.123E-14
    I_C1017 (b22_21 VSS) capacitor c=5.984E-15
    I_C1018 (b23_21 VSS) capacitor c=2.409E-15
    I_C1019 (b24_20 VSS) capacitor c=2.900E-15
    I_C1020 (b24_21 VSS) capacitor c=2.063E-15
    I_C1021 (dd21_b3_1 VSS) capacitor c=2.419E-14
    I_C1022 (b8_21 VSS) capacitor c=5.249E-15
    I_C1023 (dd20_b3_1 VSS) capacitor c=2.440E-14
    I_C1024 (b8_20 VSS) capacitor c=2.945E-15
    I_C1025 (b9_21 VSS) capacitor c=2.256E-15
    I_C1026 (b9_20 VSS) capacitor c=2.303E-15
    I_C1027 (b10_21 VSS) capacitor c=2.381E-15
    I_C1028 (b10_20 VSS) capacitor c=2.359E-15
    I_C1029 (b12_8 VSS) capacitor c=2.654E-15
    I_C1030 (qu20_b3_2 VSS) capacitor c=9.065E-15
    I_C1031 (b12_17 VSS) capacitor c=3.047E-15
    I_C1032 (qu20_b3_3 VSS) capacitor c=9.383E-15
    I_C1033 (b12_20 VSS) capacitor c=2.264E-15
    I_C1034 (b12_23 VSS) capacitor c=2.137E-15
    I_C1035 (qu20_b3_4 VSS) capacitor c=1.059E-14
    I_C1036 (b12_24 VSS) capacitor c=2.159E-15
    I_C1037 (b12_29 VSS) capacitor c=2.023E-15
    I_C1038 (dd19_b3_4 VSS) capacitor c=2.799E-14
    I_C1039 (b22_19 VSS) capacitor c=4.894E-15
    I_C1040 (dd18_b3_4 VSS) capacitor c=3.244E-14
    I_C1041 (b22_18 VSS) capacitor c=3.359E-15
    I_C1042 (b23_18 VSS) capacitor c=3.171E-15
    I_C1043 (b23_19 VSS) capacitor c=2.151E-15
    I_C1044 (b23_20 VSS) capacitor c=2.955E-15
    I_C1045 (I1620_pn16 VSS) capacitor c=8.350E-15
    I_C1046 (I1620_G15_0n VSS) capacitor c=4.693E-15
    I_C1047 (p23_16 VSS) capacitor c=3.351E-15
    I_C1048 (b24_19 VSS) capacitor c=1.907E-15
    I_C1049 (I930_pn15 VSS) capacitor c=6.735E-15
    I_C1050 (I930_G14_0n VSS) capacitor c=6.498E-15
    I_C1051 (p8_15 VSS) capacitor c=3.348E-15
    I_C1052 (dd19_b3_1 VSS) capacitor c=2.106E-14
    I_C1053 (b8_19 VSS) capacitor c=2.786E-15
    I_C1054 (dd18_b3_1 VSS) capacitor c=2.083E-14
    I_C1055 (b8_18 VSS) capacitor c=2.441E-15
    I_C1056 (b9_18 VSS) capacitor c=2.172E-15
    I_C1057 (b9_19 VSS) capacitor c=2.206E-15
    I_C1058 (I976_pn16 VSS) capacitor c=6.687E-15
    I_C1059 (I976_G15_0n VSS) capacitor c=6.910E-15
    I_C1060 (p9_16 VSS) capacitor c=5.737E-15
    I_C1061 (b10_18 VSS) capacitor c=2.336E-15
    I_C1062 (b10_19 VSS) capacitor c=2.924E-15
    I_C1063 (p10_31 VSS) capacitor c=5.597E-15
    I_C1064 (qu21_b3_5 VSS) capacitor c=1.825E-14
    I_C1065 (h11 VSS) capacitor c=1.808E-15
    I_C1066 (b12_13 VSS) capacitor c=3.200E-15
    I_C1067 (b12_15 VSS) capacitor c=3.406E-15
    I_C1068 (b12_16 VSS) capacitor c=3.237E-15
    I_C1069 (b12_12 VSS) capacitor c=3.664E-15
    I_C1070 (b12_22 VSS) capacitor c=2.110E-15
    I_C1071 (b12_21 VSS) capacitor c=2.245E-15
    I_C1072 (b12_25 VSS) capacitor c=2.214E-15
    I_C1073 (b12_28 VSS) capacitor c=2.687E-15
    I_C1074 (I1574_pn15 VSS) capacitor c=4.154E-15
    I_C1075 (I1574_G14_0n VSS) capacitor c=4.611E-15
    I_C1076 (p22_15 VSS) capacitor c=5.810E-15
    I_C1077 (I1574_pn16 VSS) capacitor c=6.162E-15
    I_C1078 (I1574_G15_0n VSS) capacitor c=5.795E-15
    I_C1079 (p22_16 VSS) capacitor c=4.935E-15
    I_C1080 (dd17_b3_4 VSS) capacitor c=3.056E-14
    I_C1081 (qu10_b3_2 VSS) capacitor c=9.481E-15
    I_C1082 (b22_17 VSS) capacitor c=5.362E-15
    I_C1083 (qu9_b3_2 VSS) capacitor c=1.039E-14
    I_C1084 (b23_17 VSS) capacitor c=2.268E-15
    I_C1085 (I1620_pn15 VSS) capacitor c=5.476E-15
    I_C1086 (I1620_G14_0n VSS) capacitor c=6.351E-15
    I_C1087 (p23_15 VSS) capacitor c=5.730E-15
    I_C1088 (b24_18 VSS) capacitor c=2.220E-15
    I_C1089 (I930_pn14 VSS) capacitor c=5.261E-15
    I_C1090 (I930_G13_0n VSS) capacitor c=5.818E-15
    I_C1091 (p8_14 VSS) capacitor c=6.727E-15
    I_C1092 (I930_pn16 VSS) capacitor c=4.253E-15
    I_C1093 (I930_G15_0n VSS) capacitor c=7.044E-15
    I_C1094 (p8_16 VSS) capacitor c=3.924E-15
    I_C1095 (I976_pn14 VSS) capacitor c=7.122E-15
    I_C1096 (I976_G13_0n VSS) capacitor c=4.531E-15
    I_C1097 (p9_14 VSS) capacitor c=6.346E-15
    I_C1098 (I976_pn13 VSS) capacitor c=8.690E-15
    I_C1099 (I976_G12_0n VSS) capacitor c=6.664E-15
    I_C1100 (p9_13 VSS) capacitor c=4.216E-15
    I_C1101 (I976_pn15 VSS) capacitor c=8.153E-15
    I_C1102 (I976_G14_0n VSS) capacitor c=6.264E-15
    I_C1103 (p9_15 VSS) capacitor c=4.266E-15
    I_C1104 (I1022_pn15 VSS) capacitor c=6.457E-15
    I_C1105 (I1022_G14_0n VSS) capacitor c=6.523E-15
    I_C1106 (p10_15 VSS) capacitor c=7.764E-15
    I_C1107 (I1022_pn16 VSS) capacitor c=8.939E-15
    I_C1108 (I1022_G15_0n VSS) capacitor c=4.782E-15
    I_C1109 (p10_16 VSS) capacitor c=6.025E-15
    I_C1110 (c11_o VSS) capacitor c=8.033E-15
    I_C1111 (p11_32 VSS) capacitor c=1.744E-15
    I_C1112 (qu21_b3_2 VSS) capacitor c=1.039E-14
    I_C1113 (b11_17 VSS) capacitor c=2.431E-15
    I_C1114 (b12_14 VSS) capacitor c=4.030E-15
    I_C1115 (b11_16 VSS) capacitor c=2.750E-15
    I_C1116 (I1068_pn16 VSS) capacitor c=6.992E-15
    I_C1117 (I1068_G15_0n VSS) capacitor c=8.538E-15
    I_C1118 (p11_16 VSS) capacitor c=3.487E-15
    I_C1119 (b12_18 VSS) capacitor c=2.607E-15
    I_C1120 (qu21_b3_3 VSS) capacitor c=9.063E-15
    I_C1121 (b11_20 VSS) capacitor c=2.939E-15
    I_C1122 (b11_18 VSS) capacitor c=2.514E-15
    I_C1123 (b12_19 VSS) capacitor c=2.214E-15
    I_C1124 (b11_22 VSS) capacitor c=2.546E-15
    I_C1125 (b11_21 VSS) capacitor c=2.319E-15
    I_C1126 (b11_23 VSS) capacitor c=2.464E-15
    I_C1127 (b12_26 VSS) capacitor c=2.610E-15
    I_C1128 (b11_31 VSS) capacitor c=2.033E-15
    I_C1129 (b12_27 VSS) capacitor c=2.234E-15
    I_C1130 (I1574_pn13 VSS) capacitor c=4.319E-15
    I_C1131 (I1574_G12_0n VSS) capacitor c=5.847E-15
    I_C1132 (p22_13 VSS) capacitor c=6.442E-15
    I_C1133 (I1574_pn14 VSS) capacitor c=6.621E-15
    I_C1134 (I1574_G13_0n VSS) capacitor c=4.145E-15
    I_C1135 (p22_14 VSS) capacitor c=3.683E-15
    I_C1136 (dd14_b3_4 VSS) capacitor c=3.553E-14
    I_C1137 (b22_14 VSS) capacitor c=4.712E-15
    I_C1138 (dd16_b3_4 VSS) capacitor c=3.094E-14
    I_C1139 (b22_16 VSS) capacitor c=5.216E-15
    I_C1140 (dd15_b3_4 VSS) capacitor c=3.321E-14
    I_C1141 (b22_15 VSS) capacitor c=5.842E-15
    I_C1142 (b23_16 VSS) capacitor c=2.430E-15
    I_C1143 (b23_15 VSS) capacitor c=1.746E-15
    I_C1144 (I1620_pn13 VSS) capacitor c=7.254E-15
    I_C1145 (I1620_G12_0n VSS) capacitor c=6.102E-15
    I_C1146 (p23_13 VSS) capacitor c=4.337E-15
    I_C1147 (I1620_pn14 VSS) capacitor c=7.104E-15
    I_C1148 (I1620_G13_0n VSS) capacitor c=4.757E-15
    I_C1149 (p23_14 VSS) capacitor c=3.074E-15
    I_C1150 (qu8_b3_2 VSS) capacitor c=8.573E-15
    I_C1151 (b24_17 VSS) capacitor c=2.535E-15
    I_C1152 (b24_16 VSS) capacitor c=3.247E-15
    I_C1153 (I1666_pn16 VSS) capacitor c=6.819E-15
    I_C1154 (I1666_G15_0n VSS) capacitor c=6.152E-15
    I_C1155 (p24_16 VSS) capacitor c=1.278E-14
    I_C1156 (I1666_pn14 VSS) capacitor c=8.605E-15
    I_C1157 (I1666_G13_0n VSS) capacitor c=3.559E-15
    I_C1158 (p24_14 VSS) capacitor c=1.806E-14
    I_C1159 (I1666_pn15 VSS) capacitor c=9.658E-15
    I_C1160 (I1666_G14_0n VSS) capacitor c=4.784E-15
    I_C1161 (p24_15 VSS) capacitor c=1.569E-14
    I_C1162 (I930_pn12 VSS) capacitor c=5.274E-15
    I_C1163 (I930_G11_0n VSS) capacitor c=5.271E-15
    I_C1164 (p8_12 VSS) capacitor c=6.756E-15
    I_C1165 (I930_pn13 VSS) capacitor c=5.134E-15
    I_C1166 (I930_G12_0n VSS) capacitor c=5.278E-15
    I_C1167 (p8_13 VSS) capacitor c=4.667E-15
    I_C1168 (dd17_b3_1 VSS) capacitor c=2.235E-14
    I_C1169 (qu24_b3_2 VSS) capacitor c=8.851E-15
    I_C1170 (b8_17 VSS) capacitor c=2.376E-15
    I_C1171 (dd16_b3_1 VSS) capacitor c=2.323E-14
    I_C1172 (qu23_b3_2 VSS) capacitor c=9.198E-15
    I_C1173 (b9_16 VSS) capacitor c=2.869E-15
    I_C1174 (I976_pn12 VSS) capacitor c=5.413E-15
    I_C1175 (I976_G11_0n VSS) capacitor c=7.235E-15
    I_C1176 (p9_12 VSS) capacitor c=6.666E-15
    I_C1177 (qu22_b3_2 VSS) capacitor c=8.230E-15
    I_C1178 (b10_17 VSS) capacitor c=3.263E-15
    I_C1179 (dd15_b3_1 VSS) capacitor c=2.087E-14
    I_C1180 (b10_15 VSS) capacitor c=2.399E-15
    I_C1181 (b10_16 VSS) capacitor c=2.853E-15
    I_C1182 (I1022_pn13 VSS) capacitor c=6.002E-15
    I_C1183 (I1022_G12_0n VSS) capacitor c=5.358E-15
    I_C1184 (p10_13 VSS) capacitor c=5.699E-15
    I_C1185 (I1022_pn14 VSS) capacitor c=8.310E-15
    I_C1186 (I1022_G13_0n VSS) capacitor c=4.229E-15
    I_C1187 (p10_14 VSS) capacitor c=3.927E-15
    I_C1188 (b11_13 VSS) capacitor c=2.405E-15
    I_C1189 (b11_14 VSS) capacitor c=2.410E-15
    I_C1190 (b11_15 VSS) capacitor c=2.222E-15
    I_C1191 (I1068_pn15 VSS) capacitor c=4.851E-15
    I_C1192 (I1068_G14_0n VSS) capacitor c=7.424E-15
    I_C1193 (p11_15 VSS) capacitor c=2.947E-15
    I_C1194 (b11_19 VSS) capacitor c=2.564E-15
    I_C1195 (qu21_b3_4 VSS) capacitor c=1.271E-14
    I_C1196 (b11_24 VSS) capacitor c=2.841E-15
    I_C1197 (b11_30 VSS) capacitor c=2.202E-15
    I_C1198 (I1574_pn12 VSS) capacitor c=5.569E-15
    I_C1199 (I1574_G11_0n VSS) capacitor c=4.462E-15
    I_C1200 (p22_12 VSS) capacitor c=3.861E-15
    I_C1201 (dd13_b3_4 VSS) capacitor c=3.100E-14
    I_C1202 (b22_13 VSS) capacitor c=4.429E-15
    I_C1203 (b23_14 VSS) capacitor c=2.307E-15
    I_C1204 (I1620_pn12 VSS) capacitor c=9.185E-15
    I_C1205 (I1620_G11_0n VSS) capacitor c=6.010E-15
    I_C1206 (p23_12 VSS) capacitor c=3.932E-15
    I_C1207 (b24_15 VSS) capacitor c=2.530E-15
    I_C1208 (b24_14 VSS) capacitor c=2.263E-15
    I_C1209 (b24_13 VSS) capacitor c=2.174E-15
    I_C1210 (I930_pn11 VSS) capacitor c=6.674E-15
    I_C1211 (I930_G10_0n VSS) capacitor c=3.622E-15
    I_C1212 (p8_11 VSS) capacitor c=5.934E-15
    I_C1213 (b8_16 VSS) capacitor c=2.110E-15
    I_C1214 (dd14_b3_1 VSS) capacitor c=2.227E-14
    I_C1215 (b8_14 VSS) capacitor c=3.630E-15
    I_C1216 (b8_15 VSS) capacitor c=2.540E-15
    I_C1217 (b9_15 VSS) capacitor c=3.162E-15
    I_C1218 (b9_17 VSS) capacitor c=2.984E-15
    I_C1219 (b9_14 VSS) capacitor c=2.464E-15
    I_C1220 (dd13_b3_1 VSS) capacitor c=2.871E-14
    I_C1221 (b9_13 VSS) capacitor c=2.859E-15
    I_C1222 (I976_pn11 VSS) capacitor c=7.630E-15
    I_C1223 (I976_G10_0n VSS) capacitor c=6.875E-15
    I_C1224 (p9_11 VSS) capacitor c=3.562E-15
    I_C1225 (b10_13 VSS) capacitor c=2.900E-15
    I_C1226 (b10_14 VSS) capacitor c=2.583E-15
    I_C1227 (I1022_pn11 VSS) capacitor c=6.635E-15
    I_C1228 (I1022_G10_0n VSS) capacitor c=5.306E-15
    I_C1229 (p10_11 VSS) capacitor c=5.262E-15
    I_C1230 (I1022_pn12 VSS) capacitor c=8.879E-15
    I_C1231 (I1022_G11_0n VSS) capacitor c=4.409E-15
    I_C1232 (p10_12 VSS) capacitor c=4.212E-15
    I_C1233 (b11_12 VSS) capacitor c=2.510E-15
    I_C1234 (I1068_pn13 VSS) capacitor c=5.061E-15
    I_C1235 (I1068_G12_0n VSS) capacitor c=4.899E-15
    I_C1236 (p11_13 VSS) capacitor c=3.799E-15
    I_C1237 (I1068_pn14 VSS) capacitor c=5.215E-15
    I_C1238 (I1068_G13_0n VSS) capacitor c=8.760E-15
    I_C1239 (p11_14 VSS) capacitor c=4.982E-15
    I_C1240 (b11_25 VSS) capacitor c=2.054E-15
    I_C1241 (b11_29 VSS) capacitor c=2.368E-15
    I_C1242 (I1574_pn11 VSS) capacitor c=4.214E-15
    I_C1243 (I1574_G10_0n VSS) capacitor c=4.391E-15
    I_C1244 (p22_11 VSS) capacitor c=6.625E-15
    I_C1245 (I1574_pn10 VSS) capacitor c=6.455E-15
    I_C1246 (I1574_G9_0n VSS) capacitor c=5.564E-15
    I_C1247 (p22_10 VSS) capacitor c=3.162E-15
    I_C1248 (dd12_b3_4 VSS) capacitor c=3.612E-14
    I_C1249 (b22_12 VSS) capacitor c=3.704E-15
    I_C1250 (dd11_b3_4 VSS) capacitor c=2.722E-14
    I_C1251 (qu10_b3_1 VSS) capacitor c=9.566E-15
    I_C1252 (b22_11 VSS) capacitor c=5.672E-15
    I_C1253 (b23_12 VSS) capacitor c=2.361E-15
    I_C1254 (b23_13 VSS) capacitor c=2.485E-15
    I_C1255 (I1620_pn11 VSS) capacitor c=6.237E-15
    I_C1256 (I1620_G10_0n VSS) capacitor c=5.740E-15
    I_C1257 (p23_11 VSS) capacitor c=5.437E-15
    I_C1258 (I1620_pn10 VSS) capacitor c=1.110E-14
    I_C1259 (I1620_G9_0n VSS) capacitor c=5.871E-15
    I_C1260 (p23_10 VSS) capacitor c=3.339E-15
    I_C1261 (b24_12 VSS) capacitor c=2.822E-15
    I_C1262 (I1666_pn12 VSS) capacitor c=7.402E-15
    I_C1263 (I1666_G11_0n VSS) capacitor c=5.781E-15
    I_C1264 (p24_12 VSS) capacitor c=1.027E-14
    I_C1265 (I1666_pn11 VSS) capacitor c=7.557E-15
    I_C1266 (I1666_G10_0n VSS) capacitor c=2.957E-15
    I_C1267 (p24_11 VSS) capacitor c=1.807E-14
    I_C1268 (I1666_pn13 VSS) capacitor c=6.461E-15
    I_C1269 (I1666_G12_0n VSS) capacitor c=4.455E-15
    I_C1270 (p24_13 VSS) capacitor c=1.257E-14
    I_C1271 (I930_pn10 VSS) capacitor c=4.349E-15
    I_C1272 (I930_G9_0n VSS) capacitor c=4.987E-15
    I_C1273 (p8_10 VSS) capacitor c=6.597E-15
    I_C1274 (h8 VSS) capacitor c=3.083E-15
    I_C1275 (c8_o VSS) capacitor c=7.784E-15
    I_C1276 (p8_32 VSS) capacitor c=1.601E-15
    I_C1277 (b8_13 VSS) capacitor c=5.132E-15
    I_C1278 (dd12_b3_1 VSS) capacitor c=3.041E-14
    I_C1279 (b9_12 VSS) capacitor c=2.586E-15
    I_C1280 (I976_pn10 VSS) capacitor c=8.815E-15
    I_C1281 (I976_G9_0n VSS) capacitor c=5.485E-15
    I_C1282 (p9_10 VSS) capacitor c=4.889E-15
    I_C1283 (I976_pn9 VSS) capacitor c=7.328E-15
    I_C1284 (I976_G8_0n VSS) capacitor c=7.412E-15
    I_C1285 (p9_9 VSS) capacitor c=3.516E-15
    I_C1286 (b10_12 VSS) capacitor c=2.907E-15
    I_C1287 (I1022_pn10 VSS) capacitor c=7.397E-15
    I_C1288 (I1022_G9_0n VSS) capacitor c=3.418E-15
    I_C1289 (p10_10 VSS) capacitor c=4.066E-15
    I_C1290 (qu21_b3_1 VSS) capacitor c=1.042E-14
    I_C1291 (b11_11 VSS) capacitor c=2.582E-15
    I_C1292 (b11_9 VSS) capacitor c=3.205E-15
    I_C1293 (I1068_pn9 VSS) capacitor c=6.814E-15
    I_C1294 (I1068_G8_0n VSS) capacitor c=3.497E-15
    I_C1295 (p11_9 VSS) capacitor c=4.742E-15
    I_C1296 (I1068_pn12 VSS) capacitor c=5.210E-15
    I_C1297 (I1068_G11_0n VSS) capacitor c=7.235E-15
    I_C1298 (p11_12 VSS) capacitor c=4.168E-15
    I_C1299 (I1574_pn9 VSS) capacitor c=4.140E-15
    I_C1300 (I1574_G8_0n VSS) capacitor c=4.935E-15
    I_C1301 (p22_9 VSS) capacitor c=5.881E-15
    I_C1302 (dd9_b3_4 VSS) capacitor c=3.041E-14
    I_C1303 (b22_9 VSS) capacitor c=4.391E-15
    I_C1304 (dd10_b3_4 VSS) capacitor c=3.134E-14
    I_C1305 (b22_10 VSS) capacitor c=4.679E-15
    I_C1306 (qu9_b3_1 VSS) capacitor c=8.878E-15
    I_C1307 (b23_10 VSS) capacitor c=2.490E-15
    I_C1308 (b23_11 VSS) capacitor c=2.487E-15
    I_C1309 (b23_9 VSS) capacitor c=2.426E-15
    I_C1310 (I1620_pn9 VSS) capacitor c=7.152E-15
    I_C1311 (I1620_G8_0n VSS) capacitor c=3.779E-15
    I_C1312 (p23_9 VSS) capacitor c=5.272E-15
    I_C1313 (qu8_b3_1 VSS) capacitor c=1.008E-14
    I_C1314 (b24_11 VSS) capacitor c=2.610E-15
    I_C1315 (b24_10 VSS) capacitor c=2.527E-15
    I_C1316 (b24_9 VSS) capacitor c=2.180E-15
    I_C1317 (I1666_pn10 VSS) capacitor c=5.415E-15
    I_C1318 (I1666_G9_0n VSS) capacitor c=3.715E-15
    I_C1319 (p24_10 VSS) capacitor c=9.504E-15
    I_C1320 (I930_pn9 VSS) capacitor c=7.150E-15
    I_C1321 (I930_G8_0n VSS) capacitor c=3.288E-15
    I_C1322 (p8_9 VSS) capacitor c=3.783E-15
    I_C1323 (b8_12 VSS) capacitor c=5.456E-15
    I_C1324 (dd11_b3_1 VSS) capacitor c=2.655E-14
    I_C1325 (qu23_b3_1 VSS) capacitor c=8.685E-15
    I_C1326 (b9_11 VSS) capacitor c=2.851E-15
    I_C1327 (dd9_b3_1 VSS) capacitor c=2.497E-14
    I_C1328 (b9_9 VSS) capacitor c=2.659E-15
    I_C1329 (qu22_b3_1 VSS) capacitor c=9.250E-15
    I_C1330 (b10_11 VSS) capacitor c=2.689E-15
    I_C1331 (I1022_pn9 VSS) capacitor c=5.856E-15
    I_C1332 (I1022_G8_0n VSS) capacitor c=3.132E-15
    I_C1333 (p10_9 VSS) capacitor c=4.305E-15
    I_C1334 (b11_10 VSS) capacitor c=2.473E-15
    I_C1335 (dd7_b3_4 VSS) capacitor c=3.476E-14
    I_C1336 (b22_7 VSS) capacitor c=4.251E-15
    I_C1337 (dd8_b3_4 VSS) capacitor c=2.836E-14
    I_C1338 (b22_8 VSS) capacitor c=3.494E-15
    I_C1339 (b23_7 VSS) capacitor c=2.602E-15
    I_C1340 (b23_8 VSS) capacitor c=3.219E-15
    I_C1341 (b24_8 VSS) capacitor c=2.364E-15
    I_C1342 (b24_7 VSS) capacitor c=2.326E-15
    I_C1343 (dd10_b3_1 VSS) capacitor c=2.291E-14
    I_C1344 (qu24_b3_1 VSS) capacitor c=9.032E-15
    I_C1345 (b8_10 VSS) capacitor c=5.173E-15
    I_C1346 (p7_31 VSS) capacitor c=2.695E-15
    I_C1347 (b8_11 VSS) capacitor c=5.246E-15
    I_C1348 (b8_9 VSS) capacitor c=5.434E-15
    I_C1349 (b9_10 VSS) capacitor c=2.548E-15
    I_C1350 (dd8_b3_1 VSS) capacitor c=2.500E-14
    I_C1351 (b9_8 VSS) capacitor c=2.376E-15
    I_C1352 (dd7_b3_1 VSS) capacitor c=2.699E-14
    I_C1353 (b9_7 VSS) capacitor c=2.178E-15
    I_C1354 (I976_pn4 VSS) capacitor c=4.756E-15
    I_C1355 (I976_G3_0n VSS) capacitor c=1.041E-14
    I_C1356 (p9_4 VSS) capacitor c=5.512E-15
    I_C1357 (b10_8 VSS) capacitor c=2.854E-15
    I_C1358 (b10_10 VSS) capacitor c=2.953E-15
    I_C1359 (b10_7 VSS) capacitor c=2.682E-15
    I_C1360 (b10_9 VSS) capacitor c=2.353E-15
    I_C1361 (I1068_pn11 VSS) capacitor c=6.308E-15
    I_C1362 (I1068_G10_0n VSS) capacitor c=4.667E-15
    I_C1363 (p11_11 VSS) capacitor c=6.889E-15
    I_C1364 (b11_28 VSS) capacitor c=2.575E-15
    I_C1365 (I1574_pn4 VSS) capacitor c=4.754E-15
    I_C1366 (I1574_G3_0n VSS) capacitor c=6.273E-15
    I_C1367 (p22_4 VSS) capacitor c=6.310E-15
    I_C1368 (dd6_b3_4 VSS) capacitor c=2.867E-14
    I_C1369 (b22_6 VSS) capacitor c=5.023E-15
    I_C1370 (b23_6 VSS) capacitor c=2.417E-15
    I_C1371 (I1620_pn3 VSS) capacitor c=5.264E-15
    I_C1372 (I1620_G2_0n VSS) capacitor c=7.170E-15
    I_C1373 (p23_3 VSS) capacitor c=4.180E-15
    I_C1374 (I1620_pn4 VSS) capacitor c=7.110E-15
    I_C1375 (I1620_G3_0n VSS) capacitor c=6.405E-15
    I_C1376 (p23_4 VSS) capacitor c=3.691E-15
    I_C1377 (b24_6 VSS) capacitor c=2.719E-15
    I_C1378 (I1666_pn4 VSS) capacitor c=7.031E-15
    I_C1379 (I1666_G3_0n VSS) capacitor c=5.239E-15
    I_C1380 (p24_4 VSS) capacitor c=1.240E-14
    I_C1381 (I1666_pn9 VSS) capacitor c=9.395E-15
    I_C1382 (I1666_G8_0n VSS) capacitor c=2.930E-15
    I_C1383 (p24_9 VSS) capacitor c=1.230E-14
    I_C1384 (I930_pn4 VSS) capacitor c=4.162E-15
    I_C1385 (I930_G3_0n VSS) capacitor c=9.104E-15
    I_C1386 (p8_4 VSS) capacitor c=9.126E-15
    I_C1387 (I930_pn3 VSS) capacitor c=3.914E-15
    I_C1388 (I930_G2_0n VSS) capacitor c=7.395E-15
    I_C1389 (p8_3 VSS) capacitor c=5.701E-15
    I_C1390 (b8_8 VSS) capacitor c=5.983E-15
    I_C1391 (dd6_b3_1 VSS) capacitor c=2.524E-14
    I_C1392 (b8_6 VSS) capacitor c=6.316E-15
    I_C1393 (b8_7 VSS) capacitor c=6.400E-15
    I_C1394 (b9_6 VSS) capacitor c=2.342E-15
    I_C1395 (I976_pn3 VSS) capacitor c=6.509E-15
    I_C1396 (I976_G2_0n VSS) capacitor c=8.141E-15
    I_C1397 (p9_3 VSS) capacitor c=4.036E-15
    I_C1398 (dd3_b3_1 VSS) capacitor c=2.520E-14
    I_C1399 (qu22_b3_0 VSS) capacitor c=9.904E-15
    I_C1400 (b10_3 VSS) capacitor c=4.118E-15
    I_C1401 (dd4_b3_1 VSS) capacitor c=3.011E-14
    I_C1402 (b10_4 VSS) capacitor c=3.006E-15
    I_C1403 (b10_6 VSS) capacitor c=2.754E-15
    I_C1404 (I1022_pn3 VSS) capacitor c=5.879E-15
    I_C1405 (I1022_G2_0n VSS) capacitor c=7.485E-15
    I_C1406 (p10_3 VSS) capacitor c=5.452E-15
    I_C1407 (b11_1 VSS) capacitor c=2.535E-15
    I_C1408 (I1022_pn4 VSS) capacitor c=7.768E-15
    I_C1409 (I1022_G3_0n VSS) capacitor c=5.544E-15
    I_C1410 (p10_4 VSS) capacitor c=3.904E-15
    I_C1411 (b11_7 VSS) capacitor c=2.933E-15
    I_C1412 (b11_26 VSS) capacitor c=2.300E-15
    I_C1413 (b11_27 VSS) capacitor c=2.171E-15
    I_C1414 (dd4_b3_4 VSS) capacitor c=3.041E-14
    I_C1415 (qu10_b3_0 VSS) capacitor c=1.192E-14
    I_C1416 (b22_4 VSS) capacitor c=3.512E-15
    I_C1417 (dd5_b3_4 VSS) capacitor c=2.736E-14
    I_C1418 (b22_5 VSS) capacitor c=5.280E-15
    I_C1419 (b22_0 VSS) capacitor c=2.278E-15
    I_C1420 (qu9_b3_0 VSS) capacitor c=9.583E-15
    I_C1421 (b23_4 VSS) capacitor c=2.068E-15
    I_C1422 (b23_5 VSS) capacitor c=2.408E-15
    I_C1423 (dd1_b3_4 VSS) capacitor c=2.876E-14
    I_C1424 (b23_1 VSS) capacitor c=2.042E-15
    I_C1425 (dd3_b3_4 VSS) capacitor c=3.023E-14
    I_C1426 (qu8_b3_0 VSS) capacitor c=1.048E-14
    I_C1427 (b24_3 VSS) capacitor c=2.264E-15
    I_C1428 (b24_4 VSS) capacitor c=2.554E-15
    I_C1429 (b24_5 VSS) capacitor c=2.440E-15
    I_C1430 (I1666_pn3 VSS) capacitor c=7.405E-15
    I_C1431 (I1666_G2_0n VSS) capacitor c=6.560E-15
    I_C1432 (p24_3 VSS) capacitor c=1.025E-14
    I_C1433 (qu7_b3_4 VSS) capacitor c=1.031E-14
    I_C1434 (b25_27 VSS) capacitor c=2.639E-15
    I_C1435 (b25_25 VSS) capacitor c=2.609E-15
    I_C1436 (b25_24 VSS) capacitor c=2.494E-15
    I_C1437 (qu24_b3_0 VSS) capacitor c=1.068E-14
    I_C1438 (b8_3 VSS) capacitor c=3.801E-15
    I_C1439 (dd2_b3_1 VSS) capacitor c=2.525E-14
    I_C1440 (b8_2 VSS) capacitor c=2.688E-15
    I_C1441 (dd5_b3_1 VSS) capacitor c=2.667E-14
    I_C1442 (b8_5 VSS) capacitor c=6.382E-15
    I_C1443 (b8_4 VSS) capacitor c=5.055E-15
    I_C1444 (dd1_b3_1 VSS) capacitor c=2.605E-14
    I_C1445 (b8_1 VSS) capacitor c=1.798E-15
    I_C1446 (qu23_b3_0 VSS) capacitor c=1.294E-14
    I_C1447 (b9_5 VSS) capacitor c=2.277E-15
    I_C1448 (b9_4 VSS) capacitor c=2.778E-15
    I_C1449 (b9_3 VSS) capacitor c=2.270E-15
    I_C1450 (b9_2 VSS) capacitor c=2.251E-15
    I_C1451 (b9_1 VSS) capacitor c=1.856E-15
    I_C1452 (B_0_b3_1 VSS) capacitor c=3.015E-14
    I_C1453 (b9_0 VSS) capacitor c=4.705E-15
    I_C1454 (b10_2 VSS) capacitor c=3.970E-15
    I_C1455 (b10_5 VSS) capacitor c=3.652E-15
    I_C1456 (b11_2 VSS) capacitor c=2.852E-15
    I_C1457 (I1068_pn3 VSS) capacitor c=4.351E-15
    I_C1458 (I1068_G2_0n VSS) capacitor c=6.817E-15
    I_C1459 (p11_3 VSS) capacitor c=9.481E-15
    I_C1460 (b11_8 VSS) capacitor c=1.923E-15
    I_C1461 (I1068_pn10 VSS) capacitor c=7.001E-15
    I_C1462 (I1068_G9_0n VSS) capacitor c=7.292E-15
    I_C1463 (p11_10 VSS) capacitor c=6.998E-15
    I_C1464 (qu5_b3_4 VSS) capacitor c=8.732E-15
    I_C1465 (b27_26 VSS) capacitor c=2.729E-15
    I_C1466 (b27_25 VSS) capacitor c=2.878E-15
    I_C1467 (I1574_pn3 VSS) capacitor c=5.130E-15
    I_C1468 (I1574_G2_0n VSS) capacitor c=6.407E-15
    I_C1469 (p22_3 VSS) capacitor c=8.991E-15
    I_C1470 (b27_29 VSS) capacitor c=2.692E-15
    I_C1471 (dd2_b3_4 VSS) capacitor c=2.908E-14
    I_C1472 (b22_2 VSS) capacitor c=3.615E-15
    I_C1473 (b22_1 VSS) capacitor c=3.523E-15
    I_C1474 (b22_3 VSS) capacitor c=4.795E-15
    I_C1475 (b23_3 VSS) capacitor c=2.997E-15
    I_C1476 (b23_2 VSS) capacitor c=2.223E-15
    I_C1477 (qu6_b3_4 VSS) capacitor c=1.087E-14
    I_C1478 (b26_29 VSS) capacitor c=2.307E-15
    I_C1479 (B_0_b3_4 VSS) capacitor c=1.987E-14
    I_C1480 (b23_0 VSS) capacitor c=2.379E-15
    I_C1481 (b26_28 VSS) capacitor c=2.628E-15
    I_C1482 (b26_27 VSS) capacitor c=2.720E-15
    I_C1483 (b26_26 VSS) capacitor c=3.455E-15
    I_C1484 (b26_25 VSS) capacitor c=2.873E-15
    I_C1485 (b24_0 VSS) capacitor c=2.430E-15
    I_C1486 (b24_2 VSS) capacitor c=2.886E-15
    I_C1487 (b24_1 VSS) capacitor c=2.603E-15
    I_C1488 (qu7_b3_5 VSS) capacitor c=2.489E-14
    I_C1489 (b25_31 VSS) capacitor c=3.798E-15
    I_C1490 (b25_30 VSS) capacitor c=4.373E-15
    I_C1491 (b25_29 VSS) capacitor c=2.083E-15
    I_C1492 (qu7_b3_3 VSS) capacitor c=9.705E-15
    I_C1493 (b25_23 VSS) capacitor c=2.700E-15
    I_C1494 (b25_28 VSS) capacitor c=1.935E-15
    I_C1495 (b25_26 VSS) capacitor c=2.144E-15
    I_C1496 (qu25_b3_4 VSS) capacitor c=1.072E-14
    I_C1497 (b7_27 VSS) capacitor c=2.664E-15
    I_C1498 (b7_28 VSS) capacitor c=2.806E-15
    I_C1499 (b7_25 VSS) capacitor c=2.998E-15
    I_C1500 (b7_29 VSS) capacitor c=1.772E-15
    I_C1501 (b8_0 VSS) capacitor c=2.820E-15
    I_C1502 (qu25_b3_5 VSS) capacitor c=2.013E-14
    I_C1503 (b7_31 VSS) capacitor c=2.696E-15
    I_C1504 (qu26_b3_4 VSS) capacitor c=9.473E-15
    I_C1505 (b6_25 VSS) capacitor c=4.079E-15
    I_C1506 (b10_1 VSS) capacitor c=4.432E-15
    I_C1507 (b6_27 VSS) capacitor c=3.402E-15
    I_C1508 (b10_0 VSS) capacitor c=4.572E-15
    I_C1509 (b6_28 VSS) capacitor c=2.814E-15
    I_C1510 (b11_3 VSS) capacitor c=2.092E-15
    I_C1511 (b11_6 VSS) capacitor c=2.392E-15
    I_C1512 (I1068_pn4 VSS) capacitor c=4.817E-15
    I_C1513 (I1068_G3_0n VSS) capacitor c=7.526E-15
    I_C1514 (p11_4 VSS) capacitor c=7.881E-15
    I_C1515 (b27_27 VSS) capacitor c=2.216E-15
    I_C1516 (b27_28 VSS) capacitor c=2.806E-15
    I_C1517 (b27_24 VSS) capacitor c=2.785E-15
    I_C1518 (qu5_b3_5 VSS) capacitor c=1.786E-14
    I_C1519 (b27_30 VSS) capacitor c=2.226E-15
    I_C1520 (qu5_b3_3 VSS) capacitor c=8.917E-15
    I_C1521 (b27_23 VSS) capacitor c=2.773E-15
    I_C1522 (b27_31 VSS) capacitor c=2.512E-15
    I_C1523 (qu6_b3_5 VSS) capacitor c=1.949E-14
    I_C1524 (b26_31 VSS) capacitor c=1.953E-15
    I_C1525 (b26_30 VSS) capacitor c=2.065E-15
    I_C1526 (b26_24 VSS) capacitor c=3.259E-15
    I_C1527 (qu6_b3_3 VSS) capacitor c=1.017E-14
    I_C1528 (b26_23 VSS) capacitor c=3.038E-15
    I_C1529 (p24_31 VSS) capacitor c=7.235E-15
    I_C1530 (h25 VSS) capacitor c=2.013E-15
    I_C1531 (b25_21 VSS) capacitor c=1.820E-15
    I_C1532 (b25_22 VSS) capacitor c=2.955E-15
    I_C1533 (b25_20 VSS) capacitor c=2.328E-15
    I_C1534 (b7_26 VSS) capacitor c=2.215E-15
    I_C1535 (b7_24 VSS) capacitor c=3.169E-15
    I_C1536 (h7 VSS) capacitor c=3.487E-15
    I_C1537 (c7_o VSS) capacitor c=5.073E-15
    I_C1538 (p7_32 VSS) capacitor c=2.431E-15
    I_C1539 (qu25_b3_3 VSS) capacitor c=9.272E-15
    I_C1540 (b7_22 VSS) capacitor c=3.033E-15
    I_C1541 (b7_30 VSS) capacitor c=2.111E-15
    I_C1542 (qu26_b3_3 VSS) capacitor c=1.059E-14
    I_C1543 (b6_21 VSS) capacitor c=3.191E-15
    I_C1544 (b6_22 VSS) capacitor c=4.549E-15
    I_C1545 (b6_23 VSS) capacitor c=2.727E-15
    I_C1546 (b6_24 VSS) capacitor c=4.116E-15
    I_C1547 (b6_26 VSS) capacitor c=2.450E-15
    I_C1548 (b6_29 VSS) capacitor c=2.523E-15
    I_C1549 (qu26_b3_5 VSS) capacitor c=2.207E-14
    I_C1550 (b6_30 VSS) capacitor c=2.381E-15
    I_C1551 (b6_31 VSS) capacitor c=3.686E-15
    I_C1552 (b11_4 VSS) capacitor c=2.345E-15
    I_C1553 (b11_5 VSS) capacitor c=1.863E-15
    I_C1554 (b27_22 VSS) capacitor c=2.046E-15
    I_C1555 (b27_18 VSS) capacitor c=3.610E-15
    I_C1556 (b27_21 VSS) capacitor c=2.727E-15
    I_C1557 (p25_31 VSS) capacitor c=1.022E-14
    I_C1558 (h26 VSS) capacitor c=1.643E-15
    I_C1559 (c26_o VSS) capacitor c=2.334E-15
    I_C1560 (p26_32 VSS) capacitor c=1.493E-15
    I_C1561 (b26_18 VSS) capacitor c=3.803E-15
    I_C1562 (b26_21 VSS) capacitor c=3.425E-15
    I_C1563 (b26_22 VSS) capacitor c=3.040E-15
    I_C1564 (c25_o VSS) capacitor c=2.937E-15
    I_C1565 (p25_32 VSS) capacitor c=1.747E-15
    I_C1566 (b25_19 VSS) capacitor c=2.176E-15
    I_C1567 (b25_18 VSS) capacitor c=2.947E-15
    I_C1568 (I884_pn16 VSS) capacitor c=5.950E-15
    I_C1569 (I884_G15_0n VSS) capacitor c=7.041E-15
    I_C1570 (p7_16 VSS) capacitor c=7.568E-15
    I_C1571 (b7_18 VSS) capacitor c=3.729E-15
    I_C1572 (b7_23 VSS) capacitor c=3.114E-15
    I_C1573 (b7_19 VSS) capacitor c=3.271E-15
    I_C1574 (b7_21 VSS) capacitor c=3.377E-15
    I_C1575 (p6_31 VSS) capacitor c=2.053E-15
    I_C1576 (b6_18 VSS) capacitor c=8.644E-15
    I_C1577 (b6_19 VSS) capacitor c=3.518E-15
    I_C1578 (h5 VSS) capacitor c=4.473E-15
    I_C1579 (c5_o VSS) capacitor c=2.008E-15
    I_C1580 (p5_32 VSS) capacitor c=1.572E-15
    I_C1581 (b27_20 VSS) capacitor c=2.773E-15
    I_C1582 (h27 VSS) capacitor c=1.949E-15
    I_C1583 (c27_o VSS) capacitor c=2.504E-15
    I_C1584 (p27_32 VSS) capacitor c=1.595E-15
    I_C1585 (b27_19 VSS) capacitor c=3.183E-15
    I_C1586 (p26_31 VSS) capacitor c=3.145E-15
    I_C1587 (b26_19 VSS) capacitor c=2.736E-15
    I_C1588 (b26_20 VSS) capacitor c=2.581E-15
    I_C1589 (b7_20 VSS) capacitor c=3.063E-15
    I_C1590 (b6_20 VSS) capacitor c=3.060E-15
    I_C1591 (p5_31 VSS) capacitor c=3.060E-15
    I_C1592 (h6 VSS) capacitor c=1.815E-15
    I_C1593 (dd28_b3_0 VSS) capacitor c=5.101E-14
    I_C1594 (qu27_b3_4 VSS) capacitor c=9.918E-15
    I_C1595 (b5_28 VSS) capacitor c=2.144E-15
    I_C1596 (dd29_b3_0 VSS) capacitor c=4.164E-14
    I_C1597 (b5_29 VSS) capacitor c=2.533E-15
    I_C1598 (p4_31 VSS) capacitor c=1.765E-15
    I_C1599 (qu27_b3_5 VSS) capacitor c=2.017E-14
    I_C1600 (qu28_b3_4 VSS) capacitor c=1.026E-14
    I_C1601 (b4_28 VSS) capacitor c=2.701E-15
    I_C1602 (b4_29 VSS) capacitor c=2.564E-15
    I_C1603 (I884_pn14 VSS) capacitor c=5.223E-15
    I_C1604 (I884_G13_0n VSS) capacitor c=7.465E-15
    I_C1605 (p7_14 VSS) capacitor c=7.893E-15
    I_C1606 (I884_pn15 VSS) capacitor c=5.840E-15
    I_C1607 (I884_G14_0n VSS) capacitor c=4.585E-15
    I_C1608 (p7_15 VSS) capacitor c=7.210E-15
    I_C1609 (c6_o VSS) capacitor c=3.155E-15
    I_C1610 (p6_32 VSS) capacitor c=5.820E-15
    I_C1611 (dd30_b3_0 VSS) capacitor c=4.492E-14
    I_C1612 (b5_30 VSS) capacitor c=2.240E-15
    I_C1613 (dd31_b3_0 VSS) capacitor c=5.495E-14
    I_C1614 (b5_31 VSS) capacitor c=2.215E-15
    I_C1615 (qu28_b3_5 VSS) capacitor c=2.075E-14
    I_C1616 (b4_30 VSS) capacitor c=3.015E-15
    I_C1617 (qu5_b3_2 VSS) capacitor c=1.091E-14
    I_C1618 (b27_16 VSS) capacitor c=2.644E-15
    I_C1619 (b27_17 VSS) capacitor c=2.561E-15
    I_C1620 (qu6_b3_2 VSS) capacitor c=9.769E-15
    I_C1621 (b26_17 VSS) capacitor c=2.042E-15
    I_C1622 (b26_16 VSS) capacitor c=2.617E-15
    I_C1623 (I1712_pn16 VSS) capacitor c=8.861E-15
    I_C1624 (I1712_G15_0n VSS) capacitor c=3.614E-15
    I_C1625 (p25_16 VSS) capacitor c=3.280E-15
    I_C1626 (qu7_b3_2 VSS) capacitor c=9.044E-15
    I_C1627 (b25_17 VSS) capacitor c=2.245E-15
    I_C1628 (b25_16 VSS) capacitor c=2.210E-15
    I_C1629 (I884_pn12 VSS) capacitor c=9.429E-15
    I_C1630 (I884_G11_0n VSS) capacitor c=2.938E-15
    I_C1631 (p7_12 VSS) capacitor c=1.261E-14
    I_C1632 (qu25_b3_2 VSS) capacitor c=9.034E-15
    I_C1633 (b7_17 VSS) capacitor c=2.340E-15
    I_C1634 (qu26_b3_2 VSS) capacitor c=1.059E-14
    I_C1635 (b6_16 VSS) capacitor c=2.382E-15
    I_C1636 (b6_17 VSS) capacitor c=2.066E-15
    I_C1637 (I792_pn16 VSS) capacitor c=7.913E-15
    I_C1638 (I792_G15_0n VSS) capacitor c=3.956E-15
    I_C1639 (p5_16 VSS) capacitor c=7.181E-15
    I_C1640 (dd26_b3_0 VSS) capacitor c=5.080E-14
    I_C1641 (b5_26 VSS) capacitor c=2.087E-15
    I_C1642 (dd27_b3_0 VSS) capacitor c=4.760E-14
    I_C1643 (b5_27 VSS) capacitor c=2.157E-15
    I_C1644 (b4_27 VSS) capacitor c=2.013E-15
    I_C1645 (b4_31 VSS) capacitor c=2.693E-15
    I_C1646 (b27_15 VSS) capacitor c=2.071E-15
    I_C1647 (I1758_pn16 VSS) capacitor c=9.347E-15
    I_C1648 (I1758_G15_0n VSS) capacitor c=4.337E-15
    I_C1649 (p26_16 VSS) capacitor c=3.247E-15
    I_C1650 (I1758_pn15 VSS) capacitor c=6.887E-15
    I_C1651 (I1758_G14_0n VSS) capacitor c=4.277E-15
    I_C1652 (p26_15 VSS) capacitor c=4.838E-15
    I_C1653 (b26_15 VSS) capacitor c=2.118E-15
    I_C1654 (b26_14 VSS) capacitor c=2.107E-15
    I_C1655 (I1712_pn14 VSS) capacitor c=6.250E-15
    I_C1656 (I1712_G13_0n VSS) capacitor c=4.694E-15
    I_C1657 (p25_14 VSS) capacitor c=4.109E-15
    I_C1658 (b25_14 VSS) capacitor c=2.537E-15
    I_C1659 (b25_15 VSS) capacitor c=2.095E-15
    I_C1660 (I1712_pn15 VSS) capacitor c=4.692E-15
    I_C1661 (I1712_G14_0n VSS) capacitor c=5.953E-15
    I_C1662 (p25_15 VSS) capacitor c=7.083E-15
    I_C1663 (I884_pn13 VSS) capacitor c=6.961E-15
    I_C1664 (I884_G12_0n VSS) capacitor c=4.317E-15
    I_C1665 (p7_13 VSS) capacitor c=1.440E-14
    I_C1666 (b7_16 VSS) capacitor c=2.288E-15
    I_C1667 (I838_pn16 VSS) capacitor c=8.906E-15
    I_C1668 (I838_G15_0n VSS) capacitor c=5.471E-15
    I_C1669 (p6_16 VSS) capacitor c=5.769E-15
    I_C1670 (I792_pn15 VSS) capacitor c=9.259E-15
    I_C1671 (I792_G14_0n VSS) capacitor c=4.150E-15
    I_C1672 (p5_15 VSS) capacitor c=3.425E-15
    I_C1673 (dd25_b3_0 VSS) capacitor c=4.409E-14
    I_C1674 (b5_25 VSS) capacitor c=1.916E-15
    I_C1675 (dd24_b3_0 VSS) capacitor c=4.101E-14
    I_C1676 (b5_24 VSS) capacitor c=2.654E-15
    I_C1677 (b4_26 VSS) capacitor c=2.127E-15
    I_C1678 (I1804_pn16 VSS) capacitor c=5.806E-15
    I_C1679 (I1804_G15_0n VSS) capacitor c=6.195E-15
    I_C1680 (p27_16 VSS) capacitor c=6.859E-15
    I_C1681 (b27_14 VSS) capacitor c=2.432E-15
    I_C1682 (b27_13 VSS) capacitor c=2.690E-15
    I_C1683 (I1758_pn14 VSS) capacitor c=8.579E-15
    I_C1684 (I1758_G13_0n VSS) capacitor c=4.895E-15
    I_C1685 (p26_14 VSS) capacitor c=3.441E-15
    I_C1686 (I1758_pn13 VSS) capacitor c=6.231E-15
    I_C1687 (I1758_G12_0n VSS) capacitor c=3.709E-15
    I_C1688 (p26_13 VSS) capacitor c=6.170E-15
    I_C1689 (b26_13 VSS) capacitor c=2.696E-15
    I_C1690 (I1712_pn12 VSS) capacitor c=5.918E-15
    I_C1691 (I1712_G11_0n VSS) capacitor c=3.866E-15
    I_C1692 (p25_12 VSS) capacitor c=4.937E-15
    I_C1693 (b25_13 VSS) capacitor c=1.762E-15
    I_C1694 (b25_12 VSS) capacitor c=2.404E-15
    I_C1695 (I1712_pn13 VSS) capacitor c=4.660E-15
    I_C1696 (I1712_G12_0n VSS) capacitor c=7.791E-15
    I_C1697 (p25_13 VSS) capacitor c=6.324E-15
    I_C1698 (b7_14 VSS) capacitor c=2.233E-15
    I_C1699 (b7_15 VSS) capacitor c=2.170E-15
    I_C1700 (I838_pn15 VSS) capacitor c=9.778E-15
    I_C1701 (I838_G14_0n VSS) capacitor c=3.189E-15
    I_C1702 (p6_15 VSS) capacitor c=4.090E-15
    I_C1703 (I838_pn14 VSS) capacitor c=6.562E-15
    I_C1704 (I838_G13_0n VSS) capacitor c=3.033E-15
    I_C1705 (p6_14 VSS) capacitor c=4.741E-15
    I_C1706 (b6_15 VSS) capacitor c=2.458E-15
    I_C1707 (b6_14 VSS) capacitor c=2.288E-15
    I_C1708 (I792_pn13 VSS) capacitor c=9.378E-15
    I_C1709 (I792_G12_0n VSS) capacitor c=3.180E-15
    I_C1710 (p5_13 VSS) capacitor c=2.855E-15
    I_C1711 (I792_pn14 VSS) capacitor c=6.258E-15
    I_C1712 (I792_G13_0n VSS) capacitor c=3.509E-15
    I_C1713 (p5_14 VSS) capacitor c=5.673E-15
    I_C1714 (b4_25 VSS) capacitor c=2.306E-15
    I_C1715 (b4_24 VSS) capacitor c=3.136E-15
    I_C1716 (I1804_pn14 VSS) capacitor c=5.328E-15
    I_C1717 (I1804_G13_0n VSS) capacitor c=4.319E-15
    I_C1718 (p27_14 VSS) capacitor c=8.731E-15
    I_C1719 (b27_12 VSS) capacitor c=2.288E-15
    I_C1720 (I1758_pn12 VSS) capacitor c=8.798E-15
    I_C1721 (I1758_G11_0n VSS) capacitor c=3.339E-15
    I_C1722 (p26_12 VSS) capacitor c=3.112E-15
    I_C1723 (qu5_b3_1 VSS) capacitor c=9.850E-15
    I_C1724 (b27_11 VSS) capacitor c=2.994E-15
    I_C1725 (b26_12 VSS) capacitor c=1.796E-15
    I_C1726 (qu7_b3_1 VSS) capacitor c=1.027E-14
    I_C1727 (b25_11 VSS) capacitor c=1.846E-15
    I_C1728 (I1712_pn11 VSS) capacitor c=4.729E-15
    I_C1729 (I1712_G10_0n VSS) capacitor c=5.646E-15
    I_C1730 (p25_11 VSS) capacitor c=6.862E-15
    I_C1731 (b7_13 VSS) capacitor c=2.183E-15
    I_C1732 (b7_12 VSS) capacitor c=2.326E-15
    I_C1733 (I838_pn13 VSS) capacitor c=9.459E-15
    I_C1734 (I838_G12_0n VSS) capacitor c=4.520E-15
    I_C1735 (p6_13 VSS) capacitor c=4.064E-15
    I_C1736 (b6_12 VSS) capacitor c=2.172E-15
    I_C1737 (b6_13 VSS) capacitor c=2.308E-15
    I_C1738 (I746_pn13 VSS) capacitor c=9.502E-15
    I_C1739 (I746_G12_0n VSS) capacitor c=5.883E-15
    I_C1740 (p4_13 VSS) capacitor c=5.880E-15
    I_C1741 (I746_pn15 VSS) capacitor c=9.837E-15
    I_C1742 (I746_G14_0n VSS) capacitor c=3.880E-15
    I_C1743 (p4_15 VSS) capacitor c=4.275E-15
    I_C1744 (I1804_pn15 VSS) capacitor c=9.902E-15
    I_C1745 (I1804_G14_0n VSS) capacitor c=4.911E-15
    I_C1746 (p27_15 VSS) capacitor c=6.643E-15
    I_C1747 (I1804_pn12 VSS) capacitor c=5.547E-15
    I_C1748 (I1804_G11_0n VSS) capacitor c=5.494E-15
    I_C1749 (p27_12 VSS) capacitor c=4.007E-15
    I_C1750 (b27_10 VSS) capacitor c=2.702E-15
    I_C1751 (b27_9 VSS) capacitor c=2.178E-15
    I_C1752 (I1758_pn10 VSS) capacitor c=6.915E-15
    I_C1753 (I1758_G9_0n VSS) capacitor c=2.964E-15
    I_C1754 (p26_10 VSS) capacitor c=3.724E-15
    I_C1755 (I1758_pn11 VSS) capacitor c=6.188E-15
    I_C1756 (I1758_G10_0n VSS) capacitor c=2.828E-15
    I_C1757 (p26_11 VSS) capacitor c=6.154E-15
    I_C1758 (qu6_b3_1 VSS) capacitor c=1.062E-14
    I_C1759 (b26_11 VSS) capacitor c=2.231E-15
    I_C1760 (b26_10 VSS) capacitor c=1.803E-15
    I_C1761 (I1712_pn10 VSS) capacitor c=6.647E-15
    I_C1762 (I1712_G9_0n VSS) capacitor c=3.861E-15
    I_C1763 (p25_10 VSS) capacitor c=3.338E-15
    I_C1764 (b25_9 VSS) capacitor c=1.925E-15
    I_C1765 (b25_10 VSS) capacitor c=2.324E-15
    I_C1766 (I884_pn11 VSS) capacitor c=5.867E-15
    I_C1767 (I884_G10_0n VSS) capacitor c=4.319E-15
    I_C1768 (p7_11 VSS) capacitor c=1.306E-14
    I_C1769 (I838_pn11 VSS) capacitor c=1.012E-14
    I_C1770 (I838_G10_0n VSS) capacitor c=4.268E-15
    I_C1771 (p6_11 VSS) capacitor c=2.417E-15
    I_C1772 (I838_pn12 VSS) capacitor c=6.864E-15
    I_C1773 (I838_G11_0n VSS) capacitor c=4.480E-15
    I_C1774 (p6_12 VSS) capacitor c=5.982E-15
    I_C1775 (I792_pn11 VSS) capacitor c=6.830E-15
    I_C1776 (I792_G10_0n VSS) capacitor c=4.767E-15
    I_C1777 (p5_11 VSS) capacitor c=2.874E-15
    I_C1778 (I792_pn12 VSS) capacitor c=5.573E-15
    I_C1779 (I792_G11_0n VSS) capacitor c=4.055E-15
    I_C1780 (p5_12 VSS) capacitor c=5.185E-15
    I_C1781 (I746_pn14 VSS) capacitor c=6.573E-15
    I_C1782 (I746_G13_0n VSS) capacitor c=4.055E-15
    I_C1783 (p4_14 VSS) capacitor c=5.283E-15
    I_C1784 (I1804_pn13 VSS) capacitor c=6.489E-15
    I_C1785 (I1804_G12_0n VSS) capacitor c=4.281E-15
    I_C1786 (p27_13 VSS) capacitor c=5.077E-15
    I_C1787 (b27_8 VSS) capacitor c=2.308E-15
    I_C1788 (b27_6 VSS) capacitor c=2.483E-15
    I_C1789 (b27_7 VSS) capacitor c=2.360E-15
    I_C1790 (I1758_pn9 VSS) capacitor c=6.073E-15
    I_C1791 (I1758_G8_0n VSS) capacitor c=3.350E-15
    I_C1792 (p26_9 VSS) capacitor c=6.401E-15
    I_C1793 (b26_9 VSS) capacitor c=2.144E-15
    I_C1794 (b25_7 VSS) capacitor c=1.923E-15
    I_C1795 (b25_8 VSS) capacitor c=2.179E-15
    I_C1796 (I1712_pn9 VSS) capacitor c=5.724E-15
    I_C1797 (I1712_G8_0n VSS) capacitor c=3.786E-15
    I_C1798 (p25_9 VSS) capacitor c=6.448E-15
    I_C1799 (I884_pn10 VSS) capacitor c=5.341E-15
    I_C1800 (I884_G9_0n VSS) capacitor c=3.641E-15
    I_C1801 (p7_10 VSS) capacitor c=7.729E-15
    I_C1802 (I884_pn9 VSS) capacitor c=6.725E-15
    I_C1803 (I884_G8_0n VSS) capacitor c=3.293E-15
    I_C1804 (p7_9 VSS) capacitor c=1.241E-14
    I_C1805 (qu25_b3_1 VSS) capacitor c=9.663E-15
    I_C1806 (b7_9 VSS) capacitor c=2.484E-15
    I_C1807 (b7_10 VSS) capacitor c=2.377E-15
    I_C1808 (b7_11 VSS) capacitor c=2.676E-15
    I_C1809 (I838_pn10 VSS) capacitor c=6.094E-15
    I_C1810 (I838_G9_0n VSS) capacitor c=3.679E-15
    I_C1811 (p6_10 VSS) capacitor c=5.691E-15
    I_C1812 (qu26_b3_1 VSS) capacitor c=9.731E-15
    I_C1813 (b6_10 VSS) capacitor c=1.879E-15
    I_C1814 (b6_11 VSS) capacitor c=2.191E-15
    I_C1815 (I792_pn10 VSS) capacitor c=5.743E-15
    I_C1816 (I792_G9_0n VSS) capacitor c=6.837E-15
    I_C1817 (p5_10 VSS) capacitor c=3.614E-15
    I_C1818 (I746_pn11 VSS) capacitor c=7.359E-15
    I_C1819 (I746_G10_0n VSS) capacitor c=5.810E-15
    I_C1820 (p4_11 VSS) capacitor c=4.657E-15
    I_C1821 (I746_pn12 VSS) capacitor c=4.706E-15
    I_C1822 (I746_G11_0n VSS) capacitor c=6.327E-15
    I_C1823 (p4_12 VSS) capacitor c=5.617E-15
    I_C1824 (I746_pn16 VSS) capacitor c=5.946E-15
    I_C1825 (I746_G15_0n VSS) capacitor c=4.879E-15
    I_C1826 (p4_16 VSS) capacitor c=9.256E-15
    I_C1827 (dd31_b3_5 VSS) capacitor c=3.739E-14
    I_C1828 (qu4_b3_5 VSS) capacitor c=1.897E-14
    I_C1829 (b28_31 VSS) capacitor c=2.176E-15
    I_C1830 (p27_31 VSS) capacitor c=3.708E-15
    I_C1831 (h28 VSS) capacitor c=1.077E-14
    I_C1832 (I1804_pn11 VSS) capacitor c=5.880E-15
    I_C1833 (I1804_G10_0n VSS) capacitor c=5.693E-15
    I_C1834 (p27_11 VSS) capacitor c=6.084E-15
    I_C1835 (I1804_pn10 VSS) capacitor c=4.529E-15
    I_C1836 (I1804_G9_0n VSS) capacitor c=7.984E-15
    I_C1837 (p27_10 VSS) capacitor c=5.959E-15
    I_C1838 (b26_7 VSS) capacitor c=1.870E-15
    I_C1839 (b26_6 VSS) capacitor c=2.931E-15
    I_C1840 (b26_8 VSS) capacitor c=2.869E-15
    I_C1841 (qu7_b3_0 VSS) capacitor c=1.399E-14
    I_C1842 (b25_5 VSS) capacitor c=1.731E-15
    I_C1843 (b25_6 VSS) capacitor c=2.152E-15
    I_C1844 (I884_pn4 VSS) capacitor c=7.302E-15
    I_C1845 (I884_G3_0n VSS) capacitor c=7.557E-15
    I_C1846 (p7_4 VSS) capacitor c=1.399E-14
    I_C1847 (b7_8 VSS) capacitor c=2.793E-15
    I_C1848 (I838_pn9 VSS) capacitor c=7.762E-15
    I_C1849 (I838_G8_0n VSS) capacitor c=3.617E-15
    I_C1850 (p6_9 VSS) capacitor c=6.573E-15
    I_C1851 (b6_8 VSS) capacitor c=1.896E-15
    I_C1852 (b6_9 VSS) capacitor c=1.748E-15
    I_C1853 (I792_pn9 VSS) capacitor c=6.099E-15
    I_C1854 (I792_G8_0n VSS) capacitor c=6.346E-15
    I_C1855 (p5_9 VSS) capacitor c=3.199E-15
    I_C1856 (dd22_b3_0 VSS) capacitor c=3.995E-14
    I_C1857 (qu27_b3_3 VSS) capacitor c=9.668E-15
    I_C1858 (b5_22 VSS) capacitor c=4.446E-15
    I_C1859 (I746_pn9 VSS) capacitor c=6.119E-15
    I_C1860 (I746_G8_0n VSS) capacitor c=6.004E-15
    I_C1861 (p4_9 VSS) capacitor c=4.168E-15
    I_C1862 (I746_pn10 VSS) capacitor c=6.789E-15
    I_C1863 (I746_G9_0n VSS) capacitor c=5.851E-15
    I_C1864 (p4_10 VSS) capacitor c=5.186E-15
    I_C1865 (dd24_b3_5 VSS) capacitor c=3.897E-14
    I_C1866 (qu4_b3_4 VSS) capacitor c=1.053E-14
    I_C1867 (b28_24 VSS) capacitor c=2.315E-15
    I_C1868 (I1804_pn9 VSS) capacitor c=5.347E-15
    I_C1869 (I1804_G8_0n VSS) capacitor c=5.394E-15
    I_C1870 (p27_9 VSS) capacitor c=4.325E-15
    I_C1871 (qu5_b3_0 VSS) capacitor c=9.904E-15
    I_C1872 (b27_5 VSS) capacitor c=2.550E-15
    I_C1873 (I1758_pn4 VSS) capacitor c=6.098E-15
    I_C1874 (I1758_G3_0n VSS) capacitor c=7.763E-15
    I_C1875 (p26_4 VSS) capacitor c=3.396E-15
    I_C1876 (I1758_pn3 VSS) capacitor c=6.643E-15
    I_C1877 (I1758_G2_0n VSS) capacitor c=5.551E-15
    I_C1878 (p26_3 VSS) capacitor c=3.279E-15
    I_C1879 (qu6_b3_0 VSS) capacitor c=1.057E-14
    I_C1880 (b26_5 VSS) capacitor c=2.214E-15
    I_C1881 (I1712_pn4 VSS) capacitor c=4.749E-15
    I_C1882 (I1712_G3_0n VSS) capacitor c=6.251E-15
    I_C1883 (p25_4 VSS) capacitor c=5.000E-15
    I_C1884 (b25_1 VSS) capacitor c=2.631E-15
    I_C1885 (I884_pn3 VSS) capacitor c=5.000E-15
    I_C1886 (I884_G2_0n VSS) capacitor c=5.594E-15
    I_C1887 (p7_3 VSS) capacitor c=8.939E-15
    I_C1888 (b7_7 VSS) capacitor c=3.171E-15
    I_C1889 (b7_6 VSS) capacitor c=2.405E-15
    I_C1890 (b6_6 VSS) capacitor c=2.354E-15
    I_C1891 (b6_7 VSS) capacitor c=2.554E-15
    I_C1892 (dd18_b3_0 VSS) capacitor c=3.301E-14
    I_C1893 (b5_18 VSS) capacitor c=4.277E-15
    I_C1894 (dd20_b3_0 VSS) capacitor c=3.787E-14
    I_C1895 (b5_20 VSS) capacitor c=5.667E-15
    I_C1896 (dd23_b3_0 VSS) capacitor c=3.746E-14
    I_C1897 (b5_23 VSS) capacitor c=4.860E-15
    I_C1898 (dd21_b3_0 VSS) capacitor c=3.043E-14
    I_C1899 (b5_21 VSS) capacitor c=4.814E-15
    I_C1900 (qu28_b3_3 VSS) capacitor c=9.403E-15
    I_C1901 (b4_23 VSS) capacitor c=2.046E-15
    I_C1902 (dd30_b3_5 VSS) capacitor c=3.913E-14
    I_C1903 (b28_30 VSS) capacitor c=2.090E-15
    I_C1904 (dd27_b3_5 VSS) capacitor c=3.556E-14
    I_C1905 (b28_27 VSS) capacitor c=2.366E-15
    I_C1906 (dd26_b3_5 VSS) capacitor c=3.909E-14
    I_C1907 (b28_26 VSS) capacitor c=3.142E-15
    I_C1908 (dd25_b3_5 VSS) capacitor c=3.542E-14
    I_C1909 (b28_25 VSS) capacitor c=3.033E-15
    I_C1910 (dd20_b3_5 VSS) capacitor c=3.546E-14
    I_C1911 (qu4_b3_3 VSS) capacitor c=1.060E-14
    I_C1912 (b28_20 VSS) capacitor c=2.264E-15
    I_C1913 (b27_3 VSS) capacitor c=1.894E-15
    I_C1914 (b27_1 VSS) capacitor c=2.376E-15
    I_C1915 (b27_4 VSS) capacitor c=2.132E-15
    I_C1916 (b26_3 VSS) capacitor c=2.166E-15
    I_C1917 (b26_4 VSS) capacitor c=2.356E-15
    I_C1918 (b25_4 VSS) capacitor c=2.350E-15
    I_C1919 (I1712_pn3 VSS) capacitor c=5.054E-15
    I_C1920 (I1712_G2_0n VSS) capacitor c=9.262E-15
    I_C1921 (p25_3 VSS) capacitor c=6.569E-15
    I_C1922 (qu25_b3_0 VSS) capacitor c=1.048E-14
    I_C1923 (b7_4 VSS) capacitor c=2.922E-15
    I_C1924 (b7_5 VSS) capacitor c=2.489E-15
    I_C1925 (I838_pn3 VSS) capacitor c=7.107E-15
    I_C1926 (I838_G2_0n VSS) capacitor c=7.711E-15
    I_C1927 (p6_3 VSS) capacitor c=4.236E-15
    I_C1928 (I838_pn4 VSS) capacitor c=7.499E-15
    I_C1929 (I838_G3_0n VSS) capacitor c=7.243E-15
    I_C1930 (p6_4 VSS) capacitor c=7.261E-15
    I_C1931 (I792_pn3 VSS) capacitor c=4.737E-15
    I_C1932 (I792_G2_0n VSS) capacitor c=7.597E-15
    I_C1933 (p5_3 VSS) capacitor c=3.311E-15
    I_C1934 (I792_pn4 VSS) capacitor c=5.011E-15
    I_C1935 (I792_G3_0n VSS) capacitor c=8.251E-15
    I_C1936 (p5_4 VSS) capacitor c=5.650E-15
    I_C1937 (I746_pn3 VSS) capacitor c=4.277E-15
    I_C1938 (I746_G2_0n VSS) capacitor c=8.494E-15
    I_C1939 (p4_3 VSS) capacitor c=5.432E-15
    I_C1940 (dd12_b3_0 VSS) capacitor c=3.237E-14
    I_C1941 (qu27_b3_2 VSS) capacitor c=9.378E-15
    I_C1942 (b5_12 VSS) capacitor c=4.385E-15
    I_C1943 (I746_pn4 VSS) capacitor c=5.867E-15
    I_C1944 (I746_G3_0n VSS) capacitor c=1.020E-14
    I_C1945 (p4_4 VSS) capacitor c=4.733E-15
    I_C1946 (dd19_b3_0 VSS) capacitor c=3.563E-14
    I_C1947 (b5_19 VSS) capacitor c=5.222E-15
    I_C1948 (qu28_b3_2 VSS) capacitor c=9.080E-15
    I_C1949 (b4_12 VSS) capacitor c=2.224E-15
    I_C1950 (b4_18 VSS) capacitor c=2.093E-15
    I_C1951 (b4_19 VSS) capacitor c=2.450E-15
    I_C1952 (b4_22 VSS) capacitor c=2.397E-15
    I_C1953 (h4 VSS) capacitor c=1.811E-15
    I_C1954 (c4_o VSS) capacitor c=2.934E-15
    I_C1955 (p4_32 VSS) capacitor c=1.455E-15
    I_C1956 (dd28_b3_5 VSS) capacitor c=4.501E-14
    I_C1957 (b28_28 VSS) capacitor c=2.469E-15
    I_C1958 (dd29_b3_5 VSS) capacitor c=4.419E-14
    I_C1959 (b28_29 VSS) capacitor c=2.200E-15
    I_C1960 (dd23_b3_5 VSS) capacitor c=3.883E-14
    I_C1961 (b28_23 VSS) capacitor c=2.552E-15
    I_C1962 (dd22_b3_5 VSS) capacitor c=4.344E-14
    I_C1963 (b28_22 VSS) capacitor c=2.483E-15
    I_C1964 (dd19_b3_5 VSS) capacitor c=3.480E-14
    I_C1965 (b28_19 VSS) capacitor c=2.279E-15
    I_C1966 (dd18_b3_5 VSS) capacitor c=3.404E-14
    I_C1967 (b28_18 VSS) capacitor c=2.349E-15
    I_C1968 (dd17_b3_5 VSS) capacitor c=2.852E-14
    I_C1969 (qu4_b3_2 VSS) capacitor c=1.020E-14
    I_C1970 (b28_17 VSS) capacitor c=2.305E-15
    I_C1971 (dd13_b3_5 VSS) capacitor c=2.608E-14
    I_C1972 (b28_13 VSS) capacitor c=2.277E-15
    I_C1973 (I1804_pn4 VSS) capacitor c=5.612E-15
    I_C1974 (I1804_G3_0n VSS) capacitor c=7.445E-15
    I_C1975 (p27_4 VSS) capacitor c=3.764E-15
    I_C1976 (I1804_pn3 VSS) capacitor c=5.415E-15
    I_C1977 (I1804_G2_0n VSS) capacitor c=7.483E-15
    I_C1978 (p27_3 VSS) capacitor c=3.982E-15
    I_C1979 (dd8_b3_5 VSS) capacitor c=2.094E-14
    I_C1980 (qu4_b3_1 VSS) capacitor c=9.450E-15
    I_C1981 (b28_8 VSS) capacitor c=3.082E-15
    I_C1982 (b27_2 VSS) capacitor c=2.502E-15
    I_C1983 (b27_0 VSS) capacitor c=2.785E-15
    I_C1984 (b26_0 VSS) capacitor c=2.369E-15
    I_C1985 (b26_1 VSS) capacitor c=2.916E-15
    I_C1986 (b26_2 VSS) capacitor c=2.827E-15
    I_C1987 (b25_0 VSS) capacitor c=2.141E-15
    I_C1988 (b25_3 VSS) capacitor c=2.403E-15
    I_C1989 (b25_2 VSS) capacitor c=2.576E-15
    I_C1990 (b7_3 VSS) capacitor c=2.704E-15
    I_C1991 (b7_2 VSS) capacitor c=3.583E-15
    I_C1992 (b7_1 VSS) capacitor c=2.832E-15
    I_C1993 (b7_0 VSS) capacitor c=2.363E-15
    I_C1994 (qu26_b3_0 VSS) capacitor c=1.328E-14
    I_C1995 (b6_2 VSS) capacitor c=1.790E-15
    I_C1996 (b6_4 VSS) capacitor c=2.312E-15
    I_C1997 (b6_5 VSS) capacitor c=2.116E-15
    I_C1998 (dd9_b3_0 VSS) capacitor c=2.712E-14
    I_C1999 (qu27_b3_1 VSS) capacitor c=8.918E-15
    I_C2000 (b5_9 VSS) capacitor c=4.554E-15
    I_C2001 (dd6_b3_0 VSS) capacitor c=1.998E-14
    I_C2002 (b5_6 VSS) capacitor c=2.924E-15
    I_C2003 (dd8_b3_0 VSS) capacitor c=2.313E-14
    I_C2004 (b5_8 VSS) capacitor c=2.789E-15
    I_C2005 (dd11_b3_0 VSS) capacitor c=3.072E-14
    I_C2006 (b5_11 VSS) capacitor c=3.340E-15
    I_C2007 (dd13_b3_0 VSS) capacitor c=2.753E-14
    I_C2008 (b5_13 VSS) capacitor c=5.003E-15
    I_C2009 (dd16_b3_0 VSS) capacitor c=3.585E-14
    I_C2010 (b5_16 VSS) capacitor c=7.908E-15
    I_C2011 (dd14_b3_0 VSS) capacitor c=2.913E-14
    I_C2012 (b5_14 VSS) capacitor c=5.959E-15
    I_C2013 (qu28_b3_1 VSS) capacitor c=9.871E-15
    I_C2014 (b4_8 VSS) capacitor c=2.987E-15
    I_C2015 (b4_9 VSS) capacitor c=2.076E-15
    I_C2016 (b4_13 VSS) capacitor c=2.429E-15
    I_C2017 (b4_14 VSS) capacitor c=2.964E-15
    I_C2018 (b4_20 VSS) capacitor c=2.050E-15
    I_C2019 (b4_21 VSS) capacitor c=2.026E-15
    I_C2020 (p3_31 VSS) capacitor c=3.583E-15
    I_C2021 (dd21_b3_5 VSS) capacitor c=2.883E-14
    I_C2022 (b28_21 VSS) capacitor c=2.072E-15
    I_C2023 (dd16_b3_5 VSS) capacitor c=2.991E-14
    I_C2024 (b28_16 VSS) capacitor c=2.408E-15
    I_C2025 (dd15_b3_5 VSS) capacitor c=2.377E-14
    I_C2026 (b28_15 VSS) capacitor c=2.293E-15
    I_C2027 (dd14_b3_5 VSS) capacitor c=2.731E-14
    I_C2028 (b28_14 VSS) capacitor c=2.364E-15
    I_C2029 (dd12_b3_5 VSS) capacitor c=2.164E-14
    I_C2030 (b28_12 VSS) capacitor c=2.410E-15
    I_C2031 (dd7_b3_5 VSS) capacitor c=2.177E-14
    I_C2032 (b28_7 VSS) capacitor c=2.205E-15
    I_C2033 (dd9_b3_5 VSS) capacitor c=2.228E-14
    I_C2034 (b28_9 VSS) capacitor c=3.590E-15
    I_C2035 (dd6_b3_5 VSS) capacitor c=2.032E-14
    I_C2036 (b28_6 VSS) capacitor c=3.870E-15
    I_C2037 (qu4_b3_0 VSS) capacitor c=1.210E-14
    I_C2038 (b28_0 VSS) capacitor c=2.207E-15
    I_C2039 (b6_0 VSS) capacitor c=2.207E-15
    I_C2040 (b6_1 VSS) capacitor c=2.770E-15
    I_C2041 (b6_3 VSS) capacitor c=2.498E-15
    I_C2042 (qu27_b3_0 VSS) capacitor c=1.026E-14
    I_C2043 (b5_0 VSS) capacitor c=2.296E-15
    I_C2044 (dd1_b3_0 VSS) capacitor c=1.490E-14
    I_C2045 (b5_1 VSS) capacitor c=1.718E-15
    I_C2046 (dd2_b3_0 VSS) capacitor c=1.775E-14
    I_C2047 (b5_2 VSS) capacitor c=2.394E-15
    I_C2048 (dd4_b3_0 VSS) capacitor c=2.025E-14
    I_C2049 (b5_4 VSS) capacitor c=2.754E-15
    I_C2050 (dd5_b3_0 VSS) capacitor c=2.184E-14
    I_C2051 (b5_5 VSS) capacitor c=3.198E-15
    I_C2052 (dd7_b3_0 VSS) capacitor c=2.187E-14
    I_C2053 (b5_7 VSS) capacitor c=3.029E-15
    I_C2054 (dd10_b3_0 VSS) capacitor c=3.007E-14
    I_C2055 (b5_10 VSS) capacitor c=4.643E-15
    I_C2056 (dd17_b3_0 VSS) capacitor c=3.124E-14
    I_C2057 (b5_17 VSS) capacitor c=3.949E-15
    I_C2058 (dd15_b3_0 VSS) capacitor c=2.504E-14
    I_C2059 (b5_15 VSS) capacitor c=6.130E-15
    I_C2060 (qu28_b3_0 VSS) capacitor c=1.211E-14
    I_C2061 (b4_5 VSS) capacitor c=3.181E-15
    I_C2062 (b4_6 VSS) capacitor c=2.371E-15
    I_C2063 (b4_10 VSS) capacitor c=2.534E-15
    I_C2064 (b4_7 VSS) capacitor c=2.264E-15
    I_C2065 (b4_11 VSS) capacitor c=2.986E-15
    I_C2066 (b4_15 VSS) capacitor c=3.076E-15
    I_C2067 (b4_17 VSS) capacitor c=2.508E-15
    I_C2068 (b4_16 VSS) capacitor c=3.696E-15
    I_C2069 (I700_pn13 VSS) capacitor c=7.836E-15
    I_C2070 (I700_G12_0n VSS) capacitor c=4.506E-15
    I_C2071 (p3_13 VSS) capacitor c=4.316E-15
    I_C2072 (dd10_b3_5 VSS) capacitor c=1.802E-14
    I_C2073 (b28_10 VSS) capacitor c=3.283E-15
    I_C2074 (dd11_b3_5 VSS) capacitor c=2.386E-14
    I_C2075 (b28_11 VSS) capacitor c=4.811E-15
    I_C2076 (dd5_b3_5 VSS) capacitor c=1.954E-14
    I_C2077 (b28_5 VSS) capacitor c=3.405E-15
    I_C2078 (B_0_b3_5 VSS) capacitor c=1.501E-14
    I_C2079 (qu3_b3_0 VSS) capacitor c=1.364E-14
    I_C2080 (b29_0 VSS) capacitor c=2.045E-15
    I_C2081 (qu1_b3_0 VSS) capacitor c=1.154E-14
    I_C2082 (b31_0 VSS) capacitor c=1.742E-15
    I_C2083 (A_31_b3_5 VSS) capacitor c=1.054E-14
    I_C2084 (B_31_b3_5 VSS) capacitor c=5.336E-15
    I_C2085 (sq VSS) capacitor c=1.213E-15
    I_C2086 (b0_5 VSS) capacitor c=3.490E-15
    I_C2087 (b0_1 VSS) capacitor c=2.727E-15
    I_C2088 (B_0_b3_0 VSS) capacitor c=1.674E-14
    I_C2089 (b0_0 VSS) capacitor c=2.973E-15
    I_C2090 (dd3_b3_0 VSS) capacitor c=1.464E-14
    I_C2091 (b5_3 VSS) capacitor c=3.118E-15
    I_C2092 (b4_0 VSS) capacitor c=2.044E-15
    I_C2093 (b4_1 VSS) capacitor c=2.098E-15
    I_C2094 (b4_2 VSS) capacitor c=2.651E-15
    I_C2095 (b4_4 VSS) capacitor c=3.355E-15
    I_C2096 (b4_3 VSS) capacitor c=2.996E-15
    I_C2097 (I700_pn3 VSS) capacitor c=4.596E-15
    I_C2098 (I700_G2_0n VSS) capacitor c=8.810E-15
    I_C2099 (p3_3 VSS) capacitor c=2.727E-15
    I_C2100 (I700_pn9 VSS) capacitor c=6.510E-15
    I_C2101 (I700_G8_0n VSS) capacitor c=5.524E-15
    I_C2102 (p3_9 VSS) capacitor c=2.907E-15
    I_C2103 (I700_pn11 VSS) capacitor c=6.268E-15
    I_C2104 (I700_G10_0n VSS) capacitor c=5.618E-15
    I_C2105 (p3_11 VSS) capacitor c=4.226E-15
    I_C2106 (dd4_b3_5 VSS) capacitor c=1.435E-14
    I_C2107 (b28_4 VSS) capacitor c=3.164E-15
    I_C2108 (dd3_b3_5 VSS) capacitor c=1.659E-14
    I_C2109 (b28_3 VSS) capacitor c=3.424E-15
    I_C2110 (dd2_b3_5 VSS) capacitor c=1.442E-14
    I_C2111 (b29_2 VSS) capacitor c=2.669E-15
    I_C2112 (b28_2 VSS) capacitor c=3.637E-15
    I_C2113 (dd1_b3_5 VSS) capacitor c=1.383E-14
    I_C2114 (b29_1 VSS) capacitor c=2.203E-15
    I_C2115 (b28_1 VSS) capacitor c=3.019E-15
    I_C2116 (qu2_b3_0 VSS) capacitor c=1.301E-14
    I_C2117 (b30_3 VSS) capacitor c=3.091E-15
    I_C2118 (b30_4 VSS) capacitor c=3.127E-15
    I_C2119 (b30_2 VSS) capacitor c=2.414E-15
    I_C2120 (b30_1 VSS) capacitor c=1.776E-15
    I_C2121 (b30_0 VSS) capacitor c=2.508E-15
    I_C2122 (b31_4 VSS) capacitor c=2.633E-15
    I_C2123 (b31_3 VSS) capacitor c=2.350E-15
    I_C2124 (b31_2 VSS) capacitor c=2.621E-15
    I_C2125 (b31_1 VSS) capacitor c=2.490E-15
    I_C2126 (b0_7 VSS) capacitor c=2.344E-15
    I_C2127 (b0_3 VSS) capacitor c=2.022E-15
    I_C2128 (b0_4 VSS) capacitor c=1.964E-15
    I_C2129 (b0_2 VSS) capacitor c=2.569E-15
    I_C2130 (qu31_b3_0 VSS) capacitor c=1.097E-14
    I_C2131 (b1_3 VSS) capacitor c=4.521E-15
    I_C2132 (b1_0 VSS) capacitor c=2.097E-15
    I_C2133 (b1_1 VSS) capacitor c=2.323E-15
    I_C2134 (qu29_b3_0 VSS) capacitor c=1.128E-14
    I_C2135 (b3_0 VSS) capacitor c=2.297E-15
    I_C2136 (qu30_b3_0 VSS) capacitor c=1.029E-14
    I_C2137 (b2_0 VSS) capacitor c=2.459E-15
    I_C2138 (b3_1 VSS) capacitor c=2.394E-15
    I_C2139 (b2_1 VSS) capacitor c=2.897E-15
    I_C2140 (b2_3 VSS) capacitor c=3.154E-15
    I_C2141 (b3_2 VSS) capacitor c=2.433E-15
    I_C2142 (b3_3 VSS) capacitor c=2.382E-15
    I_C2143 (I700_pn4 VSS) capacitor c=4.854E-15
    I_C2144 (I700_G3_0n VSS) capacitor c=7.791E-15
    I_C2145 (p3_4 VSS) capacitor c=3.564E-15
    I_C2146 (b29_5 VSS) capacitor c=2.980E-15
    I_C2147 (b29_4 VSS) capacitor c=2.438E-15
    I_C2148 (b29_3 VSS) capacitor c=1.907E-15
    I_C2149 (b30_5 VSS) capacitor c=2.296E-15
    I_C2150 (b31_5 VSS) capacitor c=2.392E-15
    I_C2151 (b0_8 VSS) capacitor c=2.446E-15
    I_C2152 (b0_6 VSS) capacitor c=2.767E-15
    I_C2153 (b1_4 VSS) capacitor c=2.986E-15
    I_C2154 (b1_2 VSS) capacitor c=1.945E-15
    I_C2155 (b2_4 VSS) capacitor c=2.940E-15
    I_C2156 (b2_2 VSS) capacitor c=2.265E-15
    I_C2157 (b3_4 VSS) capacitor c=3.028E-15
    I_C2158 (b3_5 VSS) capacitor c=2.488E-15
    I_C2159 (I700_pn10 VSS) capacitor c=5.424E-15
    I_C2160 (I700_G9_0n VSS) capacitor c=6.094E-15
    I_C2161 (p3_10 VSS) capacitor c=3.998E-15
    I_C2162 (I700_pn15 VSS) capacitor c=8.063E-15
    I_C2163 (I700_G14_0n VSS) capacitor c=4.526E-15
    I_C2164 (p3_15 VSS) capacitor c=4.090E-15
    I_C2165 (I1850_pn15 VSS) capacitor c=5.833E-15
    I_C2166 (I1850_G14_0n VSS) capacitor c=5.707E-15
    I_C2167 (p28_15 VSS) capacitor c=5.300E-15
    I_C2168 (I1850_pn11 VSS) capacitor c=5.412E-15
    I_C2169 (I1850_G10_0n VSS) capacitor c=6.768E-15
    I_C2170 (p28_11 VSS) capacitor c=4.080E-15
    I_C2171 (I1850_pn4 VSS) capacitor c=6.099E-15
    I_C2172 (I1850_G3_0n VSS) capacitor c=8.792E-15
    I_C2173 (p28_4 VSS) capacitor c=3.319E-15
    I_C2174 (I1850_pn3 VSS) capacitor c=5.566E-15
    I_C2175 (I1850_G2_0n VSS) capacitor c=7.528E-15
    I_C2176 (p28_3 VSS) capacitor c=2.870E-15
    I_C2177 (I1896_pn3 VSS) capacitor c=5.954E-15
    I_C2178 (I1896_G2_0n VSS) capacitor c=8.306E-15
    I_C2179 (p29_3 VSS) capacitor c=4.220E-15
    I_C2180 (qu2_b3_1 VSS) capacitor c=9.130E-15
    I_C2181 (b30_6 VSS) capacitor c=2.371E-15
    I_C2182 (I1942_pn4 VSS) capacitor c=4.699E-15
    I_C2183 (I1942_G3_0n VSS) capacitor c=7.592E-15
    I_C2184 (p30_4 VSS) capacitor c=4.748E-15
    I_C2185 (I1942_pn3 VSS) capacitor c=4.557E-15
    I_C2186 (I1942_G2_0n VSS) capacitor c=7.392E-15
    I_C2187 (p30_3 VSS) capacitor c=4.179E-15
    I_C2188 (qu1_b3_1 VSS) capacitor c=8.602E-15
    I_C2189 (b31_6 VSS) capacitor c=2.432E-15
    I_C2190 (I1988_pn4 VSS) capacitor c=5.611E-15
    I_C2191 (I1988_G3_0n VSS) capacitor c=6.310E-15
    I_C2192 (p31_4 VSS) capacitor c=4.128E-15
    I_C2193 (I1988_pn3 VSS) capacitor c=5.266E-15
    I_C2194 (I1988_G2_0n VSS) capacitor c=6.783E-15
    I_C2195 (p31_3 VSS) capacitor c=3.339E-15
    I_C2196 (b0_9 VSS) capacitor c=2.380E-15
    I_C2197 (I562_pn3 VSS) capacitor c=3.691E-15
    I_C2198 (I562_G2_0n VSS) capacitor c=5.599E-15
    I_C2199 (p0_3 VSS) capacitor c=6.110E-15
    I_C2200 (qu31_b3_1 VSS) capacitor c=9.161E-15
    I_C2201 (b1_6 VSS) capacitor c=2.233E-15
    I_C2202 (b1_7 VSS) capacitor c=2.329E-15
    I_C2203 (b1_5 VSS) capacitor c=2.516E-15
    I_C2204 (I608_pn3 VSS) capacitor c=4.706E-15
    I_C2205 (I608_G2_0n VSS) capacitor c=6.631E-15
    I_C2206 (p1_3 VSS) capacitor c=4.442E-15
    I_C2207 (qu30_b3_1 VSS) capacitor c=9.099E-15
    I_C2208 (b2_6 VSS) capacitor c=2.988E-15
    I_C2209 (b2_7 VSS) capacitor c=3.464E-15
    I_C2210 (b2_5 VSS) capacitor c=2.766E-15
    I_C2211 (I654_pn3 VSS) capacitor c=5.316E-15
    I_C2212 (I654_G2_0n VSS) capacitor c=7.571E-15
    I_C2213 (p2_3 VSS) capacitor c=2.777E-15
    I_C2214 (qu29_b3_1 VSS) capacitor c=9.964E-15
    I_C2215 (b3_6 VSS) capacitor c=2.737E-15
    I_C2216 (I654_pn4 VSS) capacitor c=6.316E-15
    I_C2217 (I654_G3_0n VSS) capacitor c=1.238E-14
    I_C2218 (p2_4 VSS) capacitor c=2.816E-15
    I_C2219 (b3_7 VSS) capacitor c=2.149E-15
    I_C2220 (I1850_pn13 VSS) capacitor c=7.560E-15
    I_C2221 (I1850_G12_0n VSS) capacitor c=4.887E-15
    I_C2222 (p28_13 VSS) capacitor c=4.991E-15
    I_C2223 (I1850_pn9 VSS) capacitor c=6.320E-15
    I_C2224 (I1850_G8_0n VSS) capacitor c=3.431E-15
    I_C2225 (p28_9 VSS) capacitor c=3.023E-15
    I_C2226 (qu3_b3_1 VSS) capacitor c=9.409E-15
    I_C2227 (b29_8 VSS) capacitor c=2.598E-15
    I_C2228 (b29_7 VSS) capacitor c=3.325E-15
    I_C2229 (b29_6 VSS) capacitor c=2.288E-15
    I_C2230 (I1896_pn4 VSS) capacitor c=4.906E-15
    I_C2231 (I1896_G3_0n VSS) capacitor c=8.969E-15
    I_C2232 (p29_4 VSS) capacitor c=4.876E-15
    I_C2233 (b30_8 VSS) capacitor c=2.614E-15
    I_C2234 (b30_7 VSS) capacitor c=2.275E-15
    I_C2235 (b31_8 VSS) capacitor c=1.768E-15
    I_C2236 (b31_7 VSS) capacitor c=2.278E-15
    I_C2237 (I2066_pn3 VSS) capacitor c=6.155E-15
    I_C2238 (I2066_G2_0n VSS) capacitor c=7.570E-15
    I_C2239 (ru3 VSS) capacitor c=3.213E-15
    I_C2240 (b0_10 VSS) capacitor c=3.077E-15
    I_C2241 (I562_pn4 VSS) capacitor c=4.016E-15
    I_C2242 (I562_G3_0n VSS) capacitor c=7.845E-15
    I_C2243 (p0_4 VSS) capacitor c=6.530E-15
    I_C2244 (b1_10 VSS) capacitor c=3.275E-15
    I_C2245 (b1_9 VSS) capacitor c=2.842E-15
    I_C2246 (b1_8 VSS) capacitor c=2.303E-15
    I_C2247 (I608_pn4 VSS) capacitor c=5.994E-15
    I_C2248 (I608_G3_0n VSS) capacitor c=6.945E-15
    I_C2249 (p1_4 VSS) capacitor c=3.385E-15
    I_C2250 (b2_9 VSS) capacitor c=2.669E-15
    I_C2251 (b2_11 VSS) capacitor c=3.080E-15
    I_C2252 (b2_8 VSS) capacitor c=2.970E-15
    I_C2253 (b3_8 VSS) capacitor c=2.611E-15
    I_C2254 (b3_9 VSS) capacitor c=2.378E-15
    I_C2255 (I700_pn12 VSS) capacitor c=4.040E-15
    I_C2256 (I700_G11_0n VSS) capacitor c=5.376E-15
    I_C2257 (p3_12 VSS) capacitor c=5.558E-15
    I_C2258 (b29_9 VSS) capacitor c=3.204E-15
    I_C2259 (b30_11 VSS) capacitor c=2.916E-15
    I_C2260 (b30_9 VSS) capacitor c=2.704E-15
    I_C2261 (b30_10 VSS) capacitor c=3.069E-15
    I_C2262 (b31_11 VSS) capacitor c=3.007E-15
    I_C2263 (b31_9 VSS) capacitor c=2.332E-15
    I_C2264 (b31_10 VSS) capacitor c=2.708E-15
    I_C2265 (I1988_pn9 VSS) capacitor c=7.044E-15
    I_C2266 (I1988_G8_0n VSS) capacitor c=4.568E-15
    I_C2267 (p31_9 VSS) capacitor c=2.867E-15
    I_C2268 (I2066_pn4 VSS) capacitor c=9.413E-15
    I_C2269 (I2066_G3_0n VSS) capacitor c=7.924E-15
    I_C2270 (ru4 VSS) capacitor c=2.547E-15
    I_C2271 (b0_11 VSS) capacitor c=2.426E-15
    I_C2272 (I562_pn9 VSS) capacitor c=7.217E-15
    I_C2273 (I562_G8_0n VSS) capacitor c=3.854E-15
    I_C2274 (p0_9 VSS) capacitor c=2.899E-15
    I_C2275 (b1_11 VSS) capacitor c=2.308E-15
    I_C2276 (b2_10 VSS) capacitor c=2.605E-15
    I_C2277 (b3_10 VSS) capacitor c=2.588E-15
    I_C2278 (b3_11 VSS) capacitor c=2.680E-15
    I_C2279 (I700_pn14 VSS) capacitor c=4.694E-15
    I_C2280 (I700_G13_0n VSS) capacitor c=6.708E-15
    I_C2281 (p3_14 VSS) capacitor c=5.199E-15
    I_C2282 (I1850_pn14 VSS) capacitor c=7.258E-15
    I_C2283 (I1850_G13_0n VSS) capacitor c=4.919E-15
    I_C2284 (p28_14 VSS) capacitor c=3.081E-15
    I_C2285 (I1850_pn10 VSS) capacitor c=6.508E-15
    I_C2286 (I1850_G9_0n VSS) capacitor c=4.962E-15
    I_C2287 (p28_10 VSS) capacitor c=3.348E-15
    I_C2288 (b29_10 VSS) capacitor c=2.466E-15
    I_C2289 (b29_11 VSS) capacitor c=4.294E-15
    I_C2290 (I1942_pn10 VSS) capacitor c=6.312E-15
    I_C2291 (I1942_G9_0n VSS) capacitor c=5.344E-15
    I_C2292 (p30_10 VSS) capacitor c=3.840E-15
    I_C2293 (I1942_pn9 VSS) capacitor c=7.139E-15
    I_C2294 (I1942_G8_0n VSS) capacitor c=6.501E-15
    I_C2295 (p30_9 VSS) capacitor c=3.756E-15
    I_C2296 (I1988_pn10 VSS) capacitor c=5.299E-15
    I_C2297 (I1988_G9_0n VSS) capacitor c=4.667E-15
    I_C2298 (p31_10 VSS) capacitor c=5.166E-15
    I_C2299 (I1988_pn11 VSS) capacitor c=8.140E-15
    I_C2300 (I1988_G10_0n VSS) capacitor c=7.165E-15
    I_C2301 (p31_11 VSS) capacitor c=2.485E-15
    I_C2302 (I562_pn10 VSS) capacitor c=5.759E-15
    I_C2303 (I562_G9_0n VSS) capacitor c=5.139E-15
    I_C2304 (p0_10 VSS) capacitor c=6.061E-15
    I_C2305 (I562_pn11 VSS) capacitor c=5.650E-15
    I_C2306 (I562_G10_0n VSS) capacitor c=3.831E-15
    I_C2307 (p0_11 VSS) capacitor c=6.583E-15
    I_C2308 (b0_12 VSS) capacitor c=5.151E-15
    I_C2309 (qu31_b3_2 VSS) capacitor c=9.640E-15
    I_C2310 (b1_12 VSS) capacitor c=2.159E-15
    I_C2311 (I608_pn9 VSS) capacitor c=6.372E-15
    I_C2312 (I608_G8_0n VSS) capacitor c=4.524E-15
    I_C2313 (p1_9 VSS) capacitor c=4.412E-15
    I_C2314 (I654_pn9 VSS) capacitor c=5.128E-15
    I_C2315 (I654_G8_0n VSS) capacitor c=5.649E-15
    I_C2316 (p2_9 VSS) capacitor c=4.278E-15
    I_C2317 (I654_pn10 VSS) capacitor c=8.181E-15
    I_C2318 (I654_G9_0n VSS) capacitor c=5.149E-15
    I_C2319 (p2_10 VSS) capacitor c=2.810E-15
    I_C2320 (I700_pn16 VSS) capacitor c=4.528E-15
    I_C2321 (I700_G15_0n VSS) capacitor c=3.525E-15
    I_C2322 (p3_16 VSS) capacitor c=7.579E-15
    I_C2323 (c28_o VSS) capacitor c=2.075E-15
    I_C2324 (p28_32 VSS) capacitor c=1.674E-15
    I_C2325 (I1850_pn16 VSS) capacitor c=8.468E-15
    I_C2326 (I1850_G15_0n VSS) capacitor c=4.257E-15
    I_C2327 (p28_16 VSS) capacitor c=3.651E-15
    I_C2328 (qu3_b3_2 VSS) capacitor c=1.095E-14
    I_C2329 (b29_15 VSS) capacitor c=2.364E-15
    I_C2330 (I1850_pn12 VSS) capacitor c=6.463E-15
    I_C2331 (I1850_G11_0n VSS) capacitor c=4.118E-15
    I_C2332 (p28_12 VSS) capacitor c=2.712E-15
    I_C2333 (b29_13 VSS) capacitor c=2.143E-15
    I_C2334 (b29_12 VSS) capacitor c=2.469E-15
    I_C2335 (qu2_b3_2 VSS) capacitor c=8.766E-15
    I_C2336 (b30_13 VSS) capacitor c=3.265E-15
    I_C2337 (b30_12 VSS) capacitor c=2.394E-15
    I_C2338 (I1942_pn11 VSS) capacitor c=6.155E-15
    I_C2339 (I1942_G10_0n VSS) capacitor c=7.664E-15
    I_C2340 (p30_11 VSS) capacitor c=3.286E-15
    I_C2341 (qu1_b3_2 VSS) capacitor c=9.705E-15
    I_C2342 (b31_12 VSS) capacitor c=2.656E-15
    I_C2343 (b31_13 VSS) capacitor c=2.391E-15
    I_C2344 (I1988_pn12 VSS) capacitor c=5.292E-15
    I_C2345 (I1988_G11_0n VSS) capacitor c=5.083E-15
    I_C2346 (p31_12 VSS) capacitor c=4.277E-15
    I_C2347 (I1988_pn13 VSS) capacitor c=6.264E-15
    I_C2348 (I1988_G12_0n VSS) capacitor c=4.888E-15
    I_C2349 (p31_13 VSS) capacitor c=3.217E-15
    I_C2350 (I2066_pn9 VSS) capacitor c=6.985E-15
    I_C2351 (I2066_G8_0n VSS) capacitor c=4.192E-15
    I_C2352 (ru9 VSS) capacitor c=4.228E-15
    I_C2353 (I2066_pn11 VSS) capacitor c=6.036E-15
    I_C2354 (I2066_G10_0n VSS) capacitor c=4.527E-15
    I_C2355 (ru11 VSS) capacitor c=6.142E-15
    I_C2356 (I2066_pn10 VSS) capacitor c=7.110E-15
    I_C2357 (I2066_G9_0n VSS) capacitor c=3.764E-15
    I_C2358 (ru10 VSS) capacitor c=3.167E-15
    I_C2359 (b0_13 VSS) capacitor c=2.685E-15
    I_C2360 (b0_14 VSS) capacitor c=4.965E-15
    I_C2361 (b1_14 VSS) capacitor c=2.223E-15
    I_C2362 (b1_13 VSS) capacitor c=1.999E-15
    I_C2363 (I608_pn11 VSS) capacitor c=6.532E-15
    I_C2364 (I608_G10_0n VSS) capacitor c=4.944E-15
    I_C2365 (p1_11 VSS) capacitor c=4.451E-15
    I_C2366 (I608_pn10 VSS) capacitor c=1.015E-14
    I_C2367 (I608_G9_0n VSS) capacitor c=5.085E-15
    I_C2368 (p1_10 VSS) capacitor c=2.953E-15
    I_C2369 (qu30_b3_2 VSS) capacitor c=9.168E-15
    I_C2370 (b2_12 VSS) capacitor c=2.410E-15
    I_C2371 (b2_13 VSS) capacitor c=2.355E-15
    I_C2372 (I654_pn11 VSS) capacitor c=6.837E-15
    I_C2373 (I654_G10_0n VSS) capacitor c=4.857E-15
    I_C2374 (p2_11 VSS) capacitor c=3.780E-15
    I_C2375 (qu29_b3_2 VSS) capacitor c=9.175E-15
    I_C2376 (b3_12 VSS) capacitor c=2.237E-15
    I_C2377 (b3_13 VSS) capacitor c=2.060E-15
    I_C2378 (b29_16 VSS) capacitor c=2.576E-15
    I_C2379 (b29_14 VSS) capacitor c=3.054E-15
    I_C2380 (I1896_pn10 VSS) capacitor c=4.886E-15
    I_C2381 (I1896_G9_0n VSS) capacitor c=4.801E-15
    I_C2382 (p29_10 VSS) capacitor c=5.733E-15
    I_C2383 (I1896_pn9 VSS) capacitor c=5.758E-15
    I_C2384 (I1896_G8_0n VSS) capacitor c=6.076E-15
    I_C2385 (p29_9 VSS) capacitor c=4.710E-15
    I_C2386 (b30_14 VSS) capacitor c=3.182E-15
    I_C2387 (b30_15 VSS) capacitor c=2.638E-15
    I_C2388 (I1942_pn12 VSS) capacitor c=5.957E-15
    I_C2389 (I1942_G11_0n VSS) capacitor c=6.002E-15
    I_C2390 (p30_12 VSS) capacitor c=4.591E-15
    I_C2391 (I1942_pn13 VSS) capacitor c=5.818E-15
    I_C2392 (I1942_G12_0n VSS) capacitor c=8.927E-15
    I_C2393 (p30_13 VSS) capacitor c=3.923E-15
    I_C2394 (b31_15 VSS) capacitor c=2.563E-15
    I_C2395 (b31_14 VSS) capacitor c=2.628E-15
    I_C2396 (I1988_pn14 VSS) capacitor c=5.888E-15
    I_C2397 (I1988_G13_0n VSS) capacitor c=7.587E-15
    I_C2398 (p31_14 VSS) capacitor c=4.278E-15
    I_C2399 (I562_pn12 VSS) capacitor c=4.207E-15
    I_C2400 (I562_G11_0n VSS) capacitor c=5.072E-15
    I_C2401 (p0_12 VSS) capacitor c=8.473E-15
    I_C2402 (I562_pn13 VSS) capacitor c=6.225E-15
    I_C2403 (I562_G12_0n VSS) capacitor c=5.301E-15
    I_C2404 (p0_13 VSS) capacitor c=4.284E-15
    I_C2405 (b0_16 VSS) capacitor c=3.303E-15
    I_C2406 (b0_15 VSS) capacitor c=4.864E-15
    I_C2407 (b1_15 VSS) capacitor c=2.751E-15
    I_C2408 (I608_pn13 VSS) capacitor c=5.207E-15
    I_C2409 (I608_G12_0n VSS) capacitor c=5.862E-15
    I_C2410 (p1_13 VSS) capacitor c=4.466E-15
    I_C2411 (I608_pn12 VSS) capacitor c=7.096E-15
    I_C2412 (I608_G11_0n VSS) capacitor c=6.519E-15
    I_C2413 (p1_12 VSS) capacitor c=3.499E-15
    I_C2414 (b2_14 VSS) capacitor c=2.626E-15
    I_C2415 (b2_15 VSS) capacitor c=2.606E-15
    I_C2416 (I654_pn13 VSS) capacitor c=7.629E-15
    I_C2417 (I654_G12_0n VSS) capacitor c=5.520E-15
    I_C2418 (p2_13 VSS) capacitor c=5.451E-15
    I_C2419 (b3_15 VSS) capacitor c=3.056E-15
    I_C2420 (b3_14 VSS) capacitor c=2.399E-15
    I_C2421 (I654_pn12 VSS) capacitor c=8.855E-15
    I_C2422 (I654_G11_0n VSS) capacitor c=5.763E-15
    I_C2423 (p2_12 VSS) capacitor c=2.794E-15
    I_C2424 (p28_31 VSS) capacitor c=8.557E-15
    I_C2425 (qu3_b3_5 VSS) capacitor c=2.751E-14
    I_C2426 (h29 VSS) capacitor c=2.048E-15
    I_C2427 (b29_17 VSS) capacitor c=2.442E-15
    I_C2428 (I1896_pn12 VSS) capacitor c=5.660E-15
    I_C2429 (I1896_G11_0n VSS) capacitor c=5.688E-15
    I_C2430 (p29_12 VSS) capacitor c=6.947E-15
    I_C2431 (I1896_pn11 VSS) capacitor c=4.566E-15
    I_C2432 (I1896_G10_0n VSS) capacitor c=5.285E-15
    I_C2433 (p29_11 VSS) capacitor c=5.341E-15
    I_C2434 (b30_17 VSS) capacitor c=3.020E-15
    I_C2435 (b30_16 VSS) capacitor c=2.142E-15
    I_C2436 (I1942_pn14 VSS) capacitor c=5.496E-15
    I_C2437 (I1942_G13_0n VSS) capacitor c=6.224E-15
    I_C2438 (p30_14 VSS) capacitor c=4.604E-15
    I_C2439 (I1942_pn15 VSS) capacitor c=7.719E-15
    I_C2440 (I1942_G14_0n VSS) capacitor c=5.580E-15
    I_C2441 (p30_15 VSS) capacitor c=3.451E-15
    I_C2442 (b31_17 VSS) capacitor c=3.086E-15
    I_C2443 (b31_16 VSS) capacitor c=2.387E-15
    I_C2444 (I1988_pn16 VSS) capacitor c=6.252E-15
    I_C2445 (I1988_G15_0n VSS) capacitor c=4.220E-15
    I_C2446 (p31_16 VSS) capacitor c=4.706E-15
    I_C2447 (I1988_pn15 VSS) capacitor c=7.248E-15
    I_C2448 (I1988_G14_0n VSS) capacitor c=5.997E-15
    I_C2449 (p31_15 VSS) capacitor c=3.076E-15
    I_C2450 (I2066_pn13 VSS) capacitor c=5.500E-15
    I_C2451 (I2066_G12_0n VSS) capacitor c=3.844E-15
    I_C2452 (ru13 VSS) capacitor c=5.650E-15
    I_C2453 (I2066_pn12 VSS) capacitor c=9.460E-15
    I_C2454 (I2066_G11_0n VSS) capacitor c=4.834E-15
    I_C2455 (ru12 VSS) capacitor c=2.706E-15
    I_C2456 (I562_pn14 VSS) capacitor c=4.962E-15
    I_C2457 (I562_G13_0n VSS) capacitor c=4.021E-15
    I_C2458 (p0_14 VSS) capacitor c=6.798E-15
    I_C2459 (I562_pn15 VSS) capacitor c=4.517E-15
    I_C2460 (I562_G14_0n VSS) capacitor c=4.670E-15
    I_C2461 (p0_15 VSS) capacitor c=4.849E-15
    I_C2462 (b0_17 VSS) capacitor c=2.337E-15
    I_C2463 (b1_16 VSS) capacitor c=2.571E-15
    I_C2464 (b1_17 VSS) capacitor c=2.682E-15
    I_C2465 (I608_pn14 VSS) capacitor c=7.590E-15
    I_C2466 (I608_G13_0n VSS) capacitor c=5.343E-15
    I_C2467 (p1_14 VSS) capacitor c=4.071E-15
    I_C2468 (b2_17 VSS) capacitor c=2.647E-15
    I_C2469 (b2_16 VSS) capacitor c=2.771E-15
    I_C2470 (I654_pn15 VSS) capacitor c=7.102E-15
    I_C2471 (I654_G14_0n VSS) capacitor c=5.029E-15
    I_C2472 (p2_15 VSS) capacitor c=6.442E-15
    I_C2473 (I654_pn14 VSS) capacitor c=8.290E-15
    I_C2474 (I654_G13_0n VSS) capacitor c=4.816E-15
    I_C2475 (p2_14 VSS) capacitor c=3.823E-15
    I_C2476 (b3_16 VSS) capacitor c=2.847E-15
    I_C2477 (b3_17 VSS) capacitor c=2.158E-15
    I_C2478 (c29_o VSS) capacitor c=1.882E-15
    I_C2479 (p29_32 VSS) capacitor c=1.594E-15
    I_C2480 (I1896_pn16 VSS) capacitor c=5.249E-15
    I_C2481 (I1896_G15_0n VSS) capacitor c=4.007E-15
    I_C2482 (p29_16 VSS) capacitor c=6.839E-15
    I_C2483 (I1896_pn14 VSS) capacitor c=5.300E-15
    I_C2484 (I1896_G13_0n VSS) capacitor c=4.310E-15
    I_C2485 (p29_14 VSS) capacitor c=4.583E-15
    I_C2486 (I1896_pn15 VSS) capacitor c=5.452E-15
    I_C2487 (I1896_G14_0n VSS) capacitor c=5.363E-15
    I_C2488 (p29_15 VSS) capacitor c=4.927E-15
    I_C2489 (I1896_pn13 VSS) capacitor c=5.300E-15
    I_C2490 (I1896_G12_0n VSS) capacitor c=4.969E-15
    I_C2491 (p29_13 VSS) capacitor c=5.661E-15
    I_C2492 (I1942_pn16 VSS) capacitor c=5.460E-15
    I_C2493 (I1942_G15_0n VSS) capacitor c=5.048E-15
    I_C2494 (p30_16 VSS) capacitor c=5.111E-15
    I_C2495 (qu1_b3_3 VSS) capacitor c=8.958E-15
    I_C2496 (b31_18 VSS) capacitor c=3.018E-15
    I_C2497 (I562_pn16 VSS) capacitor c=5.826E-15
    I_C2498 (I562_G15_0n VSS) capacitor c=4.884E-15
    I_C2499 (p0_16 VSS) capacitor c=6.201E-15
    I_C2500 (b0_18 VSS) capacitor c=2.978E-15
    I_C2501 (I608_pn15 VSS) capacitor c=5.492E-15
    I_C2502 (I608_G14_0n VSS) capacitor c=4.968E-15
    I_C2503 (p1_15 VSS) capacitor c=4.263E-15
    I_C2504 (I654_pn16 VSS) capacitor c=9.099E-15
    I_C2505 (I654_G15_0n VSS) capacitor c=4.298E-15
    I_C2506 (p2_16 VSS) capacitor c=3.007E-15
    I_C2507 (qu3_b3_3 VSS) capacitor c=1.141E-14
    I_C2508 (b29_22 VSS) capacitor c=2.988E-15
    I_C2509 (b29_20 VSS) capacitor c=2.155E-15
    I_C2510 (b29_19 VSS) capacitor c=2.350E-15
    I_C2511 (b29_18 VSS) capacitor c=2.083E-15
    I_C2512 (qu2_b3_3 VSS) capacitor c=1.004E-14
    I_C2513 (b30_19 VSS) capacitor c=2.221E-15
    I_C2514 (b30_20 VSS) capacitor c=2.514E-15
    I_C2515 (b30_18 VSS) capacitor c=2.358E-15
    I_C2516 (b31_19 VSS) capacitor c=2.272E-15
    I_C2517 (b31_20 VSS) capacitor c=2.702E-15
    I_C2518 (I2066_pn14 VSS) capacitor c=8.359E-15
    I_C2519 (I2066_G13_0n VSS) capacitor c=5.553E-15
    I_C2520 (ru14 VSS) capacitor c=4.350E-15
    I_C2521 (b0_19 VSS) capacitor c=2.379E-15
    I_C2522 (qu31_b3_3 VSS) capacitor c=9.207E-15
    I_C2523 (b1_19 VSS) capacitor c=2.461E-15
    I_C2524 (b1_18 VSS) capacitor c=2.403E-15
    I_C2525 (I608_pn16 VSS) capacitor c=9.431E-15
    I_C2526 (I608_G15_0n VSS) capacitor c=4.896E-15
    I_C2527 (p1_16 VSS) capacitor c=3.040E-15
    I_C2528 (qu30_b3_3 VSS) capacitor c=9.013E-15
    I_C2529 (b2_19 VSS) capacitor c=2.144E-15
    I_C2530 (b2_18 VSS) capacitor c=1.956E-15
    I_C2531 (qu29_b3_3 VSS) capacitor c=9.526E-15
    I_C2532 (b3_19 VSS) capacitor c=2.833E-15
    I_C2533 (b3_18 VSS) capacitor c=3.131E-15
    I_C2534 (b3_20 VSS) capacitor c=2.033E-15
    I_C2535 (b29_31 VSS) capacitor c=2.373E-15
    I_C2536 (b29_30 VSS) capacitor c=2.298E-15
    I_C2537 (b29_23 VSS) capacitor c=2.387E-15
    I_C2538 (b29_21 VSS) capacitor c=2.541E-15
    I_C2539 (b30_21 VSS) capacitor c=1.753E-15
    I_C2540 (b31_21 VSS) capacitor c=2.731E-15
    I_C2541 (b0_20 VSS) capacitor c=4.122E-15
    I_C2542 (b0_21 VSS) capacitor c=2.824E-15
    I_C2543 (b1_21 VSS) capacitor c=1.958E-15
    I_C2544 (b1_20 VSS) capacitor c=2.563E-15
    I_C2545 (b2_21 VSS) capacitor c=2.012E-15
    I_C2546 (b2_20 VSS) capacitor c=1.917E-15
    I_C2547 (b3_23 VSS) capacitor c=2.121E-15
    I_C2548 (b3_21 VSS) capacitor c=2.854E-15
    I_C2549 (b30_22 VSS) capacitor c=2.232E-15
    I_C2550 (b30_23 VSS) capacitor c=2.060E-15
    I_C2551 (b31_23 VSS) capacitor c=2.662E-15
    I_C2552 (b31_22 VSS) capacitor c=2.140E-15
    I_C2553 (I2066_pn15 VSS) capacitor c=7.060E-15
    I_C2554 (I2066_G14_0n VSS) capacitor c=2.516E-15
    I_C2555 (ru15 VSS) capacitor c=4.049E-15
    I_C2556 (h0 VSS) capacitor c=2.089E-15
    I_C2557 (b0_22 VSS) capacitor c=2.094E-15
    I_C2558 (b1_22 VSS) capacitor c=2.166E-15
    I_C2559 (b2_22 VSS) capacitor c=1.993E-15
    I_C2560 (h3 VSS) capacitor c=2.766E-15
    I_C2561 (c3_o VSS) capacitor c=3.842E-15
    I_C2562 (p3_32 VSS) capacitor c=1.601E-15
    I_C2563 (b3_22 VSS) capacitor c=3.668E-15
    I_C2564 (qu3_b3_4 VSS) capacitor c=1.276E-14
    I_C2565 (b29_24 VSS) capacitor c=2.121E-15
    I_C2566 (qu2_b3_4 VSS) capacitor c=9.419E-15
    I_C2567 (b30_24 VSS) capacitor c=2.500E-15
    I_C2568 (qu1_b3_4 VSS) capacitor c=8.809E-15
    I_C2569 (b31_25 VSS) capacitor c=2.285E-15
    I_C2570 (b31_24 VSS) capacitor c=2.003E-15
    I_C2571 (I2066_pn16 VSS) capacitor c=8.643E-15
    I_C2572 (I2066_G15_0n VSS) capacitor c=3.178E-15
    I_C2573 (ru16 VSS) capacitor c=2.335E-15
    I_C2574 (c0_o VSS) capacitor c=2.292E-15
    I_C2575 (p0_32 VSS) capacitor c=1.487E-15
    I_C2576 (b0_24 VSS) capacitor c=3.399E-15
    I_C2577 (b0_23 VSS) capacitor c=2.436E-15
    I_C2578 (qu31_b3_4 VSS) capacitor c=9.705E-15
    I_C2579 (b1_24 VSS) capacitor c=2.328E-15
    I_C2580 (b1_23 VSS) capacitor c=2.472E-15
    I_C2581 (b2_23 VSS) capacitor c=1.974E-15
    I_C2582 (qu30_b3_4 VSS) capacitor c=1.068E-14
    I_C2583 (b2_24 VSS) capacitor c=2.370E-15
    I_C2584 (p2_31 VSS) capacitor c=2.627E-15
    I_C2585 (qu29_b3_5 VSS) capacitor c=2.181E-14
    I_C2586 (qu29_b3_4 VSS) capacitor c=9.417E-15
    I_C2587 (b3_25 VSS) capacitor c=2.436E-15
    I_C2588 (b3_26 VSS) capacitor c=2.983E-15
    I_C2589 (b3_24 VSS) capacitor c=2.139E-15
    I_C2590 (b29_25 VSS) capacitor c=2.325E-15
    I_C2591 (b30_26 VSS) capacitor c=2.284E-15
    I_C2592 (b30_25 VSS) capacitor c=2.510E-15
    I_C2593 (h30 VSS) capacitor c=3.740E-15
    I_C2594 (c30_o VSS) capacitor c=2.243E-15
    I_C2595 (p30_32 VSS) capacitor c=4.139E-15
    I_C2596 (b31_26 VSS) capacitor c=2.364E-15
    I_C2597 (h31 VSS) capacitor c=4.666E-15
    I_C2598 (c31_o VSS) capacitor c=2.678E-15
    I_C2599 (p31_32 VSS) capacitor c=2.288E-15
    I_C2600 (b0_25 VSS) capacitor c=2.859E-15
    I_C2601 (b0_27 VSS) capacitor c=4.399E-15
    I_C2602 (b0_26 VSS) capacitor c=6.608E-15
    I_C2603 (b1_27 VSS) capacitor c=1.744E-15
    I_C2604 (b1_25 VSS) capacitor c=2.560E-15
    I_C2605 (b2_25 VSS) capacitor c=2.487E-15
    I_C2606 (b2_27 VSS) capacitor c=2.451E-15
    I_C2607 (b3_30 VSS) capacitor c=2.988E-15
    I_C2608 (b3_28 VSS) capacitor c=3.750E-15
    I_C2609 (b3_29 VSS) capacitor c=2.696E-15
    I_C2610 (b3_27 VSS) capacitor c=2.582E-15
    I_C2611 (b29_29 VSS) capacitor c=2.165E-15
    I_C2612 (b29_28 VSS) capacitor c=2.153E-15
    I_C2613 (b29_27 VSS) capacitor c=2.568E-15
    I_C2614 (b29_26 VSS) capacitor c=2.125E-15
    I_C2615 (b30_27 VSS) capacitor c=1.951E-15
    I_C2616 (b30_28 VSS) capacitor c=1.898E-15
    I_C2617 (p29_31 VSS) capacitor c=4.130E-15
    I_C2618 (qu2_b3_5 VSS) capacitor c=1.957E-14
    I_C2619 (b30_31 VSS) capacitor c=2.260E-15
    I_C2620 (b30_30 VSS) capacitor c=2.014E-15
    I_C2621 (p30_31 VSS) capacitor c=1.988E-15
    I_C2622 (qu1_b3_5 VSS) capacitor c=1.886E-14
    I_C2623 (b31_27 VSS) capacitor c=2.422E-15
    I_C2624 (b31_28 VSS) capacitor c=2.866E-15
    I_C2625 (b31_31 VSS) capacitor c=2.472E-15
    I_C2626 (b31_30 VSS) capacitor c=2.081E-15
    I_C2627 (b0_29 VSS) capacitor c=2.488E-15
    I_C2628 (b1_29 VSS) capacitor c=2.058E-15
    I_C2629 (b1_28 VSS) capacitor c=2.610E-15
    I_C2630 (b1_26 VSS) capacitor c=2.392E-15
    I_C2631 (qu30_b3_5 VSS) capacitor c=1.557E-14
    I_C2632 (b2_30 VSS) capacitor c=3.033E-15
    I_C2633 (p1_31 VSS) capacitor c=2.967E-15
    I_C2634 (h2 VSS) capacitor c=9.464E-15
    I_C2635 (b2_26 VSS) capacitor c=2.001E-15
    I_C2636 (b2_29 VSS) capacitor c=2.385E-15
    I_C2637 (b2_28 VSS) capacitor c=2.486E-15
    I_C2638 (c2_o VSS) capacitor c=1.960E-15
    I_C2639 (p2_32 VSS) capacitor c=1.473E-15
    I_C2640 (b3_31 VSS) capacitor c=2.157E-15
    I_C2641 (b30_29 VSS) capacitor c=2.277E-15
    I_C2642 (b31_29 VSS) capacitor c=2.432E-15
    I_C2643 (b0_28 VSS) capacitor c=2.355E-15
    I_C2644 (b0_31 VSS) capacitor c=2.350E-15
    I_C2645 (b0_30 VSS) capacitor c=2.907E-15
    I_C2646 (p0_31 VSS) capacitor c=5.476E-15
    I_C2647 (qu31_b3_5 VSS) capacitor c=1.688E-14
    I_C2648 (h1 VSS) capacitor c=5.119E-15
    I_C2649 (b1_30 VSS) capacitor c=2.442E-15
    I_C2650 (b1_31 VSS) capacitor c=2.197E-15
    I_C2651 (c1_o VSS) capacitor c=2.331E-15
    I_C2652 (p1_32 VSS) capacitor c=1.547E-15
    I_C2653 (b2_31 VSS) capacitor c=2.279E-15
    I_C2654 (qu12 VSS) capacitor c=7.962E-16
    I_C2655 (qu12_b0 VSS) capacitor c=1.351E-15
    I_C2656 (qu15 VSS) capacitor c=7.595E-16
    I_C2657 (qu15_b0 VSS) capacitor c=9.580E-16
    I_C2658 (qu16 VSS) capacitor c=1.002E-15
    I_C2659 (qu16_b0 VSS) capacitor c=9.580E-16
    I_C2660 (qu11 VSS) capacitor c=7.536E-16
    I_C2661 (qu11_b0 VSS) capacitor c=9.424E-16
    I_C2662 (qu13 VSS) capacitor c=7.165E-16
    I_C2663 (qu13_b0 VSS) capacitor c=1.155E-15
    I_C2664 (qu14 VSS) capacitor c=1.498E-15
    I_C2665 (qu14_b0 VSS) capacitor c=8.041E-16
    I_C2666 (qu17 VSS) capacitor c=5.084E-15
    I_C2667 (qu17_b0 VSS) capacitor c=1.057E-15
    I_C2668 (I1206_G6_0 VSS) capacitor c=8.642E-15
    I_C2669 (I1206_G6_0n VSS) capacitor c=7.354E-16
    I_C2670 (I1206_G7_0 VSS) capacitor c=8.696E-15
    I_C2671 (I1206_G7_0n VSS) capacitor c=1.176E-15
    I_C2672 (I1482_G7_0 VSS) capacitor c=7.166E-15
    I_C2673 (I1482_G7_0n VSS) capacitor c=6.522E-16
    I_C2674 (I1206_G5_0 VSS) capacitor c=7.841E-15
    I_C2675 (I1206_G5_0n VSS) capacitor c=8.876E-16
    I_C2676 (I1436_G7_0 VSS) capacitor c=7.089E-15
    I_C2677 (I1436_G7_0n VSS) capacitor c=1.262E-15
    I_C2678 (I1390_G7_0 VSS) capacitor c=6.885E-15
    I_C2679 (I1390_G7_0n VSS) capacitor c=8.381E-16
    I_C2680 (I1344_G7_0 VSS) capacitor c=7.744E-15
    I_C2681 (I1344_G7_0n VSS) capacitor c=1.215E-15
    I_C2682 (I1298_G7_0 VSS) capacitor c=6.231E-15
    I_C2683 (I1298_G7_0n VSS) capacitor c=1.085E-15
    I_C2684 (I1252_G7_0 VSS) capacitor c=6.566E-15
    I_C2685 (I1252_G7_0n VSS) capacitor c=1.214E-15
    I_C2686 (I1206_G4_0 VSS) capacitor c=7.306E-15
    I_C2687 (I1206_G4_0n VSS) capacitor c=5.801E-16
    I_C2688 (I1206_G3_0np VSS) capacitor c=5.919E-16
    I_C2689 (I1252_G6_0 VSS) capacitor c=7.245E-15
    I_C2690 (I1252_G6_0n VSS) capacitor c=1.737E-15
    I_C2691 (I1206_G2_0np VSS) capacitor c=5.675E-16
    I_C2692 (I1160_G6_0 VSS) capacitor c=8.562E-15
    I_C2693 (I1160_G6_0n VSS) capacitor c=7.177E-16
    I_C2694 (I1482_G6_0 VSS) capacitor c=5.281E-15
    I_C2695 (I1482_G6_0n VSS) capacitor c=1.217E-15
    I_C2696 (I1482_G5_0 VSS) capacitor c=6.251E-15
    I_C2697 (I1482_G5_0n VSS) capacitor c=7.768E-16
    I_C2698 (I1436_G5_0 VSS) capacitor c=7.238E-15
    I_C2699 (I1436_G5_0n VSS) capacitor c=9.902E-16
    I_C2700 (I1436_G6_0 VSS) capacitor c=8.587E-15
    I_C2701 (I1436_G6_0n VSS) capacitor c=7.282E-16
    I_C2702 (I1390_G6_0 VSS) capacitor c=7.290E-15
    I_C2703 (I1390_G6_0n VSS) capacitor c=9.349E-16
    I_C2704 (I1344_G6_0 VSS) capacitor c=7.243E-15
    I_C2705 (I1344_G6_0n VSS) capacitor c=6.665E-16
    I_C2706 (I1298_G6_0 VSS) capacitor c=6.199E-15
    I_C2707 (I1298_G6_0n VSS) capacitor c=1.092E-15
    I_C2708 (I1252_G5_0 VSS) capacitor c=5.631E-15
    I_C2709 (I1252_G5_0n VSS) capacitor c=1.511E-15
    I_C2710 (I1206_G1_0 VSS) capacitor c=9.009E-15
    I_C2711 (I1206_G1_0n VSS) capacitor c=2.112E-15
    I_C2712 (I1160_G2_0np VSS) capacitor c=5.732E-16
    I_C2713 (I1390_G5_0 VSS) capacitor c=7.802E-15
    I_C2714 (I1390_G5_0n VSS) capacitor c=1.679E-15
    I_C2715 (I1344_G5_0 VSS) capacitor c=6.314E-15
    I_C2716 (I1344_G5_0n VSS) capacitor c=1.830E-15
    I_C2717 (I1298_G5_0 VSS) capacitor c=5.383E-15
    I_C2718 (I1298_G5_0n VSS) capacitor c=1.160E-15
    I_C2719 (I1160_G4_0 VSS) capacitor c=5.551E-15
    I_C2720 (I1160_G4_0n VSS) capacitor c=1.338E-15
    I_C2721 (I1528_G7_0 VSS) capacitor c=7.986E-15
    I_C2722 (I1528_G7_0n VSS) capacitor c=8.322E-16
    I_C2723 (I1436_G4_0 VSS) capacitor c=4.922E-15
    I_C2724 (I1436_G4_0n VSS) capacitor c=8.284E-16
    I_C2725 (I1390_G4_0 VSS) capacitor c=7.901E-15
    I_C2726 (I1390_G4_0n VSS) capacitor c=6.600E-16
    I_C2727 (I1298_G4_0 VSS) capacitor c=6.319E-15
    I_C2728 (I1298_G4_0n VSS) capacitor c=8.695E-16
    I_C2729 (I1252_G4_0 VSS) capacitor c=4.240E-15
    I_C2730 (I1252_G4_0n VSS) capacitor c=7.441E-16
    I_C2731 (I1160_G0_0 VSS) capacitor c=9.684E-15
    I_C2732 (I1160_G0_0n VSS) capacitor c=8.351E-15
    I_C2733 (I1482_G2_0np VSS) capacitor c=6.569E-16
    I_C2734 (I1482_G4_0 VSS) capacitor c=6.460E-15
    I_C2735 (I1482_G4_0n VSS) capacitor c=1.307E-15
    I_C2736 (I1482_G3_0np VSS) capacitor c=6.713E-16
    I_C2737 (I1436_G3_0np VSS) capacitor c=5.960E-16
    I_C2738 (I1390_G3_0np VSS) capacitor c=7.713E-16
    I_C2739 (I1298_G3_0np VSS) capacitor c=5.976E-16
    I_C2740 (I1252_G3_0np VSS) capacitor c=5.730E-16
    I_C2741 (I1160_G5_0 VSS) capacitor c=8.315E-15
    I_C2742 (I1160_G5_0n VSS) capacitor c=6.368E-16
    I_C2743 (qu18 VSS) capacitor c=8.083E-16
    I_C2744 (qu18_b0 VSS) capacitor c=9.296E-16
    I_C2745 (I1528_G6_0 VSS) capacitor c=6.378E-15
    I_C2746 (I1528_G6_0n VSS) capacitor c=9.402E-16
    I_C2747 (I1344_G3_0np VSS) capacitor c=7.046E-16
    I_C2748 (I1344_G4_0 VSS) capacitor c=7.011E-15
    I_C2749 (I1344_G4_0n VSS) capacitor c=7.921E-16
    I_C2750 (I1298_G2_0np VSS) capacitor c=5.813E-16
    I_C2751 (I1252_G2_0np VSS) capacitor c=1.315E-15
    I_C2752 (I1160_G1_0 VSS) capacitor c=6.834E-15
    I_C2753 (I1160_G1_0n VSS) capacitor c=2.056E-15
    I_C2754 (I1160_G3_0np VSS) capacitor c=9.370E-16
    I_C2755 (I1160_G7_0 VSS) capacitor c=8.095E-15
    I_C2756 (I1160_G7_0n VSS) capacitor c=5.990E-16
    I_C2757 (I1436_G2_0np VSS) capacitor c=5.756E-16
    I_C2758 (I1390_G2_0np VSS) capacitor c=7.334E-16
    I_C2759 (I1344_G2_0np VSS) capacitor c=6.184E-16
    I_C2760 (I1528_G5_0 VSS) capacitor c=6.439E-15
    I_C2761 (I1528_G5_0n VSS) capacitor c=7.726E-16
    I_C2762 (I1482_G1_0 VSS) capacitor c=6.290E-15
    I_C2763 (I1482_G1_0n VSS) capacitor c=2.504E-15
    I_C2764 (I1436_G1_0 VSS) capacitor c=5.892E-15
    I_C2765 (I1436_G1_0n VSS) capacitor c=2.784E-15
    I_C2766 (I1390_G1_0 VSS) capacitor c=6.416E-15
    I_C2767 (I1390_G1_0n VSS) capacitor c=2.276E-15
    I_C2768 (I1298_G1_0 VSS) capacitor c=5.711E-15
    I_C2769 (I1298_G1_0n VSS) capacitor c=2.433E-15
    I_C2770 (I1252_G1_0 VSS) capacitor c=6.724E-15
    I_C2771 (I1252_G1_0n VSS) capacitor c=2.477E-15
    I_C2772 (I1206_G0_0 VSS) capacitor c=8.074E-15
    I_C2773 (I1206_G0_0n VSS) capacitor c=6.195E-15
    I_C2774 (I1528_G3_0np VSS) capacitor c=8.668E-16
    I_C2775 (I1528_G2_0np VSS) capacitor c=6.066E-16
    I_C2776 (I1344_G1_0 VSS) capacitor c=5.240E-15
    I_C2777 (I1344_G1_0n VSS) capacitor c=2.533E-15
    I_C2778 (I1252_G0_0 VSS) capacitor c=6.156E-15
    I_C2779 (I1252_G0_0n VSS) capacitor c=3.553E-15
    I_C2780 (I1528_G4_0 VSS) capacitor c=4.701E-15
    I_C2781 (I1528_G4_0n VSS) capacitor c=1.002E-15
    I_C2782 (I1344_G0_0 VSS) capacitor c=7.253E-15
    I_C2783 (I1344_G0_0n VSS) capacitor c=4.942E-15
    I_C2784 (I1298_cinn VSS) capacitor c=8.837E-16
    I_C2785 (I1298_G0_0 VSS) capacitor c=5.635E-15
    I_C2786 (I1298_G0_0n VSS) capacitor c=2.993E-15
    I_C2787 (nqkn16 VSS) capacitor c=8.839E-15
    I_C2788 (nqk16 VSS) capacitor c=1.260E-15
    I_C2789 (I1114_G7_0 VSS) capacitor c=6.766E-15
    I_C2790 (I1114_G7_0n VSS) capacitor c=7.883E-16
    I_C2791 (qu19 VSS) capacitor c=7.769E-16
    I_C2792 (qu19_b0 VSS) capacitor c=8.868E-16
    I_C2793 (I1436_G0_0 VSS) capacitor c=6.420E-15
    I_C2794 (I1436_G0_0n VSS) capacitor c=3.639E-15
    I_C2795 (I1390_G0_0 VSS) capacitor c=5.383E-15
    I_C2796 (I1390_G0_0n VSS) capacitor c=3.805E-15
    I_C2797 (I1252_cinn VSS) capacitor c=9.006E-16
    I_C2798 (nqkn17 VSS) capacitor c=5.105E-15
    I_C2799 (nqk17 VSS) capacitor c=7.029E-16
    I_C2800 (I1206_cinn VSS) capacitor c=7.366E-16
    I_C2801 (nqkn18 VSS) capacitor c=3.132E-15
    I_C2802 (nqk18 VSS) capacitor c=8.034E-16
    I_C2803 (nqkn19 VSS) capacitor c=2.734E-15
    I_C2804 (nqk19 VSS) capacitor c=1.307E-15
    I_C2805 (I1160_cinn VSS) capacitor c=6.482E-16
    I_C2806 (I1114_G3_0np VSS) capacitor c=7.417E-16
    I_C2807 (I1114_G5_0 VSS) capacitor c=7.279E-15
    I_C2808 (I1114_G5_0n VSS) capacitor c=6.301E-16
    I_C2809 (I1528_G1_0 VSS) capacitor c=7.013E-15
    I_C2810 (I1528_G1_0n VSS) capacitor c=1.992E-15
    I_C2811 (I1482_G0_0 VSS) capacitor c=8.585E-15
    I_C2812 (I1482_G0_0n VSS) capacitor c=5.641E-15
    I_C2813 (nqkn12 VSS) capacitor c=5.319E-15
    I_C2814 (nqk12 VSS) capacitor c=8.958E-16
    I_C2815 (nqkn13 VSS) capacitor c=4.847E-15
    I_C2816 (nqk13 VSS) capacitor c=7.765E-16
    I_C2817 (nqkn14 VSS) capacitor c=2.439E-15
    I_C2818 (nqk14 VSS) capacitor c=3.402E-15
    I_C2819 (nqkn15 VSS) capacitor c=3.196E-15
    I_C2820 (nqk15 VSS) capacitor c=8.813E-16
    I_C2821 (I1344_cinn VSS) capacitor c=6.764E-16
    I_C2822 (nakn15 VSS) capacitor c=4.599E-15
    I_C2823 (nak15 VSS) capacitor c=1.057E-15
    I_C2824 (nakn16 VSS) capacitor c=6.764E-15
    I_C2825 (nak16 VSS) capacitor c=1.032E-15
    I_C2826 (nakn17 VSS) capacitor c=2.426E-15
    I_C2827 (nak17 VSS) capacitor c=8.405E-16
    I_C2828 (nakn18 VSS) capacitor c=2.827E-15
    I_C2829 (nak18 VSS) capacitor c=6.192E-16
    I_C2830 (I1114_cinn VSS) capacitor c=6.490E-16
    I_C2831 (I1114_G1_0 VSS) capacitor c=4.488E-15
    I_C2832 (I1114_G1_0n VSS) capacitor c=3.370E-15
    I_C2833 (I1528_G0_0 VSS) capacitor c=8.158E-15
    I_C2834 (I1528_G0_0n VSS) capacitor c=1.888E-15
    I_C2835 (nqkn11 VSS) capacitor c=8.790E-15
    I_C2836 (nqk11 VSS) capacitor c=1.002E-15
    I_C2837 (I1482_cinn VSS) capacitor c=9.098E-16
    I_C2838 (nakn11 VSS) capacitor c=7.863E-15
    I_C2839 (nak11 VSS) capacitor c=1.088E-15
    I_C2840 (I1436_cinn VSS) capacitor c=8.247E-16
    I_C2841 (nakn12 VSS) capacitor c=4.765E-15
    I_C2842 (nak12 VSS) capacitor c=1.019E-15
    I_C2843 (I1390_cinn VSS) capacitor c=6.516E-16
    I_C2844 (nakn13 VSS) capacitor c=3.540E-15
    I_C2845 (nak13 VSS) capacitor c=8.654E-16
    I_C2846 (nakn14 VSS) capacitor c=4.499E-15
    I_C2847 (nak14 VSS) capacitor c=8.413E-16
    I_C2848 (qu22 VSS) capacitor c=1.793E-15
    I_C2849 (qu22_b0 VSS) capacitor c=1.195E-15
    I_C2850 (nakn19 VSS) capacitor c=2.096E-15
    I_C2851 (nak19 VSS) capacitor c=8.391E-16
    I_C2852 (nakn20 VSS) capacitor c=2.260E-15
    I_C2853 (nak20 VSS) capacitor c=8.851E-16
    I_C2854 (nqkn20 VSS) capacitor c=3.948E-15
    I_C2855 (nqk20 VSS) capacitor c=9.857E-16
    I_C2856 (I1114_G0_0 VSS) capacitor c=5.141E-15
    I_C2857 (I1114_G0_0n VSS) capacitor c=4.321E-15
    I_C2858 (qu10 VSS) capacitor c=1.003E-15
    I_C2859 (qu10_b0 VSS) capacitor c=1.498E-15
    I_C2860 (I1528_cinn VSS) capacitor c=6.322E-16
    I_C2861 (nakn10 VSS) capacitor c=1.093E-14
    I_C2862 (nak10 VSS) capacitor c=8.749E-16
    I_C2863 (I1114_G2_0np VSS) capacitor c=5.785E-16
    I_C2864 (I1114_G4_0 VSS) capacitor c=4.875E-15
    I_C2865 (I1114_G4_0n VSS) capacitor c=9.480E-16
    I_C2866 (I1114_G6_0 VSS) capacitor c=5.121E-15
    I_C2867 (I1114_G6_0n VSS) capacitor c=7.718E-16
    I_C2868 (nqkn21 VSS) capacitor c=2.233E-15
    I_C2869 (nqk21 VSS) capacitor c=6.448E-16
    I_C2870 (I1068_cinn VSS) capacitor c=6.710E-16
    I_C2871 (qu9 VSS) capacitor c=9.009E-16
    I_C2872 (qu9_b0 VSS) capacitor c=9.192E-16
    I_C2873 (qu8 VSS) capacitor c=1.036E-15
    I_C2874 (qu8_b0 VSS) capacitor c=1.140E-15
    I_C2875 (I976_G7_0 VSS) capacitor c=9.429E-15
    I_C2876 (I976_G7_0n VSS) capacitor c=9.316E-16
    I_C2877 (I976_G6_0 VSS) capacitor c=8.678E-15
    I_C2878 (I976_G6_0n VSS) capacitor c=7.961E-16
    I_C2879 (nqkn22 VSS) capacitor c=2.953E-15
    I_C2880 (nqk22 VSS) capacitor c=7.448E-15
    I_C2881 (I1620_G7_0 VSS) capacitor c=8.180E-15
    I_C2882 (I1620_G7_0n VSS) capacitor c=1.087E-15
    I_C2883 (I976_G5_0 VSS) capacitor c=6.005E-15
    I_C2884 (I976_G5_0n VSS) capacitor c=1.367E-15
    I_C2885 (I976_G4_0 VSS) capacitor c=7.791E-15
    I_C2886 (I976_G4_0n VSS) capacitor c=9.059E-16
    I_C2887 (I1022_G7_0 VSS) capacitor c=6.320E-15
    I_C2888 (I1022_G7_0n VSS) capacitor c=8.020E-16
    I_C2889 (qu21 VSS) capacitor c=1.491E-15
    I_C2890 (qu21_b0 VSS) capacitor c=2.430E-15
    I_C2891 (I1574_G7_0 VSS) capacitor c=6.917E-15
    I_C2892 (I1574_G7_0n VSS) capacitor c=1.299E-15
    I_C2893 (I1620_G6_0 VSS) capacitor c=6.637E-15
    I_C2894 (I1620_G6_0n VSS) capacitor c=1.386E-15
    I_C2895 (I1666_G7_0 VSS) capacitor c=7.042E-15
    I_C2896 (I1666_G7_0n VSS) capacitor c=9.040E-16
    I_C2897 (I930_G6_0 VSS) capacitor c=5.987E-15
    I_C2898 (I930_G6_0n VSS) capacitor c=1.393E-15
    I_C2899 (I976_G3_0np VSS) capacitor c=7.855E-16
    I_C2900 (I1022_G6_0 VSS) capacitor c=6.302E-15
    I_C2901 (I1022_G6_0n VSS) capacitor c=7.560E-16
    I_C2902 (qu20 VSS) capacitor c=7.185E-16
    I_C2903 (qu20_b0 VSS) capacitor c=9.135E-16
    I_C2904 (I1620_G5_0 VSS) capacitor c=5.863E-15
    I_C2905 (I1620_G5_0n VSS) capacitor c=1.306E-15
    I_C2906 (I1666_G6_0 VSS) capacitor c=6.422E-15
    I_C2907 (I1666_G6_0n VSS) capacitor c=8.343E-16
    I_C2908 (I930_G5_0 VSS) capacitor c=5.339E-15
    I_C2909 (I930_G5_0n VSS) capacitor c=9.333E-16
    I_C2910 (I930_G7_0 VSS) capacitor c=5.865E-15
    I_C2911 (I930_G7_0n VSS) capacitor c=1.045E-15
    I_C2912 (I1022_G5_0 VSS) capacitor c=5.967E-15
    I_C2913 (I1022_G5_0n VSS) capacitor c=1.042E-15
    I_C2914 (I1574_G6_0 VSS) capacitor c=5.052E-15
    I_C2915 (I1574_G6_0n VSS) capacitor c=1.685E-15
    I_C2916 (I1574_G5_0 VSS) capacitor c=4.790E-15
    I_C2917 (I1574_G5_0n VSS) capacitor c=8.026E-16
    I_C2918 (I1620_G4_0 VSS) capacitor c=4.638E-15
    I_C2919 (I1620_G4_0n VSS) capacitor c=7.983E-16
    I_C2920 (I1620_G3_0np VSS) capacitor c=5.880E-16
    I_C2921 (I1666_G5_0 VSS) capacitor c=5.116E-15
    I_C2922 (I1666_G5_0n VSS) capacitor c=1.016E-15
    I_C2923 (I930_G2_0np VSS) capacitor c=6.059E-16
    I_C2924 (I976_G2_0np VSS) capacitor c=5.990E-16
    I_C2925 (I1574_G3_0np VSS) capacitor c=5.648E-16
    I_C2926 (I930_G3_0np VSS) capacitor c=5.521E-16
    I_C2927 (I930_G4_0 VSS) capacitor c=4.104E-15
    I_C2928 (I930_G4_0n VSS) capacitor c=8.373E-16
    I_C2929 (I1022_G4_0 VSS) capacitor c=4.908E-15
    I_C2930 (I1022_G4_0n VSS) capacitor c=8.587E-16
    I_C2931 (I1022_G3_0np VSS) capacitor c=5.758E-16
    I_C2932 (I1620_G2_0np VSS) capacitor c=1.426E-15
    I_C2933 (I1620_G1_0 VSS) capacitor c=6.086E-15
    I_C2934 (I1620_G1_0n VSS) capacitor c=2.074E-15
    I_C2935 (I1666_G3_0np VSS) capacitor c=5.963E-16
    I_C2936 (I1666_G4_0 VSS) capacitor c=5.552E-15
    I_C2937 (I1666_G4_0n VSS) capacitor c=8.330E-16
    I_C2938 (qu23 VSS) capacitor c=7.548E-16
    I_C2939 (qu23_b0 VSS) capacitor c=7.933E-16
    I_C2940 (I976_G1_0 VSS) capacitor c=6.889E-15
    I_C2941 (I976_G1_0n VSS) capacitor c=2.188E-15
    I_C2942 (I1022_G2_0np VSS) capacitor c=5.526E-16
    I_C2943 (I1574_G2_0np VSS) capacitor c=5.925E-16
    I_C2944 (I1574_G1_0 VSS) capacitor c=4.762E-15
    I_C2945 (I1574_G1_0n VSS) capacitor c=2.489E-15
    I_C2946 (I1666_G1_0 VSS) capacitor c=5.098E-15
    I_C2947 (I1666_G1_0n VSS) capacitor c=2.065E-15
    I_C2948 (I1666_G2_0np VSS) capacitor c=1.059E-15
    I_C2949 (I930_G1_0 VSS) capacitor c=8.884E-15
    I_C2950 (I930_G1_0n VSS) capacitor c=2.123E-15
    I_C2951 (I976_G0_0 VSS) capacitor c=8.397E-15
    I_C2952 (I976_G0_0n VSS) capacitor c=5.680E-15
    I_C2953 (I1022_G1_0 VSS) capacitor c=5.181E-15
    I_C2954 (I1022_G1_0n VSS) capacitor c=3.030E-15
    I_C2955 (I1068_G4_0 VSS) capacitor c=5.756E-15
    I_C2956 (I1068_G4_0n VSS) capacitor c=1.135E-15
    I_C2957 (I1574_G4_0 VSS) capacitor c=5.016E-15
    I_C2958 (I1574_G4_0n VSS) capacitor c=6.291E-16
    I_C2959 (nqkn10 VSS) capacitor c=2.300E-15
    I_C2960 (nqk10 VSS) capacitor c=7.836E-16
    I_C2961 (nakn9 VSS) capacitor c=3.211E-15
    I_C2962 (nak9 VSS) capacitor c=6.256E-16
    I_C2963 (I1068_G6_0 VSS) capacitor c=4.935E-15
    I_C2964 (I1068_G6_0n VSS) capacitor c=1.790E-15
    I_C2965 (nqkn9 VSS) capacitor c=2.365E-15
    I_C2966 (nqk9 VSS) capacitor c=8.257E-16
    I_C2967 (I1574_cinn VSS) capacitor c=8.182E-16
    I_C2968 (I1620_G0_0 VSS) capacitor c=5.562E-15
    I_C2969 (I1620_G0_0n VSS) capacitor c=3.552E-15
    I_C2970 (I930_G0_0 VSS) capacitor c=7.059E-15
    I_C2971 (I930_G0_0n VSS) capacitor c=4.003E-15
    I_C2972 (qu24 VSS) capacitor c=1.964E-15
    I_C2973 (qu24_b0 VSS) capacitor c=1.704E-15
    I_C2974 (I1022_G0_0 VSS) capacitor c=4.564E-15
    I_C2975 (I1022_G0_0n VSS) capacitor c=3.048E-15
    I_C2976 (I1068_G0_0 VSS) capacitor c=1.240E-14
    I_C2977 (I1068_G0_0n VSS) capacitor c=4.851E-15
    I_C2978 (I1068_G2_0np VSS) capacitor c=6.792E-16
    I_C2979 (I1574_G0_0 VSS) capacitor c=6.346E-15
    I_C2980 (I1574_G0_0n VSS) capacitor c=5.191E-15
    I_C2981 (I1620_cinn VSS) capacitor c=6.653E-16
    I_C2982 (qu7 VSS) capacitor c=7.390E-15
    I_C2983 (qu7_b0 VSS) capacitor c=8.932E-16
    I_C2984 (I1666_G0_0 VSS) capacitor c=1.054E-14
    I_C2985 (I1666_G0_0n VSS) capacitor c=6.062E-15
    I_C2986 (I930_cinn VSS) capacitor c=6.221E-16
    I_C2987 (I1022_cinn VSS) capacitor c=8.462E-16
    I_C2988 (nqkn23 VSS) capacitor c=2.131E-15
    I_C2989 (nqk23 VSS) capacitor c=8.933E-16
    I_C2990 (nqkn8 VSS) capacitor c=2.682E-15
    I_C2991 (nqk8 VSS) capacitor c=1.432E-15
    I_C2992 (nakn8 VSS) capacitor c=3.101E-15
    I_C2993 (nak8 VSS) capacitor c=6.934E-16
    I_C2994 (nakn7 VSS) capacitor c=8.547E-15
    I_C2995 (nak7 VSS) capacitor c=8.593E-16
    I_C2996 (I1666_cinn VSS) capacitor c=6.914E-16
    I_C2997 (nakn23 VSS) capacitor c=5.013E-15
    I_C2998 (nak23 VSS) capacitor c=1.129E-15
    I_C2999 (I976_cinn VSS) capacitor c=6.454E-16
    I_C3000 (I1068_G3_0np VSS) capacitor c=5.718E-16
    I_C3001 (I1068_G7_0 VSS) capacitor c=5.428E-15
    I_C3002 (I1068_G7_0n VSS) capacitor c=6.239E-16
    I_C3003 (nqkn7 VSS) capacitor c=1.901E-15
    I_C3004 (nqk7 VSS) capacitor c=1.225E-15
    I_C3005 (qu6 VSS) capacitor c=8.150E-16
    I_C3006 (qu6_b0 VSS) capacitor c=1.086E-15
    I_C3007 (I884_G7_0 VSS) capacitor c=6.685E-15
    I_C3008 (I884_G7_0n VSS) capacitor c=6.042E-16
    I_C3009 (nakn22 VSS) capacitor c=2.055E-15
    I_C3010 (nak22 VSS) capacitor c=9.075E-16
    I_C3011 (nakn21 VSS) capacitor c=1.343E-14
    I_C3012 (nak21 VSS) capacitor c=7.066E-16
    I_C3013 (nqkn24 VSS) capacitor c=2.304E-15
    I_C3014 (nqk24 VSS) capacitor c=6.594E-16
    I_C3015 (nqkn25 VSS) capacitor c=2.253E-15
    I_C3016 (nqk25 VSS) capacitor c=9.218E-16
    I_C3017 (I1068_G1_0 VSS) capacitor c=9.516E-15
    I_C3018 (I1068_G1_0n VSS) capacitor c=1.906E-15
    I_C3019 (qu5 VSS) capacitor c=1.116E-15
    I_C3020 (qu5_b0 VSS) capacitor c=8.586E-16
    I_C3021 (qu26 VSS) capacitor c=2.277E-15
    I_C3022 (qu26_b0 VSS) capacitor c=1.628E-15
    I_C3023 (nqkn26 VSS) capacitor c=2.533E-15
    I_C3024 (nqk26 VSS) capacitor c=6.705E-16
    I_C3025 (I1068_G5_0 VSS) capacitor c=5.891E-15
    I_C3026 (I1068_G5_0n VSS) capacitor c=1.311E-15
    I_C3027 (I792_G7_0 VSS) capacitor c=9.238E-15
    I_C3028 (I792_G7_0n VSS) capacitor c=6.445E-16
    I_C3029 (qu4 VSS) capacitor c=6.922E-16
    I_C3030 (qu4_b0 VSS) capacitor c=6.259E-15
    I_C3031 (I1712_G7_0 VSS) capacitor c=5.652E-15
    I_C3032 (I1712_G7_0n VSS) capacitor c=1.568E-15
    I_C3033 (qu25 VSS) capacitor c=1.059E-15
    I_C3034 (qu25_b0 VSS) capacitor c=8.322E-16
    I_C3035 (I1758_G7_0 VSS) capacitor c=6.603E-15
    I_C3036 (I1758_G7_0n VSS) capacitor c=1.334E-15
    I_C3037 (I1758_G6_0 VSS) capacitor c=7.062E-15
    I_C3038 (I1758_G6_0n VSS) capacitor c=6.665E-16
    I_C3039 (I884_G3_0np VSS) capacitor c=6.108E-16
    I_C3040 (I838_G7_0 VSS) capacitor c=7.289E-15
    I_C3041 (I838_G7_0n VSS) capacitor c=8.666E-16
    I_C3042 (I1804_G7_0 VSS) capacitor c=6.393E-15
    I_C3043 (I1804_G7_0n VSS) capacitor c=8.150E-16
    I_C3044 (I1712_G5_0 VSS) capacitor c=6.647E-15
    I_C3045 (I1712_G5_0n VSS) capacitor c=8.216E-16
    I_C3046 (I838_G6_0 VSS) capacitor c=6.290E-15
    I_C3047 (I838_G6_0n VSS) capacitor c=1.010E-15
    I_C3048 (I792_G6_0 VSS) capacitor c=7.271E-15
    I_C3049 (I792_G6_0n VSS) capacitor c=8.646E-16
    I_C3050 (I792_G5_0 VSS) capacitor c=7.693E-15
    I_C3051 (I792_G5_0n VSS) capacitor c=8.184E-16
    I_C3052 (I746_G6_0 VSS) capacitor c=5.864E-15
    I_C3053 (I746_G6_0n VSS) capacitor c=8.008E-16
    I_C3054 (I1804_G5_0 VSS) capacitor c=8.815E-15
    I_C3055 (I1804_G5_0n VSS) capacitor c=9.405E-16
    I_C3056 (I1758_G5_0 VSS) capacitor c=6.606E-15
    I_C3057 (I1758_G5_0n VSS) capacitor c=7.545E-16
    I_C3058 (I884_G5_0 VSS) capacitor c=4.755E-15
    I_C3059 (I884_G5_0n VSS) capacitor c=1.245E-15
    I_C3060 (I884_G4_0 VSS) capacitor c=4.553E-15
    I_C3061 (I884_G4_0n VSS) capacitor c=8.182E-16
    I_C3062 (I884_G6_0 VSS) capacitor c=6.892E-15
    I_C3063 (I884_G6_0n VSS) capacitor c=1.377E-15
    I_C3064 (I1758_G3_0np VSS) capacitor c=7.857E-16
    I_C3065 (I1758_G4_0 VSS) capacitor c=5.974E-15
    I_C3066 (I1758_G4_0n VSS) capacitor c=7.660E-16
    I_C3067 (I1712_G3_0np VSS) capacitor c=5.606E-16
    I_C3068 (I1712_G6_0 VSS) capacitor c=6.483E-15
    I_C3069 (I1712_G6_0n VSS) capacitor c=1.019E-15
    I_C3070 (I838_G5_0 VSS) capacitor c=4.615E-15
    I_C3071 (I838_G5_0n VSS) capacitor c=7.840E-16
    I_C3072 (I838_G3_0np VSS) capacitor c=6.043E-16
    I_C3073 (I792_G4_0 VSS) capacitor c=5.556E-15
    I_C3074 (I792_G4_0n VSS) capacitor c=1.309E-15
    I_C3075 (I792_G3_0np VSS) capacitor c=8.944E-16
    I_C3076 (I746_G2_0np VSS) capacitor c=1.077E-15
    I_C3077 (I746_G4_0 VSS) capacitor c=7.442E-15
    I_C3078 (I746_G4_0n VSS) capacitor c=9.695E-16
    I_C3079 (I1804_G6_0 VSS) capacitor c=8.061E-15
    I_C3080 (I1804_G6_0n VSS) capacitor c=9.530E-16
    I_C3081 (I1804_G3_0np VSS) capacitor c=5.970E-16
    I_C3082 (I1758_G2_0np VSS) capacitor c=5.751E-16
    I_C3083 (I1712_G1_0 VSS) capacitor c=5.281E-15
    I_C3084 (I1712_G1_0n VSS) capacitor c=2.628E-15
    I_C3085 (I1712_G2_0np VSS) capacitor c=7.854E-16
    I_C3086 (I884_G2_0np VSS) capacitor c=6.165E-16
    I_C3087 (I838_G4_0 VSS) capacitor c=5.739E-15
    I_C3088 (I838_G4_0n VSS) capacitor c=7.509E-16
    I_C3089 (I792_G2_0np VSS) capacitor c=6.990E-16
    I_C3090 (I746_G5_0 VSS) capacitor c=7.997E-15
    I_C3091 (I746_G5_0n VSS) capacitor c=1.016E-15
    I_C3092 (I1758_G1_0 VSS) capacitor c=8.376E-15
    I_C3093 (I1758_G1_0n VSS) capacitor c=2.777E-15
    I_C3094 (I1712_G4_0 VSS) capacitor c=5.087E-15
    I_C3095 (I1712_G4_0n VSS) capacitor c=1.196E-15
    I_C3096 (I838_G2_0np VSS) capacitor c=5.557E-16
    I_C3097 (I1804_G4_0 VSS) capacitor c=8.462E-15
    I_C3098 (I1804_G4_0n VSS) capacitor c=6.583E-16
    I_C3099 (I1804_G1_0 VSS) capacitor c=8.213E-15
    I_C3100 (I1804_G1_0n VSS) capacitor c=1.707E-15
    I_C3101 (dd24 VSS) capacitor c=2.313E-15
    I_C3102 (dd24_b0 VSS) capacitor c=8.198E-16
    I_C3103 (I884_G1_0 VSS) capacitor c=7.402E-15
    I_C3104 (I884_G1_0n VSS) capacitor c=2.834E-15
    I_C3105 (I838_G1_0 VSS) capacitor c=5.814E-15
    I_C3106 (I838_G1_0n VSS) capacitor c=2.350E-15
    I_C3107 (I792_G1_0 VSS) capacitor c=7.266E-15
    I_C3108 (I792_G1_0n VSS) capacitor c=2.126E-15
    I_C3109 (I746_G1_0 VSS) capacitor c=7.800E-15
    I_C3110 (I746_G1_0n VSS) capacitor c=1.914E-15
    I_C3111 (I746_G3_0np VSS) capacitor c=7.270E-16
    I_C3112 (I746_G7_0 VSS) capacitor c=8.761E-15
    I_C3113 (I746_G7_0n VSS) capacitor c=8.671E-16
    I_C3114 (I1804_G2_0np VSS) capacitor c=8.049E-16
    I_C3115 (nqkn6 VSS) capacitor c=3.558E-15
    I_C3116 (nqk6 VSS) capacitor c=1.083E-14
    I_C3117 (nakn6 VSS) capacitor c=3.138E-15
    I_C3118 (nak6 VSS) capacitor c=1.611E-15
    I_C3119 (I1758_G0_0 VSS) capacitor c=4.095E-15
    I_C3120 (I1758_G0_0n VSS) capacitor c=3.096E-15
    I_C3121 (dd25 VSS) capacitor c=1.402E-15
    I_C3122 (dd25_b0 VSS) capacitor c=7.835E-16
    I_C3123 (dd26 VSS) capacitor c=9.169E-16
    I_C3124 (dd26_b0 VSS) capacitor c=9.101E-16
    I_C3125 (dd27 VSS) capacitor c=9.339E-16
    I_C3126 (dd27_b0 VSS) capacitor c=9.328E-16
    I_C3127 (I884_G0_0 VSS) capacitor c=6.703E-15
    I_C3128 (I884_G0_0n VSS) capacitor c=3.279E-15
    I_C3129 (I884_cinn VSS) capacitor c=1.094E-15
    I_C3130 (I838_G0_0 VSS) capacitor c=4.232E-15
    I_C3131 (I838_G0_0n VSS) capacitor c=4.422E-15
    I_C3132 (I746_G0_0 VSS) capacitor c=1.156E-14
    I_C3133 (I746_G0_0n VSS) capacitor c=4.820E-15
    I_C3134 (I1804_G0_0 VSS) capacitor c=9.058E-15
    I_C3135 (I1804_G0_0n VSS) capacitor c=5.280E-15
    I_C3136 (I1758_cinn VSS) capacitor c=7.718E-16
    I_C3137 (I1712_cinn VSS) capacitor c=8.060E-16
    I_C3138 (I1712_G0_0 VSS) capacitor c=8.294E-15
    I_C3139 (I1712_G0_0n VSS) capacitor c=5.422E-15
    I_C3140 (nbkn25 VSS) capacitor c=2.936E-15
    I_C3141 (nbk25 VSS) capacitor c=8.702E-16
    I_C3142 (nbkn26 VSS) capacitor c=2.458E-15
    I_C3143 (nbk26 VSS) capacitor c=9.357E-16
    I_C3144 (nbkn27 VSS) capacitor c=2.023E-15
    I_C3145 (nbk27 VSS) capacitor c=1.112E-15
    I_C3146 (dd28 VSS) capacitor c=1.029E-15
    I_C3147 (dd28_b0 VSS) capacitor c=9.018E-16
    I_C3148 (dd30 VSS) capacitor c=1.336E-15
    I_C3149 (dd30_b0 VSS) capacitor c=8.189E-16
    I_C3150 (dd31 VSS) capacitor c=1.507E-15
    I_C3151 (dd31_b0 VSS) capacitor c=8.207E-16
    I_C3152 (qu27 VSS) capacitor c=8.849E-16
    I_C3153 (qu27_b0 VSS) capacitor c=1.645E-15
    I_C3154 (nqkn5 VSS) capacitor c=2.933E-15
    I_C3155 (nqk5 VSS) capacitor c=6.543E-16
    I_C3156 (dd22 VSS) capacitor c=2.094E-15
    I_C3157 (dd22_b0 VSS) capacitor c=9.703E-16
    I_C3158 (dd23 VSS) capacitor c=1.189E-15
    I_C3159 (dd23_b0 VSS) capacitor c=1.214E-15
    I_C3160 (nbkn24 VSS) capacitor c=2.437E-15
    I_C3161 (nbk24 VSS) capacitor c=6.807E-16
    I_C3162 (nbkn28 VSS) capacitor c=2.022E-15
    I_C3163 (nbk28 VSS) capacitor c=7.573E-16
    I_C3164 (dd29 VSS) capacitor c=1.001E-15
    I_C3165 (dd29_b0 VSS) capacitor c=1.213E-15
    I_C3166 (I792_G0_0 VSS) capacitor c=5.348E-15
    I_C3167 (I792_G0_0n VSS) capacitor c=3.961E-15
    I_C3168 (nqkn27 VSS) capacitor c=1.189E-14
    I_C3169 (nqk27 VSS) capacitor c=7.199E-16
    I_C3170 (I1804_cinn VSS) capacitor c=6.108E-16
    I_C3171 (nakn5 VSS) capacitor c=1.885E-15
    I_C3172 (nak5 VSS) capacitor c=6.441E-16
    I_C3173 (nakn4 VSS) capacitor c=2.871E-15
    I_C3174 (nak4 VSS) capacitor c=8.278E-16
    I_C3175 (nakn3 VSS) capacitor c=3.459E-15
    I_C3176 (nak3 VSS) capacitor c=7.140E-16
    I_C3177 (nakn2 VSS) capacitor c=1.853E-15
    I_C3178 (nak2 VSS) capacitor c=8.771E-16
    I_C3179 (nbkn23 VSS) capacitor c=2.257E-15
    I_C3180 (nbk23 VSS) capacitor c=8.378E-16
    I_C3181 (dd19 VSS) capacitor c=1.367E-15
    I_C3182 (dd19_b0 VSS) capacitor c=1.403E-15
    I_C3183 (dd18 VSS) capacitor c=1.903E-15
    I_C3184 (dd18_b0 VSS) capacitor c=1.081E-15
    I_C3185 (nbkn29 VSS) capacitor c=1.982E-15
    I_C3186 (nbk29 VSS) capacitor c=6.590E-16
    I_C3187 (dd17 VSS) capacitor c=1.195E-15
    I_C3188 (dd17_b0 VSS) capacitor c=8.398E-16
    I_C3189 (nbkn30 VSS) capacitor c=2.807E-15
    I_C3190 (nbk30 VSS) capacitor c=6.514E-16
    I_C3191 (sq_b0 VSS) capacitor c=1.011E-15
    I_C3192 (dd13 VSS) capacitor c=1.548E-15
    I_C3193 (dd13_b0 VSS) capacitor c=8.644E-16
    I_C3194 (dd15 VSS) capacitor c=2.281E-15
    I_C3195 (dd15_b0 VSS) capacitor c=9.128E-16
    I_C3196 (dd12 VSS) capacitor c=1.384E-15
    I_C3197 (dd12_b0 VSS) capacitor c=9.771E-16
    I_C3198 (dd8 VSS) capacitor c=2.869E-15
    I_C3199 (dd8_b0 VSS) capacitor c=1.183E-15
    I_C3200 (I838_cinn VSS) capacitor c=6.406E-16
    I_C3201 (I792_cinn VSS) capacitor c=6.214E-16
    I_C3202 (I746_cinn VSS) capacitor c=6.586E-16
    I_C3203 (nqkn28 VSS) capacitor c=2.089E-15
    I_C3204 (nqk28 VSS) capacitor c=7.169E-16
    I_C3205 (I700_G4_0 VSS) capacitor c=7.236E-15
    I_C3206 (I700_G4_0n VSS) capacitor c=9.390E-16
    I_C3207 (nqkn4 VSS) capacitor c=2.714E-15
    I_C3208 (nqk4 VSS) capacitor c=1.137E-15
    I_C3209 (I1850_cinn VSS) capacitor c=6.651E-16
    I_C3210 (I1896_cinn VSS) capacitor c=6.269E-16
    I_C3211 (nakn1 VSS) capacitor c=2.146E-15
    I_C3212 (nak1 VSS) capacitor c=1.055E-15
    I_C3213 (I1988_cinn VSS) capacitor c=7.295E-16
    I_C3214 (dd21 VSS) capacitor c=9.145E-16
    I_C3215 (dd21_b0 VSS) capacitor c=1.548E-15
    I_C3216 (dd20 VSS) capacitor c=1.453E-15
    I_C3217 (dd20_b0 VSS) capacitor c=2.030E-15
    I_C3218 (nbkn22 VSS) capacitor c=1.825E-15
    I_C3219 (nbk22 VSS) capacitor c=6.889E-16
    I_C3220 (dd16 VSS) capacitor c=1.467E-15
    I_C3221 (dd16_b0 VSS) capacitor c=1.298E-15
    I_C3222 (nbkn12 VSS) capacitor c=1.779E-15
    I_C3223 (nbk12 VSS) capacitor c=7.592E-16
    I_C3224 (dd9 VSS) capacitor c=1.907E-15
    I_C3225 (dd9_b0 VSS) capacitor c=9.406E-16
    I_C3226 (dd11 VSS) capacitor c=9.977E-16
    I_C3227 (dd11_b0 VSS) capacitor c=9.345E-16
    I_C3228 (dd10 VSS) capacitor c=1.173E-15
    I_C3229 (dd10_b0 VSS) capacitor c=9.176E-16
    I_C3230 (dd7 VSS) capacitor c=1.781E-15
    I_C3231 (dd7_b0 VSS) capacitor c=1.076E-15
    I_C3232 (dd2 VSS) capacitor c=1.152E-15
    I_C3233 (dd2_b0 VSS) capacitor c=8.982E-16
    I_C3234 (dd4 VSS) capacitor c=2.356E-15
    I_C3235 (dd4_b0 VSS) capacitor c=8.704E-16
    I_C3236 (dd1 VSS) capacitor c=1.179E-15
    I_C3237 (dd1_b0 VSS) capacitor c=9.901E-16
    I_C3238 (nakn24 VSS) capacitor c=1.393E-14
    I_C3239 (nak24 VSS) capacitor c=6.882E-16
    I_C3240 (nakn25 VSS) capacitor c=2.096E-15
    I_C3241 (nak25 VSS) capacitor c=1.085E-15
    I_C3242 (nakn26 VSS) capacitor c=4.753E-15
    I_C3243 (nak26 VSS) capacitor c=9.741E-16
    I_C3244 (nakn27 VSS) capacitor c=1.845E-15
    I_C3245 (nak27 VSS) capacitor c=1.212E-15
    I_C3246 (nakn28 VSS) capacitor c=1.953E-15
    I_C3247 (nak28 VSS) capacitor c=1.033E-15
    I_C3248 (I700_cinn VSS) capacitor c=6.661E-16
    I_C3249 (I700_G0_0 VSS) capacitor c=9.471E-15
    I_C3250 (I700_G0_0n VSS) capacitor c=5.128E-15
    I_C3251 (nqkn3 VSS) capacitor c=3.860E-15
    I_C3252 (nqk3 VSS) capacitor c=1.049E-15
    I_C3253 (I1942_cinn VSS) capacitor c=6.297E-16
    I_C3254 (dmn1 VSS) capacitor c=1.101E-15
    I_C3255 (dm1 VSS) capacitor c=3.044E-15
    I_C3256 (dmn0 VSS) capacitor c=1.124E-15
    I_C3257 (dm0 VSS) capacitor c=1.452E-15
    I_C3258 (nbkn21 VSS) capacitor c=2.173E-15
    I_C3259 (nbk21 VSS) capacitor c=1.224E-15
    I_C3260 (I2066_cinn VSS) capacitor c=6.138E-16
    I_C3261 (nbkn20 VSS) capacitor c=2.247E-15
    I_C3262 (nbk20 VSS) capacitor c=7.382E-16
    I_C3263 (nbkn19 VSS) capacitor c=2.941E-15
    I_C3264 (nbk19 VSS) capacitor c=8.172E-16
    I_C3265 (nbkn18 VSS) capacitor c=1.846E-15
    I_C3266 (nbk18 VSS) capacitor c=6.646E-16
    I_C3267 (nbkn17 VSS) capacitor c=2.006E-15
    I_C3268 (nbk17 VSS) capacitor c=7.579E-16
    I_C3269 (nbkn16 VSS) capacitor c=1.847E-15
    I_C3270 (nbk16 VSS) capacitor c=8.551E-16
    I_C3271 (dd14 VSS) capacitor c=1.029E-15
    I_C3272 (dd14_b0 VSS) capacitor c=1.542E-15
    I_C3273 (nbkn13 VSS) capacitor c=2.511E-15
    I_C3274 (nbk13 VSS) capacitor c=8.559E-16
    I_C3275 (nbkn11 VSS) capacitor c=1.939E-15
    I_C3276 (nbk11 VSS) capacitor c=9.971E-16
    I_C3277 (nbkn10 VSS) capacitor c=2.331E-15
    I_C3278 (nbk10 VSS) capacitor c=8.227E-16
    I_C3279 (dd3 VSS) capacitor c=1.184E-15
    I_C3280 (dd3_b0 VSS) capacitor c=9.795E-16
    I_C3281 (nbkn2 VSS) capacitor c=2.235E-15
    I_C3282 (nbk2 VSS) capacitor c=6.471E-16
    I_C3283 (nbkn1 VSS) capacitor c=1.777E-15
    I_C3284 (nbk1 VSS) capacitor c=9.305E-16
    I_C3285 (I562_cinn VSS) capacitor c=7.555E-16
    I_C3286 (nakn29 VSS) capacitor c=1.887E-15
    I_C3287 (nak29 VSS) capacitor c=9.285E-16
    I_C3288 (I700_G2_0np VSS) capacitor c=5.959E-16
    I_C3289 (nqkn2 VSS) capacitor c=1.991E-15
    I_C3290 (nqk2 VSS) capacitor c=6.840E-16
    I_C3291 (nqkn1 VSS) capacitor c=2.292E-15
    I_C3292 (nqk1 VSS) capacitor c=1.156E-15
    I_C3293 (p31_32_b3_0 VSS) capacitor c=3.110E-15
    I_C3294 (dmn3 VSS) capacitor c=7.235E-16
    I_C3295 (dm3 VSS) capacitor c=2.898E-15
    I_C3296 (dmn2 VSS) capacitor c=1.293E-15
    I_C3297 (dm2 VSS) capacitor c=2.374E-15
    I_C3298 (dmn4 VSS) capacitor c=1.022E-15
    I_C3299 (dm4 VSS) capacitor c=2.200E-15
    I_C3300 (B_0_b0 VSS) capacitor c=1.018E-15
    I_C3301 (nbkn15 VSS) capacitor c=2.029E-15
    I_C3302 (nbk15 VSS) capacitor c=8.324E-16
    I_C3303 (nbkn14 VSS) capacitor c=2.296E-15
    I_C3304 (nbk14 VSS) capacitor c=8.845E-16
    I_C3305 (nbkn9 VSS) capacitor c=2.867E-15
    I_C3306 (nbk9 VSS) capacitor c=1.007E-15
    I_C3307 (dd6 VSS) capacitor c=1.189E-15
    I_C3308 (dd6_b0 VSS) capacitor c=1.965E-15
    I_C3309 (nbkn3 VSS) capacitor c=1.878E-15
    I_C3310 (nbk3 VSS) capacitor c=9.984E-16
    I_C3311 (dd5 VSS) capacitor c=2.054E-15
    I_C3312 (dd5_b0 VSS) capacitor c=1.447E-15
    I_C3313 (nakn30 VSS) capacitor c=2.013E-15
    I_C3314 (nak30 VSS) capacitor c=8.285E-16
    I_C3315 (I608_cinn VSS) capacitor c=9.335E-16
    I_C3316 (sq_b3_5 VSS) capacitor c=4.608E-15
    I_C3317 (sqn VSS) capacitor c=5.133E-15
    I_C3318 (nqkn29 VSS) capacitor c=3.029E-15
    I_C3319 (nqk29 VSS) capacitor c=9.413E-16
    I_C3320 (nqkn30 VSS) capacitor c=2.166E-15
    I_C3321 (nqk30 VSS) capacitor c=9.033E-16
    I_C3322 (I654_cinn VSS) capacitor c=1.645E-15
    I_C3323 (I700_G6_0 VSS) capacitor c=6.233E-15
    I_C3324 (I700_G6_0n VSS) capacitor c=6.598E-16
    I_C3325 (I1850_G6_0 VSS) capacitor c=6.969E-15
    I_C3326 (I1850_G6_0n VSS) capacitor c=8.837E-16
    I_C3327 (I1850_G4_0 VSS) capacitor c=7.016E-15
    I_C3328 (I1850_G4_0n VSS) capacitor c=7.300E-16
    I_C3329 (I1850_G2_0np VSS) capacitor c=5.768E-16
    I_C3330 (I1850_G0_0 VSS) capacitor c=8.901E-15
    I_C3331 (I1850_G0_0n VSS) capacitor c=4.945E-15
    I_C3332 (I1942_G0_0 VSS) capacitor c=4.862E-15
    I_C3333 (I1942_G0_0n VSS) capacitor c=4.135E-15
    I_C3334 (dmn5 VSS) capacitor c=1.207E-15
    I_C3335 (dm5 VSS) capacitor c=2.845E-15
    I_C3336 (nrkn1 VSS) capacitor c=1.631E-15
    I_C3337 (nrk1 VSS) capacitor c=8.664E-16
    I_C3338 (nbkn8 VSS) capacitor c=2.486E-15
    I_C3339 (nbk8 VSS) capacitor c=6.638E-16
    I_C3340 (nbkn7 VSS) capacitor c=1.986E-15
    I_C3341 (nbk7 VSS) capacitor c=8.435E-16
    I_C3342 (nbkn6 VSS) capacitor c=1.961E-15
    I_C3343 (nbk6 VSS) capacitor c=1.158E-15
    I_C3344 (nbkn5 VSS) capacitor c=2.046E-15
    I_C3345 (nbk5 VSS) capacitor c=1.005E-15
    I_C3346 (nbkn4 VSS) capacitor c=2.453E-15
    I_C3347 (nbk4 VSS) capacitor c=6.189E-16
    I_C3348 (I654_G0_0 VSS) capacitor c=7.158E-15
    I_C3349 (I654_G0_0n VSS) capacitor c=5.218E-15
    I_C3350 (I700_G1_0 VSS) capacitor c=8.791E-15
    I_C3351 (I700_G1_0n VSS) capacitor c=3.109E-15
    I_C3352 (I1988_G1_0 VSS) capacitor c=4.621E-15
    I_C3353 (I1988_G1_0n VSS) capacitor c=1.722E-15
    I_C3354 (I1988_G0_0 VSS) capacitor c=7.436E-15
    I_C3355 (I1988_G0_0n VSS) capacitor c=4.666E-15
    I_C3356 (dmn6 VSS) capacitor c=9.078E-16
    I_C3357 (dm6 VSS) capacitor c=1.630E-15
    I_C3358 (dmn7 VSS) capacitor c=6.792E-16
    I_C3359 (dm7 VSS) capacitor c=1.596E-15
    I_C3360 (I2066_G0_0 VSS) capacitor c=6.068E-15
    I_C3361 (I2066_G0_0n VSS) capacitor c=3.207E-15
    I_C3362 (B_31_b0 VSS) capacitor c=1.871E-15
    I_C3363 (nrkn2 VSS) capacitor c=2.384E-15
    I_C3364 (nrk2 VSS) capacitor c=8.474E-16
    I_C3365 (nrkn3 VSS) capacitor c=1.826E-15
    I_C3366 (nrk3 VSS) capacitor c=7.171E-16
    I_C3367 (nrkn4 VSS) capacitor c=2.661E-15
    I_C3368 (nrk4 VSS) capacitor c=8.130E-16
    I_C3369 (I562_G0_0 VSS) capacitor c=4.853E-15
    I_C3370 (I562_G0_0n VSS) capacitor c=3.214E-15
    I_C3371 (I608_G0_0 VSS) capacitor c=6.025E-15
    I_C3372 (I608_G0_0n VSS) capacitor c=3.833E-15
    I_C3373 (I1850_G5_0 VSS) capacitor c=5.155E-15
    I_C3374 (I1850_G5_0n VSS) capacitor c=1.167E-15
    I_C3375 (I1850_G1_0 VSS) capacitor c=7.031E-15
    I_C3376 (I1850_G1_0n VSS) capacitor c=1.954E-15
    I_C3377 (dmn8 VSS) capacitor c=1.015E-15
    I_C3378 (dm8 VSS) capacitor c=1.711E-15
    I_C3379 (dmn9 VSS) capacitor c=9.486E-16
    I_C3380 (dm9 VSS) capacitor c=2.232E-15
    I_C3381 (nrkn5 VSS) capacitor c=1.786E-15
    I_C3382 (nrk5 VSS) capacitor c=1.052E-15
    I_C3383 (I700_G3_0np VSS) capacitor c=5.677E-16
    I_C3384 (I700_G5_0 VSS) capacitor c=7.302E-15
    I_C3385 (I700_G5_0n VSS) capacitor c=1.018E-15
    I_C3386 (I1850_G3_0np VSS) capacitor c=7.435E-16
    I_C3387 (I1896_G0_0 VSS) capacitor c=1.001E-14
    I_C3388 (I1896_G0_0n VSS) capacitor c=6.210E-15
    I_C3389 (I1942_G1_0 VSS) capacitor c=5.881E-15
    I_C3390 (I1942_G1_0n VSS) capacitor c=1.573E-15
    I_C3391 (I1988_G2_0np VSS) capacitor c=5.952E-16
    I_C3392 (dmn10 VSS) capacitor c=7.350E-16
    I_C3393 (dm10 VSS) capacitor c=1.819E-15
    I_C3394 (dmn11 VSS) capacitor c=1.056E-15
    I_C3395 (dm11 VSS) capacitor c=2.014E-15
    I_C3396 (I2066_G1_0 VSS) capacitor c=6.011E-15
    I_C3397 (I2066_G1_0n VSS) capacitor c=2.561E-15
    I_C3398 (nrkn7 VSS) capacitor c=2.283E-15
    I_C3399 (nrk7 VSS) capacitor c=7.794E-16
    I_C3400 (nrkn6 VSS) capacitor c=2.231E-15
    I_C3401 (nrk6 VSS) capacitor c=6.144E-16
    I_C3402 (I562_G1_0 VSS) capacitor c=6.664E-15
    I_C3403 (I562_G1_0n VSS) capacitor c=1.710E-15
    I_C3404 (I562_G2_0np VSS) capacitor c=8.573E-16
    I_C3405 (I562_G4_0 VSS) capacitor c=4.904E-15
    I_C3406 (I562_G4_0n VSS) capacitor c=8.607E-16
    I_C3407 (I608_G1_0 VSS) capacitor c=5.683E-15
    I_C3408 (I608_G1_0n VSS) capacitor c=1.593E-15
    I_C3409 (I1850_G7_0 VSS) capacitor c=5.727E-15
    I_C3410 (I1850_G7_0n VSS) capacitor c=6.318E-16
    I_C3411 (I1942_G2_0np VSS) capacitor c=5.826E-16
    I_C3412 (I1988_G3_0np VSS) capacitor c=5.937E-16
    I_C3413 (dmn12 VSS) capacitor c=8.246E-16
    I_C3414 (dm12 VSS) capacitor c=1.946E-15
    I_C3415 (dmn13 VSS) capacitor c=6.497E-16
    I_C3416 (dm13 VSS) capacitor c=2.050E-15
    I_C3417 (nrkn8 VSS) capacitor c=2.606E-15
    I_C3418 (nrk8 VSS) capacitor c=6.416E-16
    I_C3419 (I608_G2_0np VSS) capacitor c=9.952E-16
    I_C3420 (I654_G2_0np VSS) capacitor c=7.842E-16
    I_C3421 (I654_G1_0 VSS) capacitor c=7.838E-15
    I_C3422 (I654_G1_0n VSS) capacitor c=1.708E-15
    I_C3423 (I700_G7_0 VSS) capacitor c=7.709E-15
    I_C3424 (I700_G7_0n VSS) capacitor c=1.071E-15
    I_C3425 (qu3 VSS) capacitor c=7.076E-16
    I_C3426 (qu3_b0 VSS) capacitor c=7.952E-16
    I_C3427 (I1942_G3_0np VSS) capacitor c=9.431E-16
    I_C3428 (I1988_G5_0 VSS) capacitor c=5.428E-15
    I_C3429 (I1988_G5_0n VSS) capacitor c=1.730E-15
    I_C3430 (I1988_G4_0 VSS) capacitor c=9.219E-15
    I_C3431 (I1988_G4_0n VSS) capacitor c=1.040E-15
    I_C3432 (dmn15 VSS) capacitor c=6.586E-16
    I_C3433 (dm15 VSS) capacitor c=1.946E-15
    I_C3434 (dmn14 VSS) capacitor c=8.042E-16
    I_C3435 (dm14 VSS) capacitor c=1.781E-15
    I_C3436 (I2066_G2_0np VSS) capacitor c=6.049E-16
    I_C3437 (nrkn9 VSS) capacitor c=1.761E-15
    I_C3438 (nrk9 VSS) capacitor c=7.054E-16
    I_C3439 (I562_G3_0np VSS) capacitor c=8.610E-16
    I_C3440 (I608_G3_0np VSS) capacitor c=6.962E-16
    I_C3441 (qu2 VSS) capacitor c=8.534E-16
    I_C3442 (qu2_b0 VSS) capacitor c=6.124E-15
    I_C3443 (I1896_G7_0 VSS) capacitor c=7.816E-15
    I_C3444 (I1896_G7_0n VSS) capacitor c=6.372E-16
    I_C3445 (I1896_G3_0np VSS) capacitor c=5.826E-16
    I_C3446 (I1896_G1_0 VSS) capacitor c=8.490E-15
    I_C3447 (I1896_G1_0n VSS) capacitor c=2.083E-15
    I_C3448 (I1942_G4_0 VSS) capacitor c=6.114E-15
    I_C3449 (I1942_G4_0n VSS) capacitor c=1.752E-15
    I_C3450 (dmn16 VSS) capacitor c=8.992E-16
    I_C3451 (dm16 VSS) capacitor c=1.941E-15
    I_C3452 (dmn17 VSS) capacitor c=1.350E-15
    I_C3453 (dm17 VSS) capacitor c=2.294E-15
    I_C3454 (I2066_G4_0 VSS) capacitor c=4.308E-15
    I_C3455 (I2066_G4_0n VSS) capacitor c=7.074E-16
    I_C3456 (I2066_G3_0np VSS) capacitor c=8.849E-16
    I_C3457 (nrkn10 VSS) capacitor c=2.109E-15
    I_C3458 (nrk10 VSS) capacitor c=6.973E-16
    I_C3459 (I608_G4_0 VSS) capacitor c=5.552E-15
    I_C3460 (I608_G4_0n VSS) capacitor c=7.080E-16
    I_C3461 (I1988_G6_0 VSS) capacitor c=7.852E-15
    I_C3462 (I1988_G6_0n VSS) capacitor c=9.233E-16
    I_C3463 (dmn18 VSS) capacitor c=1.455E-15
    I_C3464 (dm18 VSS) capacitor c=1.595E-15
    I_C3465 (I2066_G5_0 VSS) capacitor c=6.813E-15
    I_C3466 (I2066_G5_0n VSS) capacitor c=1.150E-15
    I_C3467 (nrkn11 VSS) capacitor c=2.376E-15
    I_C3468 (nrk11 VSS) capacitor c=6.843E-16
    I_C3469 (I562_G7_0 VSS) capacitor c=7.011E-15
    I_C3470 (I562_G7_0n VSS) capacitor c=1.346E-15
    I_C3471 (I562_G5_0 VSS) capacitor c=7.146E-15
    I_C3472 (I562_G5_0n VSS) capacitor c=1.214E-15
    I_C3473 (I562_G6_0 VSS) capacitor c=5.611E-15
    I_C3474 (I562_G6_0n VSS) capacitor c=7.038E-16
    I_C3475 (I654_G4_0 VSS) capacitor c=6.160E-15
    I_C3476 (I654_G4_0n VSS) capacitor c=8.877E-16
    I_C3477 (I654_G3_0np VSS) capacitor c=8.917E-16
    I_C3478 (I1896_G5_0 VSS) capacitor c=9.088E-15
    I_C3479 (I1896_G5_0n VSS) capacitor c=8.478E-16
    I_C3480 (I1942_G5_0 VSS) capacitor c=6.131E-15
    I_C3481 (I1942_G5_0n VSS) capacitor c=6.334E-16
    I_C3482 (I1988_G7_0 VSS) capacitor c=8.731E-15
    I_C3483 (I1988_G7_0n VSS) capacitor c=8.075E-16
    I_C3484 (dmn20 VSS) capacitor c=6.566E-16
    I_C3485 (dm20 VSS) capacitor c=1.641E-15
    I_C3486 (dmn19 VSS) capacitor c=1.177E-15
    I_C3487 (dm19 VSS) capacitor c=1.916E-15
    I_C3488 (nrkn13 VSS) capacitor c=2.251E-15
    I_C3489 (nrk13 VSS) capacitor c=7.470E-16
    I_C3490 (nrkn12 VSS) capacitor c=2.013E-15
    I_C3491 (nrk12 VSS) capacitor c=6.959E-16
    I_C3492 (I608_G6_0 VSS) capacitor c=6.764E-15
    I_C3493 (I608_G6_0n VSS) capacitor c=8.338E-16
    I_C3494 (I608_G5_0 VSS) capacitor c=7.607E-15
    I_C3495 (I608_G5_0n VSS) capacitor c=1.245E-15
    I_C3496 (I654_G6_0 VSS) capacitor c=6.821E-15
    I_C3497 (I654_G6_0n VSS) capacitor c=1.442E-15
    I_C3498 (I654_G5_0 VSS) capacitor c=5.828E-15
    I_C3499 (I654_G5_0n VSS) capacitor c=1.038E-15
    I_C3500 (I1896_G4_0 VSS) capacitor c=8.995E-15
    I_C3501 (I1896_G4_0n VSS) capacitor c=1.272E-15
    I_C3502 (I1896_G2_0np VSS) capacitor c=1.017E-15
    I_C3503 (I1942_G7_0 VSS) capacitor c=5.461E-15
    I_C3504 (I1942_G7_0n VSS) capacitor c=7.986E-16
    I_C3505 (I1942_G6_0 VSS) capacitor c=9.567E-15
    I_C3506 (I1942_G6_0n VSS) capacitor c=1.378E-15
    I_C3507 (dmn22 VSS) capacitor c=8.949E-16
    I_C3508 (dm22 VSS) capacitor c=2.010E-15
    I_C3509 (dmn21 VSS) capacitor c=6.631E-16
    I_C3510 (dm21 VSS) capacitor c=1.662E-15
    I_C3511 (I2066_G6_0 VSS) capacitor c=6.375E-15
    I_C3512 (I2066_G6_0n VSS) capacitor c=8.578E-16
    I_C3513 (I2066_G7_0 VSS) capacitor c=7.737E-15
    I_C3514 (I2066_G7_0n VSS) capacitor c=1.019E-15
    I_C3515 (nrkn14 VSS) capacitor c=2.325E-15
    I_C3516 (nrk14 VSS) capacitor c=6.896E-16
    I_C3517 (qu28 VSS) capacitor c=7.980E-16
    I_C3518 (qu28_b0 VSS) capacitor c=6.291E-15
    I_C3519 (dmn23 VSS) capacitor c=8.760E-16
    I_C3520 (dm23 VSS) capacitor c=1.681E-15
    I_C3521 (dmn24 VSS) capacitor c=8.636E-16
    I_C3522 (dm24 VSS) capacitor c=1.678E-15
    I_C3523 (nrkn16 VSS) capacitor c=1.958E-15
    I_C3524 (nrk16 VSS) capacitor c=2.048E-15
    I_C3525 (nrkn15 VSS) capacitor c=2.075E-15
    I_C3526 (nrk15 VSS) capacitor c=1.074E-15
    I_C3527 (nrkn18 VSS) capacitor c=2.220E-15
    I_C3528 (nrk18 VSS) capacitor c=7.379E-16
    I_C3529 (qu31 VSS) capacitor c=8.565E-16
    I_C3530 (qu31_b0 VSS) capacitor c=6.004E-15
    I_C3531 (I608_G7_0 VSS) capacitor c=7.492E-15
    I_C3532 (I608_G7_0n VSS) capacitor c=8.106E-16
    I_C3533 (I654_G7_0 VSS) capacitor c=7.016E-15
    I_C3534 (I654_G7_0n VSS) capacitor c=1.408E-15
    I_C3535 (I1896_G6_0 VSS) capacitor c=8.473E-15
    I_C3536 (I1896_G6_0n VSS) capacitor c=8.708E-16
    I_C3537 (p31_32_b0 VSS) capacitor c=9.478E-16
    I_C3538 (dmn25 VSS) capacitor c=6.718E-16
    I_C3539 (dm25 VSS) capacitor c=2.249E-15
    I_C3540 (dmn26 VSS) capacitor c=7.216E-16
    I_C3541 (dm26 VSS) capacitor c=1.830E-15
    I_C3542 (nrkn17 VSS) capacitor c=2.307E-15
    I_C3543 (nrk17 VSS) capacitor c=7.412E-16
    I_C3544 (nrkn19 VSS) capacitor c=2.147E-15
    I_C3545 (nrk19 VSS) capacitor c=6.387E-16
    I_C3546 (qu1 VSS) capacitor c=9.418E-16
    I_C3547 (qu1_b0 VSS) capacitor c=1.028E-15
    I_C3548 (dmn27 VSS) capacitor c=1.141E-15
    I_C3549 (dm27 VSS) capacitor c=1.907E-15
    I_C3550 (nrkn25 VSS) capacitor c=2.403E-15
    I_C3551 (nrk25 VSS) capacitor c=6.797E-16
    I_C3552 (nrkn20 VSS) capacitor c=3.359E-15
    I_C3553 (nrk20 VSS) capacitor c=8.991E-16
    I_C3554 (qu30 VSS) capacitor c=1.293E-15
    I_C3555 (qu30_b0 VSS) capacitor c=8.398E-16
    I_C3556 (dmn30 VSS) capacitor c=1.081E-15
    I_C3557 (dm30 VSS) capacitor c=1.941E-15
    I_C3558 (dmn28 VSS) capacitor c=7.420E-16
    I_C3559 (dm28 VSS) capacitor c=2.023E-15
    I_C3560 (dmn29 VSS) capacitor c=1.610E-15
    I_C3561 (dm29 VSS) capacitor c=1.773E-15
    I_C3562 (nrkn30 VSS) capacitor c=2.066E-15
    I_C3563 (nrk30 VSS) capacitor c=9.067E-16
    I_C3564 (nrkn29 VSS) capacitor c=2.043E-15
    I_C3565 (nrk29 VSS) capacitor c=7.793E-16
    I_C3566 (nrkn28 VSS) capacitor c=2.505E-15
    I_C3567 (nrk28 VSS) capacitor c=8.062E-16
    I_C3568 (nrkn26 VSS) capacitor c=2.130E-15
    I_C3569 (nrk26 VSS) capacitor c=7.287E-16
    I_C3570 (nrkn27 VSS) capacitor c=2.393E-15
    I_C3571 (nrk27 VSS) capacitor c=7.264E-16
    I_C3572 (nrkn24 VSS) capacitor c=2.138E-15
    I_C3573 (nrk24 VSS) capacitor c=8.471E-16
    I_C3574 (nrkn23 VSS) capacitor c=2.488E-15
    I_C3575 (nrk23 VSS) capacitor c=7.450E-16
    I_C3576 (nrkn22 VSS) capacitor c=2.251E-15
    I_C3577 (nrk22 VSS) capacitor c=7.448E-16
    I_C3578 (nrkn21 VSS) capacitor c=2.698E-15
    I_C3579 (nrk21 VSS) capacitor c=6.371E-16
    I_C3580 (A_31_b0 VSS) capacitor c=8.913E-16
    I_C3581 (qu29 VSS) capacitor c=7.508E-16
    I_C3582 (qu29_b0 VSS) capacitor c=1.452E-15
    I_C3583 (dmn31 VSS) capacitor c=1.431E-15
    I_C3584 (dm31 VSS) capacitor c=2.303E-15
    I_C3585 (I1298_pn31 VSS) capacitor c=3.324E-15
    I_C3586 (I1298_pn30 VSS) capacitor c=4.492E-15
    I_C3587 (I1298_P31_30 VSS) capacitor c=1.767E-15
    I_C3588 (I1298_pn29 VSS) capacitor c=5.849E-15
    I_C3589 (I1298_P30_29 VSS) capacitor c=2.158E-15
    I_C3590 (I1206_pn28 VSS) capacitor c=6.185E-15
    I_C3591 (I1206_pn27 VSS) capacitor c=1.121E-14
    I_C3592 (I1206_P28_27 VSS) capacitor c=2.998E-15
    I_C3593 (I1206_pn30 VSS) capacitor c=8.410E-15
    I_C3594 (I1206_pn29 VSS) capacitor c=9.102E-15
    I_C3595 (I1206_P30_29 VSS) capacitor c=2.149E-15
    I_C3596 (I1206_pn31 VSS) capacitor c=9.263E-15
    I_C3597 (I1206_P31_30 VSS) capacitor c=1.906E-15
    I_C3598 (I1482_pn30 VSS) capacitor c=4.968E-15
    I_C3599 (I1482_pn29 VSS) capacitor c=4.447E-15
    I_C3600 (I1482_P30_29 VSS) capacitor c=3.205E-15
    I_C3601 (I1482_pn28 VSS) capacitor c=5.912E-15
    I_C3602 (I1482_P29_28 VSS) capacitor c=2.589E-15
    I_C3603 (I1482_pn31 VSS) capacitor c=8.381E-15
    I_C3604 (I1482_P31_30 VSS) capacitor c=1.677E-15
    I_C3605 (I1436_pn31 VSS) capacitor c=4.077E-15
    I_C3606 (I1436_pn30 VSS) capacitor c=4.480E-15
    I_C3607 (I1436_P31_30 VSS) capacitor c=1.403E-15
    I_C3608 (I1436_pn29 VSS) capacitor c=5.117E-15
    I_C3609 (I1436_pn28 VSS) capacitor c=6.800E-15
    I_C3610 (I1436_P29_28 VSS) capacitor c=2.296E-15
    I_C3611 (I1436_P30_29 VSS) capacitor c=2.615E-15
    I_C3612 (I1390_pn31 VSS) capacitor c=3.190E-15
    I_C3613 (I1390_pn30 VSS) capacitor c=6.142E-15
    I_C3614 (I1390_P31_30 VSS) capacitor c=1.440E-15
    I_C3615 (I1390_pn29 VSS) capacitor c=4.094E-15
    I_C3616 (I1390_pn28 VSS) capacitor c=6.410E-15
    I_C3617 (I1390_P29_28 VSS) capacitor c=2.864E-15
    I_C3618 (I1390_P30_29 VSS) capacitor c=2.131E-15
    I_C3619 (I1344_pn31 VSS) capacitor c=3.327E-15
    I_C3620 (I1344_pn30 VSS) capacitor c=4.298E-15
    I_C3621 (I1344_P31_30 VSS) capacitor c=2.017E-15
    I_C3622 (I1344_pn29 VSS) capacitor c=4.296E-15
    I_C3623 (I1344_P30_29 VSS) capacitor c=4.310E-15
    I_C3624 (I1344_pn28 VSS) capacitor c=5.340E-15
    I_C3625 (I1344_P29_28 VSS) capacitor c=2.496E-15
    I_C3626 (I1344_pn27 VSS) capacitor c=4.376E-15
    I_C3627 (I1344_P28_27 VSS) capacitor c=3.428E-15
    I_C3628 (I1298_pn28 VSS) capacitor c=6.877E-15
    I_C3629 (I1298_P29_28 VSS) capacitor c=2.724E-15
    I_C3630 (I1252_pn31 VSS) capacitor c=3.168E-15
    I_C3631 (I1252_pn30 VSS) capacitor c=5.363E-15
    I_C3632 (I1252_P31_30 VSS) capacitor c=1.457E-15
    I_C3633 (I1252_pn29 VSS) capacitor c=5.019E-15
    I_C3634 (I1252_pn28 VSS) capacitor c=6.666E-15
    I_C3635 (I1252_P29_28 VSS) capacitor c=2.485E-15
    I_C3636 (I1252_P30_29 VSS) capacitor c=1.730E-15
    I_C3637 (I1252_pn27 VSS) capacitor c=5.405E-15
    I_C3638 (I1252_P28_27 VSS) capacitor c=3.812E-15
    I_C3639 (I1206_P28_25n VSS) capacitor c=1.566E-15
    I_C3640 (I1206_P24_21n VSS) capacitor c=4.235E-15
    I_C3641 (I1206_P28_21 VSS) capacitor c=1.613E-15
    I_C3642 (I1206_P30_27n VSS) capacitor c=2.634E-15
    I_C3643 (I1206_P26_23n VSS) capacitor c=2.210E-15
    I_C3644 (I1206_P30_23 VSS) capacitor c=2.237E-15
    I_C3645 (I1206_P29_26n VSS) capacitor c=1.361E-15
    I_C3646 (I1206_P25_22n VSS) capacitor c=3.235E-15
    I_C3647 (I1206_P29_22 VSS) capacitor c=2.071E-15
    I_C3648 (I1206_P29_28 VSS) capacitor c=2.965E-15
    I_C3649 (I1482_pn27 VSS) capacitor c=4.487E-15
    I_C3650 (I1482_pn26 VSS) capacitor c=5.771E-15
    I_C3651 (I1482_P27_26 VSS) capacitor c=3.757E-15
    I_C3652 (I1482_P31_28n VSS) capacitor c=1.699E-15
    I_C3653 (I1482_P27_24n VSS) capacitor c=2.115E-15
    I_C3654 (I1482_P31_24 VSS) capacitor c=1.869E-15
    I_C3655 (I1436_P31_28n VSS) capacitor c=1.521E-15
    I_C3656 (I1436_P27_24n VSS) capacitor c=2.636E-15
    I_C3657 (I1436_P31_24 VSS) capacitor c=1.777E-15
    I_C3658 (I1436_pn27 VSS) capacitor c=4.651E-15
    I_C3659 (I1436_pn26 VSS) capacitor c=6.913E-15
    I_C3660 (I1436_P27_26 VSS) capacitor c=2.539E-15
    I_C3661 (I1436_P28_27 VSS) capacitor c=2.190E-15
    I_C3662 (I1390_pn27 VSS) capacitor c=5.928E-15
    I_C3663 (I1390_pn26 VSS) capacitor c=5.452E-15
    I_C3664 (I1390_P27_26 VSS) capacitor c=2.466E-15
    I_C3665 (I1390_P28_27 VSS) capacitor c=2.615E-15
    I_C3666 (I1344_pn26 VSS) capacitor c=6.863E-15
    I_C3667 (I1344_P27_26 VSS) capacitor c=2.927E-15
    I_C3668 (I1298_P31_28n VSS) capacitor c=1.988E-15
    I_C3669 (I1298_P27_24n VSS) capacitor c=3.236E-15
    I_C3670 (I1298_P31_24 VSS) capacitor c=1.551E-15
    I_C3671 (I1298_pn27 VSS) capacitor c=5.587E-15
    I_C3672 (I1298_pn26 VSS) capacitor c=6.567E-15
    I_C3673 (I1298_P27_26 VSS) capacitor c=2.247E-15
    I_C3674 (I1298_P28_27 VSS) capacitor c=2.193E-15
    I_C3675 (I1252_P31_28n VSS) capacitor c=2.069E-15
    I_C3676 (I1252_P27_24n VSS) capacitor c=3.306E-15
    I_C3677 (I1252_P31_24 VSS) capacitor c=1.418E-15
    I_C3678 (I1252_pn26 VSS) capacitor c=1.014E-14
    I_C3679 (I1252_P27_26 VSS) capacitor c=2.530E-15
    I_C3680 (I1252_pn25 VSS) capacitor c=5.449E-15
    I_C3681 (I1252_P26_25 VSS) capacitor c=1.842E-15
    I_C3682 (I1206_P22_19n VSS) capacitor c=2.676E-15
    I_C3683 (I1206_P26_19 VSS) capacitor c=2.038E-15
    I_C3684 (I1206_pn26 VSS) capacitor c=7.982E-15
    I_C3685 (I1206_pn25 VSS) capacitor c=1.080E-14
    I_C3686 (I1206_P26_25 VSS) capacitor c=2.909E-15
    I_C3687 (I1206_pn24 VSS) capacitor c=8.004E-15
    I_C3688 (I1206_pn23 VSS) capacitor c=9.982E-15
    I_C3689 (I1206_P24_23 VSS) capacitor c=2.497E-15
    I_C3690 (I1206_P27_24n VSS) capacitor c=2.568E-15
    I_C3691 (I1206_P23_20n VSS) capacitor c=2.211E-15
    I_C3692 (I1206_P27_20 VSS) capacitor c=2.214E-15
    I_C3693 (I1206_P25_24 VSS) capacitor c=3.604E-15
    I_C3694 (I1206_P31_28n VSS) capacitor c=1.656E-15
    I_C3695 (I1206_P31_24 VSS) capacitor c=1.434E-15
    I_C3696 (I1206_P27_26 VSS) capacitor c=2.916E-15
    I_C3697 (I1482_P28_27 VSS) capacitor c=2.525E-15
    I_C3698 (I1482_pn25 VSS) capacitor c=4.608E-15
    I_C3699 (I1482_P26_25 VSS) capacitor c=3.215E-15
    I_C3700 (I1482_pn24 VSS) capacitor c=4.221E-15
    I_C3701 (I1482_P25_24 VSS) capacitor c=2.257E-15
    I_C3702 (I1482_P29_26n VSS) capacitor c=1.580E-15
    I_C3703 (I1482_P25_22n VSS) capacitor c=3.426E-15
    I_C3704 (I1482_P29_22 VSS) capacitor c=1.600E-15
    I_C3705 (I1482_P23_20n VSS) capacitor c=2.404E-15
    I_C3706 (I1482_P27_20 VSS) capacitor c=1.987E-15
    I_C3707 (I1482_P19_16n VSS) capacitor c=4.327E-15
    I_C3708 (I1482_P23_16 VSS) capacitor c=3.647E-15
    I_C3709 (I1436_P23_20n VSS) capacitor c=3.122E-15
    I_C3710 (I1436_P27_20 VSS) capacitor c=1.651E-15
    I_C3711 (I1436_P29_26n VSS) capacitor c=1.881E-15
    I_C3712 (I1436_P25_22n VSS) capacitor c=3.925E-15
    I_C3713 (I1436_P29_22 VSS) capacitor c=1.838E-15
    I_C3714 (I1436_pn25 VSS) capacitor c=5.551E-15
    I_C3715 (I1436_pn24 VSS) capacitor c=6.094E-15
    I_C3716 (I1436_P25_24 VSS) capacitor c=2.067E-15
    I_C3717 (I1436_P30_27n VSS) capacitor c=1.486E-15
    I_C3718 (I1436_P26_23n VSS) capacitor c=4.235E-15
    I_C3719 (I1436_P30_23 VSS) capacitor c=1.803E-15
    I_C3720 (I1436_P26_25 VSS) capacitor c=2.358E-15
    I_C3721 (I1390_P31_28n VSS) capacitor c=1.709E-15
    I_C3722 (I1390_P27_24n VSS) capacitor c=3.937E-15
    I_C3723 (I1390_P31_24 VSS) capacitor c=1.725E-15
    I_C3724 (I1390_pn25 VSS) capacitor c=5.476E-15
    I_C3725 (I1390_pn24 VSS) capacitor c=6.911E-15
    I_C3726 (I1390_P25_24 VSS) capacitor c=2.086E-15
    I_C3727 (I1390_P26_25 VSS) capacitor c=2.651E-15
    I_C3728 (I1344_P31_28n VSS) capacitor c=1.702E-15
    I_C3729 (I1344_P27_24n VSS) capacitor c=3.401E-15
    I_C3730 (I1344_P31_24 VSS) capacitor c=1.865E-15
    I_C3731 (I1344_pn25 VSS) capacitor c=4.132E-15
    I_C3732 (I1344_pn24 VSS) capacitor c=5.770E-15
    I_C3733 (I1344_P25_24 VSS) capacitor c=1.958E-15
    I_C3734 (I1344_P26_25 VSS) capacitor c=3.519E-15
    I_C3735 (I1298_P29_26n VSS) capacitor c=1.783E-15
    I_C3736 (I1298_P25_22n VSS) capacitor c=3.851E-15
    I_C3737 (I1298_P29_22 VSS) capacitor c=1.598E-15
    I_C3738 (I1298_pn25 VSS) capacitor c=4.689E-15
    I_C3739 (I1298_pn24 VSS) capacitor c=7.047E-15
    I_C3740 (I1298_P25_24 VSS) capacitor c=2.055E-15
    I_C3741 (I1298_P26_25 VSS) capacitor c=2.474E-15
    I_C3742 (I1252_P29_26n VSS) capacitor c=2.213E-15
    I_C3743 (I1252_P25_22n VSS) capacitor c=4.509E-15
    I_C3744 (I1252_P29_22 VSS) capacitor c=1.912E-15
    I_C3745 (I1252_pn24 VSS) capacitor c=5.762E-15
    I_C3746 (I1252_P25_24 VSS) capacitor c=2.619E-15
    I_C3747 (I1252_P30_27n VSS) capacitor c=1.834E-15
    I_C3748 (I1252_P26_23n VSS) capacitor c=4.863E-15
    I_C3749 (I1252_P30_23 VSS) capacitor c=1.758E-15
    I_C3750 (I1252_pn23 VSS) capacitor c=5.739E-15
    I_C3751 (I1252_P24_23 VSS) capacitor c=2.290E-15
    I_C3752 (I1206_P18_15n VSS) capacitor c=3.321E-15
    I_C3753 (I1206_P22_15 VSS) capacitor c=3.516E-15
    I_C3754 (I1206_pn22 VSS) capacitor c=7.433E-15
    I_C3755 (I1206_pn21 VSS) capacitor c=8.234E-15
    I_C3756 (I1206_P22_21 VSS) capacitor c=2.216E-15
    I_C3757 (I1206_P21_18n VSS) capacitor c=3.282E-15
    I_C3758 (I1206_P25_18 VSS) capacitor c=2.238E-15
    I_C3759 (I1206_P19_16n VSS) capacitor c=2.980E-15
    I_C3760 (I1206_P23_16 VSS) capacitor c=3.288E-15
    I_C3761 (I1206_P23_22 VSS) capacitor c=2.183E-15
    I_C3762 (I1482_P28_25n VSS) capacitor c=1.821E-15
    I_C3763 (I1482_P24_21n VSS) capacitor c=3.624E-15
    I_C3764 (I1482_P28_21 VSS) capacitor c=1.705E-15
    I_C3765 (I1482_pn23 VSS) capacitor c=8.179E-15
    I_C3766 (I1482_P24_23 VSS) capacitor c=2.217E-15
    I_C3767 (I1482_pn22 VSS) capacitor c=6.097E-15
    I_C3768 (I1482_P23_22 VSS) capacitor c=3.161E-15
    I_C3769 (I1436_pn23 VSS) capacitor c=5.004E-15
    I_C3770 (I1436_pn22 VSS) capacitor c=6.757E-15
    I_C3771 (I1436_P23_22 VSS) capacitor c=2.454E-15
    I_C3772 (I1436_P24_23 VSS) capacitor c=2.656E-15
    I_C3773 (I1390_P29_26n VSS) capacitor c=2.387E-15
    I_C3774 (I1390_P25_22n VSS) capacitor c=3.557E-15
    I_C3775 (I1390_P29_22 VSS) capacitor c=2.469E-15
    I_C3776 (I1390_pn23 VSS) capacitor c=5.228E-15
    I_C3777 (I1390_pn22 VSS) capacitor c=7.196E-15
    I_C3778 (I1390_P23_22 VSS) capacitor c=2.209E-15
    I_C3779 (I1390_P24_23 VSS) capacitor c=3.075E-15
    I_C3780 (I1390_P30_27n VSS) capacitor c=2.550E-15
    I_C3781 (I1390_P26_23n VSS) capacitor c=5.081E-15
    I_C3782 (I1390_P30_23 VSS) capacitor c=1.450E-15
    I_C3783 (I1344_P29_26n VSS) capacitor c=3.057E-15
    I_C3784 (I1344_P25_22n VSS) capacitor c=4.020E-15
    I_C3785 (I1344_P29_22 VSS) capacitor c=1.497E-15
    I_C3786 (I1344_pn23 VSS) capacitor c=4.132E-15
    I_C3787 (I1344_pn22 VSS) capacitor c=5.266E-15
    I_C3788 (I1344_P23_22 VSS) capacitor c=2.083E-15
    I_C3789 (I1344_P24_23 VSS) capacitor c=3.187E-15
    I_C3790 (I1344_P30_27n VSS) capacitor c=2.218E-15
    I_C3791 (I1344_P26_23n VSS) capacitor c=2.849E-15
    I_C3792 (I1344_P30_23 VSS) capacitor c=1.632E-15
    I_C3793 (I1298_P23_20n VSS) capacitor c=2.786E-15
    I_C3794 (I1298_P27_20 VSS) capacitor c=1.837E-15
    I_C3795 (I1298_pn23 VSS) capacitor c=5.976E-15
    I_C3796 (I1298_pn22 VSS) capacitor c=6.371E-15
    I_C3797 (I1298_P23_22 VSS) capacitor c=3.005E-15
    I_C3798 (I1298_P30_27n VSS) capacitor c=2.058E-15
    I_C3799 (I1298_P26_23n VSS) capacitor c=3.480E-15
    I_C3800 (I1298_P30_23 VSS) capacitor c=2.086E-15
    I_C3801 (I1298_P24_23 VSS) capacitor c=2.295E-15
    I_C3802 (I1252_P23_20n VSS) capacitor c=2.266E-15
    I_C3803 (I1252_P19_16n VSS) capacitor c=4.970E-15
    I_C3804 (I1252_P23_16 VSS) capacitor c=2.549E-15
    I_C3805 (I1252_P27_20 VSS) capacitor c=1.868E-15
    I_C3806 (I1252_pn22 VSS) capacitor c=7.207E-15
    I_C3807 (I1252_P23_22 VSS) capacitor c=2.314E-15
    I_C3808 (I1252_P28_25n VSS) capacitor c=2.006E-15
    I_C3809 (I1252_P24_21n VSS) capacitor c=4.867E-15
    I_C3810 (I1252_P28_21 VSS) capacitor c=2.330E-15
    I_C3811 (I1206_P20_17n VSS) capacitor c=3.516E-15
    I_C3812 (I1206_P16_13n VSS) capacitor c=4.845E-15
    I_C3813 (I1206_P20_13 VSS) capacitor c=4.908E-15
    I_C3814 (I1206_P24_17 VSS) capacitor c=1.749E-15
    I_C3815 (I1206_pn20 VSS) capacitor c=7.561E-15
    I_C3816 (I1206_pn19 VSS) capacitor c=1.074E-14
    I_C3817 (I1206_P20_19 VSS) capacitor c=2.060E-15
    I_C3818 (I1206_P15_12n VSS) capacitor c=2.962E-15
    I_C3819 (I1206_P11_8n VSS) capacitor c=5.085E-15
    I_C3820 (I1206_P15_8 VSS) capacitor c=2.360E-15
    I_C3821 (I1206_P17_14n VSS) capacitor c=4.298E-15
    I_C3822 (I1206_P21_14 VSS) capacitor c=3.613E-15
    I_C3823 (I1206_P19_12 VSS) capacitor c=4.540E-15
    I_C3824 (I1206_pn18 VSS) capacitor c=8.181E-15
    I_C3825 (I1206_P19_18 VSS) capacitor c=1.946E-15
    I_C3826 (I1206_P21_20 VSS) capacitor c=2.923E-15
    I_C3827 (I1528_pn29 VSS) capacitor c=1.146E-14
    I_C3828 (I1528_pn28 VSS) capacitor c=1.285E-14
    I_C3829 (I1528_P29_28 VSS) capacitor c=1.957E-15
    I_C3830 (I1528_pn27 VSS) capacitor c=7.173E-15
    I_C3831 (I1528_P28_27 VSS) capacitor c=2.554E-15
    I_C3832 (I1528_pn31 VSS) capacitor c=7.140E-15
    I_C3833 (I1528_pn30 VSS) capacitor c=9.043E-15
    I_C3834 (I1528_P31_30 VSS) capacitor c=2.435E-15
    I_C3835 (I1528_P30_29 VSS) capacitor c=1.876E-15
    I_C3836 (I1482_P30_27n VSS) capacitor c=2.714E-15
    I_C3837 (I1482_P26_23n VSS) capacitor c=3.039E-15
    I_C3838 (I1482_P30_23 VSS) capacitor c=2.462E-15
    I_C3839 (I1482_pn21 VSS) capacitor c=6.129E-15
    I_C3840 (I1482_P22_21 VSS) capacitor c=2.200E-15
    I_C3841 (I1482_P21_18n VSS) capacitor c=2.310E-15
    I_C3842 (I1482_P25_18 VSS) capacitor c=1.538E-15
    I_C3843 (I1436_P19_16n VSS) capacitor c=4.348E-15
    I_C3844 (I1436_P23_16 VSS) capacitor c=3.923E-15
    I_C3845 (I1436_P21_18n VSS) capacitor c=2.970E-15
    I_C3846 (I1436_P25_18 VSS) capacitor c=1.709E-15
    I_C3847 (I1436_P28_25n VSS) capacitor c=2.144E-15
    I_C3848 (I1436_P24_21n VSS) capacitor c=3.871E-15
    I_C3849 (I1436_P28_21 VSS) capacitor c=1.580E-15
    I_C3850 (I1436_pn21 VSS) capacitor c=6.052E-15
    I_C3851 (I1436_P22_21 VSS) capacitor c=2.734E-15
    I_C3852 (I1390_P23_20n VSS) capacitor c=2.530E-15
    I_C3853 (I1390_P19_16n VSS) capacitor c=3.423E-15
    I_C3854 (I1390_P23_16 VSS) capacitor c=4.537E-15
    I_C3855 (I1390_P27_20 VSS) capacitor c=1.845E-15
    I_C3856 (I1390_P28_25n VSS) capacitor c=2.497E-15
    I_C3857 (I1390_P24_21n VSS) capacitor c=4.359E-15
    I_C3858 (I1390_P28_21 VSS) capacitor c=2.134E-15
    I_C3859 (I1390_pn21 VSS) capacitor c=5.249E-15
    I_C3860 (I1390_P22_21 VSS) capacitor c=1.703E-15
    I_C3861 (I1344_P23_20n VSS) capacitor c=2.159E-15
    I_C3862 (I1344_P19_16n VSS) capacitor c=3.274E-15
    I_C3863 (I1344_P23_16 VSS) capacitor c=3.891E-15
    I_C3864 (I1344_P27_20 VSS) capacitor c=1.800E-15
    I_C3865 (I1344_pn21 VSS) capacitor c=5.080E-15
    I_C3866 (I1344_P22_21 VSS) capacitor c=3.028E-15
    I_C3867 (I1344_P28_25n VSS) capacitor c=1.649E-15
    I_C3868 (I1344_P24_21n VSS) capacitor c=4.099E-15
    I_C3869 (I1344_P28_21 VSS) capacitor c=1.862E-15
    I_C3870 (I1298_P19_16n VSS) capacitor c=4.577E-15
    I_C3871 (I1298_P23_16 VSS) capacitor c=3.884E-15
    I_C3872 (I1298_pn21 VSS) capacitor c=5.360E-15
    I_C3873 (I1298_pn20 VSS) capacitor c=6.051E-15
    I_C3874 (I1298_P21_20 VSS) capacitor c=2.672E-15
    I_C3875 (I1298_P28_25n VSS) capacitor c=2.757E-15
    I_C3876 (I1298_P24_21n VSS) capacitor c=3.599E-15
    I_C3877 (I1298_P28_21 VSS) capacitor c=1.546E-15
    I_C3878 (I1298_P22_21 VSS) capacitor c=2.237E-15
    I_C3879 (I1252_pn21 VSS) capacitor c=4.710E-15
    I_C3880 (I1252_pn20 VSS) capacitor c=6.490E-15
    I_C3881 (I1252_P21_20 VSS) capacitor c=3.317E-15
    I_C3882 (I1252_P22_21 VSS) capacitor c=2.272E-15
    I_C3883 (I1206_P14_11n VSS) capacitor c=2.258E-15
    I_C3884 (I1206_P10_7n VSS) capacitor c=5.311E-15
    I_C3885 (I1206_P14_7 VSS) capacitor c=2.925E-15
    I_C3886 (I1206_P18_11 VSS) capacitor c=4.398E-15
    I_C3887 (I1206_pn17 VSS) capacitor c=9.336E-15
    I_C3888 (I1206_P18_17 VSS) capacitor c=1.915E-15
    I_C3889 (I1206_P13_10n VSS) capacitor c=2.753E-15
    I_C3890 (I1206_P17_10 VSS) capacitor c=5.418E-15
    I_C3891 (I1206_P17_16 VSS) capacitor c=1.992E-15
    I_C3892 (I1528_P31_28n VSS) capacitor c=1.736E-15
    I_C3893 (I1528_P27_24n VSS) capacitor c=2.642E-15
    I_C3894 (I1528_P31_24 VSS) capacitor c=1.579E-15
    I_C3895 (I1528_pn26 VSS) capacitor c=1.023E-14
    I_C3896 (I1528_P27_26 VSS) capacitor c=2.394E-15
    I_C3897 (I1528_pn25 VSS) capacitor c=1.295E-14
    I_C3898 (I1528_P26_25 VSS) capacitor c=3.211E-15
    I_C3899 (I1482_P22_19n VSS) capacitor c=2.879E-15
    I_C3900 (I1482_P26_19 VSS) capacitor c=1.914E-15
    I_C3901 (I1482_P18_15n VSS) capacitor c=3.442E-15
    I_C3902 (I1482_P22_15 VSS) capacitor c=2.480E-15
    I_C3903 (I1482_pn20 VSS) capacitor c=6.730E-15
    I_C3904 (I1482_pn19 VSS) capacitor c=8.294E-15
    I_C3905 (I1482_P20_19 VSS) capacitor c=3.135E-15
    I_C3906 (I1482_P17_14n VSS) capacitor c=4.571E-15
    I_C3907 (I1482_P21_14 VSS) capacitor c=3.992E-15
    I_C3908 (I1482_P21_20 VSS) capacitor c=4.015E-15
    I_C3909 (I1436_pn20 VSS) capacitor c=6.662E-15
    I_C3910 (I1436_P21_20 VSS) capacitor c=3.294E-15
    I_C3911 (I1436_P22_19n VSS) capacitor c=3.126E-15
    I_C3912 (I1436_P26_19 VSS) capacitor c=2.531E-15
    I_C3913 (I1436_P18_15n VSS) capacitor c=3.734E-15
    I_C3914 (I1436_P22_15 VSS) capacitor c=3.841E-15
    I_C3915 (I1436_pn19 VSS) capacitor c=5.760E-15
    I_C3916 (I1436_P20_19 VSS) capacitor c=2.503E-15
    I_C3917 (I1390_pn20 VSS) capacitor c=6.593E-15
    I_C3918 (I1390_P21_20 VSS) capacitor c=3.001E-15
    I_C3919 (I1390_pn19 VSS) capacitor c=6.019E-15
    I_C3920 (I1390_P20_19 VSS) capacitor c=3.678E-15
    I_C3921 (I1344_P21_18n VSS) capacitor c=3.012E-15
    I_C3922 (I1344_P25_18 VSS) capacitor c=4.082E-15
    I_C3923 (I1344_pn20 VSS) capacitor c=5.996E-15
    I_C3924 (I1344_P21_20 VSS) capacitor c=2.795E-15
    I_C3925 (I1344_pn19 VSS) capacitor c=4.932E-15
    I_C3926 (I1344_P20_19 VSS) capacitor c=2.800E-15
    I_C3927 (I1344_P22_19n VSS) capacitor c=2.495E-15
    I_C3928 (I1344_P26_19 VSS) capacitor c=2.794E-15
    I_C3929 (I1298_P21_18n VSS) capacitor c=2.637E-15
    I_C3930 (I1298_P25_18 VSS) capacitor c=2.155E-15
    I_C3931 (I1298_pn19 VSS) capacitor c=5.329E-15
    I_C3932 (I1298_P20_19 VSS) capacitor c=2.117E-15
    I_C3933 (I1252_P21_18n VSS) capacitor c=2.628E-15
    I_C3934 (I1252_P17_14n VSS) capacitor c=5.646E-15
    I_C3935 (I1252_P21_14 VSS) capacitor c=3.837E-15
    I_C3936 (I1252_P25_18 VSS) capacitor c=2.409E-15
    I_C3937 (I1252_pn19 VSS) capacitor c=6.267E-15
    I_C3938 (I1252_pn18 VSS) capacitor c=9.566E-15
    I_C3939 (I1252_P19_18 VSS) capacitor c=1.906E-15
    I_C3940 (I1252_P22_19n VSS) capacitor c=2.252E-15
    I_C3941 (I1252_P18_15n VSS) capacitor c=3.601E-15
    I_C3942 (I1252_P22_15 VSS) capacitor c=4.082E-15
    I_C3943 (I1252_P26_19 VSS) capacitor c=2.164E-15
    I_C3944 (I1252_P20_19 VSS) capacitor c=2.709E-15
    I_C3945 (I1206_P7_4n VSS) capacitor c=4.848E-15
    I_C3946 (I1206_P11_4 VSS) capacitor c=1.369E-15
    I_C3947 (I1206_P9_6n VSS) capacitor c=4.325E-15
    I_C3948 (I1206_P13_6 VSS) capacitor c=3.509E-15
    I_C3949 (I1206_P16_15 VSS) capacitor c=4.713E-15
    I_C3950 (I1160_pn26 VSS) capacitor c=5.013E-15
    I_C3951 (I1160_pn25 VSS) capacitor c=6.439E-15
    I_C3952 (I1160_P26_25 VSS) capacitor c=3.543E-15
    I_C3953 (I1160_P30_27n VSS) capacitor c=1.687E-15
    I_C3954 (I1160_P26_23n VSS) capacitor c=2.451E-15
    I_C3955 (I1160_P30_23 VSS) capacitor c=1.649E-15
    I_C3956 (I1160_pn28 VSS) capacitor c=4.846E-15
    I_C3957 (I1160_pn27 VSS) capacitor c=5.732E-15
    I_C3958 (I1160_P28_27 VSS) capacitor c=2.882E-15
    I_C3959 (I1160_P27_26 VSS) capacitor c=5.378E-15
    I_C3960 (I1528_pn24 VSS) capacitor c=6.403E-15
    I_C3961 (I1528_P25_24 VSS) capacitor c=3.453E-15
    I_C3962 (I1528_P30_27n VSS) capacitor c=2.447E-15
    I_C3963 (I1528_P26_23n VSS) capacitor c=2.561E-15
    I_C3964 (I1528_P30_23 VSS) capacitor c=1.882E-15
    I_C3965 (I1528_pn23 VSS) capacitor c=7.243E-15
    I_C3966 (I1528_P24_23 VSS) capacitor c=2.857E-15
    I_C3967 (I1482_P20_17n VSS) capacitor c=2.637E-15
    I_C3968 (I1482_P24_17 VSS) capacitor c=1.675E-15
    I_C3969 (I1482_P15_12n VSS) capacitor c=3.424E-15
    I_C3970 (I1482_P11_8n VSS) capacitor c=3.613E-15
    I_C3971 (I1482_P15_8 VSS) capacitor c=3.752E-15
    I_C3972 (I1482_P19_12 VSS) capacitor c=4.355E-15
    I_C3973 (I1482_pn18 VSS) capacitor c=5.522E-15
    I_C3974 (I1482_P19_18 VSS) capacitor c=2.663E-15
    I_C3975 (I1436_P17_14n VSS) capacitor c=4.371E-15
    I_C3976 (I1436_P21_14 VSS) capacitor c=4.594E-15
    I_C3977 (I1436_pn17 VSS) capacitor c=6.039E-15
    I_C3978 (I1436_P17_16 VSS) capacitor c=2.171E-15
    I_C3979 (I1436_pn18 VSS) capacitor c=6.814E-15
    I_C3980 (I1436_P19_18 VSS) capacitor c=2.544E-15
    I_C3981 (I1436_P20_17n VSS) capacitor c=2.485E-15
    I_C3982 (I1436_P24_17 VSS) capacitor c=3.805E-15
    I_C3983 (I1436_P18_17 VSS) capacitor c=3.160E-15
    I_C3984 (I1390_P21_18n VSS) capacitor c=2.177E-15
    I_C3985 (I1390_P17_14n VSS) capacitor c=4.286E-15
    I_C3986 (I1390_P21_14 VSS) capacitor c=4.112E-15
    I_C3987 (I1390_P25_18 VSS) capacitor c=3.816E-15
    I_C3988 (I1390_pn18 VSS) capacitor c=6.397E-15
    I_C3989 (I1390_P19_18 VSS) capacitor c=2.361E-15
    I_C3990 (I1390_P22_19n VSS) capacitor c=2.502E-15
    I_C3991 (I1390_P26_19 VSS) capacitor c=2.474E-15
    I_C3992 (I1390_P18_15n VSS) capacitor c=5.006E-15
    I_C3993 (I1390_P22_15 VSS) capacitor c=4.359E-15
    I_C3994 (I1344_P17_14n VSS) capacitor c=3.728E-15
    I_C3995 (I1344_P21_14 VSS) capacitor c=4.226E-15
    I_C3996 (I1344_pn18 VSS) capacitor c=5.409E-15
    I_C3997 (I1344_P19_18 VSS) capacitor c=3.203E-15
    I_C3998 (I1344_pn17 VSS) capacitor c=4.742E-15
    I_C3999 (I1344_P18_17 VSS) capacitor c=2.548E-15
    I_C4000 (I1344_P18_15n VSS) capacitor c=3.724E-15
    I_C4001 (I1344_P22_15 VSS) capacitor c=2.588E-15
    I_C4002 (I1298_P17_14n VSS) capacitor c=2.815E-15
    I_C4003 (I1298_P21_14 VSS) capacitor c=5.308E-15
    I_C4004 (I1298_pn18 VSS) capacitor c=5.943E-15
    I_C4005 (I1298_P19_18 VSS) capacitor c=2.392E-15
    I_C4006 (I1298_P22_19n VSS) capacitor c=2.387E-15
    I_C4007 (I1298_P18_15n VSS) capacitor c=3.710E-15
    I_C4008 (I1298_P22_15 VSS) capacitor c=3.093E-15
    I_C4009 (I1298_P26_19 VSS) capacitor c=1.743E-15
    I_C4010 (I1298_pn17 VSS) capacitor c=6.375E-15
    I_C4011 (I1298_P18_17 VSS) capacitor c=2.439E-15
    I_C4012 (I1252_P15_12n VSS) capacitor c=2.994E-15
    I_C4013 (I1252_P19_12 VSS) capacitor c=4.227E-15
    I_C4014 (I1252_pn17 VSS) capacitor c=5.761E-15
    I_C4015 (I1252_P17_16 VSS) capacitor c=2.559E-15
    I_C4016 (I1252_P20_17n VSS) capacitor c=3.221E-15
    I_C4017 (I1252_P24_17 VSS) capacitor c=3.643E-15
    I_C4018 (I1252_P16_15 VSS) capacitor c=2.073E-15
    I_C4019 (I1252_P18_17 VSS) capacitor c=2.421E-15
    I_C4020 (I1206_P12_9n VSS) capacitor c=2.741E-15
    I_C4021 (I1206_P16_9 VSS) capacitor c=5.649E-15
    I_C4022 (I1206_P8_5n VSS) capacitor c=3.813E-15
    I_C4023 (I1206_P12_5 VSS) capacitor c=3.274E-15
    I_C4024 (I1206_P5_2n VSS) capacitor c=4.575E-15
    I_C4025 (I1206_P9_2 VSS) capacitor c=1.955E-15
    I_C4026 (I1206_P14_13 VSS) capacitor c=3.534E-15
    I_C4027 (I1206_P13_12 VSS) capacitor c=2.796E-15
    I_C4028 (I1206_P15_14 VSS) capacitor c=2.461E-15
    I_C4029 (I1160_P10_7n VSS) capacitor c=5.676E-15
    I_C4030 (I1160_P6_3n VSS) capacitor c=5.499E-15
    I_C4031 (I1160_P10_3 VSS) capacitor c=1.702E-15
    I_C4032 (I1160_P14_11n VSS) capacitor c=3.637E-15
    I_C4033 (I1160_P14_7 VSS) capacitor c=3.819E-15
    I_C4034 (I1160_P18_15n VSS) capacitor c=4.570E-15
    I_C4035 (I1160_P18_11 VSS) capacitor c=2.679E-15
    I_C4036 (I1160_P22_19n VSS) capacitor c=3.602E-15
    I_C4037 (I1160_P22_15 VSS) capacitor c=2.856E-15
    I_C4038 (I1160_P26_19 VSS) capacitor c=2.601E-15
    I_C4039 (I1160_pn29 VSS) capacitor c=4.479E-15
    I_C4040 (I1160_P29_28 VSS) capacitor c=5.084E-15
    I_C4041 (I1528_P29_26n VSS) capacitor c=2.135E-15
    I_C4042 (I1528_P25_22n VSS) capacitor c=3.020E-15
    I_C4043 (I1528_P29_22 VSS) capacitor c=3.295E-15
    I_C4044 (I1528_P23_20n VSS) capacitor c=3.035E-15
    I_C4045 (I1528_P27_20 VSS) capacitor c=4.661E-15
    I_C4046 (I1528_pn22 VSS) capacitor c=1.040E-14
    I_C4047 (I1528_P23_22 VSS) capacitor c=3.098E-15
    I_C4048 (I1482_P14_11n VSS) capacitor c=4.116E-15
    I_C4049 (I1482_P18_11 VSS) capacitor c=2.908E-15
    I_C4050 (I1482_P16_13n VSS) capacitor c=3.623E-15
    I_C4051 (I1482_P20_13 VSS) capacitor c=3.739E-15
    I_C4052 (I1482_pn17 VSS) capacitor c=6.480E-15
    I_C4053 (I1482_P18_17 VSS) capacitor c=2.801E-15
    I_C4054 (I1482_P16_15 VSS) capacitor c=2.322E-15
    I_C4055 (I1482_P17_16 VSS) capacitor c=2.694E-15
    I_C4056 (I1436_P15_12n VSS) capacitor c=2.459E-15
    I_C4057 (I1436_P11_8n VSS) capacitor c=4.485E-15
    I_C4058 (I1436_P15_8 VSS) capacitor c=3.010E-15
    I_C4059 (I1436_P19_12 VSS) capacitor c=5.142E-15
    I_C4060 (I1436_P16_13n VSS) capacitor c=4.071E-15
    I_C4061 (I1436_P20_13 VSS) capacitor c=4.794E-15
    I_C4062 (I1436_P16_15 VSS) capacitor c=2.422E-15
    I_C4063 (I1390_P15_12n VSS) capacitor c=2.968E-15
    I_C4064 (I1390_P19_12 VSS) capacitor c=5.773E-15
    I_C4065 (I1390_pn17 VSS) capacitor c=6.920E-15
    I_C4066 (I1390_P17_16 VSS) capacitor c=2.455E-15
    I_C4067 (I1390_P18_17 VSS) capacitor c=2.460E-15
    I_C4068 (I1344_P15_12n VSS) capacitor c=2.587E-15
    I_C4069 (I1344_P19_12 VSS) capacitor c=4.890E-15
    I_C4070 (I1344_P17_16 VSS) capacitor c=2.846E-15
    I_C4071 (I1298_P15_12n VSS) capacitor c=2.778E-15
    I_C4072 (I1298_P19_12 VSS) capacitor c=6.433E-15
    I_C4073 (I1298_P17_16 VSS) capacitor c=2.239E-15
    I_C4074 (I1298_P20_17n VSS) capacitor c=2.705E-15
    I_C4075 (I1298_P24_17 VSS) capacitor c=3.557E-15
    I_C4076 (I1298_P16_13n VSS) capacitor c=3.219E-15
    I_C4077 (I1298_P20_13 VSS) capacitor c=4.542E-15
    I_C4078 (I1298_P16_15 VSS) capacitor c=2.412E-15
    I_C4079 (I1252_P11_8n VSS) capacitor c=5.036E-15
    I_C4080 (I1252_P15_8 VSS) capacitor c=3.270E-15
    I_C4081 (I1252_P15_14 VSS) capacitor c=2.135E-15
    I_C4082 (I1252_P16_13n VSS) capacitor c=5.235E-15
    I_C4083 (I1252_P20_13 VSS) capacitor c=4.435E-15
    I_C4084 (I1252_P14_11n VSS) capacitor c=1.894E-15
    I_C4085 (I1252_P18_11 VSS) capacitor c=4.702E-15
    I_C4086 (I1206_P6_3n VSS) capacitor c=2.635E-15
    I_C4087 (I1206_P10_3 VSS) capacitor c=3.425E-15
    I_C4088 (I1206_P12_11 VSS) capacitor c=2.700E-15
    I_C4089 (I1206_P11_10 VSS) capacitor c=2.588E-15
    I_C4090 (I1160_P24_21n VSS) capacitor c=2.602E-15
    I_C4091 (I1160_P20_17n VSS) capacitor c=2.224E-15
    I_C4092 (I1160_P24_17 VSS) capacitor c=1.921E-15
    I_C4093 (I1160_P28_25n VSS) capacitor c=2.731E-15
    I_C4094 (I1160_P28_21 VSS) capacitor c=1.566E-15
    I_C4095 (I1160_pn24 VSS) capacitor c=4.345E-15
    I_C4096 (I1160_pn23 VSS) capacitor c=9.114E-15
    I_C4097 (I1160_P24_23 VSS) capacitor c=3.110E-15
    I_C4098 (I1160_pn30 VSS) capacitor c=5.342E-15
    I_C4099 (I1160_P30_29 VSS) capacitor c=3.291E-15
    I_C4100 (I1528_P21_18n VSS) capacitor c=2.332E-15
    I_C4101 (I1528_P25_18 VSS) capacitor c=6.377E-15
    I_C4102 (I1528_P19_16n VSS) capacitor c=2.782E-15
    I_C4103 (I1528_P23_16 VSS) capacitor c=2.814E-15
    I_C4104 (I1528_pn21 VSS) capacitor c=6.773E-15
    I_C4105 (I1528_pn20 VSS) capacitor c=8.986E-15
    I_C4106 (I1528_P21_20 VSS) capacitor c=3.829E-15
    I_C4107 (I1528_P22_19n VSS) capacitor c=2.480E-15
    I_C4108 (I1528_P26_19 VSS) capacitor c=3.689E-15
    I_C4109 (I1528_P28_25n VSS) capacitor c=3.490E-15
    I_C4110 (I1528_P24_21n VSS) capacitor c=3.998E-15
    I_C4111 (I1528_P28_21 VSS) capacitor c=4.240E-15
    I_C4112 (I1528_pn19 VSS) capacitor c=8.013E-15
    I_C4113 (I1528_pn18 VSS) capacitor c=9.667E-15
    I_C4114 (I1528_P19_18 VSS) capacitor c=3.345E-15
    I_C4115 (I1528_P22_21 VSS) capacitor c=2.601E-15
    I_C4116 (I1528_P20_19 VSS) capacitor c=3.056E-15
    I_C4117 (I1482_P13_10n VSS) capacitor c=2.985E-15
    I_C4118 (I1482_P9_6n VSS) capacitor c=4.607E-15
    I_C4119 (I1482_P13_6 VSS) capacitor c=2.856E-15
    I_C4120 (I1482_P17_10 VSS) capacitor c=5.347E-15
    I_C4121 (I1482_P15_14 VSS) capacitor c=2.331E-15
    I_C4122 (I1436_P13_10n VSS) capacitor c=2.741E-15
    I_C4123 (I1436_P17_10 VSS) capacitor c=5.847E-15
    I_C4124 (I1436_P15_14 VSS) capacitor c=2.560E-15
    I_C4125 (I1436_P14_11n VSS) capacitor c=2.876E-15
    I_C4126 (I1436_P18_11 VSS) capacitor c=3.707E-15
    I_C4127 (I1390_P11_8n VSS) capacitor c=3.719E-15
    I_C4128 (I1390_P15_8 VSS) capacitor c=3.435E-15
    I_C4129 (I1390_P15_14 VSS) capacitor c=2.549E-15
    I_C4130 (I1390_P20_17n VSS) capacitor c=2.945E-15
    I_C4131 (I1390_P24_17 VSS) capacitor c=3.103E-15
    I_C4132 (I1390_P16_13n VSS) capacitor c=3.780E-15
    I_C4133 (I1390_P20_13 VSS) capacitor c=4.524E-15
    I_C4134 (I1390_P16_15 VSS) capacitor c=2.390E-15
    I_C4135 (I1344_P11_8n VSS) capacitor c=4.585E-15
    I_C4136 (I1344_P15_8 VSS) capacitor c=4.532E-15
    I_C4137 (I1344_P15_14 VSS) capacitor c=2.174E-15
    I_C4138 (I1344_P16_15 VSS) capacitor c=2.821E-15
    I_C4139 (I1344_P20_17n VSS) capacitor c=3.379E-15
    I_C4140 (I1344_P24_17 VSS) capacitor c=3.443E-15
    I_C4141 (I1344_P16_13n VSS) capacitor c=3.620E-15
    I_C4142 (I1344_P20_13 VSS) capacitor c=4.992E-15
    I_C4143 (I1344_P14_11n VSS) capacitor c=3.299E-15
    I_C4144 (I1344_P18_11 VSS) capacitor c=3.096E-15
    I_C4145 (I1298_P11_8n VSS) capacitor c=5.055E-15
    I_C4146 (I1298_P15_8 VSS) capacitor c=3.732E-15
    I_C4147 (I1298_P15_14 VSS) capacitor c=2.241E-15
    I_C4148 (I1298_P14_11n VSS) capacitor c=2.891E-15
    I_C4149 (I1298_P10_7n VSS) capacitor c=3.488E-15
    I_C4150 (I1298_P14_7 VSS) capacitor c=3.301E-15
    I_C4151 (I1298_P18_11 VSS) capacitor c=4.145E-15
    I_C4152 (I1252_P13_10n VSS) capacitor c=3.828E-15
    I_C4153 (I1252_P17_10 VSS) capacitor c=3.595E-15
    I_C4154 (I1252_P10_7n VSS) capacitor c=3.093E-15
    I_C4155 (I1252_P14_7 VSS) capacitor c=4.362E-15
    I_C4156 (I1252_P14_13 VSS) capacitor c=2.159E-15
    I_C4157 (I1206_P10_9 VSS) capacitor c=1.758E-15
    I_C4158 (I1206_pn8 VSS) capacitor c=4.045E-15
    I_C4159 (I1206_P9_8 VSS) capacitor c=2.863E-15
    I_C4160 (I1160_P8_5n VSS) capacitor c=3.862E-15
    I_C4161 (I1160_P4_1n VSS) capacitor c=3.289E-15
    I_C4162 (I1160_P8_1 VSS) capacitor c=1.885E-15
    I_C4163 (I1160_P12_9n VSS) capacitor c=2.703E-15
    I_C4164 (I1160_P12_5 VSS) capacitor c=2.424E-15
    I_C4165 (I1160_P16_13n VSS) capacitor c=2.344E-15
    I_C4166 (I1160_P16_9 VSS) capacitor c=3.817E-15
    I_C4167 (I1160_P16_15 VSS) capacitor c=2.007E-15
    I_C4168 (I1160_P20_13 VSS) capacitor c=3.417E-15
    I_C4169 (I1160_pn20 VSS) capacitor c=5.257E-15
    I_C4170 (I1160_pn19 VSS) capacitor c=8.817E-15
    I_C4171 (I1160_P20_19 VSS) capacitor c=2.025E-15
    I_C4172 (I1160_pn22 VSS) capacitor c=6.220E-15
    I_C4173 (I1160_pn21 VSS) capacitor c=7.287E-15
    I_C4174 (I1160_P22_21 VSS) capacitor c=2.074E-15
    I_C4175 (I1160_P25_24 VSS) capacitor c=2.278E-15
    I_C4176 (I1528_pn17 VSS) capacitor c=9.019E-15
    I_C4177 (I1528_P17_16 VSS) capacitor c=2.920E-15
    I_C4178 (I1528_P18_15n VSS) capacitor c=3.564E-15
    I_C4179 (I1528_P22_15 VSS) capacitor c=4.133E-15
    I_C4180 (I1528_P18_17 VSS) capacitor c=2.419E-15
    I_C4181 (I1482_P10_7n VSS) capacitor c=3.960E-15
    I_C4182 (I1482_P14_7 VSS) capacitor c=4.009E-15
    I_C4183 (I1482_P12_9n VSS) capacitor c=2.956E-15
    I_C4184 (I1482_P16_9 VSS) capacitor c=5.751E-15
    I_C4185 (I1482_P14_13 VSS) capacitor c=2.296E-15
    I_C4186 (I1482_P13_12 VSS) capacitor c=2.133E-15
    I_C4187 (I1436_P9_6n VSS) capacitor c=3.713E-15
    I_C4188 (I1436_P13_6 VSS) capacitor c=3.180E-15
    I_C4189 (I1436_P13_12 VSS) capacitor c=2.914E-15
    I_C4190 (I1436_P10_7n VSS) capacitor c=4.018E-15
    I_C4191 (I1436_P14_7 VSS) capacitor c=3.180E-15
    I_C4192 (I1436_P14_13 VSS) capacitor c=2.425E-15
    I_C4193 (I1390_P13_10n VSS) capacitor c=2.037E-15
    I_C4194 (I1390_P9_6n VSS) capacitor c=3.743E-15
    I_C4195 (I1390_P13_6 VSS) capacitor c=4.034E-15
    I_C4196 (I1390_P17_10 VSS) capacitor c=3.739E-15
    I_C4197 (I1390_P14_11n VSS) capacitor c=2.505E-15
    I_C4198 (I1390_P10_7n VSS) capacitor c=3.778E-15
    I_C4199 (I1390_P14_7 VSS) capacitor c=3.224E-15
    I_C4200 (I1390_P18_11 VSS) capacitor c=4.585E-15
    I_C4201 (I1390_P14_13 VSS) capacitor c=2.176E-15
    I_C4202 (I1344_P13_10n VSS) capacitor c=3.188E-15
    I_C4203 (I1344_P9_6n VSS) capacitor c=4.385E-15
    I_C4204 (I1344_P13_6 VSS) capacitor c=3.837E-15
    I_C4205 (I1344_P17_10 VSS) capacitor c=3.478E-15
    I_C4206 (I1344_P14_13 VSS) capacitor c=2.136E-15
    I_C4207 (I1344_P10_7n VSS) capacitor c=3.671E-15
    I_C4208 (I1344_P14_7 VSS) capacitor c=2.717E-15
    I_C4209 (I1298_P13_10n VSS) capacitor c=2.441E-15
    I_C4210 (I1298_P9_6n VSS) capacitor c=2.919E-15
    I_C4211 (I1298_P13_6 VSS) capacitor c=3.898E-15
    I_C4212 (I1298_P17_10 VSS) capacitor c=5.592E-15
    I_C4213 (I1298_P13_12 VSS) capacitor c=2.514E-15
    I_C4214 (I1298_P12_9n VSS) capacitor c=2.118E-15
    I_C4215 (I1298_P16_9 VSS) capacitor c=4.001E-15
    I_C4216 (I1298_P14_13 VSS) capacitor c=2.138E-15
    I_C4217 (I1252_P9_6n VSS) capacitor c=3.995E-15
    I_C4218 (I1252_P13_6 VSS) capacitor c=2.884E-15
    I_C4219 (I1252_P7_4n VSS) capacitor c=2.432E-15
    I_C4220 (I1252_P11_4 VSS) capacitor c=1.649E-15
    I_C4221 (I1252_P13_12 VSS) capacitor c=2.778E-15
