    I_MXI1880_MN5 (XI1880_n2 XI1880_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1880_MN4 (b29_16 XI1880_An XI1880_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1880_MN2 (XI1880_n1 dd16_b3_5 b29_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1880_MN3 (VSS qu3_b3_2 XI1880_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1880_MN0 (XI1880_An dd16_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI681_MN1 (XI681_Bn qu29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI681_MN5 (XI681_n2 XI681_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI681_MN4 (b3_13 XI681_An XI681_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI681_MN2 (XI681_n1 dd13_b3_0 b3_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI681_MN3 (VSS qu29_b3_2 XI681_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI681_MN0 (XI681_An dd13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI680_MN1 (XI680_Bn qu29_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI680_MN5 (XI680_n2 XI680_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI680_MN4 (b3_12 XI680_An XI680_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI680_MN2 (XI680_n1 dd12_b3_0 b3_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI680_MN3 (VSS qu29_b3_2 XI680_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI680_MN0 (XI680_An dd12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I214_MN1 (XI654_I214_Bn I654_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I214_MN5 (XI654_I214_n2 XI654_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I214_MN4 (p2_11 XI654_I214_An XI654_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I214_MN2 (XI654_I214_n1 I654_pn11 p2_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I214_MN3 (VSS I654_G10_0n XI654_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I214_MN0 (XI654_I214_An I654_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI635_MN1 (XI635_Bn qu30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI635_MN5 (XI635_n2 XI635_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI635_MN4 (b2_13 XI635_An XI635_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI635_MN2 (XI635_n1 dd13_b3_0 b2_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI635_MN3 (VSS qu30_b3_2 XI635_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI635_MN0 (XI635_An dd13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI634_MN1 (XI634_Bn qu30_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI634_MN5 (XI634_n2 XI634_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI634_MN4 (b2_12 XI634_An XI634_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI634_MN2 (XI634_n1 dd12_b3_0 b2_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI634_MN3 (VSS qu30_b3_2 XI634_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI634_MN0 (XI634_An dd12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I213_MN1 (XI608_I213_Bn I608_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I213_MN5 (XI608_I213_n2 XI608_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I213_MN4 (p1_10 XI608_I213_An XI608_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I213_MN2 (XI608_I213_n1 I608_pn10 p1_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I213_MN3 (VSS I608_G9_0n XI608_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I213_MN0 (XI608_I213_An I608_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I214_MN1 (XI608_I214_Bn I608_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I214_MN5 (XI608_I214_n2 XI608_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I214_MN4 (p1_11 XI608_I214_An XI608_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I214_MN2 (XI608_I214_n1 I608_pn11 p1_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I214_MN3 (VSS I608_G10_0n XI608_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I214_MN0 (XI608_I214_An I608_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI589_MN1 (XI589_Bn qu31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI589_MN5 (XI589_n2 XI589_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI589_MN4 (b1_13 XI589_An XI589_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI589_MN2 (XI589_n1 dd13_b3_0 b1_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI589_MN3 (VSS qu31_b3_2 XI589_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI589_MN0 (XI589_An dd13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI590_MN1 (XI590_Bn qu31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI590_MN5 (XI590_n2 XI590_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI590_MN4 (b1_14 XI590_An XI590_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI590_MN2 (XI590_n1 dd14_b3_0 b1_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI590_MN3 (VSS qu31_b3_2 XI590_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI590_MN0 (XI590_An dd14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI544_MN1 (XI544_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI544_MN5 (XI544_n2 XI544_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI544_MN4 (b0_14 XI544_An XI544_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI544_MN2 (XI544_n1 dd14_b3_0 b0_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI544_MN3 (VSS VDD XI544_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI544_MN0 (XI544_An dd14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI543_MN1 (XI543_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI543_MN5 (XI543_n2 XI543_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI543_MN4 (b0_13 XI543_An XI543_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI543_MN2 (XI543_n1 dd13_b3_0 b0_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI543_MN3 (VSS VDD XI543_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI543_MN0 (XI543_An dd13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I213_MN1 (XI2066_I213_Bn I2066_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I213_MN5 (XI2066_I213_n2 XI2066_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I213_MN4 (ru10 XI2066_I213_An XI2066_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I213_MN2 (XI2066_I213_n1 I2066_pn10 ru10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I213_MN3 (VSS I2066_G9_0n XI2066_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I213_MN0 (XI2066_I213_An I2066_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I214_MN1 (XI2066_I214_Bn I2066_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I214_MN5 (XI2066_I214_n2 XI2066_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I214_MN4 (ru11 XI2066_I214_An XI2066_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I214_MN2 (XI2066_I214_n1 I2066_pn11 ru11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I214_MN3 (VSS I2066_G10_0n XI2066_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I214_MN0 (XI2066_I214_An I2066_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I212_MN1 (XI2066_I212_Bn I2066_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I212_MN5 (XI2066_I212_n2 XI2066_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I212_MN4 (ru9 XI2066_I212_An XI2066_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I212_MN2 (XI2066_I212_n1 I2066_pn9 ru9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I212_MN3 (VSS I2066_G8_0n XI2066_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I212_MN0 (XI2066_I212_An I2066_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I216_MN1 (XI1988_I216_Bn I1988_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I216_MN5 (XI1988_I216_n2 XI1988_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I216_MN4 (p31_13 XI1988_I216_An XI1988_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I216_MN2 (XI1988_I216_n1 I1988_pn13 p31_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I216_MN3 (VSS I1988_G12_0n XI1988_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I216_MN0 (XI1988_I216_An I1988_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I215_MN1 (XI1988_I215_Bn I1988_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I215_MN5 (XI1988_I215_n2 XI1988_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I215_MN4 (p31_12 XI1988_I215_An XI1988_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I215_MN2 (XI1988_I215_n1 I1988_pn12 p31_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I215_MN3 (VSS I1988_G11_0n XI1988_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I215_MN0 (XI1988_I215_An I1988_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1969_MN1 (XI1969_Bn qu1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1969_MN5 (XI1969_n2 XI1969_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1969_MN4 (b31_13 XI1969_An XI1969_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1969_MN2 (XI1969_n1 dd13_b3_5 b31_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1969_MN3 (VSS qu1_b3_2 XI1969_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1969_MN0 (XI1969_An dd13_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1968_MN1 (XI1968_Bn qu1_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1968_MN5 (XI1968_n2 XI1968_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1968_MN4 (b31_12 XI1968_An XI1968_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1968_MN2 (XI1968_n1 dd12_b3_5 b31_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1968_MN3 (VSS qu1_b3_2 XI1968_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1968_MN0 (XI1968_An dd12_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I214_MN1 (XI1942_I214_Bn I1942_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I214_MN5 (XI1942_I214_n2 XI1942_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I214_MN4 (p30_11 XI1942_I214_An XI1942_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I214_MN2 (XI1942_I214_n1 I1942_pn11 p30_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I214_MN3 (VSS I1942_G10_0n XI1942_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I214_MN0 (XI1942_I214_An I1942_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1922_MN1 (XI1922_Bn qu2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1922_MN5 (XI1922_n2 XI1922_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1922_MN4 (b30_12 XI1922_An XI1922_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1922_MN2 (XI1922_n1 dd12_b3_5 b30_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1922_MN3 (VSS qu2_b3_2 XI1922_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1922_MN0 (XI1922_An dd12_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1923_MN1 (XI1923_Bn qu2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1923_MN5 (XI1923_n2 XI1923_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1923_MN4 (b30_13 XI1923_An XI1923_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1923_MN2 (XI1923_n1 dd13_b3_5 b30_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1923_MN3 (VSS qu2_b3_2 XI1923_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1923_MN0 (XI1923_An dd13_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1876_MN1 (XI1876_Bn qu3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1876_MN5 (XI1876_n2 XI1876_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1876_MN4 (b29_12 XI1876_An XI1876_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1876_MN2 (XI1876_n1 dd12_b3_5 b29_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1876_MN3 (VSS qu3_b3_2 XI1876_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1876_MN0 (XI1876_An dd12_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1877_MN1 (XI1877_Bn qu3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1877_MN5 (XI1877_n2 XI1877_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1877_MN4 (b29_13 XI1877_An XI1877_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1877_MN2 (XI1877_n1 dd13_b3_5 b29_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1877_MN3 (VSS qu3_b3_2 XI1877_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1877_MN0 (XI1877_An dd13_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I215_MN1 (XI1850_I215_Bn I1850_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I215_MN5 (XI1850_I215_n2 XI1850_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I215_MN4 (p28_12 XI1850_I215_An XI1850_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I215_MN2 (XI1850_I215_n1 I1850_pn12 p28_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I215_MN3 (VSS I1850_G11_0n XI1850_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I215_MN0 (XI1850_I215_An I1850_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1879_MN1 (XI1879_Bn qu3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1879_MN5 (XI1879_n2 XI1879_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1879_MN4 (b29_15 XI1879_An XI1879_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1879_MN2 (XI1879_n1 dd15_b3_5 b29_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1879_MN3 (VSS qu3_b3_2 XI1879_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1879_MN0 (XI1879_An dd15_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I219_MN1 (XI1850_I219_Bn I1850_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I219_MN5 (XI1850_I219_n2 XI1850_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I219_MN4 (p28_16 XI1850_I219_An XI1850_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I219_MN2 (XI1850_I219_n1 I1850_pn16 p28_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I219_MN3 (VSS I1850_G15_0n XI1850_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I219_MN0 (XI1850_I219_An I1850_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1852_MN1 (XI1852_Bn c28_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1852_MN5 (XI1852_n2 XI1852_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1852_MN4 (p28_32 XI1852_An XI1852_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1852_MN2 (XI1852_n1 h28 p28_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1852_MN3 (VSS c28_o XI1852_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1852_MN0 (XI1852_An h28 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I219_MN1 (XI700_I219_Bn I700_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I219_MN5 (XI700_I219_n2 XI700_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I219_MN4 (p3_16 XI700_I219_An XI700_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I219_MN2 (XI700_I219_n1 I700_pn16 p3_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I219_MN3 (VSS I700_G15_0n XI700_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I219_MN0 (XI700_I219_An I700_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I213_MN1 (XI654_I213_Bn I654_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I213_MN5 (XI654_I213_n2 XI654_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I213_MN4 (p2_10 XI654_I213_An XI654_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I213_MN2 (XI654_I213_n1 I654_pn10 p2_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I213_MN3 (VSS I654_G9_0n XI654_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I213_MN0 (XI654_I213_An I654_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I212_MN1 (XI654_I212_Bn I654_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I212_MN5 (XI654_I212_n2 XI654_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I212_MN4 (p2_9 XI654_I212_An XI654_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I212_MN2 (XI654_I212_n1 I654_pn9 p2_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I212_MN3 (VSS I654_G8_0n XI654_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I212_MN0 (XI654_I212_An I654_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I212_MN1 (XI608_I212_Bn I608_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I212_MN5 (XI608_I212_n2 XI608_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I212_MN4 (p1_9 XI608_I212_An XI608_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I212_MN2 (XI608_I212_n1 I608_pn9 p1_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I212_MN3 (VSS I608_G8_0n XI608_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I212_MN0 (XI608_I212_An I608_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI588_MN1 (XI588_Bn qu31_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI588_MN5 (XI588_n2 XI588_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI588_MN4 (b1_12 XI588_An XI588_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI588_MN2 (XI588_n1 dd12_b3_0 b1_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI588_MN3 (VSS qu31_b3_2 XI588_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI588_MN0 (XI588_An dd12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI542_MN1 (XI542_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI542_MN5 (XI542_n2 XI542_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI542_MN4 (b0_12 XI542_An XI542_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI542_MN2 (XI542_n1 dd12_b3_0 b0_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI542_MN3 (VSS VDD XI542_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI542_MN0 (XI542_An dd12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I214_MN1 (XI562_I214_Bn I562_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I214_MN5 (XI562_I214_n2 XI562_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I214_MN4 (p0_11 XI562_I214_An XI562_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I214_MN2 (XI562_I214_n1 I562_pn11 p0_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I214_MN3 (VSS I562_G10_0n XI562_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I214_MN0 (XI562_I214_An I562_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I213_MN1 (XI562_I213_Bn I562_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I213_MN5 (XI562_I213_n2 XI562_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I213_MN4 (p0_10 XI562_I213_An XI562_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I213_MN2 (XI562_I213_n1 I562_pn10 p0_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I213_MN3 (VSS I562_G9_0n XI562_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I213_MN0 (XI562_I213_An I562_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I214_MN1 (XI1988_I214_Bn I1988_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I214_MN5 (XI1988_I214_n2 XI1988_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I214_MN4 (p31_11 XI1988_I214_An XI1988_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I214_MN2 (XI1988_I214_n1 I1988_pn11 p31_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I214_MN3 (VSS I1988_G10_0n XI1988_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I214_MN0 (XI1988_I214_An I1988_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I213_MN1 (XI1988_I213_Bn I1988_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I213_MN5 (XI1988_I213_n2 XI1988_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I213_MN4 (p31_10 XI1988_I213_An XI1988_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I213_MN2 (XI1988_I213_n1 I1988_pn10 p31_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I213_MN3 (VSS I1988_G9_0n XI1988_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I213_MN0 (XI1988_I213_An I1988_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I212_MN1 (XI1942_I212_Bn I1942_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I212_MN5 (XI1942_I212_n2 XI1942_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I212_MN4 (p30_9 XI1942_I212_An XI1942_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I212_MN2 (XI1942_I212_n1 I1942_pn9 p30_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I212_MN3 (VSS I1942_G8_0n XI1942_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I212_MN0 (XI1942_I212_An I1942_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I213_MN1 (XI1942_I213_Bn I1942_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I213_MN5 (XI1942_I213_n2 XI1942_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I213_MN4 (p30_10 XI1942_I213_An XI1942_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I213_MN2 (XI1942_I213_n1 I1942_pn10 p30_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I213_MN3 (VSS I1942_G9_0n XI1942_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I213_MN0 (XI1942_I213_An I1942_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1875_MN1 (XI1875_Bn qu3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1875_MN5 (XI1875_n2 XI1875_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1875_MN4 (b29_11 XI1875_An XI1875_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1875_MN2 (XI1875_n1 dd11_b3_5 b29_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1875_MN3 (VSS qu3_b3_1 XI1875_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1875_MN0 (XI1875_An dd11_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1874_MN1 (XI1874_Bn qu3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1874_MN5 (XI1874_n2 XI1874_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1874_MN4 (b29_10 XI1874_An XI1874_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1874_MN2 (XI1874_n1 dd10_b3_5 b29_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1874_MN3 (VSS qu3_b3_1 XI1874_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1874_MN0 (XI1874_An dd10_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I213_MN1 (XI1850_I213_Bn I1850_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I213_MN5 (XI1850_I213_n2 XI1850_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I213_MN4 (p28_10 XI1850_I213_An XI1850_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I213_MN2 (XI1850_I213_n1 I1850_pn10 p28_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I213_MN3 (VSS I1850_G9_0n XI1850_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I213_MN0 (XI1850_I213_An I1850_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I217_MN1 (XI1850_I217_Bn I1850_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I217_MN5 (XI1850_I217_n2 XI1850_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I217_MN4 (p28_14 XI1850_I217_An XI1850_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I217_MN2 (XI1850_I217_n1 I1850_pn14 p28_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I217_MN3 (VSS I1850_G13_0n XI1850_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I217_MN0 (XI1850_I217_An I1850_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I217_MN1 (XI700_I217_Bn I700_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I217_MN5 (XI700_I217_n2 XI700_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I217_MN4 (p3_14 XI700_I217_An XI700_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I217_MN2 (XI700_I217_n1 I700_pn14 p3_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I217_MN3 (VSS I700_G13_0n XI700_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I217_MN0 (XI700_I217_An I700_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI679_MN1 (XI679_Bn qu29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI679_MN5 (XI679_n2 XI679_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI679_MN4 (b3_11 XI679_An XI679_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI679_MN2 (XI679_n1 dd11_b3_0 b3_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI679_MN3 (VSS qu29_b3_1 XI679_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI679_MN0 (XI679_An dd11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI678_MN1 (XI678_Bn qu29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI678_MN5 (XI678_n2 XI678_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI678_MN4 (b3_10 XI678_An XI678_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI678_MN2 (XI678_n1 dd10_b3_0 b3_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI678_MN3 (VSS qu29_b3_1 XI678_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI678_MN0 (XI678_An dd10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI632_MN1 (XI632_Bn qu30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI632_MN5 (XI632_n2 XI632_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI632_MN4 (b2_10 XI632_An XI632_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI632_MN2 (XI632_n1 dd10_b3_0 b2_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI632_MN3 (VSS qu30_b3_1 XI632_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI632_MN0 (XI632_An dd10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI587_MN1 (XI587_Bn qu31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI587_MN5 (XI587_n2 XI587_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI587_MN4 (b1_11 XI587_An XI587_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI587_MN2 (XI587_n1 dd11_b3_0 b1_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI587_MN3 (VSS qu31_b3_1 XI587_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI587_MN0 (XI587_An dd11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I212_MN1 (XI562_I212_Bn I562_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I212_MN5 (XI562_I212_n2 XI562_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I212_MN4 (p0_9 XI562_I212_An XI562_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I212_MN2 (XI562_I212_n1 I562_pn9 p0_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I212_MN3 (VSS I562_G8_0n XI562_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I212_MN0 (XI562_I212_An I562_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI541_MN1 (XI541_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI541_MN5 (XI541_n2 XI541_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI541_MN4 (b0_11 XI541_An XI541_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI541_MN2 (XI541_n1 dd11_b3_0 b0_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI541_MN3 (VSS VDD XI541_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI541_MN0 (XI541_An dd11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I207_MN1 (XI2066_I207_Bn I2066_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I207_MN5 (XI2066_I207_n2 XI2066_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I207_MN4 (ru4 XI2066_I207_An XI2066_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I207_MN2 (XI2066_I207_n1 I2066_pn4 ru4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I207_MN3 (VSS I2066_G3_0n XI2066_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I207_MN0 (XI2066_I207_An I2066_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I212_MN1 (XI1988_I212_Bn I1988_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I212_MN5 (XI1988_I212_n2 XI1988_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I212_MN4 (p31_9 XI1988_I212_An XI1988_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I212_MN2 (XI1988_I212_n1 I1988_pn9 p31_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I212_MN3 (VSS I1988_G8_0n XI1988_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I212_MN0 (XI1988_I212_An I1988_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1966_MN1 (XI1966_Bn qu1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1966_MN5 (XI1966_n2 XI1966_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1966_MN4 (b31_10 XI1966_An XI1966_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1966_MN2 (XI1966_n1 dd10_b3_5 b31_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1966_MN3 (VSS qu1_b3_1 XI1966_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1966_MN0 (XI1966_An dd10_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1965_MN1 (XI1965_Bn qu1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1965_MN5 (XI1965_n2 XI1965_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1965_MN4 (b31_9 XI1965_An XI1965_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1965_MN2 (XI1965_n1 dd9_b3_5 b31_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1965_MN3 (VSS qu1_b3_1 XI1965_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1965_MN0 (XI1965_An dd9_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1967_MN1 (XI1967_Bn qu1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1967_MN5 (XI1967_n2 XI1967_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1967_MN4 (b31_11 XI1967_An XI1967_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1967_MN2 (XI1967_n1 dd11_b3_5 b31_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1967_MN3 (VSS qu1_b3_1 XI1967_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1967_MN0 (XI1967_An dd11_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1920_MN1 (XI1920_Bn qu2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1920_MN5 (XI1920_n2 XI1920_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1920_MN4 (b30_10 XI1920_An XI1920_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1920_MN2 (XI1920_n1 dd10_b3_5 b30_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1920_MN3 (VSS qu2_b3_1 XI1920_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1920_MN0 (XI1920_An dd10_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1919_MN1 (XI1919_Bn qu2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1919_MN5 (XI1919_n2 XI1919_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1919_MN4 (b30_9 XI1919_An XI1919_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1919_MN2 (XI1919_n1 dd9_b3_5 b30_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1919_MN3 (VSS qu2_b3_1 XI1919_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1919_MN0 (XI1919_An dd9_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1921_MN1 (XI1921_Bn qu2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1921_MN5 (XI1921_n2 XI1921_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1921_MN4 (b30_11 XI1921_An XI1921_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1921_MN2 (XI1921_n1 dd11_b3_5 b30_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1921_MN3 (VSS qu2_b3_1 XI1921_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1921_MN0 (XI1921_An dd11_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1873_MN1 (XI1873_Bn qu3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1873_MN5 (XI1873_n2 XI1873_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1873_MN4 (b29_9 XI1873_An XI1873_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1873_MN2 (XI1873_n1 dd9_b3_5 b29_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1873_MN3 (VSS qu3_b3_1 XI1873_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1873_MN0 (XI1873_An dd9_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I215_MN1 (XI700_I215_Bn I700_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I215_MN5 (XI700_I215_n2 XI700_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I215_MN4 (p3_12 XI700_I215_An XI700_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I215_MN2 (XI700_I215_n1 I700_pn12 p3_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I215_MN3 (VSS I700_G11_0n XI700_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I215_MN0 (XI700_I215_An I700_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI677_MN1 (XI677_Bn qu29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI677_MN5 (XI677_n2 XI677_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI677_MN4 (b3_9 XI677_An XI677_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI677_MN2 (XI677_n1 dd9_b3_0 b3_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI677_MN3 (VSS qu29_b3_1 XI677_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI677_MN0 (XI677_An dd9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI676_MN1 (XI676_Bn qu29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI676_MN5 (XI676_n2 XI676_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI676_MN4 (b3_8 XI676_An XI676_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI676_MN2 (XI676_n1 dd8_b3_0 b3_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI676_MN3 (VSS qu29_b3_1 XI676_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI676_MN0 (XI676_An dd8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI630_MN1 (XI630_Bn qu30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI630_MN5 (XI630_n2 XI630_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI630_MN4 (b2_8 XI630_An XI630_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI630_MN2 (XI630_n1 dd8_b3_0 b2_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI630_MN3 (VSS qu30_b3_1 XI630_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI630_MN0 (XI630_An dd8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI633_MN1 (XI633_Bn qu30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI633_MN5 (XI633_n2 XI633_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI633_MN4 (b2_11 XI633_An XI633_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI633_MN2 (XI633_n1 dd11_b3_0 b2_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI633_MN3 (VSS qu30_b3_1 XI633_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI633_MN0 (XI633_An dd11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI631_MN1 (XI631_Bn qu30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI631_MN5 (XI631_n2 XI631_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI631_MN4 (b2_9 XI631_An XI631_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI631_MN2 (XI631_n1 dd9_b3_0 b2_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI631_MN3 (VSS qu30_b3_1 XI631_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI631_MN0 (XI631_An dd9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I207_MN1 (XI608_I207_Bn I608_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I207_MN5 (XI608_I207_n2 XI608_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I207_MN4 (p1_4 XI608_I207_An XI608_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I207_MN2 (XI608_I207_n1 I608_pn4 p1_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I207_MN3 (VSS I608_G3_0n XI608_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I207_MN0 (XI608_I207_An I608_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI584_MN1 (XI584_Bn qu31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI584_MN5 (XI584_n2 XI584_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI584_MN4 (b1_8 XI584_An XI584_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI584_MN2 (XI584_n1 dd8_b3_0 b1_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI584_MN3 (VSS qu31_b3_1 XI584_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI584_MN0 (XI584_An dd8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI585_MN1 (XI585_Bn qu31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI585_MN5 (XI585_n2 XI585_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI585_MN4 (b1_9 XI585_An XI585_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI585_MN2 (XI585_n1 dd9_b3_0 b1_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI585_MN3 (VSS qu31_b3_1 XI585_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI585_MN0 (XI585_An dd9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI586_MN1 (XI586_Bn qu31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI586_MN5 (XI586_n2 XI586_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI586_MN4 (b1_10 XI586_An XI586_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI586_MN2 (XI586_n1 dd10_b3_0 b1_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI586_MN3 (VSS qu31_b3_1 XI586_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI586_MN0 (XI586_An dd10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I207_MN1 (XI562_I207_Bn I562_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I207_MN5 (XI562_I207_n2 XI562_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I207_MN4 (p0_4 XI562_I207_An XI562_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I207_MN2 (XI562_I207_n1 I562_pn4 p0_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I207_MN3 (VSS I562_G3_0n XI562_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I207_MN0 (XI562_I207_An I562_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI540_MN1 (XI540_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI540_MN5 (XI540_n2 XI540_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI540_MN4 (b0_10 XI540_An XI540_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI540_MN2 (XI540_n1 dd10_b3_0 b0_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI540_MN3 (VSS VDD XI540_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI540_MN0 (XI540_An dd10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I206_MN1 (XI2066_I206_Bn I2066_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2066_I206_MN5 (XI2066_I206_n2 XI2066_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2066_I206_MN4 (ru3 XI2066_I206_An XI2066_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I206_MN2 (XI2066_I206_n1 I2066_pn3 ru3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2066_I206_MN3 (VSS I2066_G2_0n XI2066_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2066_I206_MN0 (XI2066_I206_An I2066_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1963_MN1 (XI1963_Bn qu1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1963_MN5 (XI1963_n2 XI1963_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1963_MN4 (b31_7 XI1963_An XI1963_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1963_MN2 (XI1963_n1 dd7_b3_5 b31_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1963_MN3 (VSS qu1_b3_1 XI1963_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1963_MN0 (XI1963_An dd7_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1964_MN1 (XI1964_Bn qu1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1964_MN5 (XI1964_n2 XI1964_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1964_MN4 (b31_8 XI1964_An XI1964_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1964_MN2 (XI1964_n1 dd8_b3_5 b31_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1964_MN3 (VSS qu1_b3_1 XI1964_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1964_MN0 (XI1964_An dd8_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1917_MN1 (XI1917_Bn qu2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1917_MN5 (XI1917_n2 XI1917_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1917_MN4 (b30_7 XI1917_An XI1917_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1917_MN2 (XI1917_n1 dd7_b3_5 b30_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1917_MN3 (VSS qu2_b3_1 XI1917_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1917_MN0 (XI1917_An dd7_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1918_MN1 (XI1918_Bn qu2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1918_MN5 (XI1918_n2 XI1918_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1918_MN4 (b30_8 XI1918_An XI1918_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1918_MN2 (XI1918_n1 dd8_b3_5 b30_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1918_MN3 (VSS qu2_b3_1 XI1918_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1918_MN0 (XI1918_An dd8_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I207_MN1 (XI1896_I207_Bn I1896_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I207_MN5 (XI1896_I207_n2 XI1896_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I207_MN4 (p29_4 XI1896_I207_An XI1896_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I207_MN2 (XI1896_I207_n1 I1896_pn4 p29_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I207_MN3 (VSS I1896_G3_0n XI1896_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I207_MN0 (XI1896_I207_An I1896_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1870_MN1 (XI1870_Bn qu3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1870_MN5 (XI1870_n2 XI1870_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1870_MN4 (b29_6 XI1870_An XI1870_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1870_MN2 (XI1870_n1 dd6_b3_5 b29_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1870_MN3 (VSS qu3_b3_1 XI1870_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1870_MN0 (XI1870_An dd6_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1871_MN1 (XI1871_Bn qu3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1871_MN5 (XI1871_n2 XI1871_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1871_MN4 (b29_7 XI1871_An XI1871_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1871_MN2 (XI1871_n1 dd7_b3_5 b29_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1871_MN3 (VSS qu3_b3_1 XI1871_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1871_MN0 (XI1871_An dd7_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1872_MN1 (XI1872_Bn qu3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1872_MN5 (XI1872_n2 XI1872_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1872_MN4 (b29_8 XI1872_An XI1872_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1872_MN2 (XI1872_n1 dd8_b3_5 b29_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1872_MN3 (VSS qu3_b3_1 XI1872_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1872_MN0 (XI1872_An dd8_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I212_MN1 (XI1850_I212_Bn I1850_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I212_MN5 (XI1850_I212_n2 XI1850_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I212_MN4 (p28_9 XI1850_I212_An XI1850_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I212_MN2 (XI1850_I212_n1 I1850_pn9 p28_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I212_MN3 (VSS I1850_G8_0n XI1850_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I212_MN0 (XI1850_I212_An I1850_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I216_MN1 (XI1850_I216_Bn I1850_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I216_MN5 (XI1850_I216_n2 XI1850_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I216_MN4 (p28_13 XI1850_I216_An XI1850_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I216_MN2 (XI1850_I216_n1 I1850_pn13 p28_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I216_MN3 (VSS I1850_G12_0n XI1850_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I216_MN0 (XI1850_I216_An I1850_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI675_MN1 (XI675_Bn qu29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI675_MN5 (XI675_n2 XI675_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI675_MN4 (b3_7 XI675_An XI675_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI675_MN2 (XI675_n1 dd7_b3_0 b3_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI675_MN3 (VSS qu29_b3_1 XI675_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI675_MN0 (XI675_An dd7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I207_MN1 (XI654_I207_Bn I654_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I207_MN5 (XI654_I207_n2 XI654_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I207_MN4 (p2_4 XI654_I207_An XI654_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I207_MN2 (XI654_I207_n1 I654_pn4 p2_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I207_MN3 (VSS I654_G3_0n XI654_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I207_MN0 (XI654_I207_An I654_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI674_MN1 (XI674_Bn qu29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI674_MN5 (XI674_n2 XI674_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI674_MN4 (b3_6 XI674_An XI674_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI674_MN2 (XI674_n1 dd6_b3_0 b3_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI674_MN3 (VSS qu29_b3_1 XI674_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI674_MN0 (XI674_An dd6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I206_MN1 (XI654_I206_Bn I654_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI654_I206_MN5 (XI654_I206_n2 XI654_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI654_I206_MN4 (p2_3 XI654_I206_An XI654_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I206_MN2 (XI654_I206_n1 I654_pn3 p2_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI654_I206_MN3 (VSS I654_G2_0n XI654_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI654_I206_MN0 (XI654_I206_An I654_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI627_MN1 (XI627_Bn qu30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI627_MN5 (XI627_n2 XI627_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI627_MN4 (b2_5 XI627_An XI627_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI627_MN2 (XI627_n1 dd5_b3_0 b2_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI627_MN3 (VSS qu30_b3_0 XI627_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI627_MN0 (XI627_An dd5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI629_MN1 (XI629_Bn qu30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI629_MN5 (XI629_n2 XI629_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI629_MN4 (b2_7 XI629_An XI629_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI629_MN2 (XI629_n1 dd7_b3_0 b2_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI629_MN3 (VSS qu30_b3_1 XI629_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI629_MN0 (XI629_An dd7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI628_MN1 (XI628_Bn qu30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI628_MN5 (XI628_n2 XI628_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI628_MN4 (b2_6 XI628_An XI628_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI628_MN2 (XI628_n1 dd6_b3_0 b2_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI628_MN3 (VSS qu30_b3_1 XI628_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI628_MN0 (XI628_An dd6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I206_MN1 (XI608_I206_Bn I608_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI608_I206_MN5 (XI608_I206_n2 XI608_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI608_I206_MN4 (p1_3 XI608_I206_An XI608_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I206_MN2 (XI608_I206_n1 I608_pn3 p1_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI608_I206_MN3 (VSS I608_G2_0n XI608_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI608_I206_MN0 (XI608_I206_An I608_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI581_MN1 (XI581_Bn qu31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI581_MN5 (XI581_n2 XI581_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI581_MN4 (b1_5 XI581_An XI581_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI581_MN2 (XI581_n1 dd5_b3_0 b1_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI581_MN3 (VSS qu31_b3_0 XI581_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI581_MN0 (XI581_An dd5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI583_MN1 (XI583_Bn qu31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI583_MN5 (XI583_n2 XI583_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI583_MN4 (b1_7 XI583_An XI583_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI583_MN2 (XI583_n1 dd7_b3_0 b1_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI583_MN3 (VSS qu31_b3_1 XI583_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI583_MN0 (XI583_An dd7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI582_MN1 (XI582_Bn qu31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI582_MN5 (XI582_n2 XI582_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI582_MN4 (b1_6 XI582_An XI582_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI582_MN2 (XI582_n1 dd6_b3_0 b1_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI582_MN3 (VSS qu31_b3_1 XI582_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI582_MN0 (XI582_An dd6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I206_MN1 (XI562_I206_Bn I562_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI562_I206_MN5 (XI562_I206_n2 XI562_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI562_I206_MN4 (p0_3 XI562_I206_An XI562_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I206_MN2 (XI562_I206_n1 I562_pn3 p0_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI562_I206_MN3 (VSS I562_G2_0n XI562_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI562_I206_MN0 (XI562_I206_An I562_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI539_MN1 (XI539_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI539_MN5 (XI539_n2 XI539_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI539_MN4 (b0_9 XI539_An XI539_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI539_MN2 (XI539_n1 dd9_b3_0 b0_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI539_MN3 (VSS VDD XI539_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI539_MN0 (XI539_An dd9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I206_MN1 (XI1988_I206_Bn I1988_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I206_MN5 (XI1988_I206_n2 XI1988_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I206_MN4 (p31_3 XI1988_I206_An XI1988_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I206_MN2 (XI1988_I206_n1 I1988_pn3 p31_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I206_MN3 (VSS I1988_G2_0n XI1988_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I206_MN0 (XI1988_I206_An I1988_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I207_MN1 (XI1988_I207_Bn I1988_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1988_I207_MN5 (XI1988_I207_n2 XI1988_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1988_I207_MN4 (p31_4 XI1988_I207_An XI1988_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I207_MN2 (XI1988_I207_n1 I1988_pn4 p31_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1988_I207_MN3 (VSS I1988_G3_0n XI1988_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1988_I207_MN0 (XI1988_I207_An I1988_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1962_MN1 (XI1962_Bn qu1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1962_MN5 (XI1962_n2 XI1962_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1962_MN4 (b31_6 XI1962_An XI1962_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1962_MN2 (XI1962_n1 dd6_b3_5 b31_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1962_MN3 (VSS qu1_b3_1 XI1962_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1962_MN0 (XI1962_An dd6_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I206_MN1 (XI1942_I206_Bn I1942_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I206_MN5 (XI1942_I206_n2 XI1942_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I206_MN4 (p30_3 XI1942_I206_An XI1942_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I206_MN2 (XI1942_I206_n1 I1942_pn3 p30_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I206_MN3 (VSS I1942_G2_0n XI1942_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I206_MN0 (XI1942_I206_An I1942_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I207_MN1 (XI1942_I207_Bn I1942_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1942_I207_MN5 (XI1942_I207_n2 XI1942_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1942_I207_MN4 (p30_4 XI1942_I207_An XI1942_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I207_MN2 (XI1942_I207_n1 I1942_pn4 p30_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1942_I207_MN3 (VSS I1942_G3_0n XI1942_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1942_I207_MN0 (XI1942_I207_An I1942_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1916_MN1 (XI1916_Bn qu2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1916_MN5 (XI1916_n2 XI1916_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1916_MN4 (b30_6 XI1916_An XI1916_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1916_MN2 (XI1916_n1 dd6_b3_5 b30_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1916_MN3 (VSS qu2_b3_1 XI1916_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1916_MN0 (XI1916_An dd6_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I206_MN1 (XI1896_I206_Bn I1896_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1896_I206_MN5 (XI1896_I206_n2 XI1896_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1896_I206_MN4 (p29_3 XI1896_I206_An XI1896_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I206_MN2 (XI1896_I206_n1 I1896_pn3 p29_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1896_I206_MN3 (VSS I1896_G2_0n XI1896_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1896_I206_MN0 (XI1896_I206_An I1896_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I206_MN1 (XI1850_I206_Bn I1850_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I206_MN5 (XI1850_I206_n2 XI1850_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I206_MN4 (p28_3 XI1850_I206_An XI1850_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I206_MN2 (XI1850_I206_n1 I1850_pn3 p28_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I206_MN3 (VSS I1850_G2_0n XI1850_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I206_MN0 (XI1850_I206_An I1850_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I207_MN1 (XI1850_I207_Bn I1850_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I207_MN5 (XI1850_I207_n2 XI1850_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I207_MN4 (p28_4 XI1850_I207_An XI1850_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I207_MN2 (XI1850_I207_n1 I1850_pn4 p28_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I207_MN3 (VSS I1850_G3_0n XI1850_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I207_MN0 (XI1850_I207_An I1850_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I214_MN1 (XI1850_I214_Bn I1850_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I214_MN5 (XI1850_I214_n2 XI1850_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I214_MN4 (p28_11 XI1850_I214_An XI1850_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I214_MN2 (XI1850_I214_n1 I1850_pn11 p28_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I214_MN3 (VSS I1850_G10_0n XI1850_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I214_MN0 (XI1850_I214_An I1850_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I218_MN1 (XI1850_I218_Bn I1850_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1850_I218_MN5 (XI1850_I218_n2 XI1850_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1850_I218_MN4 (p28_15 XI1850_I218_An XI1850_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I218_MN2 (XI1850_I218_n1 I1850_pn15 p28_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1850_I218_MN3 (VSS I1850_G14_0n XI1850_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1850_I218_MN0 (XI1850_I218_An I1850_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I218_MN1 (XI700_I218_Bn I700_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I218_MN5 (XI700_I218_n2 XI700_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I218_MN4 (p3_15 XI700_I218_An XI700_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I218_MN2 (XI700_I218_n1 I700_pn15 p3_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I218_MN3 (VSS I700_G14_0n XI700_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I218_MN0 (XI700_I218_An I700_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I213_MN1 (XI700_I213_Bn I700_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I213_MN5 (XI700_I213_n2 XI700_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I213_MN4 (p3_10 XI700_I213_An XI700_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I213_MN2 (XI700_I213_n1 I700_pn10 p3_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I213_MN3 (VSS I700_G9_0n XI700_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I213_MN0 (XI700_I213_An I700_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI673_MN1 (XI673_Bn qu29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI673_MN5 (XI673_n2 XI673_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI673_MN4 (b3_5 XI673_An XI673_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI673_MN2 (XI673_n1 dd5_b3_0 b3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI673_MN3 (VSS qu29_b3_0 XI673_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI673_MN0 (XI673_An dd5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI672_MN1 (XI672_Bn qu29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI672_MN5 (XI672_n2 XI672_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI672_MN4 (b3_4 XI672_An XI672_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI672_MN2 (XI672_n1 dd4_b3_0 b3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI672_MN3 (VSS qu29_b3_0 XI672_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI672_MN0 (XI672_An dd4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI624_MN1 (XI624_Bn qu30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI624_MN5 (XI624_n2 XI624_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI624_MN4 (b2_2 XI624_An XI624_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI624_MN2 (XI624_n1 dd2_b3_0 b2_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI624_MN3 (VSS qu30_b3_0 XI624_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI624_MN0 (XI624_An dd2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI626_MN1 (XI626_Bn qu30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI626_MN5 (XI626_n2 XI626_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI626_MN4 (b2_4 XI626_An XI626_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI626_MN2 (XI626_n1 dd4_b3_0 b2_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI626_MN3 (VSS qu30_b3_0 XI626_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI626_MN0 (XI626_An dd4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI578_MN1 (XI578_Bn qu31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI578_MN5 (XI578_n2 XI578_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI578_MN4 (b1_2 XI578_An XI578_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI578_MN2 (XI578_n1 dd2_b3_0 b1_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI578_MN3 (VSS qu31_b3_0 XI578_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI578_MN0 (XI578_An dd2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI580_MN1 (XI580_Bn qu31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI580_MN5 (XI580_n2 XI580_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI580_MN4 (b1_4 XI580_An XI580_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI580_MN2 (XI580_n1 dd4_b3_0 b1_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI580_MN3 (VSS qu31_b3_0 XI580_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI580_MN0 (XI580_An dd4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI536_MN1 (XI536_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI536_MN5 (XI536_n2 XI536_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI536_MN4 (b0_6 XI536_An XI536_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI536_MN2 (XI536_n1 dd6_b3_0 b0_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI536_MN3 (VSS VDD XI536_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI536_MN0 (XI536_An dd6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI538_MN1 (XI538_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI538_MN5 (XI538_n2 XI538_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI538_MN4 (b0_8 XI538_An XI538_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI538_MN2 (XI538_n1 dd8_b3_0 b0_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI538_MN3 (VSS VDD XI538_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI538_MN0 (XI538_An dd8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1961_MN1 (XI1961_Bn qu1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1961_MN5 (XI1961_n2 XI1961_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1961_MN4 (b31_5 XI1961_An XI1961_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1961_MN2 (XI1961_n1 dd5_b3_5 b31_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1961_MN3 (VSS qu1_b3_0 XI1961_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1961_MN0 (XI1961_An dd5_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1915_MN1 (XI1915_Bn qu2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1915_MN5 (XI1915_n2 XI1915_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1915_MN4 (b30_5 XI1915_An XI1915_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1915_MN2 (XI1915_n1 dd5_b3_5 b30_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1915_MN3 (VSS qu2_b3_0 XI1915_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1915_MN0 (XI1915_An dd5_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1867_MN1 (XI1867_Bn qu3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1867_MN5 (XI1867_n2 XI1867_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1867_MN4 (b29_3 XI1867_An XI1867_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1867_MN2 (XI1867_n1 dd3_b3_5 b29_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1867_MN3 (VSS qu3_b3_0 XI1867_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1867_MN0 (XI1867_An dd3_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1868_MN1 (XI1868_Bn qu3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1868_MN5 (XI1868_n2 XI1868_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1868_MN4 (b29_4 XI1868_An XI1868_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1868_MN2 (XI1868_n1 dd4_b3_5 b29_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1868_MN3 (VSS qu3_b3_0 XI1868_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1868_MN0 (XI1868_An dd4_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1869_MN1 (XI1869_Bn qu3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1869_MN5 (XI1869_n2 XI1869_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1869_MN4 (b29_5 XI1869_An XI1869_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1869_MN2 (XI1869_n1 dd5_b3_5 b29_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1869_MN3 (VSS qu3_b3_0 XI1869_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1869_MN0 (XI1869_An dd5_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I207_MN1 (XI700_I207_Bn I700_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I207_MN5 (XI700_I207_n2 XI700_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I207_MN4 (p3_4 XI700_I207_An XI700_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I207_MN2 (XI700_I207_n1 I700_pn4 p3_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I207_MN3 (VSS I700_G3_0n XI700_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I207_MN0 (XI700_I207_An I700_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI671_MN1 (XI671_Bn qu29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI671_MN5 (XI671_n2 XI671_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI671_MN4 (b3_3 XI671_An XI671_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI671_MN2 (XI671_n1 dd3_b3_0 b3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI671_MN3 (VSS qu29_b3_0 XI671_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI671_MN0 (XI671_An dd3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI670_MN1 (XI670_Bn qu29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI670_MN5 (XI670_n2 XI670_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI670_MN4 (b3_2 XI670_An XI670_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI670_MN2 (XI670_n1 dd2_b3_0 b3_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI670_MN3 (VSS qu29_b3_0 XI670_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI670_MN0 (XI670_An dd2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI625_MN1 (XI625_Bn qu30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI625_MN5 (XI625_n2 XI625_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI625_MN4 (b2_3 XI625_An XI625_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI625_MN2 (XI625_n1 dd3_b3_0 b2_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI625_MN3 (VSS qu30_b3_0 XI625_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI625_MN0 (XI625_An dd3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI623_MN1 (XI623_Bn qu30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI623_MN5 (XI623_n2 XI623_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI623_MN4 (b2_1 XI623_An XI623_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI623_MN2 (XI623_n1 dd1_b3_0 b2_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI623_MN3 (VSS qu30_b3_0 XI623_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI623_MN0 (XI623_An dd1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI669_MN1 (XI669_Bn qu29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI669_MN5 (XI669_n2 XI669_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI669_MN4 (b3_1 XI669_An XI669_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI669_MN2 (XI669_n1 dd1_b3_0 b3_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI669_MN3 (VSS qu29_b3_0 XI669_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI669_MN0 (XI669_An dd1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI622_MN1 (XI622_Bn qu30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI622_MN5 (XI622_n2 XI622_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI622_MN4 (b2_0 XI622_An XI622_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI622_MN2 (XI622_n1 B_0_b3_0 b2_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI622_MN3 (VSS qu30_b3_0 XI622_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI622_MN0 (XI622_An B_0_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI668_MN1 (XI668_Bn qu29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI668_MN5 (XI668_n2 XI668_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI668_MN4 (b3_0 XI668_An XI668_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI668_MN2 (XI668_n1 B_0_b3_0 b3_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI668_MN3 (VSS qu29_b3_0 XI668_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI668_MN0 (XI668_An B_0_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI577_MN1 (XI577_Bn qu31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI577_MN5 (XI577_n2 XI577_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI577_MN4 (b1_1 XI577_An XI577_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI577_MN2 (XI577_n1 dd1_b3_0 b1_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI577_MN3 (VSS qu31_b3_0 XI577_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI577_MN0 (XI577_An dd1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI576_MN1 (XI576_Bn qu31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI576_MN5 (XI576_n2 XI576_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI576_MN4 (b1_0 XI576_An XI576_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI576_MN2 (XI576_n1 B_0_b3_0 b1_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI576_MN3 (VSS qu31_b3_0 XI576_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI576_MN0 (XI576_An B_0_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI579_MN1 (XI579_Bn qu31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI579_MN5 (XI579_n2 XI579_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI579_MN4 (b1_3 XI579_An XI579_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI579_MN2 (XI579_n1 dd3_b3_0 b1_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI579_MN3 (VSS qu31_b3_0 XI579_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI579_MN0 (XI579_An dd3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI532_MN1 (XI532_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI532_MN5 (XI532_n2 XI532_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI532_MN4 (b0_2 XI532_An XI532_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI532_MN2 (XI532_n1 dd2_b3_0 b0_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI532_MN3 (VSS VDD XI532_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI532_MN0 (XI532_An dd2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI534_MN1 (XI534_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI534_MN5 (XI534_n2 XI534_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI534_MN4 (b0_4 XI534_An XI534_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI534_MN2 (XI534_n1 dd4_b3_0 b0_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI534_MN3 (VSS VDD XI534_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI534_MN0 (XI534_An dd4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI533_MN1 (XI533_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI533_MN5 (XI533_n2 XI533_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI533_MN4 (b0_3 XI533_An XI533_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI533_MN2 (XI533_n1 dd3_b3_0 b0_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI533_MN3 (VSS VDD XI533_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI533_MN0 (XI533_An dd3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI537_MN1 (XI537_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI537_MN5 (XI537_n2 XI537_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI537_MN4 (b0_7 XI537_An XI537_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI537_MN2 (XI537_n1 dd7_b3_0 b0_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI537_MN3 (VSS VDD XI537_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI537_MN0 (XI537_An dd7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1957_MN1 (XI1957_Bn qu1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1957_MN5 (XI1957_n2 XI1957_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1957_MN4 (b31_1 XI1957_An XI1957_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1957_MN2 (XI1957_n1 dd1_b3_5 b31_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1957_MN3 (VSS qu1_b3_0 XI1957_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1957_MN0 (XI1957_An dd1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1958_MN1 (XI1958_Bn qu1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1958_MN5 (XI1958_n2 XI1958_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1958_MN4 (b31_2 XI1958_An XI1958_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1958_MN2 (XI1958_n1 dd2_b3_5 b31_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1958_MN3 (VSS qu1_b3_0 XI1958_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1958_MN0 (XI1958_An dd2_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1959_MN1 (XI1959_Bn qu1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1959_MN5 (XI1959_n2 XI1959_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1959_MN4 (b31_3 XI1959_An XI1959_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1959_MN2 (XI1959_n1 dd3_b3_5 b31_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1959_MN3 (VSS qu1_b3_0 XI1959_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1959_MN0 (XI1959_An dd3_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1960_MN1 (XI1960_Bn qu1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1960_MN5 (XI1960_n2 XI1960_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1960_MN4 (b31_4 XI1960_An XI1960_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1960_MN2 (XI1960_n1 dd4_b3_5 b31_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1960_MN3 (VSS qu1_b3_0 XI1960_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1960_MN0 (XI1960_An dd4_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1910_MN1 (XI1910_Bn qu2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1910_MN5 (XI1910_n2 XI1910_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1910_MN4 (b30_0 XI1910_An XI1910_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1910_MN2 (XI1910_n1 B_0_b3_5 b30_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1910_MN3 (VSS qu2_b3_0 XI1910_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1910_MN0 (XI1910_An B_0_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1911_MN1 (XI1911_Bn qu2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1911_MN5 (XI1911_n2 XI1911_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1911_MN4 (b30_1 XI1911_An XI1911_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1911_MN2 (XI1911_n1 dd1_b3_5 b30_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1911_MN3 (VSS qu2_b3_0 XI1911_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1911_MN0 (XI1911_An dd1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1912_MN1 (XI1912_Bn qu2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1912_MN5 (XI1912_n2 XI1912_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1912_MN4 (b30_2 XI1912_An XI1912_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1912_MN2 (XI1912_n1 dd2_b3_5 b30_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1912_MN3 (VSS qu2_b3_0 XI1912_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1912_MN0 (XI1912_An dd2_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1914_MN1 (XI1914_Bn qu2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1914_MN5 (XI1914_n2 XI1914_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1914_MN4 (b30_4 XI1914_An XI1914_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1914_MN2 (XI1914_n1 dd4_b3_5 b30_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1914_MN3 (VSS qu2_b3_0 XI1914_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1914_MN0 (XI1914_An dd4_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1913_MN1 (XI1913_Bn qu2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1913_MN5 (XI1913_n2 XI1913_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1913_MN4 (b30_3 XI1913_An XI1913_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1913_MN2 (XI1913_n1 dd3_b3_5 b30_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1913_MN3 (VSS qu2_b3_0 XI1913_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1913_MN0 (XI1913_An dd3_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1819_MN1 (XI1819_Bn qu4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1819_MN5 (XI1819_n2 XI1819_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1819_MN4 (b28_1 XI1819_An XI1819_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1819_MN2 (XI1819_n1 dd1_b3_5 b28_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1819_MN3 (VSS qu4_b3_0 XI1819_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1819_MN0 (XI1819_An dd1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1865_MN1 (XI1865_Bn qu3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1865_MN5 (XI1865_n2 XI1865_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1865_MN4 (b29_1 XI1865_An XI1865_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1865_MN2 (XI1865_n1 dd1_b3_5 b29_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1865_MN3 (VSS qu3_b3_0 XI1865_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1865_MN0 (XI1865_An dd1_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1820_MN1 (XI1820_Bn qu4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1820_MN5 (XI1820_n2 XI1820_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1820_MN4 (b28_2 XI1820_An XI1820_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1820_MN2 (XI1820_n1 dd2_b3_5 b28_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1820_MN3 (VSS qu4_b3_0 XI1820_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1820_MN0 (XI1820_An dd2_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1866_MN1 (XI1866_Bn qu3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1866_MN5 (XI1866_n2 XI1866_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1866_MN4 (b29_2 XI1866_An XI1866_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1866_MN2 (XI1866_n1 dd2_b3_5 b29_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1866_MN3 (VSS qu3_b3_0 XI1866_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1866_MN0 (XI1866_An dd2_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1821_MN1 (XI1821_Bn qu4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1821_MN5 (XI1821_n2 XI1821_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1821_MN4 (b28_3 XI1821_An XI1821_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1821_MN2 (XI1821_n1 dd3_b3_5 b28_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1821_MN3 (VSS qu4_b3_0 XI1821_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1821_MN0 (XI1821_An dd3_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1822_MN1 (XI1822_Bn qu4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1822_MN5 (XI1822_n2 XI1822_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1822_MN4 (b28_4 XI1822_An XI1822_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1822_MN2 (XI1822_n1 dd4_b3_5 b28_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1822_MN3 (VSS qu4_b3_0 XI1822_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1822_MN0 (XI1822_An dd4_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I214_MN1 (XI700_I214_Bn I700_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I214_MN5 (XI700_I214_n2 XI700_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I214_MN4 (p3_11 XI700_I214_An XI700_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I214_MN2 (XI700_I214_n1 I700_pn11 p3_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I214_MN3 (VSS I700_G10_0n XI700_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I214_MN0 (XI700_I214_An I700_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I212_MN1 (XI700_I212_Bn I700_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I212_MN5 (XI700_I212_n2 XI700_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I212_MN4 (p3_9 XI700_I212_An XI700_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I212_MN2 (XI700_I212_n1 I700_pn9 p3_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I212_MN3 (VSS I700_G8_0n XI700_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I212_MN0 (XI700_I212_An I700_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I206_MN1 (XI700_I206_Bn I700_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I206_MN5 (XI700_I206_n2 XI700_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I206_MN4 (p3_3 XI700_I206_An XI700_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I206_MN2 (XI700_I206_n1 I700_pn3 p3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I206_MN3 (VSS I700_G2_0n XI700_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I206_MN0 (XI700_I206_An I700_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI717_MN1 (XI717_Bn qu28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI717_MN5 (XI717_n2 XI717_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI717_MN4 (b4_3 XI717_An XI717_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI717_MN2 (XI717_n1 dd3_b3_0 b4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI717_MN3 (VSS qu28_b3_0 XI717_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI717_MN0 (XI717_An dd3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI718_MN1 (XI718_Bn qu28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI718_MN5 (XI718_n2 XI718_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI718_MN4 (b4_4 XI718_An XI718_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI718_MN2 (XI718_n1 dd4_b3_0 b4_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI718_MN3 (VSS qu28_b3_0 XI718_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI718_MN0 (XI718_An dd4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI716_MN1 (XI716_Bn qu28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI716_MN5 (XI716_n2 XI716_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI716_MN4 (b4_2 XI716_An XI716_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI716_MN2 (XI716_n1 dd2_b3_0 b4_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI716_MN3 (VSS qu28_b3_0 XI716_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI716_MN0 (XI716_An dd2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI715_MN1 (XI715_Bn qu28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI715_MN5 (XI715_n2 XI715_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI715_MN4 (b4_1 XI715_An XI715_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI715_MN2 (XI715_n1 dd1_b3_0 b4_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI715_MN3 (VSS qu28_b3_0 XI715_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI715_MN0 (XI715_An dd1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI714_MN1 (XI714_Bn qu28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI714_MN5 (XI714_n2 XI714_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI714_MN4 (b4_0 XI714_An XI714_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI714_MN2 (XI714_n1 B_0_b3_0 b4_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI714_MN3 (VSS qu28_b3_0 XI714_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI714_MN0 (XI714_An B_0_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI763_MN1 (XI763_Bn qu27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI763_MN5 (XI763_n2 XI763_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI763_MN4 (b5_3 XI763_An XI763_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI763_MN2 (XI763_n1 dd3_b3_0 b5_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI763_MN3 (VSS qu27_b3_0 XI763_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI763_MN0 (XI763_An dd3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI530_MN1 (XI530_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI530_MN5 (XI530_n2 XI530_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI530_MN4 (b0_0 XI530_An XI530_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI530_MN2 (XI530_n1 B_0_b3_0 b0_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI530_MN3 (VSS VDD XI530_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI530_MN0 (XI530_An B_0_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI531_MN1 (XI531_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI531_MN5 (XI531_n2 XI531_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI531_MN4 (b0_1 XI531_An XI531_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI531_MN2 (XI531_n1 dd1_b3_0 b0_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI531_MN3 (VSS VDD XI531_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI531_MN0 (XI531_An dd1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI535_MN1 (XI535_Bn VDD VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI535_MN5 (XI535_n2 XI535_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI535_MN4 (b0_5 XI535_An XI535_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI535_MN2 (XI535_n1 dd5_b3_0 b0_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI535_MN3 (VSS VDD XI535_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI535_MN0 (XI535_An dd5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2067_MN1 (XI2067_Bn B_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI2067_MN5 (XI2067_n2 XI2067_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI2067_MN4 (sq XI2067_An XI2067_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2067_MN2 (XI2067_n1 A_31_b3_5 sq VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI2067_MN3 (VSS B_31_b3_5 XI2067_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI2067_MN0 (XI2067_An A_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1956_MN1 (XI1956_Bn qu1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1956_MN5 (XI1956_n2 XI1956_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1956_MN4 (b31_0 XI1956_An XI1956_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1956_MN2 (XI1956_n1 B_0_b3_5 b31_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1956_MN3 (VSS qu1_b3_0 XI1956_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1956_MN0 (XI1956_An B_0_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1864_MN1 (XI1864_Bn qu3_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1864_MN5 (XI1864_n2 XI1864_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1864_MN4 (b29_0 XI1864_An XI1864_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1864_MN2 (XI1864_n1 B_0_b3_5 b29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1864_MN3 (VSS qu3_b3_0 XI1864_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1864_MN0 (XI1864_An B_0_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1823_MN1 (XI1823_Bn qu4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1823_MN5 (XI1823_n2 XI1823_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1823_MN4 (b28_5 XI1823_An XI1823_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1823_MN2 (XI1823_n1 dd5_b3_5 b28_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1823_MN3 (VSS qu4_b3_0 XI1823_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1823_MN0 (XI1823_An dd5_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1829_MN1 (XI1829_Bn qu4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1829_MN5 (XI1829_n2 XI1829_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1829_MN4 (b28_11 XI1829_An XI1829_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1829_MN2 (XI1829_n1 dd11_b3_5 b28_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1829_MN3 (VSS qu4_b3_1 XI1829_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1829_MN0 (XI1829_An dd11_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1828_MN1 (XI1828_Bn qu4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1828_MN5 (XI1828_n2 XI1828_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1828_MN4 (b28_10 XI1828_An XI1828_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1828_MN2 (XI1828_n1 dd10_b3_5 b28_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1828_MN3 (VSS qu4_b3_1 XI1828_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1828_MN0 (XI1828_An dd10_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I216_MN1 (XI700_I216_Bn I700_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI700_I216_MN5 (XI700_I216_n2 XI700_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI700_I216_MN4 (p3_13 XI700_I216_An XI700_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I216_MN2 (XI700_I216_n1 I700_pn13 p3_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI700_I216_MN3 (VSS I700_G12_0n XI700_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI700_I216_MN0 (XI700_I216_An I700_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI730_MN1 (XI730_Bn qu28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI730_MN5 (XI730_n2 XI730_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI730_MN4 (b4_16 XI730_An XI730_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI730_MN2 (XI730_n1 dd16_b3_0 b4_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI730_MN3 (VSS qu28_b3_2 XI730_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI730_MN0 (XI730_An dd16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI731_MN1 (XI731_Bn qu28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI731_MN5 (XI731_n2 XI731_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI731_MN4 (b4_17 XI731_An XI731_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI731_MN2 (XI731_n1 dd17_b3_0 b4_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI731_MN3 (VSS qu28_b3_2 XI731_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI731_MN0 (XI731_An dd17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI729_MN1 (XI729_Bn qu28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI729_MN5 (XI729_n2 XI729_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI729_MN4 (b4_15 XI729_An XI729_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI729_MN2 (XI729_n1 dd15_b3_0 b4_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI729_MN3 (VSS qu28_b3_2 XI729_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI729_MN0 (XI729_An dd15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI725_MN1 (XI725_Bn qu28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI725_MN5 (XI725_n2 XI725_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI725_MN4 (b4_11 XI725_An XI725_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI725_MN2 (XI725_n1 dd11_b3_0 b4_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI725_MN3 (VSS qu28_b3_1 XI725_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI725_MN0 (XI725_An dd11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI721_MN1 (XI721_Bn qu28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI721_MN5 (XI721_n2 XI721_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI721_MN4 (b4_7 XI721_An XI721_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI721_MN2 (XI721_n1 dd7_b3_0 b4_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI721_MN3 (VSS qu28_b3_1 XI721_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI721_MN0 (XI721_An dd7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI724_MN1 (XI724_Bn qu28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI724_MN5 (XI724_n2 XI724_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI724_MN4 (b4_10 XI724_An XI724_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI724_MN2 (XI724_n1 dd10_b3_0 b4_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI724_MN3 (VSS qu28_b3_1 XI724_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI724_MN0 (XI724_An dd10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI720_MN1 (XI720_Bn qu28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI720_MN5 (XI720_n2 XI720_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI720_MN4 (b4_6 XI720_An XI720_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI720_MN2 (XI720_n1 dd6_b3_0 b4_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI720_MN3 (VSS qu28_b3_1 XI720_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI720_MN0 (XI720_An dd6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI719_MN1 (XI719_Bn qu28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI719_MN5 (XI719_n2 XI719_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI719_MN4 (b4_5 XI719_An XI719_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI719_MN2 (XI719_n1 dd5_b3_0 b4_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI719_MN3 (VSS qu28_b3_0 XI719_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI719_MN0 (XI719_An dd5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI775_MN1 (XI775_Bn qu27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI775_MN5 (XI775_n2 XI775_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI775_MN4 (b5_15 XI775_An XI775_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI775_MN2 (XI775_n1 dd15_b3_0 b5_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI775_MN3 (VSS qu27_b3_2 XI775_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI775_MN0 (XI775_An dd15_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI777_MN1 (XI777_Bn qu27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI777_MN5 (XI777_n2 XI777_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI777_MN4 (b5_17 XI777_An XI777_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI777_MN2 (XI777_n1 dd17_b3_0 b5_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI777_MN3 (VSS qu27_b3_2 XI777_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI777_MN0 (XI777_An dd17_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI770_MN1 (XI770_Bn qu27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI770_MN5 (XI770_n2 XI770_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI770_MN4 (b5_10 XI770_An XI770_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI770_MN2 (XI770_n1 dd10_b3_0 b5_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI770_MN3 (VSS qu27_b3_1 XI770_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI770_MN0 (XI770_An dd10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI767_MN1 (XI767_Bn qu27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI767_MN5 (XI767_n2 XI767_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI767_MN4 (b5_7 XI767_An XI767_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI767_MN2 (XI767_n1 dd7_b3_0 b5_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI767_MN3 (VSS qu27_b3_1 XI767_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI767_MN0 (XI767_An dd7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI765_MN1 (XI765_Bn qu27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI765_MN5 (XI765_n2 XI765_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI765_MN4 (b5_5 XI765_An XI765_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI765_MN2 (XI765_n1 dd5_b3_0 b5_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI765_MN3 (VSS qu27_b3_0 XI765_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI765_MN0 (XI765_An dd5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI764_MN1 (XI764_Bn qu27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI764_MN5 (XI764_n2 XI764_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI764_MN4 (b5_4 XI764_An XI764_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI764_MN2 (XI764_n1 dd4_b3_0 b5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI764_MN3 (VSS qu27_b3_0 XI764_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI764_MN0 (XI764_An dd4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI762_MN1 (XI762_Bn qu27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI762_MN5 (XI762_n2 XI762_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI762_MN4 (b5_2 XI762_An XI762_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI762_MN2 (XI762_n1 dd2_b3_0 b5_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI762_MN3 (VSS qu27_b3_0 XI762_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI762_MN0 (XI762_An dd2_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI761_MN1 (XI761_Bn qu27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI761_MN5 (XI761_n2 XI761_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI761_MN4 (b5_1 XI761_An XI761_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI761_MN2 (XI761_n1 dd1_b3_0 b5_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI761_MN3 (VSS qu27_b3_0 XI761_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI761_MN0 (XI761_An dd1_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI760_MN1 (XI760_Bn qu27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI760_MN5 (XI760_n2 XI760_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI760_MN4 (b5_0 XI760_An XI760_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI760_MN2 (XI760_n1 B_0_b3_1 b5_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI760_MN3 (VSS qu27_b3_0 XI760_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI760_MN0 (XI760_An B_0_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI809_MN1 (XI809_Bn qu26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI809_MN5 (XI809_n2 XI809_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI809_MN4 (b6_3 XI809_An XI809_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI809_MN2 (XI809_n1 dd3_b3_1 b6_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI809_MN3 (VSS qu26_b3_0 XI809_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI809_MN0 (XI809_An dd3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI807_MN1 (XI807_Bn qu26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI807_MN5 (XI807_n2 XI807_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI807_MN4 (b6_1 XI807_An XI807_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI807_MN2 (XI807_n1 dd1_b3_1 b6_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI807_MN3 (VSS qu26_b3_0 XI807_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI807_MN0 (XI807_An dd1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI806_MN1 (XI806_Bn qu26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI806_MN5 (XI806_n2 XI806_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI806_MN4 (b6_0 XI806_An XI806_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI806_MN2 (XI806_n1 B_0_b3_1 b6_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI806_MN3 (VSS qu26_b3_0 XI806_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI806_MN0 (XI806_An B_0_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1818_MN1 (XI1818_Bn qu4_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1818_MN5 (XI1818_n2 XI1818_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1818_MN4 (b28_0 XI1818_An XI1818_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1818_MN2 (XI1818_n1 B_0_b3_4 b28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1818_MN3 (VSS qu4_b3_0 XI1818_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1818_MN0 (XI1818_An B_0_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1824_MN1 (XI1824_Bn qu4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1824_MN5 (XI1824_n2 XI1824_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1824_MN4 (b28_6 XI1824_An XI1824_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1824_MN2 (XI1824_n1 dd6_b3_5 b28_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1824_MN3 (VSS qu4_b3_1 XI1824_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1824_MN0 (XI1824_An dd6_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1827_MN1 (XI1827_Bn qu4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1827_MN5 (XI1827_n2 XI1827_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1827_MN4 (b28_9 XI1827_An XI1827_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1827_MN2 (XI1827_n1 dd9_b3_5 b28_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1827_MN3 (VSS qu4_b3_1 XI1827_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1827_MN0 (XI1827_An dd9_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1825_MN1 (XI1825_Bn qu4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1825_MN5 (XI1825_n2 XI1825_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1825_MN4 (b28_7 XI1825_An XI1825_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1825_MN2 (XI1825_n1 dd7_b3_5 b28_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1825_MN3 (VSS qu4_b3_1 XI1825_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1825_MN0 (XI1825_An dd7_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1830_MN1 (XI1830_Bn qu4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1830_MN5 (XI1830_n2 XI1830_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1830_MN4 (b28_12 XI1830_An XI1830_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1830_MN2 (XI1830_n1 dd12_b3_5 b28_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1830_MN3 (VSS qu4_b3_2 XI1830_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1830_MN0 (XI1830_An dd12_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1832_MN1 (XI1832_Bn qu4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1832_MN5 (XI1832_n2 XI1832_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1832_MN4 (b28_14 XI1832_An XI1832_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1832_MN2 (XI1832_n1 dd14_b3_5 b28_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1832_MN3 (VSS qu4_b3_2 XI1832_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1832_MN0 (XI1832_An dd14_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1833_MN1 (XI1833_Bn qu4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1833_MN5 (XI1833_n2 XI1833_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1833_MN4 (b28_15 XI1833_An XI1833_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1833_MN2 (XI1833_n1 dd15_b3_5 b28_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1833_MN3 (VSS qu4_b3_2 XI1833_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1833_MN0 (XI1833_An dd15_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1834_MN1 (XI1834_Bn qu4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1834_MN5 (XI1834_n2 XI1834_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1834_MN4 (b28_16 XI1834_An XI1834_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1834_MN2 (XI1834_n1 dd16_b3_5 b28_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1834_MN3 (VSS qu4_b3_2 XI1834_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1834_MN0 (XI1834_An dd16_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1839_MN1 (XI1839_Bn qu4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1839_MN5 (XI1839_n2 XI1839_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1839_MN4 (b28_21 XI1839_An XI1839_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1839_MN2 (XI1839_n1 dd21_b3_5 b28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1839_MN3 (VSS qu4_b3_3 XI1839_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1839_MN0 (XI1839_An dd21_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI747_MN1 (XI747_Bn qu28_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI747_MN5 (XI747_n2 XI747_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI747_MN4 (h4 XI747_An XI747_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI747_MN2 (XI747_n1 p3_31 h4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI747_MN3 (VSS qu28_b3_5 XI747_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI747_MN0 (XI747_An p3_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI735_MN1 (XI735_Bn qu28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI735_MN5 (XI735_n2 XI735_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI735_MN4 (b4_21 XI735_An XI735_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI735_MN2 (XI735_n1 dd21_b3_0 b4_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI735_MN3 (VSS qu28_b3_3 XI735_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI735_MN0 (XI735_An dd21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI734_MN1 (XI734_Bn qu28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI734_MN5 (XI734_n2 XI734_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI734_MN4 (b4_20 XI734_An XI734_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI734_MN2 (XI734_n1 dd20_b3_0 b4_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI734_MN3 (VSS qu28_b3_3 XI734_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI734_MN0 (XI734_An dd20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI728_MN1 (XI728_Bn qu28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI728_MN5 (XI728_n2 XI728_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI728_MN4 (b4_14 XI728_An XI728_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI728_MN2 (XI728_n1 dd14_b3_0 b4_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI728_MN3 (VSS qu28_b3_2 XI728_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI728_MN0 (XI728_An dd14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI727_MN1 (XI727_Bn qu28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI727_MN5 (XI727_n2 XI727_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI727_MN4 (b4_13 XI727_An XI727_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI727_MN2 (XI727_n1 dd13_b3_0 b4_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI727_MN3 (VSS qu28_b3_2 XI727_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI727_MN0 (XI727_An dd13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI723_MN1 (XI723_Bn qu28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI723_MN5 (XI723_n2 XI723_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI723_MN4 (b4_9 XI723_An XI723_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI723_MN2 (XI723_n1 dd9_b3_0 b4_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI723_MN3 (VSS qu28_b3_1 XI723_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI723_MN0 (XI723_An dd9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI722_MN1 (XI722_Bn qu28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI722_MN5 (XI722_n2 XI722_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI722_MN4 (b4_8 XI722_An XI722_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI722_MN2 (XI722_n1 dd8_b3_0 b4_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI722_MN3 (VSS qu28_b3_1 XI722_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI722_MN0 (XI722_An dd8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI774_MN1 (XI774_Bn qu27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI774_MN5 (XI774_n2 XI774_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI774_MN4 (b5_14 XI774_An XI774_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI774_MN2 (XI774_n1 dd14_b3_0 b5_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI774_MN3 (VSS qu27_b3_2 XI774_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI774_MN0 (XI774_An dd14_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI776_MN1 (XI776_Bn qu27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI776_MN5 (XI776_n2 XI776_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI776_MN4 (b5_16 XI776_An XI776_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI776_MN2 (XI776_n1 dd16_b3_0 b5_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI776_MN3 (VSS qu27_b3_2 XI776_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI776_MN0 (XI776_An dd16_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI773_MN1 (XI773_Bn qu27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI773_MN5 (XI773_n2 XI773_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI773_MN4 (b5_13 XI773_An XI773_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI773_MN2 (XI773_n1 dd13_b3_0 b5_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI773_MN3 (VSS qu27_b3_2 XI773_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI773_MN0 (XI773_An dd13_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI771_MN1 (XI771_Bn qu27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI771_MN5 (XI771_n2 XI771_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI771_MN4 (b5_11 XI771_An XI771_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI771_MN2 (XI771_n1 dd11_b3_0 b5_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI771_MN3 (VSS qu27_b3_1 XI771_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI771_MN0 (XI771_An dd11_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI768_MN1 (XI768_Bn qu27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI768_MN5 (XI768_n2 XI768_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI768_MN4 (b5_8 XI768_An XI768_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI768_MN2 (XI768_n1 dd8_b3_0 b5_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI768_MN3 (VSS qu27_b3_1 XI768_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI768_MN0 (XI768_An dd8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI766_MN1 (XI766_Bn qu27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI766_MN5 (XI766_n2 XI766_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI766_MN4 (b5_6 XI766_An XI766_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI766_MN2 (XI766_n1 dd6_b3_0 b5_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI766_MN3 (VSS qu27_b3_1 XI766_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI766_MN0 (XI766_An dd6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI769_MN1 (XI769_Bn qu27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI769_MN5 (XI769_n2 XI769_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI769_MN4 (b5_9 XI769_An XI769_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI769_MN2 (XI769_n1 dd9_b3_0 b5_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI769_MN3 (VSS qu27_b3_1 XI769_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI769_MN0 (XI769_An dd9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI811_MN1 (XI811_Bn qu26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI811_MN5 (XI811_n2 XI811_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI811_MN4 (b6_5 XI811_An XI811_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI811_MN2 (XI811_n1 dd5_b3_1 b6_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI811_MN3 (VSS qu26_b3_0 XI811_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI811_MN0 (XI811_An dd5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI810_MN1 (XI810_Bn qu26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI810_MN5 (XI810_n2 XI810_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI810_MN4 (b6_4 XI810_An XI810_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI810_MN2 (XI810_n1 dd4_b3_1 b6_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI810_MN3 (VSS qu26_b3_0 XI810_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI810_MN0 (XI810_An dd4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI808_MN1 (XI808_Bn qu26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI808_MN5 (XI808_n2 XI808_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI808_MN4 (b6_2 XI808_An XI808_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI808_MN2 (XI808_n1 dd2_b3_1 b6_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI808_MN3 (VSS qu26_b3_0 XI808_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI808_MN0 (XI808_An dd2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI852_MN1 (XI852_Bn qu25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI852_MN5 (XI852_n2 XI852_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI852_MN4 (b7_0 XI852_An XI852_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI852_MN2 (XI852_n1 B_0_b3_1 b7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI852_MN3 (VSS qu25_b3_0 XI852_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI852_MN0 (XI852_An B_0_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI853_MN1 (XI853_Bn qu25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI853_MN5 (XI853_n2 XI853_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI853_MN4 (b7_1 XI853_An XI853_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI853_MN2 (XI853_n1 dd1_b3_1 b7_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI853_MN3 (VSS qu25_b3_0 XI853_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI853_MN0 (XI853_An dd1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI854_MN1 (XI854_Bn qu25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI854_MN5 (XI854_n2 XI854_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI854_MN4 (b7_2 XI854_An XI854_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI854_MN2 (XI854_n1 dd2_b3_1 b7_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI854_MN3 (VSS qu25_b3_0 XI854_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI854_MN0 (XI854_An dd2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI855_MN1 (XI855_Bn qu25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI855_MN5 (XI855_n2 XI855_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI855_MN4 (b7_3 XI855_An XI855_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI855_MN2 (XI855_n1 dd3_b3_1 b7_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI855_MN3 (VSS qu25_b3_0 XI855_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI855_MN0 (XI855_An dd3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1682_MN1 (XI1682_Bn qu7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1682_MN5 (XI1682_n2 XI1682_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1682_MN4 (b25_2 XI1682_An XI1682_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1682_MN2 (XI1682_n1 dd2_b3_4 b25_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1682_MN3 (VSS qu7_b3_0 XI1682_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1682_MN0 (XI1682_An dd2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1683_MN1 (XI1683_Bn qu7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1683_MN5 (XI1683_n2 XI1683_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1683_MN4 (b25_3 XI1683_An XI1683_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1683_MN2 (XI1683_n1 dd3_b3_4 b25_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1683_MN3 (VSS qu7_b3_0 XI1683_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1683_MN0 (XI1683_An dd3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1680_MN1 (XI1680_Bn qu7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1680_MN5 (XI1680_n2 XI1680_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1680_MN4 (b25_0 XI1680_An XI1680_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1680_MN2 (XI1680_n1 B_0_b3_4 b25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1680_MN3 (VSS qu7_b3_0 XI1680_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1680_MN0 (XI1680_An B_0_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1728_MN1 (XI1728_Bn qu6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1728_MN5 (XI1728_n2 XI1728_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1728_MN4 (b26_2 XI1728_An XI1728_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1728_MN2 (XI1728_n1 dd2_b3_4 b26_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1728_MN3 (VSS qu6_b3_0 XI1728_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1728_MN0 (XI1728_An dd2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1727_MN1 (XI1727_Bn qu6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1727_MN5 (XI1727_n2 XI1727_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1727_MN4 (b26_1 XI1727_An XI1727_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1727_MN2 (XI1727_n1 dd1_b3_4 b26_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1727_MN3 (VSS qu6_b3_0 XI1727_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1727_MN0 (XI1727_An dd1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1726_MN1 (XI1726_Bn qu6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1726_MN5 (XI1726_n2 XI1726_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1726_MN4 (b26_0 XI1726_An XI1726_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1726_MN2 (XI1726_n1 B_0_b3_4 b26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1726_MN3 (VSS qu6_b3_0 XI1726_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1726_MN0 (XI1726_An B_0_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1772_MN1 (XI1772_Bn qu5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1772_MN5 (XI1772_n2 XI1772_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1772_MN4 (b27_0 XI1772_An XI1772_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1772_MN2 (XI1772_n1 B_0_b3_4 b27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1772_MN3 (VSS qu5_b3_0 XI1772_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1772_MN0 (XI1772_An B_0_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1774_MN1 (XI1774_Bn qu5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1774_MN5 (XI1774_n2 XI1774_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1774_MN4 (b27_2 XI1774_An XI1774_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1774_MN2 (XI1774_n1 dd2_b3_4 b27_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1774_MN3 (VSS qu5_b3_0 XI1774_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1774_MN0 (XI1774_An dd2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1826_MN1 (XI1826_Bn qu4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1826_MN5 (XI1826_n2 XI1826_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1826_MN4 (b28_8 XI1826_An XI1826_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1826_MN2 (XI1826_n1 dd8_b3_5 b28_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1826_MN3 (VSS qu4_b3_1 XI1826_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1826_MN0 (XI1826_An dd8_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I206_MN1 (XI1804_I206_Bn I1804_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I206_MN5 (XI1804_I206_n2 XI1804_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I206_MN4 (p27_3 XI1804_I206_An XI1804_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I206_MN2 (XI1804_I206_n1 I1804_pn3 p27_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I206_MN3 (VSS I1804_G2_0n XI1804_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I206_MN0 (XI1804_I206_An I1804_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I207_MN1 (XI1804_I207_Bn I1804_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I207_MN5 (XI1804_I207_n2 XI1804_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I207_MN4 (p27_4 XI1804_I207_An XI1804_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I207_MN2 (XI1804_I207_n1 I1804_pn4 p27_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I207_MN3 (VSS I1804_G3_0n XI1804_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I207_MN0 (XI1804_I207_An I1804_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1831_MN1 (XI1831_Bn qu4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1831_MN5 (XI1831_n2 XI1831_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1831_MN4 (b28_13 XI1831_An XI1831_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1831_MN2 (XI1831_n1 dd13_b3_5 b28_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1831_MN3 (VSS qu4_b3_2 XI1831_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1831_MN0 (XI1831_An dd13_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1835_MN1 (XI1835_Bn qu4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1835_MN5 (XI1835_n2 XI1835_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1835_MN4 (b28_17 XI1835_An XI1835_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1835_MN2 (XI1835_n1 dd17_b3_5 b28_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1835_MN3 (VSS qu4_b3_2 XI1835_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1835_MN0 (XI1835_An dd17_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1836_MN1 (XI1836_Bn qu4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1836_MN5 (XI1836_n2 XI1836_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1836_MN4 (b28_18 XI1836_An XI1836_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1836_MN2 (XI1836_n1 dd18_b3_5 b28_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1836_MN3 (VSS qu4_b3_3 XI1836_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1836_MN0 (XI1836_An dd18_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1837_MN1 (XI1837_Bn qu4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1837_MN5 (XI1837_n2 XI1837_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1837_MN4 (b28_19 XI1837_An XI1837_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1837_MN2 (XI1837_n1 dd19_b3_5 b28_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1837_MN3 (VSS qu4_b3_3 XI1837_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1837_MN0 (XI1837_An dd19_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1840_MN1 (XI1840_Bn qu4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1840_MN5 (XI1840_n2 XI1840_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1840_MN4 (b28_22 XI1840_An XI1840_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1840_MN2 (XI1840_n1 dd22_b3_5 b28_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1840_MN3 (VSS qu4_b3_3 XI1840_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1840_MN0 (XI1840_An dd22_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1841_MN1 (XI1841_Bn qu4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1841_MN5 (XI1841_n2 XI1841_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1841_MN4 (b28_23 XI1841_An XI1841_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1841_MN2 (XI1841_n1 dd23_b3_5 b28_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1841_MN3 (VSS qu4_b3_3 XI1841_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1841_MN0 (XI1841_An dd23_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1847_MN1 (XI1847_Bn qu4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1847_MN5 (XI1847_n2 XI1847_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1847_MN4 (b28_29 XI1847_An XI1847_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1847_MN2 (XI1847_n1 dd29_b3_5 b28_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1847_MN3 (VSS qu4_b3_4 XI1847_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1847_MN0 (XI1847_An dd29_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1846_MN1 (XI1846_Bn qu4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1846_MN5 (XI1846_n2 XI1846_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1846_MN4 (b28_28 XI1846_An XI1846_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1846_MN2 (XI1846_n1 dd28_b3_5 b28_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1846_MN3 (VSS qu4_b3_4 XI1846_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1846_MN0 (XI1846_An dd28_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI748_MN1 (XI748_Bn c4_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI748_MN5 (XI748_n2 XI748_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI748_MN4 (p4_32 XI748_An XI748_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI748_MN2 (XI748_n1 h4 p4_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI748_MN3 (VSS c4_o XI748_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI748_MN0 (XI748_An h4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI736_MN1 (XI736_Bn qu28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI736_MN5 (XI736_n2 XI736_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI736_MN4 (b4_22 XI736_An XI736_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI736_MN2 (XI736_n1 dd22_b3_0 b4_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI736_MN3 (VSS qu28_b3_3 XI736_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI736_MN0 (XI736_An dd22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI733_MN1 (XI733_Bn qu28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI733_MN5 (XI733_n2 XI733_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI733_MN4 (b4_19 XI733_An XI733_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI733_MN2 (XI733_n1 dd19_b3_0 b4_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI733_MN3 (VSS qu28_b3_3 XI733_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI733_MN0 (XI733_An dd19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI732_MN1 (XI732_Bn qu28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI732_MN5 (XI732_n2 XI732_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI732_MN4 (b4_18 XI732_An XI732_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI732_MN2 (XI732_n1 dd18_b3_0 b4_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI732_MN3 (VSS qu28_b3_3 XI732_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI732_MN0 (XI732_An dd18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI726_MN1 (XI726_Bn qu28_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI726_MN5 (XI726_n2 XI726_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI726_MN4 (b4_12 XI726_An XI726_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI726_MN2 (XI726_n1 dd12_b3_0 b4_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI726_MN3 (VSS qu28_b3_2 XI726_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI726_MN0 (XI726_An dd12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI779_MN1 (XI779_Bn qu27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI779_MN5 (XI779_n2 XI779_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI779_MN4 (b5_19 XI779_An XI779_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI779_MN2 (XI779_n1 dd19_b3_0 b5_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI779_MN3 (VSS qu27_b3_3 XI779_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI779_MN0 (XI779_An dd19_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I207_MN1 (XI746_I207_Bn I746_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I207_MN5 (XI746_I207_n2 XI746_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I207_MN4 (p4_4 XI746_I207_An XI746_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I207_MN2 (XI746_I207_n1 I746_pn4 p4_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I207_MN3 (VSS I746_G3_0n XI746_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I207_MN0 (XI746_I207_An I746_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI772_MN1 (XI772_Bn qu27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI772_MN5 (XI772_n2 XI772_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI772_MN4 (b5_12 XI772_An XI772_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI772_MN2 (XI772_n1 dd12_b3_0 b5_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI772_MN3 (VSS qu27_b3_2 XI772_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI772_MN0 (XI772_An dd12_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I206_MN1 (XI746_I206_Bn I746_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I206_MN5 (XI746_I206_n2 XI746_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I206_MN4 (p4_3 XI746_I206_An XI746_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I206_MN2 (XI746_I206_n1 I746_pn3 p4_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I206_MN3 (VSS I746_G2_0n XI746_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I206_MN0 (XI746_I206_An I746_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I207_MN1 (XI792_I207_Bn I792_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I207_MN5 (XI792_I207_n2 XI792_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I207_MN4 (p5_4 XI792_I207_An XI792_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I207_MN2 (XI792_I207_n1 I792_pn4 p5_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I207_MN3 (VSS I792_G3_0n XI792_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I207_MN0 (XI792_I207_An I792_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I206_MN1 (XI792_I206_Bn I792_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I206_MN5 (XI792_I206_n2 XI792_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I206_MN4 (p5_3 XI792_I206_An XI792_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I206_MN2 (XI792_I206_n1 I792_pn3 p5_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I206_MN3 (VSS I792_G2_0n XI792_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I206_MN0 (XI792_I206_An I792_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I207_MN1 (XI838_I207_Bn I838_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I207_MN5 (XI838_I207_n2 XI838_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I207_MN4 (p6_4 XI838_I207_An XI838_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I207_MN2 (XI838_I207_n1 I838_pn4 p6_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I207_MN3 (VSS I838_G3_0n XI838_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I207_MN0 (XI838_I207_An I838_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I206_MN1 (XI838_I206_Bn I838_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I206_MN5 (XI838_I206_n2 XI838_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I206_MN4 (p6_3 XI838_I206_An XI838_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I206_MN2 (XI838_I206_n1 I838_pn3 p6_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I206_MN3 (VSS I838_G2_0n XI838_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I206_MN0 (XI838_I206_An I838_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI857_MN1 (XI857_Bn qu25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI857_MN5 (XI857_n2 XI857_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI857_MN4 (b7_5 XI857_An XI857_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI857_MN2 (XI857_n1 dd5_b3_1 b7_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI857_MN3 (VSS qu25_b3_0 XI857_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI857_MN0 (XI857_An dd5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI856_MN1 (XI856_Bn qu25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI856_MN5 (XI856_n2 XI856_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI856_MN4 (b7_4 XI856_An XI856_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI856_MN2 (XI856_n1 dd4_b3_1 b7_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI856_MN3 (VSS qu25_b3_0 XI856_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI856_MN0 (XI856_An dd4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I206_MN1 (XI1712_I206_Bn I1712_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I206_MN5 (XI1712_I206_n2 XI1712_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I206_MN4 (p25_3 XI1712_I206_An XI1712_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I206_MN2 (XI1712_I206_n1 I1712_pn3 p25_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I206_MN3 (VSS I1712_G2_0n XI1712_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I206_MN0 (XI1712_I206_An I1712_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1684_MN1 (XI1684_Bn qu7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1684_MN5 (XI1684_n2 XI1684_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1684_MN4 (b25_4 XI1684_An XI1684_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1684_MN2 (XI1684_n1 dd4_b3_4 b25_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1684_MN3 (VSS qu7_b3_0 XI1684_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1684_MN0 (XI1684_An dd4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1730_MN1 (XI1730_Bn qu6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1730_MN5 (XI1730_n2 XI1730_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1730_MN4 (b26_4 XI1730_An XI1730_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1730_MN2 (XI1730_n1 dd4_b3_4 b26_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1730_MN3 (VSS qu6_b3_0 XI1730_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1730_MN0 (XI1730_An dd4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1729_MN1 (XI1729_Bn qu6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1729_MN5 (XI1729_n2 XI1729_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1729_MN4 (b26_3 XI1729_An XI1729_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1729_MN2 (XI1729_n1 dd3_b3_4 b26_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1729_MN3 (VSS qu6_b3_0 XI1729_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1729_MN0 (XI1729_An dd3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1776_MN1 (XI1776_Bn qu5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1776_MN5 (XI1776_n2 XI1776_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1776_MN4 (b27_4 XI1776_An XI1776_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1776_MN2 (XI1776_n1 dd4_b3_4 b27_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1776_MN3 (VSS qu5_b3_0 XI1776_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1776_MN0 (XI1776_An dd4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1773_MN1 (XI1773_Bn qu5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1773_MN5 (XI1773_n2 XI1773_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1773_MN4 (b27_1 XI1773_An XI1773_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1773_MN2 (XI1773_n1 dd1_b3_4 b27_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1773_MN3 (VSS qu5_b3_0 XI1773_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1773_MN0 (XI1773_An dd1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1775_MN1 (XI1775_Bn qu5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1775_MN5 (XI1775_n2 XI1775_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1775_MN4 (b27_3 XI1775_An XI1775_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1775_MN2 (XI1775_n1 dd3_b3_4 b27_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1775_MN3 (VSS qu5_b3_0 XI1775_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1775_MN0 (XI1775_An dd3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1838_MN1 (XI1838_Bn qu4_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1838_MN5 (XI1838_n2 XI1838_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1838_MN4 (b28_20 XI1838_An XI1838_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1838_MN2 (XI1838_n1 dd20_b3_5 b28_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1838_MN3 (VSS qu4_b3_3 XI1838_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1838_MN0 (XI1838_An dd20_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1843_MN1 (XI1843_Bn qu4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1843_MN5 (XI1843_n2 XI1843_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1843_MN4 (b28_25 XI1843_An XI1843_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1843_MN2 (XI1843_n1 dd25_b3_5 b28_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1843_MN3 (VSS qu4_b3_4 XI1843_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1843_MN0 (XI1843_An dd25_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1844_MN1 (XI1844_Bn qu4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1844_MN5 (XI1844_n2 XI1844_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1844_MN4 (b28_26 XI1844_An XI1844_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1844_MN2 (XI1844_n1 dd26_b3_5 b28_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1844_MN3 (VSS qu4_b3_4 XI1844_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1844_MN0 (XI1844_An dd26_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1845_MN1 (XI1845_Bn qu4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1845_MN5 (XI1845_n2 XI1845_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1845_MN4 (b28_27 XI1845_An XI1845_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1845_MN2 (XI1845_n1 dd27_b3_5 b28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1845_MN3 (VSS qu4_b3_4 XI1845_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1845_MN0 (XI1845_An dd27_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1848_MN1 (XI1848_Bn qu4_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1848_MN5 (XI1848_n2 XI1848_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1848_MN4 (b28_30 XI1848_An XI1848_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1848_MN2 (XI1848_n1 dd30_b3_5 b28_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1848_MN3 (VSS qu4_b3_5 XI1848_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1848_MN0 (XI1848_An dd30_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI737_MN1 (XI737_Bn qu28_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI737_MN5 (XI737_n2 XI737_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI737_MN4 (b4_23 XI737_An XI737_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI737_MN2 (XI737_n1 dd23_b3_0 b4_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI737_MN3 (VSS qu28_b3_3 XI737_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI737_MN0 (XI737_An dd23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI781_MN1 (XI781_Bn qu27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI781_MN5 (XI781_n2 XI781_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI781_MN4 (b5_21 XI781_An XI781_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI781_MN2 (XI781_n1 dd21_b3_0 b5_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI781_MN3 (VSS qu27_b3_3 XI781_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI781_MN0 (XI781_An dd21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI783_MN1 (XI783_Bn qu27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI783_MN5 (XI783_n2 XI783_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI783_MN4 (b5_23 XI783_An XI783_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI783_MN2 (XI783_n1 dd23_b3_0 b5_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI783_MN3 (VSS qu27_b3_3 XI783_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI783_MN0 (XI783_An dd23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI780_MN1 (XI780_Bn qu27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI780_MN5 (XI780_n2 XI780_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI780_MN4 (b5_20 XI780_An XI780_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI780_MN2 (XI780_n1 dd20_b3_0 b5_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI780_MN3 (VSS qu27_b3_3 XI780_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI780_MN0 (XI780_An dd20_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI778_MN1 (XI778_Bn qu27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI778_MN5 (XI778_n2 XI778_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI778_MN4 (b5_18 XI778_An XI778_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI778_MN2 (XI778_n1 dd18_b3_0 b5_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI778_MN3 (VSS qu27_b3_3 XI778_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI778_MN0 (XI778_An dd18_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI813_MN1 (XI813_Bn qu26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI813_MN5 (XI813_n2 XI813_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI813_MN4 (b6_7 XI813_An XI813_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI813_MN2 (XI813_n1 dd7_b3_1 b6_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI813_MN3 (VSS qu26_b3_1 XI813_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI813_MN0 (XI813_An dd7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI812_MN1 (XI812_Bn qu26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI812_MN5 (XI812_n2 XI812_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI812_MN4 (b6_6 XI812_An XI812_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI812_MN2 (XI812_n1 dd6_b3_1 b6_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI812_MN3 (VSS qu26_b3_1 XI812_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI812_MN0 (XI812_An dd6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI858_MN1 (XI858_Bn qu25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI858_MN5 (XI858_n2 XI858_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI858_MN4 (b7_6 XI858_An XI858_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI858_MN2 (XI858_n1 dd6_b3_1 b7_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI858_MN3 (VSS qu25_b3_1 XI858_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI858_MN0 (XI858_An dd6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI859_MN1 (XI859_Bn qu25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI859_MN5 (XI859_n2 XI859_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI859_MN4 (b7_7 XI859_An XI859_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI859_MN2 (XI859_n1 dd7_b3_1 b7_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI859_MN3 (VSS qu25_b3_1 XI859_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI859_MN0 (XI859_An dd7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I206_MN1 (XI884_I206_Bn I884_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I206_MN5 (XI884_I206_n2 XI884_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I206_MN4 (p7_3 XI884_I206_An XI884_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I206_MN2 (XI884_I206_n1 I884_pn3 p7_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I206_MN3 (VSS I884_G2_0n XI884_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I206_MN0 (XI884_I206_An I884_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1681_MN1 (XI1681_Bn qu7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1681_MN5 (XI1681_n2 XI1681_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1681_MN4 (b25_1 XI1681_An XI1681_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1681_MN2 (XI1681_n1 dd1_b3_4 b25_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1681_MN3 (VSS qu7_b3_0 XI1681_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1681_MN0 (XI1681_An dd1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I207_MN1 (XI1712_I207_Bn I1712_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I207_MN5 (XI1712_I207_n2 XI1712_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I207_MN4 (p25_4 XI1712_I207_An XI1712_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I207_MN2 (XI1712_I207_n1 I1712_pn4 p25_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I207_MN3 (VSS I1712_G3_0n XI1712_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I207_MN0 (XI1712_I207_An I1712_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1731_MN1 (XI1731_Bn qu6_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1731_MN5 (XI1731_n2 XI1731_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1731_MN4 (b26_5 XI1731_An XI1731_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1731_MN2 (XI1731_n1 dd5_b3_4 b26_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1731_MN3 (VSS qu6_b3_0 XI1731_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1731_MN0 (XI1731_An dd5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I206_MN1 (XI1758_I206_Bn I1758_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I206_MN5 (XI1758_I206_n2 XI1758_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I206_MN4 (p26_3 XI1758_I206_An XI1758_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I206_MN2 (XI1758_I206_n1 I1758_pn3 p26_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I206_MN3 (VSS I1758_G2_0n XI1758_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I206_MN0 (XI1758_I206_An I1758_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I207_MN1 (XI1758_I207_Bn I1758_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I207_MN5 (XI1758_I207_n2 XI1758_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I207_MN4 (p26_4 XI1758_I207_An XI1758_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I207_MN2 (XI1758_I207_n1 I1758_pn4 p26_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I207_MN3 (VSS I1758_G3_0n XI1758_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I207_MN0 (XI1758_I207_An I1758_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1777_MN1 (XI1777_Bn qu5_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1777_MN5 (XI1777_n2 XI1777_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1777_MN4 (b27_5 XI1777_An XI1777_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1777_MN2 (XI1777_n1 dd5_b3_4 b27_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1777_MN3 (VSS qu5_b3_0 XI1777_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1777_MN0 (XI1777_An dd5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I212_MN1 (XI1804_I212_Bn I1804_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I212_MN5 (XI1804_I212_n2 XI1804_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I212_MN4 (p27_9 XI1804_I212_An XI1804_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I212_MN2 (XI1804_I212_n1 I1804_pn9 p27_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I212_MN3 (VSS I1804_G8_0n XI1804_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I212_MN0 (XI1804_I212_An I1804_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1842_MN1 (XI1842_Bn qu4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1842_MN5 (XI1842_n2 XI1842_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1842_MN4 (b28_24 XI1842_An XI1842_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1842_MN2 (XI1842_n1 dd24_b3_5 b28_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1842_MN3 (VSS qu4_b3_4 XI1842_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1842_MN0 (XI1842_An dd24_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I213_MN1 (XI746_I213_Bn I746_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I213_MN5 (XI746_I213_n2 XI746_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I213_MN4 (p4_10 XI746_I213_An XI746_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I213_MN2 (XI746_I213_n1 I746_pn10 p4_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I213_MN3 (VSS I746_G9_0n XI746_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I213_MN0 (XI746_I213_An I746_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I212_MN1 (XI746_I212_Bn I746_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I212_MN5 (XI746_I212_n2 XI746_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I212_MN4 (p4_9 XI746_I212_An XI746_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I212_MN2 (XI746_I212_n1 I746_pn9 p4_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I212_MN3 (VSS I746_G8_0n XI746_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I212_MN0 (XI746_I212_An I746_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI782_MN1 (XI782_Bn qu27_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI782_MN5 (XI782_n2 XI782_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI782_MN4 (b5_22 XI782_An XI782_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI782_MN2 (XI782_n1 dd22_b3_0 b5_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI782_MN3 (VSS qu27_b3_3 XI782_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI782_MN0 (XI782_An dd22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I212_MN1 (XI792_I212_Bn I792_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I212_MN5 (XI792_I212_n2 XI792_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I212_MN4 (p5_9 XI792_I212_An XI792_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I212_MN2 (XI792_I212_n1 I792_pn9 p5_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I212_MN3 (VSS I792_G8_0n XI792_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I212_MN0 (XI792_I212_An I792_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI815_MN1 (XI815_Bn qu26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI815_MN5 (XI815_n2 XI815_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI815_MN4 (b6_9 XI815_An XI815_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI815_MN2 (XI815_n1 dd9_b3_1 b6_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI815_MN3 (VSS qu26_b3_1 XI815_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI815_MN0 (XI815_An dd9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI814_MN1 (XI814_Bn qu26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI814_MN5 (XI814_n2 XI814_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI814_MN4 (b6_8 XI814_An XI814_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI814_MN2 (XI814_n1 dd8_b3_1 b6_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI814_MN3 (VSS qu26_b3_1 XI814_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI814_MN0 (XI814_An dd8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I212_MN1 (XI838_I212_Bn I838_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I212_MN5 (XI838_I212_n2 XI838_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I212_MN4 (p6_9 XI838_I212_An XI838_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I212_MN2 (XI838_I212_n1 I838_pn9 p6_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I212_MN3 (VSS I838_G8_0n XI838_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I212_MN0 (XI838_I212_An I838_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI860_MN1 (XI860_Bn qu25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI860_MN5 (XI860_n2 XI860_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI860_MN4 (b7_8 XI860_An XI860_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI860_MN2 (XI860_n1 dd8_b3_1 b7_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI860_MN3 (VSS qu25_b3_1 XI860_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI860_MN0 (XI860_An dd8_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I207_MN1 (XI884_I207_Bn I884_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I207_MN5 (XI884_I207_n2 XI884_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I207_MN4 (p7_4 XI884_I207_An XI884_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I207_MN2 (XI884_I207_n1 I884_pn4 p7_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I207_MN3 (VSS I884_G3_0n XI884_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I207_MN0 (XI884_I207_An I884_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1686_MN1 (XI1686_Bn qu7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1686_MN5 (XI1686_n2 XI1686_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1686_MN4 (b25_6 XI1686_An XI1686_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1686_MN2 (XI1686_n1 dd6_b3_4 b25_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1686_MN3 (VSS qu7_b3_1 XI1686_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1686_MN0 (XI1686_An dd6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1685_MN1 (XI1685_Bn qu7_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1685_MN5 (XI1685_n2 XI1685_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1685_MN4 (b25_5 XI1685_An XI1685_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1685_MN2 (XI1685_n1 dd5_b3_4 b25_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1685_MN3 (VSS qu7_b3_0 XI1685_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1685_MN0 (XI1685_An dd5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1734_MN1 (XI1734_Bn qu6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1734_MN5 (XI1734_n2 XI1734_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1734_MN4 (b26_8 XI1734_An XI1734_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1734_MN2 (XI1734_n1 dd8_b3_4 b26_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1734_MN3 (VSS qu6_b3_1 XI1734_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1734_MN0 (XI1734_An dd8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1732_MN1 (XI1732_Bn qu6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1732_MN5 (XI1732_n2 XI1732_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1732_MN4 (b26_6 XI1732_An XI1732_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1732_MN2 (XI1732_n1 dd6_b3_4 b26_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1732_MN3 (VSS qu6_b3_1 XI1732_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1732_MN0 (XI1732_An dd6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1733_MN1 (XI1733_Bn qu6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1733_MN5 (XI1733_n2 XI1733_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1733_MN4 (b26_7 XI1733_An XI1733_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1733_MN2 (XI1733_n1 dd7_b3_4 b26_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1733_MN3 (VSS qu6_b3_1 XI1733_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1733_MN0 (XI1733_An dd7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I213_MN1 (XI1804_I213_Bn I1804_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I213_MN5 (XI1804_I213_n2 XI1804_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I213_MN4 (p27_10 XI1804_I213_An XI1804_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I213_MN2 (XI1804_I213_n1 I1804_pn10 p27_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I213_MN3 (VSS I1804_G9_0n XI1804_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I213_MN0 (XI1804_I213_An I1804_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I214_MN1 (XI1804_I214_Bn I1804_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I214_MN5 (XI1804_I214_n2 XI1804_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I214_MN4 (p27_11 XI1804_I214_An XI1804_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I214_MN2 (XI1804_I214_n1 I1804_pn11 p27_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I214_MN3 (VSS I1804_G10_0n XI1804_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I214_MN0 (XI1804_I214_An I1804_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1851_MN1 (XI1851_Bn qu4_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1851_MN5 (XI1851_n2 XI1851_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1851_MN4 (h28 XI1851_An XI1851_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1851_MN2 (XI1851_n1 p27_31 h28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1851_MN3 (VSS qu4_b3_5 XI1851_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1851_MN0 (XI1851_An p27_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1849_MN1 (XI1849_Bn qu4_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1849_MN5 (XI1849_n2 XI1849_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1849_MN4 (b28_31 XI1849_An XI1849_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1849_MN2 (XI1849_n1 dd31_b3_5 b28_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1849_MN3 (VSS qu4_b3_5 XI1849_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1849_MN0 (XI1849_An dd31_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I219_MN1 (XI746_I219_Bn I746_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I219_MN5 (XI746_I219_n2 XI746_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I219_MN4 (p4_16 XI746_I219_An XI746_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I219_MN2 (XI746_I219_n1 I746_pn16 p4_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I219_MN3 (VSS I746_G15_0n XI746_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I219_MN0 (XI746_I219_An I746_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I215_MN1 (XI746_I215_Bn I746_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I215_MN5 (XI746_I215_n2 XI746_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I215_MN4 (p4_12 XI746_I215_An XI746_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I215_MN2 (XI746_I215_n1 I746_pn12 p4_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I215_MN3 (VSS I746_G11_0n XI746_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I215_MN0 (XI746_I215_An I746_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I214_MN1 (XI746_I214_Bn I746_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I214_MN5 (XI746_I214_n2 XI746_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I214_MN4 (p4_11 XI746_I214_An XI746_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I214_MN2 (XI746_I214_n1 I746_pn11 p4_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I214_MN3 (VSS I746_G10_0n XI746_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I214_MN0 (XI746_I214_An I746_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I213_MN1 (XI792_I213_Bn I792_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I213_MN5 (XI792_I213_n2 XI792_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I213_MN4 (p5_10 XI792_I213_An XI792_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I213_MN2 (XI792_I213_n1 I792_pn10 p5_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I213_MN3 (VSS I792_G9_0n XI792_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I213_MN0 (XI792_I213_An I792_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI817_MN1 (XI817_Bn qu26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI817_MN5 (XI817_n2 XI817_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI817_MN4 (b6_11 XI817_An XI817_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI817_MN2 (XI817_n1 dd11_b3_1 b6_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI817_MN3 (VSS qu26_b3_1 XI817_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI817_MN0 (XI817_An dd11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI816_MN1 (XI816_Bn qu26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI816_MN5 (XI816_n2 XI816_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI816_MN4 (b6_10 XI816_An XI816_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI816_MN2 (XI816_n1 dd10_b3_1 b6_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI816_MN3 (VSS qu26_b3_1 XI816_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI816_MN0 (XI816_An dd10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I213_MN1 (XI838_I213_Bn I838_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I213_MN5 (XI838_I213_n2 XI838_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I213_MN4 (p6_10 XI838_I213_An XI838_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I213_MN2 (XI838_I213_n1 I838_pn10 p6_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I213_MN3 (VSS I838_G9_0n XI838_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I213_MN0 (XI838_I213_An I838_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI863_MN1 (XI863_Bn qu25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI863_MN5 (XI863_n2 XI863_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI863_MN4 (b7_11 XI863_An XI863_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI863_MN2 (XI863_n1 dd11_b3_1 b7_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI863_MN3 (VSS qu25_b3_1 XI863_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI863_MN0 (XI863_An dd11_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI862_MN1 (XI862_Bn qu25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI862_MN5 (XI862_n2 XI862_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI862_MN4 (b7_10 XI862_An XI862_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI862_MN2 (XI862_n1 dd10_b3_1 b7_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI862_MN3 (VSS qu25_b3_1 XI862_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI862_MN0 (XI862_An dd10_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI861_MN1 (XI861_Bn qu25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI861_MN5 (XI861_n2 XI861_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI861_MN4 (b7_9 XI861_An XI861_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI861_MN2 (XI861_n1 dd9_b3_1 b7_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI861_MN3 (VSS qu25_b3_1 XI861_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI861_MN0 (XI861_An dd9_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I212_MN1 (XI884_I212_Bn I884_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I212_MN5 (XI884_I212_n2 XI884_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I212_MN4 (p7_9 XI884_I212_An XI884_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I212_MN2 (XI884_I212_n1 I884_pn9 p7_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I212_MN3 (VSS I884_G8_0n XI884_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I212_MN0 (XI884_I212_An I884_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I213_MN1 (XI884_I213_Bn I884_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I213_MN5 (XI884_I213_n2 XI884_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I213_MN4 (p7_10 XI884_I213_An XI884_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I213_MN2 (XI884_I213_n1 I884_pn10 p7_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I213_MN3 (VSS I884_G9_0n XI884_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I213_MN0 (XI884_I213_An I884_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I212_MN1 (XI1712_I212_Bn I1712_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I212_MN5 (XI1712_I212_n2 XI1712_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I212_MN4 (p25_9 XI1712_I212_An XI1712_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I212_MN2 (XI1712_I212_n1 I1712_pn9 p25_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I212_MN3 (VSS I1712_G8_0n XI1712_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I212_MN0 (XI1712_I212_An I1712_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1688_MN1 (XI1688_Bn qu7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1688_MN5 (XI1688_n2 XI1688_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1688_MN4 (b25_8 XI1688_An XI1688_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1688_MN2 (XI1688_n1 dd8_b3_4 b25_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1688_MN3 (VSS qu7_b3_1 XI1688_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1688_MN0 (XI1688_An dd8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1687_MN1 (XI1687_Bn qu7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1687_MN5 (XI1687_n2 XI1687_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1687_MN4 (b25_7 XI1687_An XI1687_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1687_MN2 (XI1687_n1 dd7_b3_4 b25_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1687_MN3 (VSS qu7_b3_1 XI1687_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1687_MN0 (XI1687_An dd7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1735_MN1 (XI1735_Bn qu6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1735_MN5 (XI1735_n2 XI1735_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1735_MN4 (b26_9 XI1735_An XI1735_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1735_MN2 (XI1735_n1 dd9_b3_4 b26_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1735_MN3 (VSS qu6_b3_1 XI1735_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1735_MN0 (XI1735_An dd9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I212_MN1 (XI1758_I212_Bn I1758_G8_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I212_MN5 (XI1758_I212_n2 XI1758_I212_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I212_MN4 (p26_9 XI1758_I212_An XI1758_I212_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I212_MN2 (XI1758_I212_n1 I1758_pn9 p26_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I212_MN3 (VSS I1758_G8_0n XI1758_I212_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I212_MN0 (XI1758_I212_An I1758_pn9 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1779_MN1 (XI1779_Bn qu5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1779_MN5 (XI1779_n2 XI1779_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1779_MN4 (b27_7 XI1779_An XI1779_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1779_MN2 (XI1779_n1 dd7_b3_4 b27_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1779_MN3 (VSS qu5_b3_1 XI1779_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1779_MN0 (XI1779_An dd7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1778_MN1 (XI1778_Bn qu5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1778_MN5 (XI1778_n2 XI1778_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1778_MN4 (b27_6 XI1778_An XI1778_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1778_MN2 (XI1778_n1 dd6_b3_4 b27_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1778_MN3 (VSS qu5_b3_1 XI1778_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1778_MN0 (XI1778_An dd6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1780_MN1 (XI1780_Bn qu5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1780_MN5 (XI1780_n2 XI1780_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1780_MN4 (b27_8 XI1780_An XI1780_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1780_MN2 (XI1780_n1 dd8_b3_4 b27_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1780_MN3 (VSS qu5_b3_1 XI1780_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1780_MN0 (XI1780_An dd8_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I216_MN1 (XI1804_I216_Bn I1804_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I216_MN5 (XI1804_I216_n2 XI1804_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I216_MN4 (p27_13 XI1804_I216_An XI1804_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I216_MN2 (XI1804_I216_n1 I1804_pn13 p27_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I216_MN3 (VSS I1804_G12_0n XI1804_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I216_MN0 (XI1804_I216_An I1804_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I217_MN1 (XI746_I217_Bn I746_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I217_MN5 (XI746_I217_n2 XI746_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I217_MN4 (p4_14 XI746_I217_An XI746_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I217_MN2 (XI746_I217_n1 I746_pn14 p4_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I217_MN3 (VSS I746_G13_0n XI746_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I217_MN0 (XI746_I217_An I746_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I215_MN1 (XI792_I215_Bn I792_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I215_MN5 (XI792_I215_n2 XI792_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I215_MN4 (p5_12 XI792_I215_An XI792_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I215_MN2 (XI792_I215_n1 I792_pn12 p5_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I215_MN3 (VSS I792_G11_0n XI792_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I215_MN0 (XI792_I215_An I792_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I214_MN1 (XI792_I214_Bn I792_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I214_MN5 (XI792_I214_n2 XI792_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I214_MN4 (p5_11 XI792_I214_An XI792_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I214_MN2 (XI792_I214_n1 I792_pn11 p5_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I214_MN3 (VSS I792_G10_0n XI792_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I214_MN0 (XI792_I214_An I792_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I215_MN1 (XI838_I215_Bn I838_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I215_MN5 (XI838_I215_n2 XI838_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I215_MN4 (p6_12 XI838_I215_An XI838_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I215_MN2 (XI838_I215_n1 I838_pn12 p6_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I215_MN3 (VSS I838_G11_0n XI838_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I215_MN0 (XI838_I215_An I838_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I214_MN1 (XI838_I214_Bn I838_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I214_MN5 (XI838_I214_n2 XI838_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I214_MN4 (p6_11 XI838_I214_An XI838_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I214_MN2 (XI838_I214_n1 I838_pn11 p6_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I214_MN3 (VSS I838_G10_0n XI838_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I214_MN0 (XI838_I214_An I838_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I214_MN1 (XI884_I214_Bn I884_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I214_MN5 (XI884_I214_n2 XI884_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I214_MN4 (p7_11 XI884_I214_An XI884_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I214_MN2 (XI884_I214_n1 I884_pn11 p7_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I214_MN3 (VSS I884_G10_0n XI884_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I214_MN0 (XI884_I214_An I884_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1690_MN1 (XI1690_Bn qu7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1690_MN5 (XI1690_n2 XI1690_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1690_MN4 (b25_10 XI1690_An XI1690_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1690_MN2 (XI1690_n1 dd10_b3_4 b25_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1690_MN3 (VSS qu7_b3_1 XI1690_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1690_MN0 (XI1690_An dd10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1689_MN1 (XI1689_Bn qu7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1689_MN5 (XI1689_n2 XI1689_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1689_MN4 (b25_9 XI1689_An XI1689_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1689_MN2 (XI1689_n1 dd9_b3_4 b25_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1689_MN3 (VSS qu7_b3_1 XI1689_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1689_MN0 (XI1689_An dd9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I213_MN1 (XI1712_I213_Bn I1712_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I213_MN5 (XI1712_I213_n2 XI1712_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I213_MN4 (p25_10 XI1712_I213_An XI1712_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I213_MN2 (XI1712_I213_n1 I1712_pn10 p25_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I213_MN3 (VSS I1712_G9_0n XI1712_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I213_MN0 (XI1712_I213_An I1712_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1736_MN1 (XI1736_Bn qu6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1736_MN5 (XI1736_n2 XI1736_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1736_MN4 (b26_10 XI1736_An XI1736_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1736_MN2 (XI1736_n1 dd10_b3_4 b26_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1736_MN3 (VSS qu6_b3_1 XI1736_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1736_MN0 (XI1736_An dd10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1737_MN1 (XI1737_Bn qu6_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1737_MN5 (XI1737_n2 XI1737_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1737_MN4 (b26_11 XI1737_An XI1737_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1737_MN2 (XI1737_n1 dd11_b3_4 b26_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1737_MN3 (VSS qu6_b3_1 XI1737_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1737_MN0 (XI1737_An dd11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I214_MN1 (XI1758_I214_Bn I1758_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I214_MN5 (XI1758_I214_n2 XI1758_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I214_MN4 (p26_11 XI1758_I214_An XI1758_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I214_MN2 (XI1758_I214_n1 I1758_pn11 p26_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I214_MN3 (VSS I1758_G10_0n XI1758_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I214_MN0 (XI1758_I214_An I1758_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I213_MN1 (XI1758_I213_Bn I1758_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I213_MN5 (XI1758_I213_n2 XI1758_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I213_MN4 (p26_10 XI1758_I213_An XI1758_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I213_MN2 (XI1758_I213_n1 I1758_pn10 p26_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I213_MN3 (VSS I1758_G9_0n XI1758_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I213_MN0 (XI1758_I213_An I1758_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1781_MN1 (XI1781_Bn qu5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1781_MN5 (XI1781_n2 XI1781_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1781_MN4 (b27_9 XI1781_An XI1781_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1781_MN2 (XI1781_n1 dd9_b3_4 b27_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1781_MN3 (VSS qu5_b3_1 XI1781_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1781_MN0 (XI1781_An dd9_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1782_MN1 (XI1782_Bn qu5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1782_MN5 (XI1782_n2 XI1782_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1782_MN4 (b27_10 XI1782_An XI1782_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1782_MN2 (XI1782_n1 dd10_b3_4 b27_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1782_MN3 (VSS qu5_b3_1 XI1782_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1782_MN0 (XI1782_An dd10_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I215_MN1 (XI1804_I215_Bn I1804_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I215_MN5 (XI1804_I215_n2 XI1804_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I215_MN4 (p27_12 XI1804_I215_An XI1804_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I215_MN2 (XI1804_I215_n1 I1804_pn12 p27_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I215_MN3 (VSS I1804_G11_0n XI1804_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I215_MN0 (XI1804_I215_An I1804_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I218_MN1 (XI1804_I218_Bn I1804_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I218_MN5 (XI1804_I218_n2 XI1804_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I218_MN4 (p27_15 XI1804_I218_An XI1804_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I218_MN2 (XI1804_I218_n1 I1804_pn15 p27_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I218_MN3 (VSS I1804_G14_0n XI1804_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I218_MN0 (XI1804_I218_An I1804_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I218_MN1 (XI746_I218_Bn I746_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I218_MN5 (XI746_I218_n2 XI746_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I218_MN4 (p4_15 XI746_I218_An XI746_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I218_MN2 (XI746_I218_n1 I746_pn15 p4_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I218_MN3 (VSS I746_G14_0n XI746_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I218_MN0 (XI746_I218_An I746_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I216_MN1 (XI746_I216_Bn I746_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI746_I216_MN5 (XI746_I216_n2 XI746_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI746_I216_MN4 (p4_13 XI746_I216_An XI746_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I216_MN2 (XI746_I216_n1 I746_pn13 p4_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI746_I216_MN3 (VSS I746_G12_0n XI746_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI746_I216_MN0 (XI746_I216_An I746_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI819_MN1 (XI819_Bn qu26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI819_MN5 (XI819_n2 XI819_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI819_MN4 (b6_13 XI819_An XI819_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI819_MN2 (XI819_n1 dd13_b3_1 b6_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI819_MN3 (VSS qu26_b3_2 XI819_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI819_MN0 (XI819_An dd13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI818_MN1 (XI818_Bn qu26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI818_MN5 (XI818_n2 XI818_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI818_MN4 (b6_12 XI818_An XI818_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI818_MN2 (XI818_n1 dd12_b3_1 b6_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI818_MN3 (VSS qu26_b3_2 XI818_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI818_MN0 (XI818_An dd12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I216_MN1 (XI838_I216_Bn I838_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I216_MN5 (XI838_I216_n2 XI838_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I216_MN4 (p6_13 XI838_I216_An XI838_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I216_MN2 (XI838_I216_n1 I838_pn13 p6_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I216_MN3 (VSS I838_G12_0n XI838_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I216_MN0 (XI838_I216_An I838_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI864_MN1 (XI864_Bn qu25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI864_MN5 (XI864_n2 XI864_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI864_MN4 (b7_12 XI864_An XI864_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI864_MN2 (XI864_n1 dd12_b3_1 b7_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI864_MN3 (VSS qu25_b3_2 XI864_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI864_MN0 (XI864_An dd12_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI865_MN1 (XI865_Bn qu25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI865_MN5 (XI865_n2 XI865_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI865_MN4 (b7_13 XI865_An XI865_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI865_MN2 (XI865_n1 dd13_b3_1 b7_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI865_MN3 (VSS qu25_b3_2 XI865_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI865_MN0 (XI865_An dd13_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I214_MN1 (XI1712_I214_Bn I1712_G10_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I214_MN5 (XI1712_I214_n2 XI1712_I214_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I214_MN4 (p25_11 XI1712_I214_An XI1712_I214_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I214_MN2 (XI1712_I214_n1 I1712_pn11 p25_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I214_MN3 (VSS I1712_G10_0n XI1712_I214_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I214_MN0 (XI1712_I214_An I1712_pn11 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1691_MN1 (XI1691_Bn qu7_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1691_MN5 (XI1691_n2 XI1691_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1691_MN4 (b25_11 XI1691_An XI1691_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1691_MN2 (XI1691_n1 dd11_b3_4 b25_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1691_MN3 (VSS qu7_b3_1 XI1691_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1691_MN0 (XI1691_An dd11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1738_MN1 (XI1738_Bn qu6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1738_MN5 (XI1738_n2 XI1738_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1738_MN4 (b26_12 XI1738_An XI1738_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1738_MN2 (XI1738_n1 dd12_b3_4 b26_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1738_MN3 (VSS qu6_b3_2 XI1738_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1738_MN0 (XI1738_An dd12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1783_MN1 (XI1783_Bn qu5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1783_MN5 (XI1783_n2 XI1783_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1783_MN4 (b27_11 XI1783_An XI1783_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1783_MN2 (XI1783_n1 dd11_b3_4 b27_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1783_MN3 (VSS qu5_b3_1 XI1783_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1783_MN0 (XI1783_An dd11_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I215_MN1 (XI1758_I215_Bn I1758_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I215_MN5 (XI1758_I215_n2 XI1758_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I215_MN4 (p26_12 XI1758_I215_An XI1758_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I215_MN2 (XI1758_I215_n1 I1758_pn12 p26_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I215_MN3 (VSS I1758_G11_0n XI1758_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I215_MN0 (XI1758_I215_An I1758_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1784_MN1 (XI1784_Bn qu5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1784_MN5 (XI1784_n2 XI1784_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1784_MN4 (b27_12 XI1784_An XI1784_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1784_MN2 (XI1784_n1 dd12_b3_4 b27_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1784_MN3 (VSS qu5_b3_2 XI1784_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1784_MN0 (XI1784_An dd12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I217_MN1 (XI1804_I217_Bn I1804_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I217_MN5 (XI1804_I217_n2 XI1804_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I217_MN4 (p27_14 XI1804_I217_An XI1804_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I217_MN2 (XI1804_I217_n1 I1804_pn14 p27_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I217_MN3 (VSS I1804_G13_0n XI1804_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I217_MN0 (XI1804_I217_An I1804_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI738_MN1 (XI738_Bn qu28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI738_MN5 (XI738_n2 XI738_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI738_MN4 (b4_24 XI738_An XI738_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI738_MN2 (XI738_n1 dd24_b3_0 b4_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI738_MN3 (VSS qu28_b3_4 XI738_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI738_MN0 (XI738_An dd24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI739_MN1 (XI739_Bn qu28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI739_MN5 (XI739_n2 XI739_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI739_MN4 (b4_25 XI739_An XI739_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI739_MN2 (XI739_n1 dd25_b3_0 b4_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI739_MN3 (VSS qu28_b3_4 XI739_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI739_MN0 (XI739_An dd25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I217_MN1 (XI792_I217_Bn I792_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I217_MN5 (XI792_I217_n2 XI792_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I217_MN4 (p5_14 XI792_I217_An XI792_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I217_MN2 (XI792_I217_n1 I792_pn14 p5_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I217_MN3 (VSS I792_G13_0n XI792_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I217_MN0 (XI792_I217_An I792_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I216_MN1 (XI792_I216_Bn I792_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I216_MN5 (XI792_I216_n2 XI792_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I216_MN4 (p5_13 XI792_I216_An XI792_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I216_MN2 (XI792_I216_n1 I792_pn13 p5_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I216_MN3 (VSS I792_G12_0n XI792_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I216_MN0 (XI792_I216_An I792_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI820_MN1 (XI820_Bn qu26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI820_MN5 (XI820_n2 XI820_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI820_MN4 (b6_14 XI820_An XI820_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI820_MN2 (XI820_n1 dd14_b3_1 b6_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI820_MN3 (VSS qu26_b3_2 XI820_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI820_MN0 (XI820_An dd14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI821_MN1 (XI821_Bn qu26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI821_MN5 (XI821_n2 XI821_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI821_MN4 (b6_15 XI821_An XI821_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI821_MN2 (XI821_n1 dd15_b3_1 b6_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI821_MN3 (VSS qu26_b3_2 XI821_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI821_MN0 (XI821_An dd15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I217_MN1 (XI838_I217_Bn I838_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I217_MN5 (XI838_I217_n2 XI838_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I217_MN4 (p6_14 XI838_I217_An XI838_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I217_MN2 (XI838_I217_n1 I838_pn14 p6_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I217_MN3 (VSS I838_G13_0n XI838_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I217_MN0 (XI838_I217_An I838_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I218_MN1 (XI838_I218_Bn I838_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I218_MN5 (XI838_I218_n2 XI838_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I218_MN4 (p6_15 XI838_I218_An XI838_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I218_MN2 (XI838_I218_n1 I838_pn15 p6_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I218_MN3 (VSS I838_G14_0n XI838_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I218_MN0 (XI838_I218_An I838_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI867_MN1 (XI867_Bn qu25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI867_MN5 (XI867_n2 XI867_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI867_MN4 (b7_15 XI867_An XI867_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI867_MN2 (XI867_n1 dd15_b3_1 b7_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI867_MN3 (VSS qu25_b3_2 XI867_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI867_MN0 (XI867_An dd15_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI866_MN1 (XI866_Bn qu25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI866_MN5 (XI866_n2 XI866_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI866_MN4 (b7_14 XI866_An XI866_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI866_MN2 (XI866_n1 dd14_b3_1 b7_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI866_MN3 (VSS qu25_b3_2 XI866_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI866_MN0 (XI866_An dd14_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I216_MN1 (XI1712_I216_Bn I1712_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I216_MN5 (XI1712_I216_n2 XI1712_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I216_MN4 (p25_13 XI1712_I216_An XI1712_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I216_MN2 (XI1712_I216_n1 I1712_pn13 p25_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I216_MN3 (VSS I1712_G12_0n XI1712_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I216_MN0 (XI1712_I216_An I1712_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1692_MN1 (XI1692_Bn qu7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1692_MN5 (XI1692_n2 XI1692_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1692_MN4 (b25_12 XI1692_An XI1692_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1692_MN2 (XI1692_n1 dd12_b3_4 b25_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1692_MN3 (VSS qu7_b3_2 XI1692_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1692_MN0 (XI1692_An dd12_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1693_MN1 (XI1693_Bn qu7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1693_MN5 (XI1693_n2 XI1693_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1693_MN4 (b25_13 XI1693_An XI1693_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1693_MN2 (XI1693_n1 dd13_b3_4 b25_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1693_MN3 (VSS qu7_b3_2 XI1693_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1693_MN0 (XI1693_An dd13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I215_MN1 (XI1712_I215_Bn I1712_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I215_MN5 (XI1712_I215_n2 XI1712_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I215_MN4 (p25_12 XI1712_I215_An XI1712_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I215_MN2 (XI1712_I215_n1 I1712_pn12 p25_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I215_MN3 (VSS I1712_G11_0n XI1712_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I215_MN0 (XI1712_I215_An I1712_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1739_MN1 (XI1739_Bn qu6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1739_MN5 (XI1739_n2 XI1739_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1739_MN4 (b26_13 XI1739_An XI1739_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1739_MN2 (XI1739_n1 dd13_b3_4 b26_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1739_MN3 (VSS qu6_b3_2 XI1739_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1739_MN0 (XI1739_An dd13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I216_MN1 (XI1758_I216_Bn I1758_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I216_MN5 (XI1758_I216_n2 XI1758_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I216_MN4 (p26_13 XI1758_I216_An XI1758_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I216_MN2 (XI1758_I216_n1 I1758_pn13 p26_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I216_MN3 (VSS I1758_G12_0n XI1758_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I216_MN0 (XI1758_I216_An I1758_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I217_MN1 (XI1758_I217_Bn I1758_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I217_MN5 (XI1758_I217_n2 XI1758_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I217_MN4 (p26_14 XI1758_I217_An XI1758_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I217_MN2 (XI1758_I217_n1 I1758_pn14 p26_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I217_MN3 (VSS I1758_G13_0n XI1758_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I217_MN0 (XI1758_I217_An I1758_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1785_MN1 (XI1785_Bn qu5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1785_MN5 (XI1785_n2 XI1785_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1785_MN4 (b27_13 XI1785_An XI1785_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1785_MN2 (XI1785_n1 dd13_b3_4 b27_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1785_MN3 (VSS qu5_b3_2 XI1785_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1785_MN0 (XI1785_An dd13_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1786_MN1 (XI1786_Bn qu5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1786_MN5 (XI1786_n2 XI1786_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1786_MN4 (b27_14 XI1786_An XI1786_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1786_MN2 (XI1786_n1 dd14_b3_4 b27_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1786_MN3 (VSS qu5_b3_2 XI1786_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1786_MN0 (XI1786_An dd14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I219_MN1 (XI1804_I219_Bn I1804_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1804_I219_MN5 (XI1804_I219_n2 XI1804_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1804_I219_MN4 (p27_16 XI1804_I219_An XI1804_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I219_MN2 (XI1804_I219_n1 I1804_pn16 p27_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1804_I219_MN3 (VSS I1804_G15_0n XI1804_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1804_I219_MN0 (XI1804_I219_An I1804_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI740_MN1 (XI740_Bn qu28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI740_MN5 (XI740_n2 XI740_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI740_MN4 (b4_26 XI740_An XI740_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI740_MN2 (XI740_n1 dd26_b3_0 b4_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI740_MN3 (VSS qu28_b3_4 XI740_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI740_MN0 (XI740_An dd26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI784_MN1 (XI784_Bn qu27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI784_MN5 (XI784_n2 XI784_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI784_MN4 (b5_24 XI784_An XI784_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI784_MN2 (XI784_n1 dd24_b3_0 b5_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI784_MN3 (VSS qu27_b3_4 XI784_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI784_MN0 (XI784_An dd24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI785_MN1 (XI785_Bn qu27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI785_MN5 (XI785_n2 XI785_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI785_MN4 (b5_25 XI785_An XI785_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI785_MN2 (XI785_n1 dd25_b3_0 b5_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI785_MN3 (VSS qu27_b3_4 XI785_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI785_MN0 (XI785_An dd25_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I218_MN1 (XI792_I218_Bn I792_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I218_MN5 (XI792_I218_n2 XI792_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I218_MN4 (p5_15 XI792_I218_An XI792_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I218_MN2 (XI792_I218_n1 I792_pn15 p5_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I218_MN3 (VSS I792_G14_0n XI792_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I218_MN0 (XI792_I218_An I792_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I219_MN1 (XI838_I219_Bn I838_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI838_I219_MN5 (XI838_I219_n2 XI838_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI838_I219_MN4 (p6_16 XI838_I219_An XI838_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I219_MN2 (XI838_I219_n1 I838_pn16 p6_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI838_I219_MN3 (VSS I838_G15_0n XI838_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI838_I219_MN0 (XI838_I219_An I838_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI868_MN1 (XI868_Bn qu25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI868_MN5 (XI868_n2 XI868_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI868_MN4 (b7_16 XI868_An XI868_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI868_MN2 (XI868_n1 dd16_b3_1 b7_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI868_MN3 (VSS qu25_b3_2 XI868_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI868_MN0 (XI868_An dd16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I216_MN1 (XI884_I216_Bn I884_G12_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I216_MN5 (XI884_I216_n2 XI884_I216_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I216_MN4 (p7_13 XI884_I216_An XI884_I216_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I216_MN2 (XI884_I216_n1 I884_pn13 p7_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I216_MN3 (VSS I884_G12_0n XI884_I216_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I216_MN0 (XI884_I216_An I884_pn13 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I218_MN1 (XI1712_I218_Bn I1712_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I218_MN5 (XI1712_I218_n2 XI1712_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I218_MN4 (p25_15 XI1712_I218_An XI1712_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I218_MN2 (XI1712_I218_n1 I1712_pn15 p25_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I218_MN3 (VSS I1712_G14_0n XI1712_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I218_MN0 (XI1712_I218_An I1712_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1695_MN1 (XI1695_Bn qu7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1695_MN5 (XI1695_n2 XI1695_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1695_MN4 (b25_15 XI1695_An XI1695_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1695_MN2 (XI1695_n1 dd15_b3_4 b25_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1695_MN3 (VSS qu7_b3_2 XI1695_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1695_MN0 (XI1695_An dd15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1694_MN1 (XI1694_Bn qu7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1694_MN5 (XI1694_n2 XI1694_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1694_MN4 (b25_14 XI1694_An XI1694_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1694_MN2 (XI1694_n1 dd14_b3_4 b25_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1694_MN3 (VSS qu7_b3_2 XI1694_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1694_MN0 (XI1694_An dd14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I217_MN1 (XI1712_I217_Bn I1712_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I217_MN5 (XI1712_I217_n2 XI1712_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I217_MN4 (p25_14 XI1712_I217_An XI1712_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I217_MN2 (XI1712_I217_n1 I1712_pn14 p25_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I217_MN3 (VSS I1712_G13_0n XI1712_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I217_MN0 (XI1712_I217_An I1712_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1740_MN1 (XI1740_Bn qu6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1740_MN5 (XI1740_n2 XI1740_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1740_MN4 (b26_14 XI1740_An XI1740_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1740_MN2 (XI1740_n1 dd14_b3_4 b26_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1740_MN3 (VSS qu6_b3_2 XI1740_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1740_MN0 (XI1740_An dd14_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1741_MN1 (XI1741_Bn qu6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1741_MN5 (XI1741_n2 XI1741_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1741_MN4 (b26_15 XI1741_An XI1741_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1741_MN2 (XI1741_n1 dd15_b3_4 b26_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1741_MN3 (VSS qu6_b3_2 XI1741_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1741_MN0 (XI1741_An dd15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I218_MN1 (XI1758_I218_Bn I1758_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I218_MN5 (XI1758_I218_n2 XI1758_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I218_MN4 (p26_15 XI1758_I218_An XI1758_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I218_MN2 (XI1758_I218_n1 I1758_pn15 p26_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I218_MN3 (VSS I1758_G14_0n XI1758_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I218_MN0 (XI1758_I218_An I1758_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I219_MN1 (XI1758_I219_Bn I1758_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1758_I219_MN5 (XI1758_I219_n2 XI1758_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1758_I219_MN4 (p26_16 XI1758_I219_An XI1758_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I219_MN2 (XI1758_I219_n1 I1758_pn16 p26_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1758_I219_MN3 (VSS I1758_G15_0n XI1758_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1758_I219_MN0 (XI1758_I219_An I1758_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1787_MN1 (XI1787_Bn qu5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1787_MN5 (XI1787_n2 XI1787_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1787_MN4 (b27_15 XI1787_An XI1787_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1787_MN2 (XI1787_n1 dd15_b3_4 b27_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1787_MN3 (VSS qu5_b3_2 XI1787_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1787_MN0 (XI1787_An dd15_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI745_MN1 (XI745_Bn qu28_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI745_MN5 (XI745_n2 XI745_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI745_MN4 (b4_31 XI745_An XI745_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI745_MN2 (XI745_n1 dd31_b3_0 b4_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI745_MN3 (VSS qu28_b3_5 XI745_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI745_MN0 (XI745_An dd31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI741_MN1 (XI741_Bn qu28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI741_MN5 (XI741_n2 XI741_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI741_MN4 (b4_27 XI741_An XI741_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI741_MN2 (XI741_n1 dd27_b3_0 b4_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI741_MN3 (VSS qu28_b3_4 XI741_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI741_MN0 (XI741_An dd27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI787_MN1 (XI787_Bn qu27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI787_MN5 (XI787_n2 XI787_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI787_MN4 (b5_27 XI787_An XI787_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI787_MN2 (XI787_n1 dd27_b3_0 b5_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI787_MN3 (VSS qu27_b3_4 XI787_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI787_MN0 (XI787_An dd27_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI786_MN1 (XI786_Bn qu27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI786_MN5 (XI786_n2 XI786_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI786_MN4 (b5_26 XI786_An XI786_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI786_MN2 (XI786_n1 dd26_b3_0 b5_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI786_MN3 (VSS qu27_b3_4 XI786_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI786_MN0 (XI786_An dd26_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I219_MN1 (XI792_I219_Bn I792_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI792_I219_MN5 (XI792_I219_n2 XI792_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI792_I219_MN4 (p5_16 XI792_I219_An XI792_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I219_MN2 (XI792_I219_n1 I792_pn16 p5_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI792_I219_MN3 (VSS I792_G15_0n XI792_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI792_I219_MN0 (XI792_I219_An I792_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI823_MN1 (XI823_Bn qu26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI823_MN5 (XI823_n2 XI823_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI823_MN4 (b6_17 XI823_An XI823_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI823_MN2 (XI823_n1 dd17_b3_1 b6_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI823_MN3 (VSS qu26_b3_2 XI823_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI823_MN0 (XI823_An dd17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI822_MN1 (XI822_Bn qu26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI822_MN5 (XI822_n2 XI822_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI822_MN4 (b6_16 XI822_An XI822_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI822_MN2 (XI822_n1 dd16_b3_1 b6_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI822_MN3 (VSS qu26_b3_2 XI822_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI822_MN0 (XI822_An dd16_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI869_MN1 (XI869_Bn qu25_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI869_MN5 (XI869_n2 XI869_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI869_MN4 (b7_17 XI869_An XI869_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI869_MN2 (XI869_n1 dd17_b3_1 b7_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI869_MN3 (VSS qu25_b3_2 XI869_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI869_MN0 (XI869_An dd17_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I215_MN1 (XI884_I215_Bn I884_G11_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I215_MN5 (XI884_I215_n2 XI884_I215_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I215_MN4 (p7_12 XI884_I215_An XI884_I215_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I215_MN2 (XI884_I215_n1 I884_pn12 p7_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I215_MN3 (VSS I884_G11_0n XI884_I215_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I215_MN0 (XI884_I215_An I884_pn12 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1696_MN1 (XI1696_Bn qu7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1696_MN5 (XI1696_n2 XI1696_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1696_MN4 (b25_16 XI1696_An XI1696_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1696_MN2 (XI1696_n1 dd16_b3_4 b25_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1696_MN3 (VSS qu7_b3_2 XI1696_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1696_MN0 (XI1696_An dd16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1697_MN1 (XI1697_Bn qu7_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1697_MN5 (XI1697_n2 XI1697_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1697_MN4 (b25_17 XI1697_An XI1697_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1697_MN2 (XI1697_n1 dd17_b3_4 b25_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1697_MN3 (VSS qu7_b3_2 XI1697_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1697_MN0 (XI1697_An dd17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I219_MN1 (XI1712_I219_Bn I1712_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1712_I219_MN5 (XI1712_I219_n2 XI1712_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1712_I219_MN4 (p25_16 XI1712_I219_An XI1712_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I219_MN2 (XI1712_I219_n1 I1712_pn16 p25_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1712_I219_MN3 (VSS I1712_G15_0n XI1712_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1712_I219_MN0 (XI1712_I219_An I1712_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1742_MN1 (XI1742_Bn qu6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1742_MN5 (XI1742_n2 XI1742_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1742_MN4 (b26_16 XI1742_An XI1742_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1742_MN2 (XI1742_n1 dd16_b3_4 b26_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1742_MN3 (VSS qu6_b3_2 XI1742_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1742_MN0 (XI1742_An dd16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1743_MN1 (XI1743_Bn qu6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1743_MN5 (XI1743_n2 XI1743_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1743_MN4 (b26_17 XI1743_An XI1743_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1743_MN2 (XI1743_n1 dd17_b3_4 b26_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1743_MN3 (VSS qu6_b3_2 XI1743_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1743_MN0 (XI1743_An dd17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1789_MN1 (XI1789_Bn qu5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1789_MN5 (XI1789_n2 XI1789_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1789_MN4 (b27_17 XI1789_An XI1789_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1789_MN2 (XI1789_n1 dd17_b3_4 b27_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1789_MN3 (VSS qu5_b3_2 XI1789_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1789_MN0 (XI1789_An dd17_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1788_MN1 (XI1788_Bn qu5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1788_MN5 (XI1788_n2 XI1788_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1788_MN4 (b27_16 XI1788_An XI1788_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1788_MN2 (XI1788_n1 dd16_b3_4 b27_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1788_MN3 (VSS qu5_b3_2 XI1788_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1788_MN0 (XI1788_An dd16_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI744_MN1 (XI744_Bn qu28_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI744_MN5 (XI744_n2 XI744_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI744_MN4 (b4_30 XI744_An XI744_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI744_MN2 (XI744_n1 dd30_b3_0 b4_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI744_MN3 (VSS qu28_b3_5 XI744_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI744_MN0 (XI744_An dd30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI791_MN1 (XI791_Bn qu27_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI791_MN5 (XI791_n2 XI791_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI791_MN4 (b5_31 XI791_An XI791_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI791_MN2 (XI791_n1 dd31_b3_0 b5_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI791_MN3 (VSS qu27_b3_5 XI791_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI791_MN0 (XI791_An dd31_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI790_MN1 (XI790_Bn qu27_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI790_MN5 (XI790_n2 XI790_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI790_MN4 (b5_30 XI790_An XI790_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI790_MN2 (XI790_n1 dd30_b3_0 b5_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI790_MN3 (VSS qu27_b3_5 XI790_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI790_MN0 (XI790_An dd30_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI840_MN1 (XI840_Bn c6_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI840_MN5 (XI840_n2 XI840_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI840_MN4 (p6_32 XI840_An XI840_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI840_MN2 (XI840_n1 h6 p6_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI840_MN3 (VSS c6_o XI840_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI840_MN0 (XI840_An h6 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I218_MN1 (XI884_I218_Bn I884_G14_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I218_MN5 (XI884_I218_n2 XI884_I218_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I218_MN4 (p7_15 XI884_I218_An XI884_I218_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I218_MN2 (XI884_I218_n1 I884_pn15 p7_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I218_MN3 (VSS I884_G14_0n XI884_I218_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I218_MN0 (XI884_I218_An I884_pn15 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I217_MN1 (XI884_I217_Bn I884_G13_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I217_MN5 (XI884_I217_n2 XI884_I217_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I217_MN4 (p7_14 XI884_I217_An XI884_I217_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I217_MN2 (XI884_I217_n1 I884_pn14 p7_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I217_MN3 (VSS I884_G13_0n XI884_I217_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I217_MN0 (XI884_I217_An I884_pn14 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI743_MN1 (XI743_Bn qu28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI743_MN5 (XI743_n2 XI743_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI743_MN4 (b4_29 XI743_An XI743_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI743_MN2 (XI743_n1 dd29_b3_0 b4_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI743_MN3 (VSS qu28_b3_4 XI743_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI743_MN0 (XI743_An dd29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI742_MN1 (XI742_Bn qu28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI742_MN5 (XI742_n2 XI742_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI742_MN4 (b4_28 XI742_An XI742_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI742_MN2 (XI742_n1 dd28_b3_0 b4_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI742_MN3 (VSS qu28_b3_4 XI742_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI742_MN0 (XI742_An dd28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI793_MN1 (XI793_Bn qu27_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI793_MN5 (XI793_n2 XI793_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI793_MN4 (h5 XI793_An XI793_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI793_MN2 (XI793_n1 p4_31 h5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI793_MN3 (VSS qu27_b3_5 XI793_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI793_MN0 (XI793_An p4_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI789_MN1 (XI789_Bn qu27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI789_MN5 (XI789_n2 XI789_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI789_MN4 (b5_29 XI789_An XI789_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI789_MN2 (XI789_n1 dd29_b3_0 b5_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI789_MN3 (VSS qu27_b3_4 XI789_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI789_MN0 (XI789_An dd29_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI788_MN1 (XI788_Bn qu27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI788_MN5 (XI788_n2 XI788_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI788_MN4 (b5_28 XI788_An XI788_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI788_MN2 (XI788_n1 dd28_b3_0 b5_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI788_MN3 (VSS qu27_b3_4 XI788_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI788_MN0 (XI788_An dd28_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI839_MN1 (XI839_Bn qu26_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI839_MN5 (XI839_n2 XI839_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI839_MN4 (h6 XI839_An XI839_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI839_MN2 (XI839_n1 p5_31 h6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI839_MN3 (VSS qu26_b3_5 XI839_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI839_MN0 (XI839_An p5_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI826_MN1 (XI826_Bn qu26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI826_MN5 (XI826_n2 XI826_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI826_MN4 (b6_20 XI826_An XI826_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI826_MN2 (XI826_n1 dd20_b3_1 b6_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI826_MN3 (VSS qu26_b3_3 XI826_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI826_MN0 (XI826_An dd20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI872_MN1 (XI872_Bn qu25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI872_MN5 (XI872_n2 XI872_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI872_MN4 (b7_20 XI872_An XI872_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI872_MN2 (XI872_n1 dd20_b3_1 b7_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI872_MN3 (VSS qu25_b3_3 XI872_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI872_MN0 (XI872_An dd20_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1746_MN1 (XI1746_Bn qu6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1746_MN5 (XI1746_n2 XI1746_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1746_MN4 (b26_20 XI1746_An XI1746_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1746_MN2 (XI1746_n1 dd20_b3_4 b26_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1746_MN3 (VSS qu6_b3_3 XI1746_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1746_MN0 (XI1746_An dd20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1745_MN1 (XI1745_Bn qu6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1745_MN5 (XI1745_n2 XI1745_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1745_MN4 (b26_19 XI1745_An XI1745_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1745_MN2 (XI1745_n1 dd19_b3_4 b26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1745_MN3 (VSS qu6_b3_3 XI1745_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1745_MN0 (XI1745_An dd19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1805_MN1 (XI1805_Bn qu5_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1805_MN5 (XI1805_n2 XI1805_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1805_MN4 (h27 XI1805_An XI1805_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1805_MN2 (XI1805_n1 p26_31 h27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1805_MN3 (VSS qu5_b3_5 XI1805_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1805_MN0 (XI1805_An p26_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1791_MN1 (XI1791_Bn qu5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1791_MN5 (XI1791_n2 XI1791_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1791_MN4 (b27_19 XI1791_An XI1791_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1791_MN2 (XI1791_n1 dd19_b3_4 b27_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1791_MN3 (VSS qu5_b3_3 XI1791_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1791_MN0 (XI1791_An dd19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1806_MN1 (XI1806_Bn c27_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1806_MN5 (XI1806_n2 XI1806_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1806_MN4 (p27_32 XI1806_An XI1806_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1806_MN2 (XI1806_n1 h27 p27_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1806_MN3 (VSS c27_o XI1806_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1806_MN0 (XI1806_An h27 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1792_MN1 (XI1792_Bn qu5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1792_MN5 (XI1792_n2 XI1792_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1792_MN4 (b27_20 XI1792_An XI1792_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1792_MN2 (XI1792_n1 dd20_b3_4 b27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1792_MN3 (VSS qu5_b3_3 XI1792_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1792_MN0 (XI1792_An dd20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI794_MN1 (XI794_Bn c5_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI794_MN5 (XI794_n2 XI794_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI794_MN4 (p5_32 XI794_An XI794_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI794_MN2 (XI794_n1 h5 p5_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI794_MN3 (VSS c5_o XI794_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI794_MN0 (XI794_An h5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI825_MN1 (XI825_Bn qu26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI825_MN5 (XI825_n2 XI825_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI825_MN4 (b6_19 XI825_An XI825_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI825_MN2 (XI825_n1 dd19_b3_1 b6_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI825_MN3 (VSS qu26_b3_3 XI825_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI825_MN0 (XI825_An dd19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI824_MN1 (XI824_Bn qu26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI824_MN5 (XI824_n2 XI824_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI824_MN4 (b6_18 XI824_An XI824_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI824_MN2 (XI824_n1 dd18_b3_1 b6_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI824_MN3 (VSS qu26_b3_3 XI824_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI824_MN0 (XI824_An dd18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI885_MN1 (XI885_Bn qu25_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI885_MN5 (XI885_n2 XI885_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI885_MN4 (h7 XI885_An XI885_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI885_MN2 (XI885_n1 p6_31 h7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI885_MN3 (VSS qu25_b3_5 XI885_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI885_MN0 (XI885_An p6_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI873_MN1 (XI873_Bn qu25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI873_MN5 (XI873_n2 XI873_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI873_MN4 (b7_21 XI873_An XI873_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI873_MN2 (XI873_n1 dd21_b3_1 b7_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI873_MN3 (VSS qu25_b3_3 XI873_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI873_MN0 (XI873_An dd21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI871_MN1 (XI871_Bn qu25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI871_MN5 (XI871_n2 XI871_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI871_MN4 (b7_19 XI871_An XI871_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI871_MN2 (XI871_n1 dd19_b3_1 b7_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI871_MN3 (VSS qu25_b3_3 XI871_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI871_MN0 (XI871_An dd19_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI875_MN1 (XI875_Bn qu25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI875_MN5 (XI875_n2 XI875_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI875_MN4 (b7_23 XI875_An XI875_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI875_MN2 (XI875_n1 dd23_b3_1 b7_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI875_MN3 (VSS qu25_b3_3 XI875_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI875_MN0 (XI875_An dd23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI870_MN1 (XI870_Bn qu25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI870_MN5 (XI870_n2 XI870_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI870_MN4 (b7_18 XI870_An XI870_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI870_MN2 (XI870_n1 dd18_b3_1 b7_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI870_MN3 (VSS qu25_b3_3 XI870_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI870_MN0 (XI870_An dd18_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I219_MN1 (XI884_I219_Bn I884_G15_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI884_I219_MN5 (XI884_I219_n2 XI884_I219_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI884_I219_MN4 (p7_16 XI884_I219_An XI884_I219_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I219_MN2 (XI884_I219_n1 I884_pn16 p7_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI884_I219_MN3 (VSS I884_G15_0n XI884_I219_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI884_I219_MN0 (XI884_I219_An I884_pn16 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1698_MN1 (XI1698_Bn qu7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1698_MN5 (XI1698_n2 XI1698_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1698_MN4 (b25_18 XI1698_An XI1698_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1698_MN2 (XI1698_n1 dd18_b3_4 b25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1698_MN3 (VSS qu7_b3_3 XI1698_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1698_MN0 (XI1698_An dd18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1699_MN1 (XI1699_Bn qu7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1699_MN5 (XI1699_n2 XI1699_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1699_MN4 (b25_19 XI1699_An XI1699_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1699_MN2 (XI1699_n1 dd19_b3_4 b25_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1699_MN3 (VSS qu7_b3_3 XI1699_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1699_MN0 (XI1699_An dd19_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1714_MN1 (XI1714_Bn c25_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1714_MN5 (XI1714_n2 XI1714_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1714_MN4 (p25_32 XI1714_An XI1714_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1714_MN2 (XI1714_n1 h25 p25_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1714_MN3 (VSS c25_o XI1714_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1714_MN0 (XI1714_An h25 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1748_MN1 (XI1748_Bn qu6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1748_MN5 (XI1748_n2 XI1748_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1748_MN4 (b26_22 XI1748_An XI1748_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1748_MN2 (XI1748_n1 dd22_b3_4 b26_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1748_MN3 (VSS qu6_b3_3 XI1748_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1748_MN0 (XI1748_An dd22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1747_MN1 (XI1747_Bn qu6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1747_MN5 (XI1747_n2 XI1747_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1747_MN4 (b26_21 XI1747_An XI1747_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1747_MN2 (XI1747_n1 dd21_b3_4 b26_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1747_MN3 (VSS qu6_b3_3 XI1747_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1747_MN0 (XI1747_An dd21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1744_MN1 (XI1744_Bn qu6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1744_MN5 (XI1744_n2 XI1744_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1744_MN4 (b26_18 XI1744_An XI1744_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1744_MN2 (XI1744_n1 dd18_b3_4 b26_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1744_MN3 (VSS qu6_b3_3 XI1744_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1744_MN0 (XI1744_An dd18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1760_MN1 (XI1760_Bn c26_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1760_MN5 (XI1760_n2 XI1760_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1760_MN4 (p26_32 XI1760_An XI1760_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1760_MN2 (XI1760_n1 h26 p26_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1760_MN3 (VSS c26_o XI1760_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1760_MN0 (XI1760_An h26 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1759_MN1 (XI1759_Bn qu6_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1759_MN5 (XI1759_n2 XI1759_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1759_MN4 (h26 XI1759_An XI1759_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1759_MN2 (XI1759_n1 p25_31 h26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1759_MN3 (VSS qu6_b3_5 XI1759_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1759_MN0 (XI1759_An p25_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1793_MN1 (XI1793_Bn qu5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1793_MN5 (XI1793_n2 XI1793_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1793_MN4 (b27_21 XI1793_An XI1793_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1793_MN2 (XI1793_n1 dd21_b3_4 b27_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1793_MN3 (VSS qu5_b3_3 XI1793_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1793_MN0 (XI1793_An dd21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1790_MN1 (XI1790_Bn qu5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1790_MN5 (XI1790_n2 XI1790_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1790_MN4 (b27_18 XI1790_An XI1790_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1790_MN2 (XI1790_n1 dd18_b3_4 b27_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1790_MN3 (VSS qu5_b3_3 XI1790_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1790_MN0 (XI1790_An dd18_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1794_MN1 (XI1794_Bn qu5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1794_MN5 (XI1794_n2 XI1794_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1794_MN4 (b27_22 XI1794_An XI1794_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1794_MN2 (XI1794_n1 dd22_b3_4 b27_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1794_MN3 (VSS qu5_b3_3 XI1794_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1794_MN0 (XI1794_An dd22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1041_MN1 (XI1041_Bn qu21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1041_MN5 (XI1041_n2 XI1041_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1041_MN4 (b11_5 XI1041_An XI1041_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1041_MN2 (XI1041_n1 dd5_b3_2 b11_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1041_MN3 (VSS qu21_b3_0 XI1041_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1041_MN0 (XI1041_An dd5_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1040_MN1 (XI1040_Bn qu21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1040_MN5 (XI1040_n2 XI1040_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1040_MN4 (b11_4 XI1040_An XI1040_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1040_MN2 (XI1040_n1 dd4_b3_2 b11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1040_MN3 (VSS qu21_b3_0 XI1040_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1040_MN0 (XI1040_An dd4_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI837_MN1 (XI837_Bn qu26_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI837_MN5 (XI837_n2 XI837_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI837_MN4 (b6_31 XI837_An XI837_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI837_MN2 (XI837_n1 dd31_b3_1 b6_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI837_MN3 (VSS qu26_b3_5 XI837_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI837_MN0 (XI837_An dd31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI836_MN1 (XI836_Bn qu26_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI836_MN5 (XI836_n2 XI836_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI836_MN4 (b6_30 XI836_An XI836_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI836_MN2 (XI836_n1 dd30_b3_1 b6_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI836_MN3 (VSS qu26_b3_5 XI836_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI836_MN0 (XI836_An dd30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI835_MN1 (XI835_Bn qu26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI835_MN5 (XI835_n2 XI835_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI835_MN4 (b6_29 XI835_An XI835_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI835_MN2 (XI835_n1 dd29_b3_1 b6_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI835_MN3 (VSS qu26_b3_4 XI835_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI835_MN0 (XI835_An dd29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI832_MN1 (XI832_Bn qu26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI832_MN5 (XI832_n2 XI832_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI832_MN4 (b6_26 XI832_An XI832_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI832_MN2 (XI832_n1 dd26_b3_1 b6_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI832_MN3 (VSS qu26_b3_4 XI832_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI832_MN0 (XI832_An dd26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI830_MN1 (XI830_Bn qu26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI830_MN5 (XI830_n2 XI830_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI830_MN4 (b6_24 XI830_An XI830_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI830_MN2 (XI830_n1 dd24_b3_1 b6_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI830_MN3 (VSS qu26_b3_4 XI830_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI830_MN0 (XI830_An dd24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI829_MN1 (XI829_Bn qu26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI829_MN5 (XI829_n2 XI829_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI829_MN4 (b6_23 XI829_An XI829_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI829_MN2 (XI829_n1 dd23_b3_1 b6_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI829_MN3 (VSS qu26_b3_3 XI829_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI829_MN0 (XI829_An dd23_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI828_MN1 (XI828_Bn qu26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI828_MN5 (XI828_n2 XI828_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI828_MN4 (b6_22 XI828_An XI828_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI828_MN2 (XI828_n1 dd22_b3_1 b6_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI828_MN3 (VSS qu26_b3_3 XI828_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI828_MN0 (XI828_An dd22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI827_MN1 (XI827_Bn qu26_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI827_MN5 (XI827_n2 XI827_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI827_MN4 (b6_21 XI827_An XI827_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI827_MN2 (XI827_n1 dd21_b3_1 b6_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI827_MN3 (VSS qu26_b3_3 XI827_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI827_MN0 (XI827_An dd21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI882_MN1 (XI882_Bn qu25_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI882_MN5 (XI882_n2 XI882_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI882_MN4 (b7_30 XI882_An XI882_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI882_MN2 (XI882_n1 dd30_b3_1 b7_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI882_MN3 (VSS qu25_b3_5 XI882_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI882_MN0 (XI882_An dd30_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI874_MN1 (XI874_Bn qu25_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI874_MN5 (XI874_n2 XI874_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI874_MN4 (b7_22 XI874_An XI874_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI874_MN2 (XI874_n1 dd22_b3_1 b7_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI874_MN3 (VSS qu25_b3_3 XI874_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI874_MN0 (XI874_An dd22_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI886_MN1 (XI886_Bn c7_o VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI886_MN5 (XI886_n2 XI886_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI886_MN4 (p7_32 XI886_An XI886_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI886_MN2 (XI886_n1 h7 p7_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI886_MN3 (VSS c7_o XI886_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI886_MN0 (XI886_An h7 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI876_MN1 (XI876_Bn qu25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI876_MN5 (XI876_n2 XI876_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI876_MN4 (b7_24 XI876_An XI876_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI876_MN2 (XI876_n1 dd24_b3_1 b7_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI876_MN3 (VSS qu25_b3_4 XI876_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI876_MN0 (XI876_An dd24_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI878_MN1 (XI878_Bn qu25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI878_MN5 (XI878_n2 XI878_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI878_MN4 (b7_26 XI878_An XI878_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI878_MN2 (XI878_n1 dd26_b3_1 b7_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI878_MN3 (VSS qu25_b3_4 XI878_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI878_MN0 (XI878_An dd26_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1700_MN1 (XI1700_Bn qu7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1700_MN5 (XI1700_n2 XI1700_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1700_MN4 (b25_20 XI1700_An XI1700_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1700_MN2 (XI1700_n1 dd20_b3_4 b25_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1700_MN3 (VSS qu7_b3_3 XI1700_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1700_MN0 (XI1700_An dd20_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1702_MN1 (XI1702_Bn qu7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1702_MN5 (XI1702_n2 XI1702_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1702_MN4 (b25_22 XI1702_An XI1702_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1702_MN2 (XI1702_n1 dd22_b3_4 b25_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1702_MN3 (VSS qu7_b3_3 XI1702_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1702_MN0 (XI1702_An dd22_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1701_MN1 (XI1701_Bn qu7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1701_MN5 (XI1701_n2 XI1701_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1701_MN4 (b25_21 XI1701_An XI1701_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1701_MN2 (XI1701_n1 dd21_b3_4 b25_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1701_MN3 (VSS qu7_b3_3 XI1701_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1701_MN0 (XI1701_An dd21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1713_MN1 (XI1713_Bn qu7_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1713_MN5 (XI1713_n2 XI1713_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1713_MN4 (h25 XI1713_An XI1713_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1713_MN2 (XI1713_n1 p24_31 h25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1713_MN3 (VSS qu7_b3_5 XI1713_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1713_MN0 (XI1713_An p24_31 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1749_MN1 (XI1749_Bn qu6_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1749_MN5 (XI1749_n2 XI1749_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1749_MN4 (b26_23 XI1749_An XI1749_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1749_MN2 (XI1749_n1 dd23_b3_4 b26_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1749_MN3 (VSS qu6_b3_3 XI1749_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1749_MN0 (XI1749_An dd23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1750_MN1 (XI1750_Bn qu6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1750_MN5 (XI1750_n2 XI1750_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1750_MN4 (b26_24 XI1750_An XI1750_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1750_MN2 (XI1750_n1 dd24_b3_4 b26_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1750_MN3 (VSS qu6_b3_4 XI1750_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1750_MN0 (XI1750_An dd24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1756_MN1 (XI1756_Bn qu6_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1756_MN5 (XI1756_n2 XI1756_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1756_MN4 (b26_30 XI1756_An XI1756_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1756_MN2 (XI1756_n1 dd30_b3_4 b26_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1756_MN3 (VSS qu6_b3_5 XI1756_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1756_MN0 (XI1756_An dd30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1757_MN1 (XI1757_Bn qu6_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1757_MN5 (XI1757_n2 XI1757_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1757_MN4 (b26_31 XI1757_An XI1757_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1757_MN2 (XI1757_n1 dd31_b3_4 b26_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1757_MN3 (VSS qu6_b3_5 XI1757_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1757_MN0 (XI1757_An dd31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1803_MN1 (XI1803_Bn qu5_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1803_MN5 (XI1803_n2 XI1803_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1803_MN4 (b27_31 XI1803_An XI1803_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1803_MN2 (XI1803_n1 dd31_b3_4 b27_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1803_MN3 (VSS qu5_b3_5 XI1803_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1803_MN0 (XI1803_An dd31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1795_MN1 (XI1795_Bn qu5_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1795_MN5 (XI1795_n2 XI1795_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1795_MN4 (b27_23 XI1795_An XI1795_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1795_MN2 (XI1795_n1 dd23_b3_4 b27_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1795_MN3 (VSS qu5_b3_3 XI1795_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1795_MN0 (XI1795_An dd23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1802_MN1 (XI1802_Bn qu5_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1802_MN5 (XI1802_n2 XI1802_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1802_MN4 (b27_30 XI1802_An XI1802_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1802_MN2 (XI1802_n1 dd30_b3_4 b27_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1802_MN3 (VSS qu5_b3_5 XI1802_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1802_MN0 (XI1802_An dd30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1796_MN1 (XI1796_Bn qu5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1796_MN5 (XI1796_n2 XI1796_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1796_MN4 (b27_24 XI1796_An XI1796_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1796_MN2 (XI1796_n1 dd24_b3_4 b27_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1796_MN3 (VSS qu5_b3_4 XI1796_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1796_MN0 (XI1796_An dd24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1800_MN1 (XI1800_Bn qu5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1800_MN5 (XI1800_n2 XI1800_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1800_MN4 (b27_28 XI1800_An XI1800_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1800_MN2 (XI1800_n1 dd28_b3_4 b27_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1800_MN3 (VSS qu5_b3_4 XI1800_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1800_MN0 (XI1800_An dd28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1799_MN1 (XI1799_Bn qu5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1799_MN5 (XI1799_n2 XI1799_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1799_MN4 (b27_27 XI1799_An XI1799_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1799_MN2 (XI1799_n1 dd27_b3_4 b27_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1799_MN3 (VSS qu5_b3_4 XI1799_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1799_MN0 (XI1799_An dd27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I207_MN1 (XI1068_I207_Bn I1068_G3_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I207_MN5 (XI1068_I207_n2 XI1068_I207_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I207_MN4 (p11_4 XI1068_I207_An XI1068_I207_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I207_MN2 (XI1068_I207_n1 I1068_pn4 p11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I207_MN3 (VSS I1068_G3_0n XI1068_I207_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I207_MN0 (XI1068_I207_An I1068_pn4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1042_MN1 (XI1042_Bn qu21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1042_MN5 (XI1042_n2 XI1042_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1042_MN4 (b11_6 XI1042_An XI1042_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1042_MN2 (XI1042_n1 dd6_b3_2 b11_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1042_MN3 (VSS qu21_b3_1 XI1042_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1042_MN0 (XI1042_An dd6_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1039_MN1 (XI1039_Bn qu21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1039_MN5 (XI1039_n2 XI1039_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1039_MN4 (b11_3 XI1039_An XI1039_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1039_MN2 (XI1039_n1 dd3_b3_2 b11_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1039_MN3 (VSS qu21_b3_0 XI1039_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1039_MN0 (XI1039_An dd3_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI834_MN1 (XI834_Bn qu26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI834_MN5 (XI834_n2 XI834_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI834_MN4 (b6_28 XI834_An XI834_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI834_MN2 (XI834_n1 dd28_b3_1 b6_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI834_MN3 (VSS qu26_b3_4 XI834_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI834_MN0 (XI834_An dd28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI990_MN1 (XI990_Bn qu22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI990_MN5 (XI990_n2 XI990_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI990_MN4 (b10_0 XI990_An XI990_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI990_MN2 (XI990_n1 B_0_b3_1 b10_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI990_MN3 (VSS qu22_b3_0 XI990_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI990_MN0 (XI990_An B_0_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI833_MN1 (XI833_Bn qu26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI833_MN5 (XI833_n2 XI833_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI833_MN4 (b6_27 XI833_An XI833_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI833_MN2 (XI833_n1 dd27_b3_1 b6_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI833_MN3 (VSS qu26_b3_4 XI833_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI833_MN0 (XI833_An dd27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI991_MN1 (XI991_Bn qu22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI991_MN5 (XI991_n2 XI991_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI991_MN4 (b10_1 XI991_An XI991_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI991_MN2 (XI991_n1 dd1_b3_1 b10_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI991_MN3 (VSS qu22_b3_0 XI991_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI991_MN0 (XI991_An dd1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI831_MN1 (XI831_Bn qu26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI831_MN5 (XI831_n2 XI831_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI831_MN4 (b6_25 XI831_An XI831_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI831_MN2 (XI831_n1 dd25_b3_1 b6_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI831_MN3 (VSS qu26_b3_4 XI831_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI831_MN0 (XI831_An dd25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI883_MN1 (XI883_Bn qu25_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI883_MN5 (XI883_n2 XI883_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI883_MN4 (b7_31 XI883_An XI883_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI883_MN2 (XI883_n1 dd31_b3_1 b7_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI883_MN3 (VSS qu25_b3_5 XI883_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI883_MN0 (XI883_An dd31_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI898_MN1 (XI898_Bn qu24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI898_MN5 (XI898_n2 XI898_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI898_MN4 (b8_0 XI898_An XI898_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI898_MN2 (XI898_n1 B_0_b3_1 b8_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI898_MN3 (VSS qu24_b3_0 XI898_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI898_MN0 (XI898_An B_0_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI881_MN1 (XI881_Bn qu25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI881_MN5 (XI881_n2 XI881_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI881_MN4 (b7_29 XI881_An XI881_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI881_MN2 (XI881_n1 dd29_b3_1 b7_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI881_MN3 (VSS qu25_b3_4 XI881_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI881_MN0 (XI881_An dd29_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI877_MN1 (XI877_Bn qu25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI877_MN5 (XI877_n2 XI877_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI877_MN4 (b7_25 XI877_An XI877_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI877_MN2 (XI877_n1 dd25_b3_1 b7_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI877_MN3 (VSS qu25_b3_4 XI877_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI877_MN0 (XI877_An dd25_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI880_MN1 (XI880_Bn qu25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI880_MN5 (XI880_n2 XI880_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI880_MN4 (b7_28 XI880_An XI880_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI880_MN2 (XI880_n1 dd28_b3_1 b7_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI880_MN3 (VSS qu25_b3_4 XI880_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI880_MN0 (XI880_An dd28_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI879_MN1 (XI879_Bn qu25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI879_MN5 (XI879_n2 XI879_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI879_MN4 (b7_27 XI879_An XI879_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI879_MN2 (XI879_n1 dd27_b3_1 b7_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI879_MN3 (VSS qu25_b3_4 XI879_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI879_MN0 (XI879_An dd27_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1706_MN1 (XI1706_Bn qu7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1706_MN5 (XI1706_n2 XI1706_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1706_MN4 (b25_26 XI1706_An XI1706_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1706_MN2 (XI1706_n1 dd26_b3_4 b25_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1706_MN3 (VSS qu7_b3_4 XI1706_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1706_MN0 (XI1706_An dd26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1708_MN1 (XI1708_Bn qu7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1708_MN5 (XI1708_n2 XI1708_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1708_MN4 (b25_28 XI1708_An XI1708_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1708_MN2 (XI1708_n1 dd28_b3_4 b25_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1708_MN3 (VSS qu7_b3_4 XI1708_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1708_MN0 (XI1708_An dd28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1703_MN1 (XI1703_Bn qu7_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1703_MN5 (XI1703_n2 XI1703_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1703_MN4 (b25_23 XI1703_An XI1703_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1703_MN2 (XI1703_n1 dd23_b3_4 b25_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1703_MN3 (VSS qu7_b3_3 XI1703_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1703_MN0 (XI1703_An dd23_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1709_MN1 (XI1709_Bn qu7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1709_MN5 (XI1709_n2 XI1709_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1709_MN4 (b25_29 XI1709_An XI1709_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1709_MN2 (XI1709_n1 dd29_b3_4 b25_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1709_MN3 (VSS qu7_b3_4 XI1709_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1709_MN0 (XI1709_An dd29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1710_MN1 (XI1710_Bn qu7_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1710_MN5 (XI1710_n2 XI1710_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1710_MN4 (b25_30 XI1710_An XI1710_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1710_MN2 (XI1710_n1 dd30_b3_4 b25_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1710_MN3 (VSS qu7_b3_5 XI1710_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1710_MN0 (XI1710_An dd30_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1711_MN1 (XI1711_Bn qu7_b3_5 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1711_MN5 (XI1711_n2 XI1711_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1711_MN4 (b25_31 XI1711_An XI1711_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1711_MN2 (XI1711_n1 dd31_b3_4 b25_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1711_MN3 (VSS qu7_b3_5 XI1711_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1711_MN0 (XI1711_An dd31_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1635_MN1 (XI1635_Bn qu8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1635_MN5 (XI1635_n2 XI1635_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1635_MN4 (b24_1 XI1635_An XI1635_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1635_MN2 (XI1635_n1 dd1_b3_4 b24_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1635_MN3 (VSS qu8_b3_0 XI1635_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1635_MN0 (XI1635_An dd1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1636_MN1 (XI1636_Bn qu8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1636_MN5 (XI1636_n2 XI1636_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1636_MN4 (b24_2 XI1636_An XI1636_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1636_MN2 (XI1636_n1 dd2_b3_4 b24_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1636_MN3 (VSS qu8_b3_0 XI1636_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1636_MN0 (XI1636_An dd2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1634_MN1 (XI1634_Bn qu8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1634_MN5 (XI1634_n2 XI1634_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1634_MN4 (b24_0 XI1634_An XI1634_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1634_MN2 (XI1634_n1 B_0_b3_4 b24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1634_MN3 (VSS qu8_b3_0 XI1634_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1634_MN0 (XI1634_An B_0_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1751_MN1 (XI1751_Bn qu6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1751_MN5 (XI1751_n2 XI1751_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1751_MN4 (b26_25 XI1751_An XI1751_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1751_MN2 (XI1751_n1 dd25_b3_4 b26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1751_MN3 (VSS qu6_b3_4 XI1751_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1751_MN0 (XI1751_An dd25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1752_MN1 (XI1752_Bn qu6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1752_MN5 (XI1752_n2 XI1752_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1752_MN4 (b26_26 XI1752_An XI1752_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1752_MN2 (XI1752_n1 dd26_b3_4 b26_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1752_MN3 (VSS qu6_b3_4 XI1752_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1752_MN0 (XI1752_An dd26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1753_MN1 (XI1753_Bn qu6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1753_MN5 (XI1753_n2 XI1753_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1753_MN4 (b26_27 XI1753_An XI1753_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1753_MN2 (XI1753_n1 dd27_b3_4 b26_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1753_MN3 (VSS qu6_b3_4 XI1753_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1753_MN0 (XI1753_An dd27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1754_MN1 (XI1754_Bn qu6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1754_MN5 (XI1754_n2 XI1754_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1754_MN4 (b26_28 XI1754_An XI1754_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1754_MN2 (XI1754_n1 dd28_b3_4 b26_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1754_MN3 (VSS qu6_b3_4 XI1754_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1754_MN0 (XI1754_An dd28_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1588_MN1 (XI1588_Bn qu9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1588_MN5 (XI1588_n2 XI1588_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1588_MN4 (b23_0 XI1588_An XI1588_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1588_MN2 (XI1588_n1 B_0_b3_4 b23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1588_MN3 (VSS qu9_b3_0 XI1588_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1588_MN0 (XI1588_An B_0_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1755_MN1 (XI1755_Bn qu6_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1755_MN5 (XI1755_n2 XI1755_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1755_MN4 (b26_29 XI1755_An XI1755_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1755_MN2 (XI1755_n1 dd29_b3_4 b26_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1755_MN3 (VSS qu6_b3_4 XI1755_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1755_MN0 (XI1755_An dd29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1590_MN1 (XI1590_Bn qu9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1590_MN5 (XI1590_n2 XI1590_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1590_MN4 (b23_2 XI1590_An XI1590_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1590_MN2 (XI1590_n1 dd2_b3_4 b23_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1590_MN3 (VSS qu9_b3_0 XI1590_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1590_MN0 (XI1590_An dd2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1591_MN1 (XI1591_Bn qu9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1591_MN5 (XI1591_n2 XI1591_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1591_MN4 (b23_3 XI1591_An XI1591_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1591_MN2 (XI1591_n1 dd3_b3_4 b23_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1591_MN3 (VSS qu9_b3_0 XI1591_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1591_MN0 (XI1591_An dd3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1545_MN1 (XI1545_Bn qu10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1545_MN5 (XI1545_n2 XI1545_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1545_MN4 (b22_3 XI1545_An XI1545_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1545_MN2 (XI1545_n1 dd3_b3_4 b22_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1545_MN3 (VSS qu10_b3_0 XI1545_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1545_MN0 (XI1545_An dd3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1543_MN1 (XI1543_Bn qu10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1543_MN5 (XI1543_n2 XI1543_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1543_MN4 (b22_1 XI1543_An XI1543_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1543_MN2 (XI1543_n1 dd1_b3_4 b22_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1543_MN3 (VSS qu10_b3_0 XI1543_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1543_MN0 (XI1543_An dd1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1544_MN1 (XI1544_Bn qu10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1544_MN5 (XI1544_n2 XI1544_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1544_MN4 (b22_2 XI1544_An XI1544_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1544_MN2 (XI1544_n1 dd2_b3_4 b22_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1544_MN3 (VSS qu10_b3_0 XI1544_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1544_MN0 (XI1544_An dd2_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1801_MN1 (XI1801_Bn qu5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1801_MN5 (XI1801_n2 XI1801_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1801_MN4 (b27_29 XI1801_An XI1801_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1801_MN2 (XI1801_n1 dd29_b3_4 b27_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1801_MN3 (VSS qu5_b3_4 XI1801_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1801_MN0 (XI1801_An dd29_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I206_MN1 (XI1574_I206_Bn I1574_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1574_I206_MN5 (XI1574_I206_n2 XI1574_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1574_I206_MN4 (p22_3 XI1574_I206_An XI1574_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I206_MN2 (XI1574_I206_n1 I1574_pn3 p22_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1574_I206_MN3 (VSS I1574_G2_0n XI1574_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1574_I206_MN0 (XI1574_I206_An I1574_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1797_MN1 (XI1797_Bn qu5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1797_MN5 (XI1797_n2 XI1797_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1797_MN4 (b27_25 XI1797_An XI1797_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1797_MN2 (XI1797_n1 dd25_b3_4 b27_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1797_MN3 (VSS qu5_b3_4 XI1797_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1797_MN0 (XI1797_An dd25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1798_MN1 (XI1798_Bn qu5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1798_MN5 (XI1798_n2 XI1798_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1798_MN4 (b27_26 XI1798_An XI1798_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1798_MN2 (XI1798_n1 dd26_b3_4 b27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1798_MN3 (VSS qu5_b3_4 XI1798_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1798_MN0 (XI1798_An dd26_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I213_MN1 (XI1068_I213_Bn I1068_G9_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I213_MN5 (XI1068_I213_n2 XI1068_I213_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I213_MN4 (p11_10 XI1068_I213_An XI1068_I213_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I213_MN2 (XI1068_I213_n1 I1068_pn10 p11_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I213_MN3 (VSS I1068_G9_0n XI1068_I213_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I213_MN0 (XI1068_I213_An I1068_pn10 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1044_MN1 (XI1044_Bn qu21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1044_MN5 (XI1044_n2 XI1044_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1044_MN4 (b11_8 XI1044_An XI1044_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1044_MN2 (XI1044_n1 dd8_b3_2 b11_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1044_MN3 (VSS qu21_b3_1 XI1044_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1044_MN0 (XI1044_An dd8_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I206_MN1 (XI1068_I206_Bn I1068_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1068_I206_MN5 (XI1068_I206_n2 XI1068_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1068_I206_MN4 (p11_3 XI1068_I206_An XI1068_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I206_MN2 (XI1068_I206_n1 I1068_pn3 p11_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1068_I206_MN3 (VSS I1068_G2_0n XI1068_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1068_I206_MN0 (XI1068_I206_An I1068_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1038_MN1 (XI1038_Bn qu21_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1038_MN5 (XI1038_n2 XI1038_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1038_MN4 (b11_2 XI1038_An XI1038_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1038_MN2 (XI1038_n1 dd2_b3_2 b11_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1038_MN3 (VSS qu21_b3_0 XI1038_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1038_MN0 (XI1038_An dd2_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI995_MN1 (XI995_Bn qu22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI995_MN5 (XI995_n2 XI995_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI995_MN4 (b10_5 XI995_An XI995_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI995_MN2 (XI995_n1 dd5_b3_1 b10_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI995_MN3 (VSS qu22_b3_0 XI995_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI995_MN0 (XI995_An dd5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI992_MN1 (XI992_Bn qu22_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI992_MN5 (XI992_n2 XI992_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI992_MN4 (b10_2 XI992_An XI992_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI992_MN2 (XI992_n1 dd2_b3_1 b10_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI992_MN3 (VSS qu22_b3_0 XI992_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI992_MN0 (XI992_An dd2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI944_MN1 (XI944_Bn qu23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI944_MN5 (XI944_n2 XI944_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI944_MN4 (b9_0 XI944_An XI944_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI944_MN2 (XI944_n1 B_0_b3_1 b9_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI944_MN3 (VSS qu23_b3_0 XI944_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI944_MN0 (XI944_An B_0_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI945_MN1 (XI945_Bn qu23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI945_MN5 (XI945_n2 XI945_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI945_MN4 (b9_1 XI945_An XI945_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI945_MN2 (XI945_n1 dd1_b3_1 b9_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI945_MN3 (VSS qu23_b3_0 XI945_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI945_MN0 (XI945_An dd1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI946_MN1 (XI946_Bn qu23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI946_MN5 (XI946_n2 XI946_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI946_MN4 (b9_2 XI946_An XI946_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI946_MN2 (XI946_n1 dd2_b3_1 b9_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI946_MN3 (VSS qu23_b3_0 XI946_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI946_MN0 (XI946_An dd2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI947_MN1 (XI947_Bn qu23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI947_MN5 (XI947_n2 XI947_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI947_MN4 (b9_3 XI947_An XI947_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI947_MN2 (XI947_n1 dd3_b3_1 b9_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI947_MN3 (VSS qu23_b3_0 XI947_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI947_MN0 (XI947_An dd3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI948_MN1 (XI948_Bn qu23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI948_MN5 (XI948_n2 XI948_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI948_MN4 (b9_4 XI948_An XI948_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI948_MN2 (XI948_n1 dd4_b3_1 b9_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI948_MN3 (VSS qu23_b3_0 XI948_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI948_MN0 (XI948_An dd4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI949_MN1 (XI949_Bn qu23_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI949_MN5 (XI949_n2 XI949_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI949_MN4 (b9_5 XI949_An XI949_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI949_MN2 (XI949_n1 dd5_b3_1 b9_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI949_MN3 (VSS qu23_b3_0 XI949_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI949_MN0 (XI949_An dd5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI899_MN1 (XI899_Bn qu24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI899_MN5 (XI899_n2 XI899_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI899_MN4 (b8_1 XI899_An XI899_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI899_MN2 (XI899_n1 dd1_b3_1 b8_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI899_MN3 (VSS qu24_b3_0 XI899_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI899_MN0 (XI899_An dd1_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI902_MN1 (XI902_Bn qu24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI902_MN5 (XI902_n2 XI902_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI902_MN4 (b8_4 XI902_An XI902_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI902_MN2 (XI902_n1 dd4_b3_1 b8_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI902_MN3 (VSS qu24_b3_0 XI902_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI902_MN0 (XI902_An dd4_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI903_MN1 (XI903_Bn qu24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI903_MN5 (XI903_n2 XI903_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI903_MN4 (b8_5 XI903_An XI903_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI903_MN2 (XI903_n1 dd5_b3_1 b8_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI903_MN3 (VSS qu24_b3_0 XI903_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI903_MN0 (XI903_An dd5_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI900_MN1 (XI900_Bn qu24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI900_MN5 (XI900_n2 XI900_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI900_MN4 (b8_2 XI900_An XI900_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI900_MN2 (XI900_n1 dd2_b3_1 b8_2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI900_MN3 (VSS qu24_b3_0 XI900_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI900_MN0 (XI900_An dd2_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI901_MN1 (XI901_Bn qu24_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI901_MN5 (XI901_n2 XI901_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI901_MN4 (b8_3 XI901_An XI901_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI901_MN2 (XI901_n1 dd3_b3_1 b8_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI901_MN3 (VSS qu24_b3_0 XI901_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI901_MN0 (XI901_An dd3_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1704_MN1 (XI1704_Bn qu7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1704_MN5 (XI1704_n2 XI1704_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1704_MN4 (b25_24 XI1704_An XI1704_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1704_MN2 (XI1704_n1 dd24_b3_4 b25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1704_MN3 (VSS qu7_b3_4 XI1704_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1704_MN0 (XI1704_An dd24_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1705_MN1 (XI1705_Bn qu7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1705_MN5 (XI1705_n2 XI1705_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1705_MN4 (b25_25 XI1705_An XI1705_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1705_MN2 (XI1705_n1 dd25_b3_4 b25_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1705_MN3 (VSS qu7_b3_4 XI1705_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1705_MN0 (XI1705_An dd25_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1707_MN1 (XI1707_Bn qu7_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1707_MN5 (XI1707_n2 XI1707_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1707_MN4 (b25_27 XI1707_An XI1707_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1707_MN2 (XI1707_n1 dd27_b3_4 b25_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1707_MN3 (VSS qu7_b3_4 XI1707_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1707_MN0 (XI1707_An dd27_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I206_MN1 (XI1666_I206_Bn I1666_G2_0n VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1666_I206_MN5 (XI1666_I206_n2 XI1666_I206_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1666_I206_MN4 (p24_3 XI1666_I206_An XI1666_I206_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I206_MN2 (XI1666_I206_n1 I1666_pn3 p24_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1666_I206_MN3 (VSS I1666_G2_0n XI1666_I206_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1666_I206_MN0 (XI1666_I206_An I1666_pn3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1639_MN1 (XI1639_Bn qu8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1639_MN5 (XI1639_n2 XI1639_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1639_MN4 (b24_5 XI1639_An XI1639_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1639_MN2 (XI1639_n1 dd5_b3_4 b24_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1639_MN3 (VSS qu8_b3_0 XI1639_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1639_MN0 (XI1639_An dd5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1638_MN1 (XI1638_Bn qu8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1638_MN5 (XI1638_n2 XI1638_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1638_MN4 (b24_4 XI1638_An XI1638_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1638_MN2 (XI1638_n1 dd4_b3_4 b24_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1638_MN3 (VSS qu8_b3_0 XI1638_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1638_MN0 (XI1638_An dd4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1637_MN1 (XI1637_Bn qu8_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1637_MN5 (XI1637_n2 XI1637_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1637_MN4 (b24_3 XI1637_An XI1637_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1637_MN2 (XI1637_n1 dd3_b3_4 b24_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1637_MN3 (VSS qu8_b3_0 XI1637_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1637_MN0 (XI1637_An dd3_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1589_MN1 (XI1589_Bn qu9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1589_MN5 (XI1589_n2 XI1589_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1589_MN4 (b23_1 XI1589_An XI1589_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1589_MN2 (XI1589_n1 dd1_b3_4 b23_1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1589_MN3 (VSS qu9_b3_0 XI1589_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1589_MN0 (XI1589_An dd1_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1593_MN1 (XI1593_Bn qu9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1593_MN5 (XI1593_n2 XI1593_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1593_MN4 (b23_5 XI1593_An XI1593_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1593_MN2 (XI1593_n1 dd5_b3_4 b23_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1593_MN3 (VSS qu9_b3_0 XI1593_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1593_MN0 (XI1593_An dd5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1592_MN1 (XI1592_Bn qu9_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1592_MN5 (XI1592_n2 XI1592_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1592_MN4 (b23_4 XI1592_An XI1592_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1592_MN2 (XI1592_n1 dd4_b3_4 b23_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1592_MN3 (VSS qu9_b3_0 XI1592_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1592_MN0 (XI1592_An dd4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1542_MN1 (XI1542_Bn qu10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1542_MN5 (XI1542_n2 XI1542_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1542_MN4 (b22_0 XI1542_An XI1542_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1542_MN2 (XI1542_n1 B_0_b3_3 b22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1542_MN3 (VSS qu10_b3_0 XI1542_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1542_MN0 (XI1542_An B_0_b3_3 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1547_MN1 (XI1547_Bn qu10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1547_MN5 (XI1547_n2 XI1547_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1547_MN4 (b22_5 XI1547_An XI1547_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1547_MN2 (XI1547_n1 dd5_b3_4 b22_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1547_MN3 (VSS qu10_b3_0 XI1547_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1547_MN0 (XI1547_An dd5_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1546_MN1 (XI1546_Bn qu10_b3_0 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1546_MN5 (XI1546_n2 XI1546_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1546_MN4 (b22_4 XI1546_An XI1546_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1546_MN2 (XI1546_n1 dd4_b3_4 b22_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1546_MN3 (VSS qu10_b3_0 XI1546_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1546_MN0 (XI1546_An dd4_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1063_MN1 (XI1063_Bn qu21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1063_MN5 (XI1063_n2 XI1063_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1063_MN4 (b11_27 XI1063_An XI1063_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1063_MN2 (XI1063_n1 dd27_b3_2 b11_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1063_MN3 (VSS qu21_b3_4 XI1063_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1063_MN0 (XI1063_An dd27_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1062_MN1 (XI1062_Bn qu21_b3_4 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1062_MN5 (XI1062_n2 XI1062_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
    I_MXI1062_MN4 (b11_26 XI1062_An XI1062_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1062_MN2 (XI1062_n1 dd26_b3_2 b11_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.05279p pd=0.68u ps=0.68u
    I_MXI1062_MN3 (VSS qu21_b3_4 XI1062_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08159p as=0.05279p pd=1.16u ps=0.68u
    I_MXI1062_MN0 (XI1062_An dd26_b3_2 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1043_MN1 (XI1043_Bn qu21_b3_1 VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06959p as=0.06959p pd=1.16u ps=1.16u
    I_MXI1043_MN5 (XI1043_n2 XI1043_Bn VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05279p as=0.08159p pd=0.68u ps=1.16u
